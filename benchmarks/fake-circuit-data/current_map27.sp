R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R99 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R100 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R101 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R102 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R103 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R104 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R105 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R106 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R107 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R108 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R109 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R110 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R111 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R112 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R113 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R114 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R115 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R116 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R117 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R118 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R119 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R120 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R121 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R122 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R123 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R124 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R125 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R126 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R127 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R128 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R129 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R130 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R131 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R132 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R133 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R134 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R135 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R136 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R137 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R138 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R139 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R140 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R141 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R142 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R143 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R144 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R145 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R146 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R147 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R148 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R149 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R150 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R151 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R152 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R153 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R154 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R155 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R156 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R157 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R158 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R159 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R160 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R161 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R162 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R163 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R164 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R165 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R166 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R167 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R168 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R169 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R170 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R171 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R172 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R173 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R174 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R175 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R176 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R177 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R178 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R179 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R180 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R181 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R182 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R183 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R184 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R185 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R186 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R187 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R188 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R189 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R190 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R191 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R192 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R193 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R194 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R195 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R196 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R197 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R198 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R199 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R200 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R201 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R202 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R203 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R204 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R205 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R206 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R207 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R208 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R209 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R210 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R211 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R212 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R213 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R214 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R215 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R216 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R217 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R218 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R219 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R220 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R221 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R222 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R223 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R224 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R225 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R226 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R227 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R228 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R229 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R230 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R231 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R232 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R233 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R234 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R235 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R236 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R237 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R238 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R239 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R240 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R241 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R242 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R243 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R244 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R245 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R246 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R247 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R248 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R249 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R250 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R251 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R252 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R253 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R254 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R255 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R256 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R257 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R258 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R259 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R260 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R261 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R262 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R263 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R264 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R265 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R266 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R267 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R268 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R269 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R270 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R271 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R272 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R273 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R274 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R275 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R276 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R277 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R278 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R279 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R280 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R281 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R282 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R283 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R284 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R285 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R286 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R287 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R288 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R289 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R290 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R291 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R292 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R293 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R294 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R295 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R296 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R297 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R298 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R299 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R300 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R301 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R302 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R303 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R304 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R305 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R306 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R307 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R308 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R309 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R310 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R311 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R312 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R313 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R314 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R315 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R316 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R317 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R318 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R319 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R320 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R321 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R322 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R323 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R324 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R325 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R326 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R327 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R328 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R329 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R330 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R331 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R332 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R333 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R334 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R335 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R336 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R337 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R338 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R339 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R340 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R341 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R342 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R343 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R344 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R345 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R346 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R347 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R348 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R349 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R350 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R351 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R352 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R353 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R354 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R355 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R356 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R357 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R358 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R359 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R360 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R361 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R362 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R363 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R364 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R365 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R366 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R367 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R368 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R369 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R370 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R371 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R372 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R373 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R374 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R375 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R376 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R377 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R378 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R379 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R380 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R381 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R382 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R383 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R384 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R385 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R386 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R387 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R388 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R389 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R390 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R391 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R392 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R393 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R394 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R395 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R396 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R397 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R398 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R399 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R400 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R401 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R402 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R403 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R404 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R405 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R406 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R407 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R408 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R409 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R410 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R411 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R412 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R413 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R414 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R415 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R416 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R417 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R418 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R419 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R420 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R421 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R422 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R423 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R424 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R425 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R426 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R427 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R428 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R429 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R430 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R431 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R432 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R433 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R434 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R435 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R436 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R437 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R438 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R439 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R440 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R441 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R442 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R443 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R444 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R445 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R446 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R447 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R448 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R449 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R450 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R451 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R452 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R453 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R454 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R455 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R456 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R457 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R458 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R459 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R460 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R461 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R462 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R463 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R464 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R465 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R466 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R467 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R468 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R469 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R470 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R471 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R472 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R473 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R474 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R475 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R476 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R477 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R478 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R479 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R480 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R481 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R482 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R483 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R484 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R485 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R486 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R487 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R488 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R489 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R490 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R491 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R492 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R493 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R494 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R495 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R496 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R497 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R498 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R499 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R500 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R501 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R502 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R503 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R504 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R505 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R506 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R507 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R508 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R509 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R510 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R511 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R512 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R513 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R514 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R515 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R516 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R517 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R518 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R519 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R520 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R521 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R522 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R523 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R524 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R525 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R526 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R527 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R528 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R529 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R530 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R531 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R532 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R533 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R534 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R535 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R536 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R537 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R538 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R539 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R540 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R541 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R542 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R543 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R544 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R545 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R546 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R547 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R548 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R549 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R550 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R551 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R552 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R553 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R554 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R555 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R556 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R557 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R558 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R559 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R560 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R561 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R562 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R563 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R564 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R565 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R566 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R567 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R568 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R569 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R570 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R571 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R572 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R573 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R574 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R575 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R576 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R577 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R578 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R579 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R580 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R581 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R582 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R583 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R584 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R585 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R586 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R587 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R588 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R589 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R590 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R591 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R592 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R593 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R594 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R595 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R596 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R597 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R598 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R599 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R600 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R601 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R602 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R603 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R604 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R605 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R606 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R607 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R608 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R609 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R610 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R611 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R612 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R613 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R614 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R615 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R616 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R617 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R618 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R619 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R620 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R621 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R622 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R623 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R624 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R625 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R626 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R627 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R628 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R629 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R630 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R631 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R632 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R633 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R634 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R635 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R636 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R637 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R638 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R639 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R640 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R641 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R642 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R643 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R644 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R645 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R646 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R647 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R648 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R649 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R650 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R651 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R652 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R653 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R654 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R655 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R656 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R657 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R658 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R659 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R660 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R661 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R662 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R663 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R664 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R665 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R666 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R667 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R668 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R669 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R670 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R671 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R672 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R673 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R674 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R675 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R676 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R677 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R678 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R679 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R680 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R681 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R682 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R683 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R684 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R685 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R686 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R687 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R688 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R689 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R690 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R691 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R692 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R693 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R694 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R695 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R696 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R697 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R698 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R699 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R700 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R701 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R702 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R703 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R704 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R705 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R706 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R707 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R708 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R709 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R710 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R711 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R712 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R713 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R714 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R715 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R716 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R717 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R718 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R719 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R720 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R721 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R722 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R723 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R724 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R725 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R726 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R727 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R728 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R729 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R730 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R731 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R732 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R733 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R734 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R735 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R736 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R737 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R738 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R739 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R740 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R741 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R742 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R743 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R744 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R745 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R746 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R747 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R748 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R749 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R750 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R751 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R752 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R753 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R754 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R755 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R756 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R757 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R758 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R759 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R760 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R761 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R762 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R763 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R764 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R765 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R766 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R767 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R768 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R769 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R770 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R771 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R772 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R773 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R774 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R775 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R776 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R777 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R778 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R779 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R780 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R781 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R782 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R783 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R784 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R785 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R786 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R787 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R788 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R789 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R790 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R791 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R792 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R793 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R794 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R795 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R796 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R797 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R798 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R799 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R800 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R801 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R802 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R803 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R804 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R805 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R806 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R807 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R808 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R809 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R810 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R811 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R812 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R813 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R814 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R815 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R816 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R817 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R818 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R819 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R820 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R821 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R822 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R823 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R824 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R825 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R826 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R827 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R828 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R829 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R830 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R831 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R832 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R833 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R834 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R835 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R836 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R837 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R838 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R839 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R840 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R841 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R842 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R843 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R844 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R845 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R846 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R847 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R848 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R849 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R850 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R851 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R852 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R853 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R854 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R855 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R856 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R857 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R858 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R859 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R860 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R861 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R862 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R863 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R864 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R865 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R866 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R867 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R868 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R869 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R870 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R871 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R872 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R873 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R874 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R875 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R876 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R877 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R878 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R879 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R880 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R881 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R882 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R883 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R884 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R885 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R886 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R887 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R888 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R889 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R890 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R891 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R892 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R893 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R894 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R895 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R896 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R897 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R898 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R899 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R900 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R901 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R902 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R903 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R904 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R905 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R906 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R907 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R908 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R909 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R910 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R911 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R912 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R913 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R914 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R915 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R916 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R917 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R918 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R919 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R920 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R921 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R922 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R923 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R924 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R925 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R926 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R927 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R928 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R929 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R930 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R931 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R932 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R933 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R934 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R935 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R936 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R937 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R938 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R939 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R940 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R941 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R942 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R943 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R944 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R945 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R946 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R947 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R948 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R949 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R950 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R951 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R952 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R953 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R954 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R955 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R956 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R957 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R958 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R959 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R960 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R961 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R962 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R963 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R964 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R965 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R966 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R967 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R968 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R969 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R970 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R971 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R972 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R973 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R974 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R975 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R976 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R977 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R978 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R979 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R980 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R981 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R982 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R983 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R984 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R985 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R986 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R987 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R988 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R989 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R990 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R991 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R992 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R993 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R994 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R995 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R996 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R997 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R998 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R999 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1000 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1001 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1002 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1003 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1004 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1005 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1006 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1007 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1008 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1009 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1010 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1011 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1012 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1013 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1014 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1015 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1016 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1017 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1018 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1019 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1020 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1021 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1022 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1023 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1024 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1025 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1026 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1027 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1028 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1029 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1030 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1031 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1032 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1033 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1034 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1035 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1036 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1037 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1038 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1039 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1040 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1041 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1042 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1043 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1044 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1045 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1046 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1047 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1048 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1049 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1050 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1051 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1052 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1053 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1054 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1055 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1056 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1057 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1058 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1059 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1060 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1061 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1062 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1063 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1064 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1065 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1066 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1067 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1068 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1069 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1070 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1071 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1072 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1073 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1074 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1075 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1076 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1077 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1078 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1079 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1080 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1081 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1082 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1083 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1084 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1085 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1086 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1087 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1088 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1089 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1090 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1091 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1092 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1093 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1094 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1095 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1096 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1097 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1098 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1099 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1100 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1101 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1102 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1103 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1104 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1105 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1106 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1107 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1108 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1109 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1110 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1111 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1112 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1113 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1114 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1115 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1116 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1117 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1118 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1119 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1120 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1121 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1122 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1123 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1124 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1125 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1126 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1127 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1128 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1129 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1130 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1131 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1132 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1133 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1134 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1135 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1136 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1137 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1138 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1139 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1140 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1141 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1142 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1143 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1144 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1145 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1146 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1147 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1148 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1149 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1150 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1151 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1152 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1153 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1154 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1155 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1156 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1157 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1158 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1159 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1160 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1161 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1162 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1163 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1164 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1165 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1166 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1167 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1168 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1169 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1170 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1171 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1172 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1173 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1174 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1175 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1176 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1177 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1178 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1179 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1180 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1181 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1182 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1183 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1184 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1185 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1186 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1187 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1188 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1189 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1190 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1191 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1192 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1193 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1194 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1195 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1196 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1197 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1198 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1199 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1200 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1201 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1202 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1203 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1204 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1205 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1206 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1207 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1208 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1209 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1210 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1211 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1212 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1213 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1214 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1215 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1216 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1217 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1218 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1219 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1220 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1221 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1222 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1223 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1224 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1225 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1226 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1227 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1228 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1229 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1230 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1231 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1232 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1233 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1234 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1235 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1236 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1237 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1238 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1239 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1240 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1241 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1242 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1243 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1244 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1245 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1246 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1247 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1248 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1249 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1250 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1251 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1252 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1253 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1254 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1255 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1256 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1257 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1258 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1259 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1260 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1261 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1262 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1263 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1264 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1265 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1266 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1267 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1268 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1269 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1270 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1271 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1272 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1273 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1274 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1275 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1276 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1277 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1278 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1279 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1280 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1281 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1282 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1283 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1284 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1285 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1286 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1287 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1288 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1289 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1290 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1291 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1292 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1293 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1294 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1295 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1296 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1297 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1298 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1299 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1300 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1301 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1302 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1303 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1304 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1305 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1306 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1307 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1308 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1309 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1310 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1311 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1312 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1313 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1314 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1315 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1316 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1317 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1318 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1319 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1320 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1321 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1322 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1323 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1324 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1325 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1326 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1327 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1328 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1329 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1330 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1331 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1332 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1333 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1334 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1335 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1336 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1337 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1338 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1339 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1340 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1341 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1342 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1343 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1344 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1345 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1346 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1347 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1348 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1349 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1350 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1351 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1352 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1353 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1354 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1355 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1356 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1357 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1358 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1359 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1360 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1361 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1362 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1363 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1364 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1365 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1366 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1367 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1368 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1369 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1370 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1371 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1372 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1373 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1374 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1375 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1376 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1377 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1378 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1379 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1380 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1381 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1382 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1383 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1384 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1385 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1386 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1387 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1388 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1389 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1390 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1391 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1392 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1393 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1394 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1395 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1396 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1397 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1398 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1399 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1400 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1401 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1402 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1403 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1404 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1405 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1406 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1407 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1408 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1409 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1410 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1411 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1412 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1413 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1414 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1415 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1416 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1417 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1418 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1419 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1420 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1421 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1422 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1423 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1424 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1425 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1426 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1427 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1428 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1429 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1430 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1431 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1432 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1433 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1434 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1435 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1436 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1437 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1438 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1439 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1440 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1441 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1442 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1443 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1444 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1445 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1446 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1447 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1448 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1449 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1450 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1451 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1452 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1453 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1454 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1455 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1456 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1457 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1458 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1459 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1460 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1461 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1462 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1463 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1464 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1465 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1466 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1467 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1468 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1469 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1470 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1471 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1472 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1473 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1474 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R1475 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R1476 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R1477 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R1478 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R1479 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R1480 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R1481 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R1482 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R1483 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R1484 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R1485 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R1486 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R1487 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R1488 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R1489 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R1490 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R1491 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R1492 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R1493 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R1494 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R1495 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R1496 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R1497 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R1498 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R1499 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R1500 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R1501 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R1502 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R1503 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R1504 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R1505 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R1506 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R1507 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R1508 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R1509 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R1510 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R1511 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R1512 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R1513 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R1514 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R1515 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R1516 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R1517 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R1518 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R1519 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R1520 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R1521 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R1522 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R1523 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R1524 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R1525 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R1526 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R1527 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R1528 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R1529 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R1530 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R1531 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R1532 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R1533 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R1534 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R1535 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R1536 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R1537 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R1538 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R1539 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R1540 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R1541 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R1542 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R1543 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R1544 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R1545 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R1546 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R1547 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R1548 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R1549 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R1550 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R1551 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R1552 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R1553 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R1554 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R1555 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R1556 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R1557 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R1558 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R1559 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R1560 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R1561 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R1562 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R1563 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R1564 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R1565 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R1566 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R1567 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R1568 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R1569 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R1570 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R1571 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R1572 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R1573 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R1574 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R1575 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R1576 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R1577 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R1578 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R1579 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R1580 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R1581 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R1582 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R1583 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R1584 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R1585 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R1586 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R1587 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R1588 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R1589 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R1590 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R1591 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R1592 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R1593 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R1594 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R1595 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R1596 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R1597 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R1598 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R1599 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R1600 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R1601 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R1602 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R1603 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R1604 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R1605 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R1606 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R1607 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R1608 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R1609 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R1610 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R1611 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R1612 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R1613 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R1614 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R1615 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R1616 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R1617 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R1618 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R1619 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R1620 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R1621 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R1622 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R1623 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R1624 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R1625 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R1626 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R1627 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R1628 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R1629 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R1630 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R1631 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R1632 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R1633 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R1634 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R1635 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R1636 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R1637 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R1638 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R1639 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R1640 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R1641 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R1642 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R1643 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R1644 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R1645 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R1646 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R1647 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R1648 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R1649 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R1650 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R1651 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R1652 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R1653 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R1654 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R1655 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R1656 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R1657 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R1658 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R1659 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R1660 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R1661 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R1662 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R1663 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R1664 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R1665 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R1666 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R1667 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R1668 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R1669 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R1670 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R1671 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R1672 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R1673 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R1674 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R1675 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R1676 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R1677 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R1678 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R1679 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R1680 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R1681 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R1682 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R1683 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R1684 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R1685 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R1686 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R1687 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R1688 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R1689 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R1690 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R1691 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R1692 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R1693 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R1694 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R1695 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R1696 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R1697 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R1698 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R1699 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R1700 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R1701 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R1702 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R1703 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R1704 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R1705 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R1706 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R1707 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R1708 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R1709 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R1710 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R1711 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R1712 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R1713 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R1714 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R1715 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R1716 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R1717 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R1718 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R1719 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R1720 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R1721 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R1722 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R1723 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R1724 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R1725 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R1726 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R1727 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R1728 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R1729 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R1730 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R1731 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R1732 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R1733 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R1734 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R1735 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R1736 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R1737 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R1738 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R1739 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R1740 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R1741 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R1742 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R1743 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R1744 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R1745 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R1746 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R1747 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R1748 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R1749 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R1750 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R1751 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R1752 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R1753 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R1754 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R1755 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R1756 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R1757 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R1758 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R1759 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R1760 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R1761 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R1762 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R1763 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R1764 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R1765 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R1766 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R1767 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R1768 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R1769 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R1770 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R1771 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R1772 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R1773 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R1774 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R1775 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R1776 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R1777 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R1778 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R1779 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R1780 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R1781 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R1782 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R1783 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R1784 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R1785 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R1786 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R1787 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R1788 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R1789 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R1790 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R1791 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R1792 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R1793 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R1794 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R1795 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R1796 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R1797 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R1798 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R1799 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R1800 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R1801 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R1802 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R1803 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R1804 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R1805 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R1806 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R1807 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R1808 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R1809 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R1810 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R1811 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R1812 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R1813 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R1814 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R1815 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R1816 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R1817 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R1818 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R1819 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R1820 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R1821 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R1822 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R1823 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R1824 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R1825 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R1826 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R1827 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R1828 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R1829 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R1830 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R1831 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R1832 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R1833 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R1834 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R1835 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R1836 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R1837 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R1838 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R1839 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R1840 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R1841 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R1842 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R1843 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R1844 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R1845 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R1846 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R1847 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R1848 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R1849 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R1850 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R1851 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R1852 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R1853 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R1854 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R1855 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R1856 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R1857 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R1858 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R1859 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R1860 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R1861 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R1862 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R1863 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R1864 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R1865 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R1866 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R1867 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R1868 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R1869 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R1870 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R1871 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R1872 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R1873 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R1874 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R1875 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R1876 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R1877 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R1878 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R1879 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R1880 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R1881 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R1882 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R1883 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R1884 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R1885 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R1886 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R1887 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R1888 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R1889 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R1890 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R1891 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R1892 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R1893 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R1894 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R1895 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R1896 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R1897 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R1898 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R1899 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R1900 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R1901 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R1902 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R1903 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R1904 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R1905 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R1906 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R1907 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R1908 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R1909 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R1910 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R1911 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R1912 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R1913 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R1914 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R1915 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R1916 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R1917 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R1918 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R1919 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R1920 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R1921 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R1922 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R1923 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R1924 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R1925 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R1926 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R1927 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R1928 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R1929 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R1930 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R1931 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R1932 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R1933 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R1934 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R1935 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R1936 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R1937 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R1938 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R1939 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R1940 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R1941 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R1942 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R1943 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R1944 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R1945 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R1946 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R1947 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R1948 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R1949 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R1950 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R1951 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R1952 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R1953 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R1954 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R1955 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R1956 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R1957 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R1958 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R1959 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R1960 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R1961 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R1962 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R1963 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R1964 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R1965 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R1966 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R1967 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R1968 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R1969 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R1970 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R1971 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R1972 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R1973 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R1974 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R1975 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R1976 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R1977 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R1978 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R1979 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R1980 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R1981 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R1982 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R1983 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R1984 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R1985 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R1986 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R1987 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R1988 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R1989 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R1990 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R1991 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R1992 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R1993 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R1994 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R1995 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R1996 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R1997 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R1998 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R1999 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2000 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2001 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2002 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2003 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2004 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2005 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2006 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2007 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2008 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2009 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2010 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2011 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2012 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2013 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2014 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2015 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2016 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2017 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2018 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2019 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2020 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2021 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2022 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2023 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2024 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2025 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2026 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2027 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2028 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2029 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2030 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2031 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2032 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2033 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2034 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2035 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2036 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2037 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2038 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2039 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2040 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2041 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2042 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2043 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2044 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2045 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2046 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2047 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2048 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2049 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2050 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2051 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2052 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2053 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2054 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2055 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2056 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2057 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2058 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2059 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2060 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2061 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2062 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2063 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2064 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2065 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2066 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2067 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2068 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2069 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2070 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2071 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2072 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2073 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2074 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2075 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2076 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2077 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2078 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2079 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2080 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2081 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2082 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2083 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2084 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2085 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2086 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2087 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2088 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2089 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2090 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2091 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2092 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2093 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2094 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2095 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2096 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2097 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2098 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2099 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2100 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2101 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2102 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2103 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2104 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2105 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2106 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2107 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2108 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2109 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2110 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2111 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2112 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2113 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2114 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2115 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2116 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2117 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2118 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2119 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2120 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2121 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2122 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2123 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2124 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2125 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2126 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2127 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2128 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2129 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2130 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2131 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2132 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2133 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2134 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2135 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2136 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2137 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2138 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2139 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2140 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2141 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2142 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2143 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2144 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2145 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2146 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2147 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2148 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2149 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2150 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2151 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2152 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2153 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2154 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2155 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2156 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2157 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2158 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2159 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2160 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2161 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2162 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2163 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2164 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2165 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2166 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2167 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2168 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2169 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2170 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2171 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2172 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2173 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2174 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2175 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2176 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2177 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2178 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2179 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2180 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2181 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2182 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2183 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2184 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2185 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2186 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2187 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2188 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2189 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2190 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2191 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2192 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2193 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2194 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2195 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2196 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2197 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2198 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2199 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2200 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2201 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2202 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2203 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2204 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2205 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2206 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2207 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2208 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2209 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2210 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2211 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2212 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2213 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2214 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2215 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2216 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2217 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2218 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2219 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2220 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2221 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2222 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2223 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2224 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2225 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2226 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2227 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2228 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2229 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R2230 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R2231 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R2232 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R2233 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R2234 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R2235 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R2236 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R2237 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R2238 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R2239 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R2240 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R2241 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R2242 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R2243 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R2244 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R2245 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R2246 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R2247 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R2248 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R2249 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R2250 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R2251 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R2252 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R2253 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R2254 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R2255 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R2256 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R2257 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R2258 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R2259 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R2260 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R2261 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R2262 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R2263 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R2264 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R2265 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R2266 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R2267 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R2268 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R2269 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R2270 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R2271 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R2272 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R2273 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R2274 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R2275 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R2276 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R2277 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R2278 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R2279 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R2280 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R2281 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R2282 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R2283 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R2284 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R2285 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R2286 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R2287 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R2288 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R2289 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R2290 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R2291 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R2292 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R2293 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R2294 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R2295 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R2296 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R2297 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R2298 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R2299 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R2300 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R2301 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R2302 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R2303 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R2304 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R2305 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R2306 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R2307 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R2308 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R2309 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R2310 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R2311 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R2312 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R2313 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R2314 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R2315 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R2316 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R2317 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R2318 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R2319 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R2320 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R2321 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R2322 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R2323 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R2324 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R2325 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R2326 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R2327 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R2328 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R2329 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R2330 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R2331 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R2332 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R2333 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R2334 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R2335 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R2336 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R2337 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R2338 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R2339 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R2340 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R2341 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R2342 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R2343 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R2344 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R2345 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R2346 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R2347 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R2348 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R2349 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R2350 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R2351 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R2352 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R2353 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R2354 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R2355 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R2356 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R2357 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R2358 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R2359 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R2360 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R2361 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R2362 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R2363 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R2364 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R2365 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R2366 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R2367 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R2368 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R2369 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R2370 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R2371 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R2372 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R2373 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R2374 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R2375 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R2376 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R2377 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R2378 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R2379 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R2380 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R2381 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R2382 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R2383 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R2384 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R2385 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R2386 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R2387 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R2388 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R2389 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R2390 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R2391 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R2392 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R2393 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R2394 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R2395 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R2396 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R2397 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R2398 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R2399 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R2400 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R2401 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R2402 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R2403 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R2404 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R2405 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R2406 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R2407 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R2408 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R2409 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R2410 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R2411 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R2412 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R2413 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R2414 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R2415 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R2416 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R2417 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R2418 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R2419 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R2420 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R2421 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R2422 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R2423 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R2424 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R2425 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R2426 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R2427 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R2428 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R2429 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R2430 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R2431 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R2432 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R2433 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R2434 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R2435 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R2436 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R2437 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R2438 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R2439 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R2440 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R2441 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R2442 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R2443 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R2444 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R2445 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R2446 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R2447 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R2448 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R2449 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R2450 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R2451 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R2452 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R2453 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R2454 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R2455 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R2456 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R2457 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R2458 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R2459 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R2460 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R2461 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R2462 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R2463 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R2464 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R2465 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R2466 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R2467 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R2468 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R2469 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R2470 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R2471 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R2472 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R2473 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R2474 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R2475 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R2476 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R2477 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R2478 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R2479 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R2480 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R2481 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R2482 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R2483 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R2484 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R2485 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R2486 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R2487 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R2488 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R2489 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R2490 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R2491 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R2492 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R2493 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R2494 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R2495 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R2496 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R2497 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R2498 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R2499 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R2500 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R2501 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R2502 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R2503 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R2504 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R2505 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R2506 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R2507 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R2508 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R2509 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R2510 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R2511 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R2512 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R2513 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R2514 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R2515 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R2516 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R2517 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R2518 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R2519 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R2520 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R2521 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R2522 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R2523 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R2524 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R2525 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R2526 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R2527 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R2528 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R2529 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R2530 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R2531 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R2532 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R2533 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R2534 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R2535 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R2536 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R2537 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R2538 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R2539 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R2540 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R2541 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R2542 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R2543 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R2544 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R2545 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R2546 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R2547 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R2548 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R2549 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R2550 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R2551 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R2552 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R2553 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R2554 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R2555 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R2556 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R2557 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R2558 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R2559 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R2560 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R2561 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R2562 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R2563 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R2564 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R2565 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R2566 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R2567 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R2568 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R2569 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R2570 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R2571 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R2572 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R2573 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R2574 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R2575 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R2576 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R2577 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R2578 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R2579 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R2580 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R2581 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R2582 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R2583 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R2584 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R2585 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R2586 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R2587 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R2588 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R2589 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R2590 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R2591 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R2592 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R2593 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R2594 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R2595 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R2596 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R2597 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R2598 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R2599 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R2600 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R2601 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R2602 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R2603 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R2604 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R2605 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R2606 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R2607 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R2608 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R2609 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R2610 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R2611 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R2612 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R2613 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R2614 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R2615 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R2616 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R2617 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R2618 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R2619 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R2620 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R2621 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R2622 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R2623 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R2624 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R2625 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R2626 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R2627 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R2628 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R2629 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R2630 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R2631 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R2632 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R2633 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R2634 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R2635 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R2636 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R2637 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R2638 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R2639 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R2640 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R2641 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R2642 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R2643 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R2644 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R2645 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R2646 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R2647 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R2648 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R2649 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R2650 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R2651 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R2652 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R2653 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R2654 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R2655 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R2656 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R2657 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R2658 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R2659 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R2660 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R2661 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R2662 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R2663 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R2664 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R2665 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R2666 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R2667 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R2668 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R2669 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R2670 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R2671 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R2672 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R2673 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R2674 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R2675 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R2676 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R2677 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R2678 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R2679 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R2680 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R2681 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R2682 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R2683 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R2684 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R2685 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R2686 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R2687 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R2688 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R2689 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R2690 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R2691 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R2692 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R2693 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R2694 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R2695 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R2696 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R2697 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R2698 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R2699 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R2700 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R2701 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R2702 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R2703 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R2704 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R2705 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R2706 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R2707 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R2708 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R2709 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R2710 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R2711 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R2712 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R2713 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R2714 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R2715 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R2716 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R2717 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R2718 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R2719 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R2720 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R2721 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R2722 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R2723 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R2724 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R2725 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R2726 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R2727 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R2728 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R2729 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R2730 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R2731 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R2732 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R2733 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R2734 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R2735 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R2736 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R2737 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R2738 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R2739 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R2740 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R2741 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R2742 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R2743 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R2744 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R2745 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R2746 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R2747 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R2748 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R2749 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R2750 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R2751 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R2752 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R2753 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R2754 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R2755 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R2756 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R2757 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R2758 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R2759 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R2760 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R2761 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R2762 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R2763 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R2764 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R2765 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R2766 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R2767 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R2768 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R2769 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R2770 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R2771 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R2772 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R2773 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R2774 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R2775 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R2776 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R2777 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R2778 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R2779 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R2780 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R2781 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R2782 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R2783 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R2784 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R2785 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R2786 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R2787 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R2788 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R2789 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R2790 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R2791 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R2792 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R2793 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R2794 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R2795 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R2796 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R2797 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R2798 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R2799 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R2800 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R2801 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R2802 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R2803 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R2804 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R2805 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R2806 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R2807 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R2808 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R2809 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R2810 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R2811 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R2812 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R2813 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R2814 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R2815 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R2816 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R2817 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R2818 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R2819 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R2820 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R2821 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R2822 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R2823 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R2824 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R2825 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R2826 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R2827 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R2828 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R2829 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R2830 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R2831 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R2832 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R2833 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R2834 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R2835 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R2836 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R2837 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R2838 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R2839 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R2840 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R2841 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R2842 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R2843 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R2844 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R2845 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R2846 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R2847 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R2848 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R2849 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R2850 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R2851 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R2852 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R2853 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R2854 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R2855 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R2856 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R2857 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R2858 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R2859 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R2860 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R2861 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R2862 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R2863 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R2864 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R2865 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R2866 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R2867 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R2868 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R2869 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R2870 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R2871 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R2872 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R2873 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R2874 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R2875 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R2876 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R2877 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R2878 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R2879 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R2880 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R2881 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R2882 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R2883 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R2884 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R2885 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R2886 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R2887 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R2888 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R2889 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R2890 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R2891 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R2892 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R2893 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R2894 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R2895 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R2896 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R2897 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R2898 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R2899 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R2900 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R2901 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R2902 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R2903 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R2904 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R2905 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R2906 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R2907 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R2908 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R2909 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R2910 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R2911 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R2912 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R2913 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R2914 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R2915 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R2916 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R2917 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R2918 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R2919 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R2920 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R2921 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R2922 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R2923 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R2924 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R2925 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R2926 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R2927 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R2928 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R2929 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R2930 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R2931 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R2932 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R2933 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R2934 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R2935 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R2936 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R2937 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R2938 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R2939 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R2940 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R2941 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R2942 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R2943 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R2944 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R2945 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R2946 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R2947 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R2948 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R2949 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R2950 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R2951 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R2952 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R2953 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R2954 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R2955 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R2956 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R2957 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R2958 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R2959 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R2960 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R2961 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R2962 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R2963 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R2964 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R2965 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R2966 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R2967 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R2968 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R2969 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R2970 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R2971 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R2972 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R2973 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R2974 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R2975 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R2976 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R2977 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R2978 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R2979 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R2980 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R2981 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R2982 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R2983 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R2984 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R2985 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R2986 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R2987 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R2988 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R2989 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R2990 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R2991 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R2992 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R2993 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R2994 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R2995 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R2996 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R2997 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R2998 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R2999 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R3000 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R3001 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R3002 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R3003 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R3004 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R3005 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R3006 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R3007 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R3008 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R3009 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R3010 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R3011 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R3012 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R3013 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R3014 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R3015 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R3016 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R3017 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R3018 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R3019 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R3020 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R3021 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R3022 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R3023 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R3024 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R3025 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R3026 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R3027 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R3028 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R3029 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R3030 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R3031 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R3032 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R3033 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R3034 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R3035 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R3036 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R3037 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R3038 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R3039 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R3040 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R3041 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R3042 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R3043 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R3044 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R3045 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R3046 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R3047 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R3048 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R3049 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R3050 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R3051 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R3052 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R3053 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R3054 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R3055 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R3056 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R3057 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R3058 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R3059 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R3060 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R3061 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R3062 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R3063 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R3064 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R3065 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R3066 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R3067 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R3068 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R3069 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R3070 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R3071 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R3072 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R3073 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R3074 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R3075 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R3076 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R3077 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R3078 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R3079 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R3080 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R3081 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R3082 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R3083 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R3084 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R3085 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R3086 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R3087 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R3088 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R3089 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R3090 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R3091 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R3092 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R3093 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R3094 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R3095 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R3096 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R3097 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R3098 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R3099 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R3100 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R3101 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R3102 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R3103 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R3104 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R3105 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R3106 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R3107 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R3108 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R3109 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R3110 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R3111 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R3112 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R3113 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R3114 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R3115 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R3116 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R3117 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R3118 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R3119 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R3120 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R3121 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R3122 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R3123 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R3124 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R3125 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R3126 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R3127 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R3128 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R3129 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R3130 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R3131 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R3132 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R3133 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R3134 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R3135 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R3136 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R3137 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R3138 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R3139 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R3140 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R3141 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R3142 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R3143 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R3144 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R3145 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R3146 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R3147 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R3148 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R3149 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R3150 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R3151 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R3152 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R3153 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R3154 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R3155 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R3156 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R3157 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R3158 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R3159 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R3160 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R3161 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R3162 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R3163 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R3164 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R3165 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R3166 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R3167 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R3168 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R3169 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R3170 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R3171 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R3172 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R3173 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R3174 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R3175 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R3176 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R3177 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R3178 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R3179 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R3180 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R3181 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R3182 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R3183 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R3184 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R3185 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R3186 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R3187 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R3188 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R3189 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R3190 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R3191 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R3192 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R3193 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R3194 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R3195 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R3196 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R3197 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R3198 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R3199 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R3200 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R3201 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R3202 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R3203 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R3204 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R3205 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R3206 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R3207 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R3208 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R3209 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R3210 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R3211 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R3212 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R3213 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R3214 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R3215 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R3216 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R3217 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R3218 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R3219 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R3220 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R3221 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R3222 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R3223 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R3224 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R3225 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R3226 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R3227 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R3228 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R3229 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R3230 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R3231 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R3232 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R3233 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R3234 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R3235 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R3236 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R3237 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R3238 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R3239 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R3240 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R3241 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R3242 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R3243 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R3244 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R3245 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R3246 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R3247 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R3248 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R3249 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R3250 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R3251 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R3252 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R3253 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R3254 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R3255 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R3256 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R3257 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R3258 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R3259 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R3260 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R3261 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R3262 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R3263 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R3264 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R3265 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R3266 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R3267 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R3268 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R3269 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R3270 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R3271 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R3272 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R3273 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R3274 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R3275 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R3276 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R3277 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R3278 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R3279 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R3280 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R3281 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R3282 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R3283 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R3284 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R3285 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R3286 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R3287 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R3288 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R3289 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R3290 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R3291 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R3292 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R3293 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R3294 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R3295 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R3296 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R3297 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R3298 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R3299 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R3300 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R3301 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R3302 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R3303 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R3304 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R3305 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R3306 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R3307 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R3308 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R3309 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R3310 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R3311 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R3312 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R3313 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R3314 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R3315 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R3316 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R3317 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R3318 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R3319 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R3320 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R3321 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R3322 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R3323 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R3324 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R3325 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R3326 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R3327 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R3328 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R3329 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R3330 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R3331 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R3332 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R3333 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R3334 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R3335 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R3336 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R3337 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R3338 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R3339 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R3340 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R3341 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R3342 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R3343 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R3344 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R3345 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R3346 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R3347 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R3348 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R3349 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R3350 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R3351 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R3352 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R3353 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R3354 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R3355 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R3356 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R3357 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R3358 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R3359 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R3360 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R3361 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R3362 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R3363 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R3364 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R3365 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R3366 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R3367 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R3368 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R3369 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R3370 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R3371 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R3372 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R3373 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R3374 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R3375 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R3376 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R3377 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R3378 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R3379 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R3380 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R3381 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R3382 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R3383 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R3384 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R3385 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R3386 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R3387 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R3388 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R3389 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R3390 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R3391 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R3392 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R3393 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R3394 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R3395 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R3396 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R3397 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R3398 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R3399 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R3400 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R3401 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R3402 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R3403 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R3404 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R3405 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R3406 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R3407 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R3408 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R3409 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R3410 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R3411 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R3412 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R3413 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R3414 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R3415 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R3416 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R3417 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R3418 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R3419 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R3420 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R3421 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R3422 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R3423 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R3424 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R3425 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R3426 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R3427 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R3428 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R3429 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R3430 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R3431 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R3432 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R3433 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R3434 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R3435 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R3436 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R3437 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R3438 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R3439 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R3440 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R3441 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R3442 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R3443 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R3444 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R3445 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R3446 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R3447 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R3448 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R3449 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R3450 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R3451 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R3452 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R3453 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R3454 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R3455 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R3456 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R3457 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R3458 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R3459 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R3460 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R3461 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R3462 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R3463 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R3464 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R3465 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R3466 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R3467 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R3468 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R3469 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R3470 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R3471 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R3472 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R3473 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R3474 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R3475 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R3476 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R3477 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R3478 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R3479 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R3480 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R3481 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R3482 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R3483 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R3484 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R3485 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R3486 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R3487 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R3488 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R3489 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R3490 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R3491 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R3492 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R3493 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R3494 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R3495 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R3496 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R3497 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R3498 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R3499 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R3500 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R3501 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R3502 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R3503 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R3504 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R3505 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R3506 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R3507 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R3508 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R3509 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R3510 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R3511 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R3512 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R3513 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R3514 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R3515 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R3516 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R3517 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R3518 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R3519 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R3520 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R3521 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R3522 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R3523 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R3524 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R3525 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R3526 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R3527 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R3528 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R3529 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R3530 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R3531 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R3532 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R3533 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R3534 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R3535 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R3536 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R3537 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R3538 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R3539 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R3540 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R3541 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R3542 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R3543 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R3544 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R3545 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R3546 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R3547 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R3548 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R3549 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R3550 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R3551 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R3552 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R3553 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R3554 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R3555 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R3556 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R3557 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R3558 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R3559 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R3560 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R3561 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R3562 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R3563 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R3564 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R3565 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R3566 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R3567 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R3568 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R3569 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R3570 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R3571 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R3572 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R3573 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R3574 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R3575 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R3576 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R3577 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R3578 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R3579 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R3580 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R3581 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R3582 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R3583 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R3584 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R3585 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R3586 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R3587 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R3588 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R3589 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R3590 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R3591 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R3592 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R3593 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R3594 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R3595 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R3596 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R3597 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R3598 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R3599 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R3600 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R3601 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R3602 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R3603 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R3604 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R3605 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R3606 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R3607 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R3608 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R3609 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R3610 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R3611 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R3612 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R3613 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R3614 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R3615 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R3616 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R3617 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R3618 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R3619 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R3620 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R3621 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R3622 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R3623 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R3624 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R3625 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R3626 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R3627 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R3628 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R3629 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R3630 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R3631 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R3632 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R3633 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R3634 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R3635 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R3636 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R3637 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R3638 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R3639 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R3640 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R3641 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R3642 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R3643 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R3644 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R3645 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R3646 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R3647 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R3648 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R3649 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R3650 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R3651 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R3652 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R3653 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R3654 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R3655 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R3656 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R3657 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R3658 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R3659 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R3660 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R3661 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R3662 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R3663 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R3664 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R3665 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R3666 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R3667 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R3668 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R3669 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R3670 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R3671 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R3672 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R3673 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R3674 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R3675 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R3676 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R3677 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R3678 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R3679 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R3680 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R3681 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R3682 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R3683 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R3684 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R3685 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R3686 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R3687 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R3688 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R3689 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R3690 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R3691 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R3692 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R3693 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R3694 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R3695 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R3696 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R3697 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R3698 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R3699 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R3700 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R3701 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R3702 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R3703 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R3704 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R3705 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R3706 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R3707 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R3708 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R3709 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R3710 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R3711 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R3712 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R3713 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R3714 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R3715 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R3716 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R3717 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R3718 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R3719 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R3720 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R3721 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R3722 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R3723 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R3724 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R3725 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R3726 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R3727 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R3728 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R3729 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R3730 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R3731 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R3732 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R3733 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R3734 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R3735 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R3736 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R3737 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R3738 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R3739 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R3740 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R3741 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R3742 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R3743 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R3744 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R3745 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R3746 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R3747 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R3748 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R3749 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R3750 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R3751 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R3752 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R3753 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R3754 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R3755 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R3756 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R3757 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R3758 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R3759 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R3760 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R3761 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R3762 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R3763 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R3764 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R3765 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R3766 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R3767 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R3768 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R3769 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R3770 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R3771 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R3772 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R3773 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R3774 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R3775 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R3776 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R3777 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R3778 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R3779 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R3780 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R3781 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R3782 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R3783 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R3784 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R3785 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R3786 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R3787 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R3788 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R3789 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R3790 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R3791 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R3792 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R3793 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R3794 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R3795 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R3796 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R3797 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R3798 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R3799 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R3800 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R3801 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R3802 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R3803 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R3804 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R3805 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R3806 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R3807 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R3808 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R3809 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R3810 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R3811 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R3812 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R3813 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R3814 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R3815 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R3816 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R3817 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R3818 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R3819 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R3820 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R3821 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R3822 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R3823 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R3824 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R3825 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R3826 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R3827 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R3828 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R3829 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R3830 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R3831 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R3832 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R3833 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R3834 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R3835 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R3836 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R3837 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R3838 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R3839 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R3840 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R3841 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R3842 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R3843 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R3844 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R3845 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R3846 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R3847 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R3848 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R3849 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R3850 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R3851 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R3852 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R3853 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R3854 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R3855 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R3856 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R3857 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R3858 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R3859 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R3860 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R3861 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R3862 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R3863 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R3864 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R3865 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R3866 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R3867 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R3868 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R3869 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R3870 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R3871 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R3872 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R3873 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R3874 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R3875 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R3876 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R3877 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R3878 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R3879 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R3880 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R3881 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R3882 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R3883 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R3884 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R3885 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R3886 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R3887 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R3888 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R3889 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R3890 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R3891 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R3892 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R3893 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R3894 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R3895 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R3896 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R3897 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R3898 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R3899 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R3900 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R3901 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R3902 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R3903 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R3904 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R3905 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R3906 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R3907 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R3908 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R3909 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R3910 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R3911 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R3912 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R3913 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R3914 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R3915 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R3916 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R3917 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R3918 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R3919 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R3920 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R3921 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R3922 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R3923 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R3924 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R3925 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R3926 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R3927 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R3928 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R3929 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R3930 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R3931 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R3932 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R3933 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R3934 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R3935 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R3936 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R3937 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R3938 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R3939 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R3940 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R3941 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R3942 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R3943 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R3944 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R3945 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R3946 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R3947 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R3948 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R3949 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R3950 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R3951 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R3952 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R3953 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R3954 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R3955 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R3956 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R3957 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R3958 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R3959 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R3960 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R3961 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R3962 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R3963 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R3964 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R3965 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R3966 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R3967 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R3968 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R3969 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R3970 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R3971 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R3972 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R3973 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R3974 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R3975 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R3976 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R3977 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R3978 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R3979 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R3980 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R3981 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R3982 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R3983 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R3984 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R3985 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R3986 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R3987 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R3988 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R3989 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R3990 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R3991 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R3992 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R3993 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R3994 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R3995 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R3996 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R3997 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R3998 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R3999 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R4000 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R4001 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R4002 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R4003 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R4004 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R4005 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R4006 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R4007 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R4008 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R4009 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R4010 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R4011 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R4012 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R4013 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R4014 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R4015 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R4016 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R4017 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R4018 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R4019 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R4020 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R4021 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R4022 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R4023 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R4024 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R4025 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R4026 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R4027 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R4028 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R4029 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R4030 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R4031 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R4032 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R4033 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R4034 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R4035 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R4036 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R4037 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R4038 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R4039 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R4040 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R4041 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R4042 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R4043 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R4044 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R4045 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R4046 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R4047 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R4048 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R4049 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R4050 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R4051 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R4052 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R4053 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R4054 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R4055 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R4056 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R4057 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R4058 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R4059 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R4060 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R4061 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R4062 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R4063 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R4064 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R4065 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R4066 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R4067 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R4068 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R4069 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R4070 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R4071 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R4072 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R4073 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R4074 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R4075 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R4076 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R4077 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R4078 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R4079 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R4080 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R4081 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R4082 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R4083 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R4084 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R4085 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R4086 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R4087 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R4088 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R4089 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R4090 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R4091 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R4092 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R4093 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R4094 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R4095 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R4096 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R4097 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R4098 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R4099 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R4100 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R4101 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R4102 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R4103 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R4104 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R4105 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R4106 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R4107 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R4108 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R4109 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R4110 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R4111 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R4112 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R4113 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R4114 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R4115 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R4116 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R4117 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R4118 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R4119 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R4120 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R4121 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R4122 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R4123 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R4124 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R4125 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R4126 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R4127 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R4128 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R4129 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R4130 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R4131 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R4132 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R4133 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R4134 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R4135 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R4136 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R4137 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R4138 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R4139 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R4140 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R4141 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R4142 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R4143 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R4144 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R4145 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R4146 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R4147 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R4148 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R4149 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R4150 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R4151 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R4152 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R4153 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R4154 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R4155 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R4156 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R4157 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R4158 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R4159 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R4160 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R4161 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R4162 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R4163 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R4164 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R4165 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R4166 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R4167 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R4168 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R4169 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R4170 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R4171 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R4172 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R4173 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R4174 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R4175 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R4176 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R4177 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R4178 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R4179 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R4180 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R4181 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R4182 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R4183 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R4184 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R4185 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R4186 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R4187 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R4188 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R4189 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R4190 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R4191 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R4192 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R4193 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R4194 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R4195 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R4196 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R4197 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R4198 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R4199 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R4200 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R4201 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R4202 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R4203 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R4204 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R4205 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R4206 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R4207 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R4208 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R4209 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R4210 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R4211 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R4212 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R4213 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R4214 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R4215 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R4216 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R4217 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R4218 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R4219 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R4220 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R4221 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R4222 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R4223 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R4224 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R4225 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R4226 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R4227 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R4228 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R4229 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R4230 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R4231 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R4232 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R4233 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R4234 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R4235 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R4236 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R4237 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R4238 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R4239 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R4240 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R4241 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R4242 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R4243 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R4244 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R4245 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R4246 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R4247 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R4248 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R4249 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R4250 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R4251 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R4252 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R4253 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R4254 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R4255 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R4256 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R4257 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R4258 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R4259 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R4260 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R4261 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R4262 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R4263 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R4264 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R4265 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R4266 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R4267 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R4268 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R4269 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R4270 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R4271 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R4272 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R4273 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R4274 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R4275 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R4276 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R4277 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R4278 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R4279 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R4280 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R4281 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R4282 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R4283 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R4284 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R4285 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R4286 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R4287 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R4288 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R4289 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R4290 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R4291 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R4292 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R4293 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R4294 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R4295 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R4296 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R4297 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R4298 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R4299 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R4300 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R4301 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R4302 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R4303 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R4304 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R4305 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R4306 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R4307 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R4308 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R4309 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R4310 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R4311 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R4312 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R4313 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R4314 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R4315 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R4316 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R4317 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R4318 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R4319 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R4320 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R4321 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R4322 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R4323 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R4324 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R4325 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R4326 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R4327 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R4328 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R4329 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R4330 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R4331 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R4332 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R4333 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R4334 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R4335 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R4336 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R4337 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R4338 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R4339 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R4340 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R4341 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R4342 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R4343 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R4344 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R4345 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R4346 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R4347 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R4348 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R4349 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R4350 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R4351 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R4352 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R4353 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R4354 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R4355 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R4356 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R4357 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R4358 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R4359 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R4360 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R4361 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R4362 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R4363 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R4364 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R4365 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R4366 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R4367 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R4368 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R4369 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R4370 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R4371 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R4372 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R4373 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R4374 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R4375 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R4376 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R4377 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R4378 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R4379 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R4380 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R4381 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R4382 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R4383 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R4384 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R4385 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R4386 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R4387 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R4388 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R4389 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R4390 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R4391 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R4392 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R4393 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R4394 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R4395 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R4396 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R4397 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R4398 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R4399 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R4400 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R4401 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R4402 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R4403 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R4404 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R4405 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R4406 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R4407 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R4408 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R4409 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R4410 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R4411 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R4412 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R4413 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R4414 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R4415 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R4416 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R4417 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R4418 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R4419 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R4420 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R4421 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R4422 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R4423 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R4424 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R4425 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R4426 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R4427 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R4428 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R4429 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R4430 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R4431 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R4432 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R4433 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R4434 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R4435 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R4436 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R4437 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R4438 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R4439 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R4440 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R4441 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R4442 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R4443 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R4444 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R4445 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R4446 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R4447 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R4448 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R4449 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R4450 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R4451 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R4452 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R4453 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R4454 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R4455 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R4456 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R4457 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R4458 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R4459 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R4460 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R4461 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R4462 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R4463 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R4464 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R4465 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R4466 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R4467 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R4468 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R4469 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R4470 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R4471 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R4472 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R4473 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R4474 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R4475 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R4476 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R4477 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R4478 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R4479 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R4480 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R4481 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R4482 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R4483 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R4484 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R4485 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R4486 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R4487 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R4488 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R4489 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R4490 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R4491 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R4492 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R4493 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R4494 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R4495 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R4496 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R4497 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R4498 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R4499 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R4500 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R4501 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R4502 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R4503 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R4504 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R4505 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R4506 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R4507 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R4508 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R4509 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R4510 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R4511 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R4512 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R4513 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R4514 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R4515 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R4516 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R4517 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R4518 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R4519 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R4520 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R4521 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R4522 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R4523 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R4524 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R4525 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R4526 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R4527 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R4528 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R4529 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R4530 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R4531 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R4532 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R4533 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R4534 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R4535 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R4536 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R4537 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R4538 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R4539 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R4540 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R4541 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R4542 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R4543 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R4544 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R4545 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R4546 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R4547 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R4548 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R4549 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R4550 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R4551 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R4552 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R4553 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R4554 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R4555 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R4556 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R4557 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R4558 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R4559 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R4560 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R4561 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R4562 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R4563 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R4564 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R4565 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R4566 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R4567 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R4568 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R4569 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R4570 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R4571 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R4572 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R4573 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R4574 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R4575 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R4576 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R4577 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R4578 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R4579 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R4580 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R4581 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R4582 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R4583 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R4584 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R4585 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R4586 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R4587 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R4588 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R4589 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R4590 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R4591 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R4592 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R4593 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R4594 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R4595 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R4596 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R4597 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R4598 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R4599 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R4600 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R4601 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R4602 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R4603 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R4604 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R4605 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R4606 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R4607 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R4608 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R4609 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R4610 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R4611 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R4612 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R4613 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R4614 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R4615 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R4616 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R4617 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R4618 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R4619 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R4620 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R4621 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R4622 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R4623 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R4624 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R4625 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R4626 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R4627 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R4628 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R4629 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R4630 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R4631 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R4632 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R4633 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R4634 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R4635 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R4636 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R4637 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R4638 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R4639 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R4640 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R4641 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R4642 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R4643 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R4644 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R4645 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R4646 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R4647 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R4648 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R4649 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R4650 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R4651 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R4652 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R4653 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R4654 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R4655 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R4656 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R4657 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R4658 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R4659 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R4660 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R4661 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R4662 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R4663 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R4664 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R4665 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R4666 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R4667 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R4668 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R4669 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R4670 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R4671 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R4672 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R4673 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R4674 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R4675 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R4676 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R4677 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R4678 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R4679 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R4680 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R4681 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R4682 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R4683 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R4684 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R4685 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R4686 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R4687 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R4688 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R4689 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R4690 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R4691 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R4692 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R4693 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R4694 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R4695 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R4696 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R4697 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R4698 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R4699 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R4700 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R4701 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R4702 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R4703 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R4704 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R4705 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R4706 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R4707 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R4708 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R4709 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R4710 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R4711 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R4712 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R4713 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R4714 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R4715 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R4716 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R4717 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R4718 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R4719 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R4720 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R4721 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R4722 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R4723 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R4724 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R4725 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R4726 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R4727 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R4728 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R4729 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R4730 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R4731 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R4732 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R4733 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R4734 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R4735 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R4736 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R4737 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R4738 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R4739 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R4740 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R4741 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R4742 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R4743 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R4744 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R4745 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R4746 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R4747 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R4748 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R4749 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R4750 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R4751 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R4752 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R4753 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R4754 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R4755 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R4756 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R4757 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R4758 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R4759 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R4760 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R4761 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R4762 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R4763 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R4764 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R4765 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R4766 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R4767 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R4768 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R4769 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R4770 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R4771 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R4772 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R4773 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R4774 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R4775 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R4776 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R4777 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R4778 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R4779 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R4780 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R4781 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R4782 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R4783 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R4784 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R4785 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R4786 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R4787 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R4788 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R4789 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R4790 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R4791 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R4792 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R4793 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R4794 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R4795 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R4796 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R4797 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R4798 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R4799 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R4800 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R4801 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R4802 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R4803 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R4804 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R4805 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R4806 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R4807 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R4808 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R4809 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R4810 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R4811 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R4812 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R4813 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R4814 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R4815 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R4816 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R4817 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R4818 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R4819 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R4820 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R4821 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R4822 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R4823 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R4824 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R4825 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R4826 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R4827 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R4828 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R4829 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R4830 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R4831 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R4832 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R4833 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R4834 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R4835 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R4836 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R4837 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R4838 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R4839 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R4840 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R4841 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R4842 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R4843 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R4844 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R4845 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R4846 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R4847 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R4848 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R4849 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R4850 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R4851 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R4852 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R4853 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R4854 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R4855 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R4856 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R4857 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R4858 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R4859 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R4860 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R4861 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R4862 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R4863 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R4864 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R4865 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R4866 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R4867 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R4868 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R4869 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R4870 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R4871 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R4872 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R4873 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R4874 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R4875 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R4876 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R4877 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R4878 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R4879 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R4880 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R4881 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R4882 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R4883 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R4884 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R4885 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R4886 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R4887 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R4888 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R4889 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R4890 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R4891 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R4892 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R4893 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R4894 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R4895 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R4896 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R4897 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R4898 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R4899 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R4900 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R4901 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R4902 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R4903 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R4904 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R4905 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R4906 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R4907 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R4908 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R4909 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R4910 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R4911 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R4912 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R4913 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R4914 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R4915 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R4916 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R4917 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R4918 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R4919 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R4920 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R4921 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R4922 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R4923 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R4924 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R4925 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R4926 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R4927 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R4928 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R4929 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R4930 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R4931 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R4932 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R4933 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R4934 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R4935 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R4936 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R4937 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R4938 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R4939 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R4940 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R4941 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R4942 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R4943 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R4944 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R4945 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R4946 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R4947 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R4948 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R4949 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R4950 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R4951 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R4952 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R4953 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R4954 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R4955 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R4956 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R4957 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R4958 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R4959 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R4960 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R4961 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R4962 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R4963 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R4964 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R4965 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R4966 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R4967 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R4968 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R4969 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R4970 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R4971 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R4972 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R4973 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R4974 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R4975 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R4976 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R4977 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R4978 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R4979 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R4980 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R4981 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R4982 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R4983 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R4984 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R4985 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R4986 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R4987 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R4988 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R4989 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R4990 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R4991 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R4992 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R4993 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R4994 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R4995 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R4996 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R4997 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R4998 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R4999 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R5000 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R5001 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R5002 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R5003 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R5004 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R5005 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R5006 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R5007 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R5008 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R5009 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R5010 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R5011 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R5012 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R5013 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R5014 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R5015 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R5016 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R5017 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R5018 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R5019 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R5020 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R5021 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R5022 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R5023 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R5024 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R5025 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R5026 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R5027 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R5028 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R5029 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R5030 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R5031 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R5032 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R5033 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R5034 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R5035 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R5036 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R5037 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R5038 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R5039 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R5040 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R5041 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R5042 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R5043 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R5044 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R5045 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R5046 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R5047 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R5048 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R5049 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R5050 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R5051 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R5052 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R5053 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R5054 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R5055 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R5056 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R5057 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R5058 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R5059 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R5060 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R5061 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R5062 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R5063 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R5064 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R5065 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R5066 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R5067 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R5068 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R5069 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R5070 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R5071 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R5072 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R5073 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R5074 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R5075 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R5076 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R5077 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R5078 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R5079 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R5080 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R5081 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R5082 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R5083 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R5084 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R5085 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R5086 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R5087 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R5088 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R5089 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R5090 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R5091 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R5092 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R5093 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R5094 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R5095 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R5096 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R5097 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R5098 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R5099 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R5100 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R5101 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R5102 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R5103 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R5104 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R5105 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R5106 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R5107 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R5108 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R5109 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R5110 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R5111 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R5112 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R5113 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R5114 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R5115 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R5116 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R5117 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R5118 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R5119 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R5120 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R5121 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R5122 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R5123 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R5124 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R5125 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R5126 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R5127 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R5128 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R5129 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R5130 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R5131 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R5132 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R5133 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R5134 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R5135 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R5136 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R5137 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R5138 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R5139 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R5140 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R5141 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R5142 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R5143 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R5144 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R5145 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R5146 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R5147 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R5148 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R5149 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R5150 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R5151 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R5152 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R5153 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R5154 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R5155 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R5156 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R5157 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R5158 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R5159 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R5160 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R5161 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R5162 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R5163 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R5164 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R5165 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R5166 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R5167 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R5168 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R5169 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R5170 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R5171 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R5172 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R5173 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R5174 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R5175 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R5176 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R5177 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R5178 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R5179 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R5180 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R5181 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R5182 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R5183 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R5184 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R5185 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R5186 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R5187 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R5188 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R5189 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R5190 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R5191 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R5192 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R5193 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R5194 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R5195 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R5196 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R5197 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R5198 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R5199 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R5200 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R5201 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R5202 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R5203 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R5204 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R5205 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R5206 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R5207 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R5208 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R5209 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R5210 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R5211 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R5212 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R5213 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R5214 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R5215 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R5216 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R5217 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R5218 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R5219 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R5220 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R5221 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R5222 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R5223 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R5224 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R5225 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R5226 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R5227 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R5228 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R5229 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R5230 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R5231 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R5232 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R5233 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R5234 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R5235 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R5236 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R5237 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R5238 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R5239 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R5240 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R5241 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R5242 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R5243 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R5244 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R5245 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R5246 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R5247 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R5248 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R5249 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R5250 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R5251 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R5252 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R5253 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R5254 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R5255 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R5256 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R5257 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R5258 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R5259 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R5260 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R5261 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R5262 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R5263 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R5264 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R5265 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R5266 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R5267 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R5268 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R5269 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R5270 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R5271 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R5272 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R5273 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R5274 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R5275 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R5276 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R5277 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R5278 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R5279 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R5280 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R5281 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R5282 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R5283 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R5284 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R5285 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R5286 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R5287 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R5288 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R5289 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R5290 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R5291 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R5292 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R5293 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R5294 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R5295 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R5296 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R5297 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R5298 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R5299 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R5300 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R5301 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R5302 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R5303 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R5304 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R5305 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R5306 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R5307 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R5308 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R5309 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R5310 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R5311 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R5312 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R5313 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R5314 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R5315 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R5316 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R5317 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R5318 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R5319 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R5320 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R5321 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R5322 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R5323 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R5324 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R5325 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R5326 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R5327 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R5328 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R5329 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R5330 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R5331 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R5332 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R5333 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R5334 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R5335 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R5336 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R5337 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R5338 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R5339 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R5340 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R5341 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R5342 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R5343 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R5344 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R5345 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R5346 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R5347 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R5348 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R5349 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R5350 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R5351 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R5352 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R5353 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R5354 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R5355 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R5356 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R5357 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R5358 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R5359 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R5360 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R5361 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R5362 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R5363 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R5364 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R5365 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R5366 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R5367 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R5368 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R5369 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R5370 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R5371 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R5372 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R5373 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R5374 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R5375 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R5376 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R5377 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R5378 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R5379 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R5380 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R5381 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R5382 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R5383 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R5384 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R5385 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R5386 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R5387 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R5388 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R5389 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R5390 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R5391 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R5392 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R5393 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R5394 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R5395 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R5396 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R5397 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R5398 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R5399 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R5400 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R5401 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R5402 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R5403 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R5404 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R5405 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R5406 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R5407 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R5408 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R5409 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R5410 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R5411 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R5412 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R5413 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R5414 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R5415 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R5416 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R5417 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R5418 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R5419 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R5420 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R5421 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R5422 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R5423 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R5424 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R5425 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R5426 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R5427 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R5428 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R5429 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R5430 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R5431 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R5432 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R5433 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R5434 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R5435 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R5436 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R5437 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R5438 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R5439 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R5440 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R5441 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R5442 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R5443 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R5444 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R5445 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R5446 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R5447 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R5448 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R5449 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R5450 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R5451 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R5452 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R5453 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R5454 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R5455 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R5456 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R5457 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R5458 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R5459 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R5460 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R5461 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R5462 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R5463 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R5464 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R5465 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R5466 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R5467 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R5468 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R5469 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R5470 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R5471 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R5472 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R5473 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R5474 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R5475 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R5476 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R5477 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R5478 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R5479 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R5480 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R5481 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R5482 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R5483 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R5484 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R5485 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R5486 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R5487 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R5488 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R5489 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R5490 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R5491 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R5492 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R5493 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R5494 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R5495 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R5496 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R5497 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R5498 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R5499 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R5500 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R5501 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R5502 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R5503 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R5504 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R5505 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R5506 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R5507 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R5508 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R5509 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R5510 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R5511 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R5512 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R5513 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R5514 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R5515 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R5516 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R5517 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R5518 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R5519 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R5520 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R5521 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R5522 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R5523 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R5524 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R5525 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R5526 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R5527 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R5528 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R5529 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R5530 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R5531 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R5532 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R5533 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R5534 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R5535 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R5536 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R5537 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R5538 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R5539 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R5540 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R5541 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R5542 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R5543 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R5544 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R5545 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R5546 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R5547 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R5548 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R5549 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R5550 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R5551 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R5552 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R5553 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R5554 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R5555 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R5556 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R5557 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R5558 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R5559 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R5560 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R5561 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R5562 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R5563 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R5564 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R5565 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R5566 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R5567 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R5568 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R5569 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R5570 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R5571 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R5572 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R5573 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R5574 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R5575 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R5576 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R5577 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R5578 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R5579 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R5580 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R5581 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R5582 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R5583 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R5584 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R5585 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R5586 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R5587 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R5588 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R5589 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R5590 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R5591 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R5592 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R5593 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R5594 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R5595 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R5596 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R5597 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R5598 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R5599 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R5600 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R5601 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R5602 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R5603 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R5604 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R5605 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R5606 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R5607 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R5608 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R5609 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R5610 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R5611 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R5612 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R5613 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R5614 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R5615 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R5616 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R5617 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R5618 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R5619 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R5620 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R5621 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R5622 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R5623 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R5624 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R5625 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R5626 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R5627 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R5628 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R5629 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R5630 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R5631 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R5632 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R5633 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R5634 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R5635 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R5636 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R5637 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R5638 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R5639 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R5640 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R5641 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R5642 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R5643 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R5644 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R5645 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R5646 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R5647 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R5648 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R5649 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R5650 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R5651 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R5652 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R5653 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R5654 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R5655 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R5656 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R5657 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R5658 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R5659 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R5660 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R5661 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R5662 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R5663 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R5664 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R5665 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R5666 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R5667 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R5668 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R5669 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R5670 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R5671 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R5672 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R5673 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R5674 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R5675 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R5676 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R5677 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R5678 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R5679 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R5680 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R5681 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R5682 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R5683 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R5684 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R5685 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R5686 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R5687 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R5688 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R5689 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R5690 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R5691 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R5692 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R5693 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R5694 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R5695 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R5696 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R5697 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R5698 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R5699 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R5700 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R5701 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R5702 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R5703 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R5704 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R5705 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R5706 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R5707 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R5708 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R5709 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R5710 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R5711 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R5712 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R5713 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R5714 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R5715 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R5716 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R5717 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R5718 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R5719 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R5720 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R5721 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R5722 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R5723 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R5724 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R5725 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R5726 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R5727 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R5728 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R5729 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R5730 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R5731 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R5732 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R5733 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R5734 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R5735 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R5736 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R5737 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R5738 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R5739 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R5740 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R5741 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R5742 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R5743 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R5744 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R5745 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R5746 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R5747 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R5748 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R5749 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R5750 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R5751 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R5752 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R5753 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R5754 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R5755 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R5756 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R5757 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R5758 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R5759 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R5760 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R5761 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R5762 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R5763 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R5764 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R5765 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R5766 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R5767 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R5768 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R5769 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R5770 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R5771 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R5772 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R5773 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R5774 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R5775 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R5776 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R5777 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R5778 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R5779 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R5780 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R5781 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R5782 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R5783 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R5784 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R5785 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R5786 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R5787 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R5788 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R5789 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R5790 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R5791 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R5792 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R5793 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R5794 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R5795 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R5796 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R5797 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R5798 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R5799 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R5800 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R5801 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R5802 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R5803 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R5804 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R5805 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R5806 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R5807 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R5808 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R5809 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R5810 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R5811 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R5812 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R5813 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R5814 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R5815 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R5816 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R5817 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R5818 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R5819 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R5820 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R5821 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R5822 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R5823 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R5824 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R5825 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R5826 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R5827 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R5828 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R5829 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R5830 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R5831 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R5832 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R5833 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R5834 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R5835 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R5836 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R5837 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R5838 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R5839 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R5840 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R5841 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R5842 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R5843 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R5844 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R5845 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R5846 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R5847 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R5848 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R5849 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R5850 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R5851 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R5852 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R5853 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R5854 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R5855 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R5856 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R5857 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R5858 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R5859 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R5860 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R5861 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R5862 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R5863 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R5864 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R5865 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R5866 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R5867 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R5868 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R5869 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R5870 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R5871 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R5872 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R5873 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R5874 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R5875 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R5876 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R5877 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R5878 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R5879 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R5880 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R5881 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R5882 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R5883 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R5884 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R5885 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R5886 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R5887 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R5888 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R5889 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R5890 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R5891 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R5892 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R5893 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R5894 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R5895 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R5896 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R5897 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R5898 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R5899 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R5900 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R5901 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R5902 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R5903 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R5904 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R5905 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R5906 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R5907 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R5908 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R5909 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R5910 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R5911 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R5912 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R5913 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R5914 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R5915 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R5916 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R5917 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R5918 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R5919 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R5920 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R5921 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R5922 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R5923 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R5924 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R5925 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R5926 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R5927 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R5928 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R5929 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R5930 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R5931 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R5932 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R5933 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R5934 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R5935 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R5936 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R5937 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R5938 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R5939 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R5940 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R5941 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R5942 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R5943 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R5944 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R5945 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R5946 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R5947 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R5948 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R5949 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R5950 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R5951 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R5952 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R5953 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R5954 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R5955 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R5956 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R5957 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R5958 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R5959 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R5960 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R5961 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R5962 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R5963 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R5964 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R5965 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R5966 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R5967 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R5968 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R5969 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R5970 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R5971 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R5972 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R5973 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R5974 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R5975 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R5976 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R5977 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R5978 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R5979 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R5980 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R5981 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R5982 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R5983 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R5984 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R5985 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R5986 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R5987 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R5988 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R5989 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R5990 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R5991 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R5992 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R5993 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R5994 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R5995 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R5996 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R5997 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R5998 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R5999 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R6000 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R6001 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R6002 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R6003 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R6004 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R6005 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R6006 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R6007 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R6008 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R6009 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R6010 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R6011 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R6012 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R6013 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R6014 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R6015 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R6016 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R6017 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R6018 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R6019 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R6020 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R6021 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R6022 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R6023 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R6024 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R6025 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R6026 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R6027 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R6028 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R6029 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R6030 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R6031 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R6032 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R6033 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R6034 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R6035 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R6036 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R6037 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R6038 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R6039 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R6040 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R6041 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R6042 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R6043 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R6044 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R6045 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R6046 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R6047 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R6048 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R6049 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R6050 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R6051 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R6052 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R6053 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R6054 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R6055 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R6056 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R6057 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R6058 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R6059 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R6060 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R6061 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R6062 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R6063 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R6064 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R6065 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R6066 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R6067 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R6068 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R6069 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R6070 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R6071 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R6072 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R6073 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R6074 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R6075 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R6076 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R6077 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R6078 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R6079 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R6080 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R6081 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R6082 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R6083 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R6084 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R6085 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R6086 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R6087 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R6088 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R6089 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R6090 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R6091 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R6092 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R6093 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R6094 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R6095 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R6096 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R6097 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R6098 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R6099 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R6100 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R6101 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R6102 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R6103 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R6104 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R6105 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R6106 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R6107 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R6108 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R6109 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R6110 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R6111 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R6112 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R6113 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R6114 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R6115 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R6116 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R6117 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R6118 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R6119 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R6120 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R6121 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R6122 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R6123 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R6124 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R6125 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R6126 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R6127 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R6128 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R6129 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R6130 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R6131 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R6132 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R6133 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R6134 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R6135 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R6136 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R6137 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R6138 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R6139 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R6140 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R6141 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R6142 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R6143 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R6144 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R6145 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R6146 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R6147 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R6148 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R6149 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R6150 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R6151 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R6152 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R6153 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R6154 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R6155 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R6156 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R6157 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R6158 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R6159 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R6160 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R6161 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R6162 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R6163 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R6164 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R6165 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R6166 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R6167 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R6168 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R6169 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R6170 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R6171 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R6172 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R6173 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R6174 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R6175 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R6176 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R6177 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R6178 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R6179 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R6180 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R6181 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R6182 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R6183 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R6184 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R6185 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R6186 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R6187 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R6188 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R6189 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R6190 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R6191 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R6192 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R6193 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R6194 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R6195 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R6196 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R6197 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R6198 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R6199 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R6200 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R6201 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R6202 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R6203 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R6204 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R6205 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R6206 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R6207 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R6208 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R6209 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R6210 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R6211 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R6212 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R6213 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R6214 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R6215 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R6216 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R6217 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R6218 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R6219 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R6220 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R6221 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R6222 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R6223 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R6224 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R6225 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R6226 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R6227 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R6228 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R6229 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R6230 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R6231 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R6232 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R6233 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R6234 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R6235 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R6236 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R6237 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R6238 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R6239 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R6240 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R6241 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R6242 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R6243 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R6244 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R6245 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R6246 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R6247 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R6248 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R6249 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R6250 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R6251 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R6252 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R6253 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R6254 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R6255 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R6256 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R6257 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R6258 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R6259 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R6260 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R6261 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R6262 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R6263 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R6264 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R6265 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R6266 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R6267 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R6268 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R6269 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R6270 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R6271 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R6272 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R6273 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R6274 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R6275 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R6276 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R6277 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R6278 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R6279 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R6280 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R6281 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R6282 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R6283 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R6284 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R6285 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R6286 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R6287 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R6288 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R6289 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R6290 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R6291 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R6292 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R6293 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R6294 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R6295 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R6296 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R6297 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R6298 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R6299 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R6300 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R6301 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R6302 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R6303 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R6304 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R6305 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R6306 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R6307 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R6308 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R6309 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R6310 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R6311 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R6312 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R6313 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R6314 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R6315 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R6316 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R6317 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R6318 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R6319 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R6320 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R6321 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R6322 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R6323 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R6324 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R6325 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R6326 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R6327 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R6328 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R6329 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R6330 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R6331 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R6332 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R6333 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R6334 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R6335 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R6336 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R6337 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R6338 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R6339 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R6340 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R6341 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R6342 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R6343 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R6344 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R6345 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R6346 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R6347 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R6348 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R6349 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R6350 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R6351 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R6352 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R6353 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R6354 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R6355 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R6356 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R6357 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R6358 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R6359 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R6360 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R6361 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R6362 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R6363 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R6364 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R6365 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R6366 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R6367 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R6368 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R6369 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R6370 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R6371 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R6372 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R6373 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R6374 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R6375 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R6376 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R6377 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R6378 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R6379 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R6380 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R6381 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R6382 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R6383 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R6384 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R6385 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R6386 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R6387 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R6388 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R6389 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R6390 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R6391 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R6392 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R6393 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R6394 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R6395 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R6396 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R6397 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R6398 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R6399 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R6400 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R6401 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R6402 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R6403 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R6404 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R6405 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R6406 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R6407 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R6408 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R6409 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R6410 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R6411 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R6412 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R6413 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R6414 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R6415 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R6416 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R6417 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R6418 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R6419 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R6420 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R6421 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R6422 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R6423 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R6424 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R6425 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R6426 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R6427 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R6428 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R6429 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R6430 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R6431 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R6432 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R6433 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R6434 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R6435 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R6436 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R6437 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R6438 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R6439 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R6440 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R6441 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R6442 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R6443 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R6444 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R6445 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R6446 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R6447 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R6448 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R6449 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R6450 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R6451 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R6452 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R6453 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R6454 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R6455 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R6456 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R6457 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R6458 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R6459 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R6460 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R6461 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R6462 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R6463 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R6464 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R6465 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R6466 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R6467 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R6468 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R6469 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R6470 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R6471 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R6472 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R6473 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R6474 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R6475 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R6476 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R6477 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R6478 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R6479 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R6480 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R6481 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R6482 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R6483 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R6484 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R6485 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R6486 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R6487 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R6488 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R6489 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R6490 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R6491 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R6492 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R6493 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R6494 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R6495 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R6496 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R6497 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R6498 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R6499 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R6500 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R6501 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R6502 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R6503 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R6504 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R6505 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R6506 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R6507 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R6508 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R6509 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R6510 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R6511 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R6512 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R6513 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R6514 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R6515 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R6516 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R6517 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R6518 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R6519 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R6520 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R6521 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R6522 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R6523 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R6524 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R6525 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R6526 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R6527 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R6528 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R6529 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R6530 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R6531 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R6532 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R6533 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R6534 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R6535 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R6536 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R6537 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R6538 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R6539 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R6540 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R6541 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R6542 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R6543 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R6544 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R6545 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R6546 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R6547 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R6548 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R6549 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R6550 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R6551 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R6552 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R6553 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R6554 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R6555 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R6556 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R6557 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R6558 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R6559 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R6560 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R6561 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R6562 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R6563 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R6564 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R6565 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R6566 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R6567 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R6568 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R6569 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R6570 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R6571 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R6572 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R6573 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R6574 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R6575 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R6576 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R6577 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R6578 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R6579 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R6580 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R6581 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R6582 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R6583 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R6584 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R6585 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R6586 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R6587 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R6588 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R6589 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R6590 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R6591 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R6592 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R6593 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R6594 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R6595 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R6596 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R6597 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R6598 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R6599 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R6600 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R6601 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R6602 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R6603 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R6604 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R6605 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R6606 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R6607 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R6608 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R6609 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R6610 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R6611 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R6612 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R6613 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R6614 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R6615 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R6616 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R6617 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R6618 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R6619 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R6620 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R6621 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R6622 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R6623 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R6624 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R6625 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R6626 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R6627 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R6628 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R6629 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R6630 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R6631 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R6632 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R6633 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R6634 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R6635 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R6636 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R6637 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R6638 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R6639 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R6640 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R6641 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R6642 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R6643 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R6644 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R6645 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R6646 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R6647 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R6648 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R6649 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R6650 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R6651 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R6652 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R6653 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R6654 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R6655 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R6656 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R6657 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R6658 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R6659 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R6660 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R6661 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R6662 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R6663 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R6664 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R6665 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R6666 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R6667 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R6668 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R6669 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R6670 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R6671 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R6672 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R6673 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R6674 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R6675 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R6676 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R6677 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R6678 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R6679 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R6680 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R6681 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R6682 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R6683 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R6684 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R6685 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R6686 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R6687 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R6688 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R6689 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R6690 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R6691 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R6692 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R6693 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R6694 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R6695 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R6696 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R6697 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R6698 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R6699 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R6700 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R6701 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R6702 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R6703 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R6704 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R6705 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R6706 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R6707 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R6708 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R6709 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R6710 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R6711 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R6712 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R6713 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R6714 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R6715 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R6716 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R6717 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R6718 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R6719 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R6720 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R6721 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R6722 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R6723 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R6724 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R6725 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R6726 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R6727 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R6728 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R6729 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R6730 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R6731 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R6732 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R6733 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R6734 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R6735 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R6736 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R6737 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R6738 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R6739 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R6740 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R6741 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R6742 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R6743 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R6744 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R6745 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R6746 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R6747 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R6748 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R6749 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R6750 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R6751 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R6752 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R6753 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R6754 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R6755 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R6756 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R6757 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R6758 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R6759 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R6760 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R6761 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R6762 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R6763 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R6764 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R6765 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R6766 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R6767 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R6768 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R6769 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R6770 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R6771 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R6772 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R6773 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R6774 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R6775 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R6776 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R6777 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R6778 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R6779 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R6780 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R6781 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R6782 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R6783 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R6784 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R6785 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R6786 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R6787 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R6788 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R6789 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R6790 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R6791 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R6792 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R6793 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R6794 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R6795 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R6796 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R6797 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R6798 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R6799 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R6800 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R6801 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R6802 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R6803 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R6804 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R6805 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R6806 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R6807 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R6808 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R6809 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R6810 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R6811 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R6812 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R6813 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R6814 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R6815 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R6816 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R6817 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R6818 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R6819 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R6820 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R6821 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R6822 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R6823 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R6824 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R6825 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R6826 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R6827 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R6828 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R6829 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R6830 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R6831 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R6832 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R6833 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R6834 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R6835 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R6836 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R6837 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R6838 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R6839 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R6840 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R6841 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R6842 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R6843 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R6844 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R6845 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R6846 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R6847 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R6848 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R6849 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R6850 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R6851 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R6852 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R6853 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R6854 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R6855 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R6856 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R6857 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R6858 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R6859 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R6860 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R6861 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R6862 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R6863 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R6864 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R6865 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R6866 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R6867 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R6868 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R6869 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R6870 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R6871 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R6872 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R6873 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R6874 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R6875 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R6876 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R6877 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R6878 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R6879 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R6880 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R6881 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R6882 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R6883 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R6884 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R6885 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R6886 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R6887 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R6888 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R6889 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R6890 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R6891 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R6892 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R6893 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R6894 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R6895 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R6896 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R6897 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R6898 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R6899 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R6900 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R6901 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R6902 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R6903 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R6904 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R6905 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R6906 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R6907 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R6908 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R6909 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R6910 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R6911 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R6912 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R6913 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R6914 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R6915 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R6916 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R6917 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R6918 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R6919 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R6920 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R6921 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R6922 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R6923 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R6924 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R6925 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R6926 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R6927 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R6928 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R6929 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R6930 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R6931 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R6932 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R6933 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R6934 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R6935 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R6936 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R6937 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R6938 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R6939 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R6940 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R6941 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R6942 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R6943 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R6944 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R6945 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R6946 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R6947 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R6948 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R6949 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R6950 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R6951 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R6952 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R6953 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R6954 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R6955 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R6956 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R6957 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R6958 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R6959 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R6960 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R6961 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R6962 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R6963 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R6964 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R6965 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R6966 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R6967 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R6968 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R6969 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R6970 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R6971 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R6972 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R6973 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R6974 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R6975 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R6976 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R6977 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R6978 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R6979 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R6980 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R6981 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R6982 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R6983 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R6984 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R6985 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R6986 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R6987 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R6988 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R6989 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R6990 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R6991 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R6992 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R6993 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R6994 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R6995 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R6996 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R6997 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R6998 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R6999 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R7000 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R7001 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R7002 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R7003 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R7004 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R7005 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R7006 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R7007 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R7008 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R7009 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R7010 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R7011 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R7012 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R7013 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R7014 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R7015 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R7016 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R7017 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R7018 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R7019 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R7020 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R7021 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R7022 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R7023 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R7024 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R7025 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R7026 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R7027 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R7028 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R7029 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R7030 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R7031 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R7032 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R7033 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R7034 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R7035 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R7036 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R7037 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R7038 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R7039 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R7040 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R7041 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R7042 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R7043 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R7044 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R7045 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R7046 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R7047 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R7048 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R7049 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R7050 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R7051 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R7052 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R7053 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R7054 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R7055 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R7056 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R7057 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R7058 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R7059 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R7060 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R7061 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R7062 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R7063 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R7064 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R7065 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R7066 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R7067 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R7068 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R7069 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R7070 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R7071 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R7072 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R7073 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R7074 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R7075 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R7076 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R7077 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R7078 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R7079 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R7080 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R7081 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R7082 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R7083 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R7084 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R7085 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R7086 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R7087 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R7088 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R7089 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R7090 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R7091 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R7092 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R7093 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R7094 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R7095 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R7096 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R7097 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R7098 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R7099 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R7100 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R7101 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R7102 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R7103 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R7104 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R7105 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R7106 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R7107 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R7108 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R7109 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R7110 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R7111 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R7112 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R7113 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R7114 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R7115 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R7116 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R7117 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R7118 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R7119 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R7120 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R7121 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R7122 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R7123 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R7124 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R7125 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R7126 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R7127 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R7128 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R7129 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R7130 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R7131 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R7132 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R7133 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R7134 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R7135 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R7136 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R7137 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R7138 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R7139 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R7140 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R7141 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R7142 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R7143 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R7144 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R7145 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R7146 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R7147 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R7148 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R7149 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R7150 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R7151 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R7152 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R7153 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R7154 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R7155 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R7156 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R7157 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R7158 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R7159 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R7160 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R7161 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R7162 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R7163 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R7164 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R7165 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R7166 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R7167 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R7168 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R7169 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R7170 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R7171 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R7172 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R7173 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R7174 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R7175 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R7176 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R7177 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R7178 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R7179 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R7180 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R7181 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R7182 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R7183 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R7184 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R7185 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R7186 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R7187 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R7188 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R7189 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R7190 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R7191 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R7192 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R7193 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R7194 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R7195 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R7196 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R7197 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R7198 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R7199 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R7200 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R7201 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R7202 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R7203 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R7204 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R7205 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R7206 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R7207 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R7208 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R7209 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R7210 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R7211 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R7212 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R7213 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R7214 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R7215 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R7216 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R7217 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R7218 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R7219 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R7220 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R7221 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R7222 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R7223 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R7224 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R7225 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R7226 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R7227 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R7228 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R7229 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R7230 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R7231 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R7232 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R7233 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R7234 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R7235 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R7236 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R7237 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R7238 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R7239 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R7240 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R7241 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R7242 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R7243 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R7244 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R7245 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R7246 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R7247 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R7248 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R7249 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R7250 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R7251 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R7252 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R7253 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R7254 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R7255 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R7256 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R7257 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R7258 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R7259 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R7260 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R7261 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R7262 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R7263 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R7264 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R7265 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R7266 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R7267 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R7268 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R7269 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R7270 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R7271 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R7272 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R7273 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R7274 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R7275 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R7276 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R7277 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R7278 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R7279 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R7280 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R7281 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R7282 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R7283 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R7284 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R7285 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R7286 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R7287 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R7288 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R7289 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R7290 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R7291 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R7292 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R7293 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R7294 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R7295 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R7296 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R7297 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R7298 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R7299 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R7300 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R7301 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R7302 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R7303 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R7304 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R7305 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R7306 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R7307 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R7308 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R7309 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R7310 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R7311 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R7312 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R7313 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R7314 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R7315 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R7316 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R7317 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R7318 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R7319 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R7320 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R7321 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R7322 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R7323 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R7324 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R7325 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R7326 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R7327 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R7328 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R7329 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R7330 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R7331 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R7332 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R7333 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R7334 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R7335 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R7336 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R7337 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R7338 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R7339 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R7340 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R7341 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R7342 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R7343 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R7344 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R7345 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R7346 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R7347 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R7348 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R7349 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R7350 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R7351 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R7352 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R7353 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R7354 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R7355 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R7356 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R7357 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R7358 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R7359 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R7360 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R7361 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R7362 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R7363 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R7364 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R7365 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R7366 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R7367 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R7368 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R7369 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R7370 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R7371 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R7372 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R7373 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R7374 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R7375 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R7376 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R7377 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R7378 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R7379 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R7380 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R7381 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R7382 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R7383 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R7384 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R7385 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R7386 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R7387 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R7388 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R7389 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R7390 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R7391 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R7392 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R7393 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R7394 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R7395 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R7396 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R7397 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R7398 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R7399 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R7400 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R7401 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R7402 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R7403 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R7404 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R7405 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R7406 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R7407 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R7408 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R7409 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R7410 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R7411 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R7412 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R7413 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R7414 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R7415 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R7416 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R7417 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R7418 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R7419 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R7420 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R7421 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R7422 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R7423 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R7424 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R7425 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R7426 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R7427 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R7428 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R7429 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R7430 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R7431 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R7432 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R7433 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R7434 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R7435 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R7436 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R7437 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R7438 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R7439 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R7440 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R7441 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R7442 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R7443 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R7444 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R7445 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R7446 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R7447 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R7448 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R7449 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R7450 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R7451 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R7452 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R7453 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R7454 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R7455 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R7456 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R7457 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R7458 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R7459 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R7460 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R7461 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R7462 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R7463 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R7464 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R7465 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R7466 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R7467 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R7468 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R7469 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R7470 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R7471 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R7472 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R7473 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R7474 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R7475 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R7476 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R7477 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R7478 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R7479 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R7480 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R7481 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R7482 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R7483 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R7484 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R7485 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R7486 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R7487 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R7488 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R7489 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R7490 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R7491 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R7492 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R7493 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R7494 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R7495 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R7496 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R7497 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R7498 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R7499 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R7500 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R7501 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R7502 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R7503 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R7504 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R7505 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R7506 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R7507 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R7508 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R7509 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R7510 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R7511 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R7512 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R7513 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R7514 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R7515 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R7516 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R7517 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R7518 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R7519 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R7520 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R7521 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R7522 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R7523 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R7524 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R7525 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R7526 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R7527 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R7528 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R7529 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R7530 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R7531 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R7532 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R7533 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R7534 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R7535 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R7536 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R7537 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R7538 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R7539 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R7540 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R7541 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R7542 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R7543 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R7544 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R7545 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R7546 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R7547 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R7548 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R7549 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R7550 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R7551 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R7552 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R7553 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R7554 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R7555 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R7556 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R7557 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R7558 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R7559 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R7560 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R7561 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R7562 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R7563 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R7564 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R7565 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R7566 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R7567 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R7568 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R7569 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R7570 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R7571 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R7572 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R7573 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R7574 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R7575 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R7576 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R7577 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R7578 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R7579 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R7580 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R7581 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R7582 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R7583 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R7584 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R7585 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R7586 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R7587 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R7588 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R7589 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R7590 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R7591 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R7592 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R7593 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R7594 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R7595 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R7596 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R7597 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R7598 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R7599 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R7600 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R7601 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R7602 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R7603 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R7604 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R7605 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R7606 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R7607 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R7608 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R7609 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R7610 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R7611 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R7612 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R7613 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R7614 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R7615 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R7616 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R7617 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R7618 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R7619 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R7620 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R7621 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R7622 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R7623 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R7624 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R7625 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R7626 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R7627 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R7628 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R7629 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R7630 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R7631 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R7632 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R7633 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R7634 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R7635 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R7636 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R7637 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R7638 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R7639 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R7640 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R7641 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R7642 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R7643 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R7644 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R7645 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R7646 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R7647 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R7648 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R7649 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R7650 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R7651 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R7652 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R7653 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R7654 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R7655 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R7656 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R7657 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R7658 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R7659 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R7660 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R7661 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R7662 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R7663 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R7664 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R7665 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R7666 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R7667 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R7668 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R7669 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R7670 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R7671 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R7672 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R7673 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R7674 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R7675 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R7676 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R7677 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R7678 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R7679 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R7680 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R7681 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R7682 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R7683 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R7684 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R7685 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R7686 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R7687 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R7688 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R7689 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R7690 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R7691 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R7692 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R7693 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R7694 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R7695 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R7696 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R7697 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R7698 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R7699 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R7700 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R7701 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R7702 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R7703 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R7704 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R7705 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R7706 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R7707 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R7708 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R7709 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R7710 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R7711 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R7712 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R7713 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R7714 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R7715 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R7716 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R7717 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R7718 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R7719 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R7720 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R7721 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R7722 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R7723 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R7724 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R7725 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R7726 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R7727 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R7728 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R7729 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R7730 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R7731 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R7732 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R7733 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R7734 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R7735 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R7736 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R7737 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R7738 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R7739 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R7740 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R7741 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R7742 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R7743 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R7744 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R7745 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R7746 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R7747 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R7748 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R7749 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R7750 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R7751 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R7752 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R7753 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R7754 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R7755 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R7756 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R7757 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R7758 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R7759 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R7760 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R7761 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R7762 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R7763 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R7764 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R7765 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R7766 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R7767 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R7768 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R7769 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R7770 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R7771 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R7772 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R7773 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R7774 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R7775 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R7776 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R7777 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R7778 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R7779 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R7780 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R7781 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R7782 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R7783 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R7784 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R7785 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R7786 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R7787 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R7788 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R7789 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R7790 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R7791 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R7792 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R7793 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R7794 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R7795 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R7796 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R7797 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R7798 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R7799 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R7800 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R7801 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R7802 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R7803 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R7804 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R7805 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R7806 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R7807 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R7808 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R7809 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R7810 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R7811 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R7812 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R7813 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R7814 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R7815 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R7816 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R7817 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R7818 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R7819 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R7820 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R7821 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R7822 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R7823 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R7824 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R7825 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R7826 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R7827 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R7828 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R7829 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R7830 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R7831 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R7832 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R7833 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R7834 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R7835 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R7836 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R7837 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R7838 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R7839 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R7840 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R7841 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R7842 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R7843 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R7844 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R7845 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R7846 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R7847 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R7848 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R7849 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R7850 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R7851 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R7852 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R7853 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R7854 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R7855 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R7856 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R7857 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R7858 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R7859 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R7860 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R7861 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R7862 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R7863 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R7864 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R7865 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R7866 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R7867 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R7868 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R7869 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R7870 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R7871 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R7872 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R7873 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R7874 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R7875 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R7876 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R7877 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R7878 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R7879 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R7880 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R7881 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R7882 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R7883 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R7884 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R7885 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R7886 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R7887 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R7888 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R7889 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R7890 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R7891 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R7892 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R7893 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R7894 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R7895 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R7896 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R7897 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R7898 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R7899 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R7900 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R7901 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R7902 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R7903 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R7904 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R7905 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R7906 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R7907 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R7908 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R7909 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R7910 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R7911 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R7912 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R7913 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R7914 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R7915 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R7916 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R7917 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R7918 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R7919 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R7920 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R7921 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R7922 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R7923 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R7924 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R7925 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R7926 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R7927 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R7928 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R7929 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R7930 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R7931 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R7932 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R7933 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R7934 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R7935 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R7936 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R7937 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R7938 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R7939 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R7940 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R7941 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R7942 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R7943 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R7944 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R7945 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R7946 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R7947 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R7948 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R7949 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R7950 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R7951 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R7952 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R7953 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R7954 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R7955 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R7956 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R7957 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R7958 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R7959 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R7960 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R7961 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R7962 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R7963 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R7964 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R7965 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R7966 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R7967 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R7968 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R7969 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R7970 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R7971 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R7972 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R7973 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R7974 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R7975 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R7976 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R7977 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R7978 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R7979 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R7980 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R7981 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R7982 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R7983 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R7984 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R7985 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R7986 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R7987 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R7988 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R7989 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R7990 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R7991 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R7992 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R7993 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R7994 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R7995 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R7996 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R7997 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R7998 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R7999 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R8000 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R8001 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R8002 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R8003 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R8004 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R8005 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R8006 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R8007 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R8008 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R8009 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R8010 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R8011 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R8012 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R8013 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R8014 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R8015 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R8016 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R8017 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R8018 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R8019 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R8020 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R8021 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R8022 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R8023 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R8024 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R8025 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R8026 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R8027 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R8028 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R8029 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R8030 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R8031 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R8032 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R8033 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R8034 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R8035 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R8036 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R8037 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R8038 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R8039 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R8040 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R8041 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R8042 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R8043 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R8044 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R8045 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R8046 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R8047 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R8048 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R8049 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R8050 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R8051 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R8052 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R8053 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R8054 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R8055 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R8056 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R8057 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R8058 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R8059 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R8060 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R8061 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R8062 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R8063 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R8064 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R8065 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R8066 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R8067 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R8068 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R8069 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R8070 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R8071 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R8072 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R8073 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R8074 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R8075 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R8076 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R8077 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R8078 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R8079 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R8080 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R8081 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R8082 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R8083 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R8084 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R8085 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R8086 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R8087 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R8088 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R8089 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R8090 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R8091 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R8092 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R8093 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R8094 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R8095 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R8096 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R8097 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R8098 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R8099 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R8100 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R8101 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R8102 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R8103 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R8104 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R8105 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R8106 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R8107 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R8108 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R8109 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R8110 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R8111 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R8112 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R8113 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R8114 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R8115 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R8116 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R8117 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R8118 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R8119 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R8120 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R8121 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R8122 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R8123 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R8124 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R8125 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R8126 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R8127 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R8128 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R8129 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R8130 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R8131 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R8132 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R8133 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R8134 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R8135 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R8136 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R8137 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R8138 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R8139 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R8140 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R8141 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R8142 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R8143 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R8144 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R8145 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R8146 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R8147 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R8148 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R8149 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R8150 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R8151 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R8152 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R8153 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R8154 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R8155 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R8156 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R8157 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R8158 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R8159 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R8160 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R8161 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R8162 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R8163 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R8164 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R8165 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R8166 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R8167 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R8168 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R8169 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R8170 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R8171 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R8172 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R8173 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R8174 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R8175 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R8176 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R8177 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R8178 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R8179 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R8180 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R8181 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R8182 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R8183 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R8184 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R8185 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R8186 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R8187 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R8188 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R8189 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R8190 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R8191 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R8192 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R8193 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R8194 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R8195 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R8196 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R8197 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R8198 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R8199 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R8200 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R8201 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R8202 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R8203 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R8204 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R8205 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R8206 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R8207 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R8208 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R8209 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R8210 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R8211 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R8212 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R8213 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R8214 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R8215 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R8216 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R8217 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R8218 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R8219 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R8220 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R8221 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R8222 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R8223 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R8224 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R8225 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R8226 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R8227 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R8228 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R8229 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R8230 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R8231 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R8232 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R8233 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R8234 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R8235 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R8236 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R8237 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R8238 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R8239 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R8240 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R8241 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R8242 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R8243 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R8244 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R8245 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R8246 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R8247 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R8248 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R8249 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R8250 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R8251 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R8252 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R8253 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R8254 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R8255 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R8256 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R8257 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R8258 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R8259 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R8260 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R8261 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R8262 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R8263 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R8264 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R8265 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R8266 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R8267 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R8268 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R8269 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R8270 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R8271 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R8272 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R8273 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R8274 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R8275 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R8276 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R8277 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R8278 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R8279 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R8280 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R8281 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R8282 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R8283 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R8284 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R8285 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R8286 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R8287 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R8288 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R8289 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R8290 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R8291 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R8292 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R8293 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R8294 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R8295 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R8296 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R8297 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R8298 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R8299 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R8300 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R8301 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R8302 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R8303 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R8304 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R8305 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R8306 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R8307 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R8308 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R8309 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R8310 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R8311 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R8312 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R8313 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R8314 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R8315 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R8316 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R8317 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R8318 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R8319 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R8320 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R8321 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R8322 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R8323 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R8324 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R8325 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R8326 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R8327 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R8328 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R8329 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R8330 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R8331 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R8332 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R8333 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R8334 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R8335 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R8336 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R8337 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R8338 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R8339 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R8340 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R8341 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R8342 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R8343 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R8344 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R8345 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R8346 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R8347 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R8348 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R8349 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R8350 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R8351 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R8352 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R8353 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R8354 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R8355 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R8356 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R8357 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R8358 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R8359 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R8360 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R8361 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R8362 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R8363 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R8364 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R8365 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R8366 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R8367 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R8368 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R8369 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R8370 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R8371 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R8372 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R8373 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R8374 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R8375 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R8376 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R8377 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R8378 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R8379 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R8380 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R8381 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R8382 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R8383 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R8384 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R8385 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R8386 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R8387 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R8388 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R8389 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R8390 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R8391 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R8392 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R8393 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R8394 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R8395 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R8396 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R8397 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R8398 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R8399 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R8400 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R8401 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R8402 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R8403 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R8404 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R8405 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R8406 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R8407 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R8408 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R8409 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R8410 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R8411 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R8412 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R8413 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R8414 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R8415 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R8416 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R8417 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R8418 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R8419 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R8420 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R8421 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R8422 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R8423 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R8424 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R8425 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R8426 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R8427 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R8428 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R8429 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R8430 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R8431 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R8432 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R8433 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R8434 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R8435 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R8436 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R8437 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R8438 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R8439 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R8440 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R8441 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R8442 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R8443 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R8444 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R8445 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R8446 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R8447 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R8448 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R8449 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R8450 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R8451 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R8452 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R8453 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R8454 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R8455 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R8456 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R8457 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R8458 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R8459 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R8460 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R8461 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R8462 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R8463 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R8464 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R8465 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R8466 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R8467 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R8468 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R8469 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R8470 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R8471 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R8472 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R8473 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R8474 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R8475 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R8476 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R8477 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R8478 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R8479 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R8480 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R8481 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R8482 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R8483 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R8484 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R8485 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R8486 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R8487 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R8488 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R8489 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R8490 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R8491 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R8492 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R8493 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R8494 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R8495 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R8496 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R8497 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R8498 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R8499 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R8500 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R8501 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R8502 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R8503 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R8504 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R8505 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R8506 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R8507 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R8508 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R8509 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R8510 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R8511 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R8512 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R8513 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R8514 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R8515 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R8516 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R8517 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R8518 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R8519 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R8520 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R8521 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R8522 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R8523 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R8524 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R8525 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R8526 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R8527 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R8528 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R8529 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R8530 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R8531 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R8532 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R8533 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R8534 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R8535 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R8536 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R8537 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R8538 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R8539 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R8540 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R8541 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R8542 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R8543 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R8544 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R8545 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R8546 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R8547 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R8548 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R8549 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R8550 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R8551 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R8552 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R8553 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R8554 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R8555 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R8556 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R8557 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R8558 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R8559 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R8560 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R8561 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R8562 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R8563 n1_m4_32000_398400 n1_m4_32000_403200 1.400000
R8564 n1_m4_32000_403200 n1_m4_32000_404000 0.233333
R8565 n1_m4_32000_408000 n1_m4_32000_404000 1.166667
R8566 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R8567 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R8568 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R8569 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R8570 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R8571 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R8572 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R8573 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R8574 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R8575 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R8576 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R8577 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R8578 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R8579 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R8580 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R8581 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R8582 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R8583 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R8584 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R8585 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R8586 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R8587 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R8588 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R8589 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R8590 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R8591 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R8592 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R8593 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R8594 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R8595 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R8596 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R8597 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R8598 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R8599 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R8600 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R8601 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R8602 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R8603 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R8604 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R8605 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R8606 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R8607 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R8608 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R8609 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R8610 n1_m4_60000_398400 n1_m4_60000_403200 1.400000
R8611 n1_m4_60000_403200 n1_m4_60000_404000 0.233333
R8612 n1_m4_60000_408000 n1_m4_60000_404000 1.166667
R8613 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R8614 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R8615 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R8616 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R8617 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R8618 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R8619 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R8620 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R8621 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R8622 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R8623 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R8624 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R8625 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R8626 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R8627 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R8628 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R8629 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R8630 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R8631 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R8632 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R8633 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R8634 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R8635 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R8636 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R8637 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R8638 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R8639 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R8640 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R8641 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R8642 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R8643 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R8644 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R8645 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R8646 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R8647 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R8648 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R8649 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R8650 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R8651 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R8652 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R8653 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R8654 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R8655 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R8656 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R8657 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R8658 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R8659 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R8660 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R8661 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R8662 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R8663 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R8664 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R8665 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R8666 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R8667 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R8668 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R8669 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R8670 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R8671 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R8672 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R8673 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R8674 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R8675 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R8676 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R8677 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R8678 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R8679 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R8680 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R8681 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R8682 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R8683 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R8684 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R8685 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R8686 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R8687 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R8688 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R8689 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R8690 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R8691 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R8692 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R8693 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R8694 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R8695 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R8696 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R8697 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R8698 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R8699 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R8700 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R8701 n1_m4_88000_398400 n1_m4_88000_403200 1.400000
R8702 n1_m4_88000_403200 n1_m4_88000_404000 0.233333
R8703 n1_m4_88000_408000 n1_m4_88000_404000 1.166667
R8704 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R8705 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R8706 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R8707 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R8708 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R8709 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R8710 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R8711 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R8712 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R8713 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R8714 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R8715 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R8716 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R8717 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R8718 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R8719 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R8720 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R8721 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R8722 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R8723 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R8724 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R8725 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R8726 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R8727 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R8728 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R8729 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R8730 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R8731 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R8732 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R8733 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R8734 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R8735 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R8736 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R8737 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R8738 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R8739 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R8740 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R8741 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R8742 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R8743 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R8744 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R8745 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R8746 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R8747 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R8748 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R8749 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R8750 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R8751 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R8752 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R8753 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R8754 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R8755 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R8756 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R8757 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R8758 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R8759 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R8760 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R8761 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R8762 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R8763 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R8764 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R8765 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R8766 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R8767 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R8768 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R8769 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R8770 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R8771 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R8772 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R8773 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R8774 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R8775 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R8776 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R8777 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R8778 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R8779 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R8780 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R8781 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R8782 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R8783 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R8784 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R8785 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R8786 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R8787 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R8788 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R8789 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R8790 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R8791 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R8792 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R8793 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R8794 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R8795 n1_m4_144000_398400 n1_m4_144000_403200 1.400000
R8796 n1_m4_144000_403200 n1_m4_144000_404000 0.233333
R8797 n1_m4_144000_408000 n1_m4_144000_404000 1.166667
R8798 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R8799 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R8800 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R8801 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R8802 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R8803 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R8804 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R8805 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R8806 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R8807 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R8808 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R8809 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R8810 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R8811 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R8812 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R8813 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R8814 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R8815 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R8816 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R8817 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R8818 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R8819 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R8820 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R8821 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R8822 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R8823 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R8824 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R8825 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R8826 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R8827 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R8828 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R8829 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R8830 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R8831 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R8832 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R8833 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R8834 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R8835 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R8836 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R8837 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R8838 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R8839 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R8840 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R8841 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R8842 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R8843 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R8844 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R8845 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R8846 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R8847 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R8848 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R8849 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R8850 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R8851 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R8852 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R8853 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R8854 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R8855 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R8856 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R8857 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R8858 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R8859 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R8860 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R8861 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R8862 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R8863 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R8864 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R8865 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R8866 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R8867 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R8868 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R8869 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R8870 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R8871 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R8872 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R8873 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R8874 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R8875 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R8876 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R8877 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R8878 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R8879 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R8880 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R8881 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R8882 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R8883 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R8884 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R8885 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R8886 n1_m4_172000_398400 n1_m4_172000_403200 1.400000
R8887 n1_m4_172000_403200 n1_m4_172000_404000 0.233333
R8888 n1_m4_172000_408000 n1_m4_172000_404000 1.166667
R8889 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R8890 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R8891 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R8892 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R8893 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R8894 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R8895 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R8896 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R8897 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R8898 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R8899 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R8900 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R8901 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R8902 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R8903 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R8904 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R8905 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R8906 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R8907 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R8908 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R8909 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R8910 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R8911 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R8912 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R8913 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R8914 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R8915 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R8916 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R8917 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R8918 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R8919 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R8920 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R8921 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R8922 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R8923 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R8924 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R8925 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R8926 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R8927 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R8928 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R8929 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R8930 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R8931 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R8932 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R8933 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R8934 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R8935 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R8936 n1_m4_228000_398400 n1_m4_228000_403200 1.400000
R8937 n1_m4_228000_403200 n1_m4_228000_404000 0.233333
R8938 n1_m4_228000_408000 n1_m4_228000_404000 1.166667
R8939 n1_m4_256000_0 n1_m4_256000_4000 1.166667
R8940 n1_m4_256000_4800 n1_m4_256000_4000 0.233333
R8941 n1_m4_256000_4800 n1_m4_256000_9600 1.400000
R8942 n1_m4_256000_9600 n1_m4_256000_14400 1.400000
R8943 n1_m4_256000_14400 n1_m4_256000_19200 1.400000
R8944 n1_m4_256000_19200 n1_m4_256000_24000 1.400000
R8945 n1_m4_256000_24000 n1_m4_256000_28800 1.400000
R8946 n1_m4_256000_28800 n1_m4_256000_33600 1.400000
R8947 n1_m4_256000_33600 n1_m4_256000_38400 1.400000
R8948 n1_m4_256000_38400 n1_m4_256000_43200 1.400000
R8949 n1_m4_256000_43200 n1_m4_256000_48000 1.400000
R8950 n1_m4_256000_48000 n1_m4_256000_52800 1.400000
R8951 n1_m4_256000_52800 n1_m4_256000_57600 1.400000
R8952 n1_m4_256000_57600 n1_m4_256000_62400 1.400000
R8953 n1_m4_256000_62400 n1_m4_256000_67200 1.400000
R8954 n1_m4_256000_67200 n1_m4_256000_72000 1.400000
R8955 n1_m4_256000_72000 n1_m4_256000_76800 1.400000
R8956 n1_m4_256000_76800 n1_m4_256000_81600 1.400000
R8957 n1_m4_256000_81600 n1_m4_256000_84000 0.700000
R8958 n1_m4_256000_86400 n1_m4_256000_84000 0.700000
R8959 n1_m4_256000_86400 n1_m4_256000_91200 1.400000
R8960 n1_m4_256000_91200 n1_m4_256000_96000 1.400000
R8961 n1_m4_256000_96000 n1_m4_256000_100800 1.400000
R8962 n1_m4_256000_100800 n1_m4_256000_105600 1.400000
R8963 n1_m4_256000_105600 n1_m4_256000_110400 1.400000
R8964 n1_m4_256000_110400 n1_m4_256000_115200 1.400000
R8965 n1_m4_256000_115200 n1_m4_256000_120000 1.400000
R8966 n1_m4_256000_120000 n1_m4_256000_124800 1.400000
R8967 n1_m4_256000_124800 n1_m4_256000_129600 1.400000
R8968 n1_m4_256000_129600 n1_m4_256000_134400 1.400000
R8969 n1_m4_256000_134400 n1_m4_256000_139200 1.400000
R8970 n1_m4_256000_139200 n1_m4_256000_144000 1.400000
R8971 n1_m4_256000_144000 n1_m4_256000_148800 1.400000
R8972 n1_m4_256000_148800 n1_m4_256000_153600 1.400000
R8973 n1_m4_256000_153600 n1_m4_256000_158400 1.400000
R8974 n1_m4_256000_158400 n1_m4_256000_163200 1.400000
R8975 n1_m4_256000_163200 n1_m4_256000_164000 0.233333
R8976 n1_m4_256000_168000 n1_m4_256000_164000 1.166667
R8977 n1_m4_256000_168000 n1_m4_256000_172800 1.400000
R8978 n1_m4_256000_172800 n1_m4_256000_177600 1.400000
R8979 n1_m4_256000_177600 n1_m4_256000_182400 1.400000
R8980 n1_m4_256000_182400 n1_m4_256000_187200 1.400000
R8981 n1_m4_256000_187200 n1_m4_256000_192000 1.400000
R8982 n1_m4_256000_192000 n1_m4_256000_196800 1.400000
R8983 n1_m4_256000_398400 n1_m4_256000_403200 1.400000
R8984 n1_m4_256000_403200 n1_m4_256000_404000 0.233333
R8985 n1_m4_256000_408000 n1_m4_256000_404000 1.166667
R8986 n1_m4_284000_398400 n1_m4_284000_403200 1.400000
R8987 n1_m4_284000_403200 n1_m4_284000_404000 0.233333
R8988 n1_m4_284000_408000 n1_m4_284000_404000 1.166667
R8989 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R8990 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R8991 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R8992 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R8993 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R8994 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R8995 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R8996 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R8997 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R8998 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R8999 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R9000 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R9001 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R9002 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R9003 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R9004 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R9005 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R9006 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R9007 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R9008 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R9009 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R9010 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R9011 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R9012 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R9013 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R9014 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R9015 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R9016 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R9017 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R9018 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R9019 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R9020 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R9021 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R9022 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R9023 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R9024 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R9025 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R9026 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R9027 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R9028 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R9029 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R9030 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R9031 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R9032 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R9033 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R9034 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R9035 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R9036 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R9037 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R9038 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R9039 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R9040 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R9041 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R9042 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R9043 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R9044 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R9045 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R9046 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R9047 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R9048 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R9049 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R9050 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R9051 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R9052 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R9053 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R9054 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R9055 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R9056 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R9057 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R9058 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R9059 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R9060 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R9061 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R9062 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R9063 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R9064 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R9065 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R9066 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R9067 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R9068 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R9069 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R9070 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R9071 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R9072 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R9073 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R9074 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R9075 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R9076 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R9077 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R9078 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R9079 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R9080 n1_m4_340000_398400 n1_m4_340000_403200 1.400000
R9081 n1_m4_340000_403200 n1_m4_340000_404000 0.233333
R9082 n1_m4_340000_408000 n1_m4_340000_404000 1.166667
R9083 n1_m4_368000_0 n1_m4_368000_4000 1.166667
R9084 n1_m4_368000_4800 n1_m4_368000_4000 0.233333
R9085 n1_m4_368000_4800 n1_m4_368000_9600 1.400000
R9086 n1_m4_368000_9600 n1_m4_368000_14400 1.400000
R9087 n1_m4_368000_14400 n1_m4_368000_19200 1.400000
R9088 n1_m4_368000_19200 n1_m4_368000_24000 1.400000
R9089 n1_m4_368000_24000 n1_m4_368000_28800 1.400000
R9090 n1_m4_368000_28800 n1_m4_368000_33600 1.400000
R9091 n1_m4_368000_33600 n1_m4_368000_38400 1.400000
R9092 n1_m4_368000_38400 n1_m4_368000_43200 1.400000
R9093 n1_m4_368000_43200 n1_m4_368000_48000 1.400000
R9094 n1_m4_368000_48000 n1_m4_368000_52800 1.400000
R9095 n1_m4_368000_52800 n1_m4_368000_57600 1.400000
R9096 n1_m4_368000_57600 n1_m4_368000_62400 1.400000
R9097 n1_m4_368000_62400 n1_m4_368000_67200 1.400000
R9098 n1_m4_368000_67200 n1_m4_368000_72000 1.400000
R9099 n1_m4_368000_72000 n1_m4_368000_76800 1.400000
R9100 n1_m4_368000_76800 n1_m4_368000_81600 1.400000
R9101 n1_m4_368000_81600 n1_m4_368000_84000 0.700000
R9102 n1_m4_368000_86400 n1_m4_368000_84000 0.700000
R9103 n1_m4_368000_86400 n1_m4_368000_91200 1.400000
R9104 n1_m4_368000_91200 n1_m4_368000_96000 1.400000
R9105 n1_m4_368000_96000 n1_m4_368000_100800 1.400000
R9106 n1_m4_368000_100800 n1_m4_368000_105600 1.400000
R9107 n1_m4_368000_105600 n1_m4_368000_110400 1.400000
R9108 n1_m4_368000_110400 n1_m4_368000_115200 1.400000
R9109 n1_m4_368000_115200 n1_m4_368000_120000 1.400000
R9110 n1_m4_368000_120000 n1_m4_368000_124800 1.400000
R9111 n1_m4_368000_124800 n1_m4_368000_129600 1.400000
R9112 n1_m4_368000_129600 n1_m4_368000_134400 1.400000
R9113 n1_m4_368000_134400 n1_m4_368000_139200 1.400000
R9114 n1_m4_368000_139200 n1_m4_368000_144000 1.400000
R9115 n1_m4_368000_144000 n1_m4_368000_148800 1.400000
R9116 n1_m4_368000_148800 n1_m4_368000_153600 1.400000
R9117 n1_m4_368000_153600 n1_m4_368000_158400 1.400000
R9118 n1_m4_368000_158400 n1_m4_368000_163200 1.400000
R9119 n1_m4_368000_163200 n1_m4_368000_164000 0.233333
R9120 n1_m4_368000_168000 n1_m4_368000_164000 1.166667
R9121 n1_m4_368000_168000 n1_m4_368000_172800 1.400000
R9122 n1_m4_368000_172800 n1_m4_368000_177600 1.400000
R9123 n1_m4_368000_177600 n1_m4_368000_182400 1.400000
R9124 n1_m4_368000_182400 n1_m4_368000_187200 1.400000
R9125 n1_m4_368000_187200 n1_m4_368000_192000 1.400000
R9126 n1_m4_368000_192000 n1_m4_368000_196800 1.400000
R9127 n1_m4_368000_398400 n1_m4_368000_403200 1.400000
R9128 n1_m4_368000_403200 n1_m4_368000_404000 0.233333
R9129 n1_m4_368000_408000 n1_m4_368000_404000 1.166667
R9130 n1_m4_396000_398400 n1_m4_396000_403200 1.400000
R9131 n1_m4_396000_403200 n1_m4_396000_404000 0.233333
R9132 n1_m4_396000_408000 n1_m4_396000_404000 1.166667
R9133 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R9134 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R9135 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R9136 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R9137 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R9138 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R9139 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R9140 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R9141 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R9142 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R9143 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R9144 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R9145 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R9146 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R9147 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R9148 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R9149 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R9150 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R9151 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R9152 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R9153 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R9154 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R9155 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R9156 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R9157 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R9158 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R9159 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R9160 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R9161 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R9162 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R9163 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R9164 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R9165 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R9166 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R9167 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R9168 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R9169 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R9170 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R9171 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R9172 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R9173 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R9174 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R9175 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R9176 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R9177 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R9178 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R9179 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R9180 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R9181 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R9182 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R9183 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R9184 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R9185 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R9186 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R9187 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R9188 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R9189 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R9190 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R9191 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R9192 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R9193 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R9194 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R9195 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R9196 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R9197 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R9198 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R9199 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R9200 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R9201 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R9202 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R9203 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R9204 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R9205 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R9206 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R9207 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R9208 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R9209 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R9210 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R9211 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R9212 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R9213 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R9214 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R9215 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R9216 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R9217 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R9218 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R9219 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R9220 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R9221 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R9222 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R9223 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R9224 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R9225 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R9226 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R9227 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R9228 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R9229 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R9230 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R9231 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R9232 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R9233 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R9234 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R9235 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R9236 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R9237 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R9238 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R9239 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R9240 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R9241 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R9242 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R9243 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R9244 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R9245 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R9246 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R9247 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R9248 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R9249 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R9250 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R9251 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R9252 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R9253 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R9254 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R9255 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R9256 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R9257 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R9258 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R9259 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R9260 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R9261 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R9262 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R9263 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R9264 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R9265 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R9266 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R9267 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R9268 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R9269 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R9270 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R9271 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R9272 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R9273 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R9274 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R9275 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R9276 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R9277 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R9278 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R9279 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R9280 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R9281 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R9282 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R9283 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R9284 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R9285 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R9286 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R9287 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R9288 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R9289 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R9290 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R9291 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R9292 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R9293 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R9294 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R9295 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R9296 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R9297 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R9298 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R9299 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R9300 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R9301 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R9302 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R9303 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R9304 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R9305 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R9306 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R9307 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R9308 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R9309 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R9310 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R9311 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R9312 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R9313 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R9314 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R9315 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R9316 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R9317 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R9318 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R9319 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R9320 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R9321 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R9322 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R9323 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R9324 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R9325 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R9326 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R9327 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R9328 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R9329 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R9330 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R9331 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R9332 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R9333 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R9334 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R9335 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R9336 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R9337 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R9338 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R9339 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R9340 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R9341 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R9342 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R9343 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R9344 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R9345 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R9346 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R9347 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R9348 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R9349 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R9350 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R9351 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R9352 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R9353 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R9354 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R9355 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R9356 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R9357 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R9358 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R9359 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R9360 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R9361 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R9362 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R9363 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R9364 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R9365 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R9366 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R9367 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R9368 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R9369 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R9370 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R9371 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R9372 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R9373 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R9374 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R9375 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R9376 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R9377 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R9378 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R9379 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R9380 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R9381 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R9382 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R9383 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R9384 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R9385 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R9386 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R9387 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R9388 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R9389 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R9390 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R9391 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R9392 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R9393 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R9394 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R9395 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R9396 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R9397 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R9398 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R9399 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R9400 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R9401 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R9402 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R9403 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R9404 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R9405 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R9406 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R9407 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R9408 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R9409 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R9410 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R9411 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R9412 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R9413 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R9414 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R9415 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R9416 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R9417 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R9418 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R9419 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R9420 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R9421 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R9422 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R9423 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R9424 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R9425 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R9426 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R9427 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R9428 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R9429 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R9430 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R9431 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R9432 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R9433 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R9434 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R9435 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R9436 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R9437 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R9438 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R9439 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R9440 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R9441 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R9442 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R9443 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R9444 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R9445 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R9446 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R9447 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R9448 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R9449 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R9450 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R9451 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R9452 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R9453 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R9454 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R9455 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R9456 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R9457 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R9458 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R9459 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R9460 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R9461 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R9462 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R9463 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R9464 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R9465 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R9466 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R9467 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R9468 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R9469 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R9470 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R9471 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R9472 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R9473 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R9474 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R9475 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R9476 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R9477 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R9478 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R9479 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R9480 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R9481 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R9482 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R9483 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R9484 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R9485 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R9486 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R9487 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R9488 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R9489 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R9490 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R9491 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R9492 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R9493 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R9494 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R9495 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R9496 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R9497 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R9498 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R9499 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R9500 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R9501 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R9502 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R9503 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R9504 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R9505 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R9506 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R9507 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R9508 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R9509 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R9510 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R9511 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R9512 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R9513 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R9514 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R9515 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R9516 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R9517 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R9518 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R9519 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R9520 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R9521 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R9522 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R9523 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R9524 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R9525 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R9526 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R9527 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R9528 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R9529 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R9530 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R9531 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R9532 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R9533 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R9534 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R9535 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R9536 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R9537 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R9538 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R9539 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R9540 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R9541 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R9542 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R9543 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R9544 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R9545 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R9546 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R9547 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R9548 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R9549 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R9550 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R9551 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R9552 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R9553 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R9554 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R9555 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R9556 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R9557 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R9558 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R9559 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R9560 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R9561 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R9562 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R9563 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R9564 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R9565 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R9566 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R9567 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R9568 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R9569 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R9570 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R9571 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R9572 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R9573 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R9574 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R9575 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R9576 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R9577 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R9578 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R9579 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R9580 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R9581 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R9582 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R9583 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R9584 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R9585 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R9586 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R9587 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R9588 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R9589 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R9590 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R9591 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R9592 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R9593 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R9594 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R9595 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R9596 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R9597 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R9598 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R9599 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R9600 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R9601 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R9602 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R9603 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R9604 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R9605 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R9606 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R9607 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R9608 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R9609 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R9610 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R9611 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R9612 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R9613 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R9614 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R9615 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R9616 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R9617 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R9618 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R9619 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R9620 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R9621 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R9622 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R9623 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R9624 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R9625 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R9626 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R9627 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R9628 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R9629 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R9630 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R9631 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R9632 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R9633 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R9634 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R9635 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R9636 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R9637 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R9638 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R9639 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R9640 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R9641 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R9642 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R9643 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R9644 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R9645 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R9646 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R9647 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R9648 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R9649 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R9650 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R9651 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R9652 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R9653 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R9654 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R9655 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R9656 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R9657 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R9658 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R9659 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R9660 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R9661 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R9662 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R9663 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R9664 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R9665 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R9666 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R9667 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R9668 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R9669 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R9670 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R9671 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R9672 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R9673 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R9674 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R9675 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R9676 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R9677 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R9678 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R9679 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R9680 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R9681 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R9682 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R9683 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R9684 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R9685 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R9686 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R9687 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R9688 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R9689 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R9690 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R9691 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R9692 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R9693 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R9694 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R9695 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R9696 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R9697 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R9698 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R9699 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R9700 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R9701 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R9702 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R9703 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R9704 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R9705 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R9706 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R9707 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R9708 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R9709 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R9710 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R9711 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R9712 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R9713 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R9714 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R9715 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R9716 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R9717 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R9718 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R9719 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R9720 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R9721 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R9722 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R9723 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R9724 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R9725 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R9726 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R9727 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R9728 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R9729 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R9730 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R9731 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R9732 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R9733 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R9734 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R9735 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R9736 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R9737 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R9738 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R9739 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R9740 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R9741 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R9742 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R9743 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R9744 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R9745 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R9746 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R9747 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R9748 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R9749 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R9750 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R9751 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R9752 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R9753 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R9754 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R9755 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R9756 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R9757 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R9758 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R9759 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R9760 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R9761 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R9762 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R9763 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R9764 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R9765 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R9766 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R9767 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R9768 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R9769 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R9770 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R9771 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R9772 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R9773 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R9774 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R9775 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R9776 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R9777 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R9778 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R9779 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R9780 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R9781 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R9782 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R9783 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R9784 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R9785 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R9786 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R9787 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R9788 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R9789 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R9790 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R9791 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R9792 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R9793 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R9794 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R9795 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R9796 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R9797 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R9798 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R9799 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R9800 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R9801 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R9802 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R9803 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R9804 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R9805 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R9806 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R9807 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R9808 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R9809 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R9810 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R9811 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R9812 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R9813 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R9814 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R9815 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R9816 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R9817 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R9818 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R9819 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R9820 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R9821 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R9822 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R9823 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R9824 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R9825 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R9826 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R9827 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R9828 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R9829 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R9830 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R9831 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R9832 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R9833 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R9834 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R9835 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R9836 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R9837 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R9838 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R9839 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R9840 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R9841 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R9842 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R9843 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R9844 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R9845 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R9846 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R9847 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R9848 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R9849 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R9850 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R9851 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R9852 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R9853 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R9854 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R9855 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R9856 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R9857 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R9858 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R9859 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R9860 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R9861 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R9862 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R9863 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R9864 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R9865 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R9866 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R9867 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R9868 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R9869 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R9870 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R9871 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R9872 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R9873 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R9874 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R9875 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R9876 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R9877 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R9878 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R9879 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R9880 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R9881 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R9882 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R9883 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R9884 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R9885 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R9886 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R9887 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R9888 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R9889 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R9890 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R9891 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R9892 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R9893 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R9894 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R9895 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R9896 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R9897 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R9898 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R9899 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R9900 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R9901 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R9902 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R9903 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R9904 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R9905 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R9906 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R9907 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R9908 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R9909 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R9910 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R9911 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R9912 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R9913 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R9914 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R9915 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R9916 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R9917 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R9918 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R9919 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R9920 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R9921 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R9922 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R9923 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R9924 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R9925 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R9926 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R9927 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R9928 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R9929 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R9930 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R9931 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R9932 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R9933 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R9934 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R9935 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R9936 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R9937 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R9938 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R9939 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R9940 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R9941 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R9942 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R9943 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R9944 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R9945 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R9946 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R9947 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R9948 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R9949 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R9950 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R9951 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R9952 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R9953 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R9954 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R9955 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R9956 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R9957 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R9958 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R9959 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R9960 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R9961 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R9962 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R9963 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R9964 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R9965 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R9966 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R9967 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R9968 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R9969 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R9970 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R9971 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R9972 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R9973 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R9974 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R9975 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R9976 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R9977 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R9978 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R9979 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R9980 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R9981 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R9982 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R9983 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R9984 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R9985 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R9986 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R9987 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R9988 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R9989 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R9990 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R9991 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R9992 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R9993 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R9994 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R9995 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R9996 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R9997 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R9998 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R9999 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R10000 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R10001 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R10002 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R10003 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R10004 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R10005 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R10006 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R10007 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R10008 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R10009 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R10010 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R10011 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R10012 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R10013 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R10014 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R10015 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R10016 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R10017 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R10018 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R10019 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R10020 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R10021 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R10022 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R10023 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R10024 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R10025 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R10026 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R10027 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R10028 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R10029 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R10030 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R10031 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R10032 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R10033 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R10034 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R10035 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R10036 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R10037 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R10038 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R10039 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R10040 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R10041 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R10042 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R10043 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R10044 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R10045 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R10046 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R10047 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R10048 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R10049 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R10050 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R10051 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R10052 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R10053 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R10054 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R10055 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R10056 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R10057 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R10058 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R10059 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R10060 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R10061 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R10062 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R10063 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R10064 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R10065 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R10066 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R10067 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R10068 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R10069 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R10070 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R10071 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R10072 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R10073 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R10074 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R10075 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R10076 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R10077 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R10078 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R10079 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R10080 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R10081 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R10082 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R10083 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R10084 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R10085 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R10086 n1_m1_4000_0 n1_m4_4000_0 15.000000
R10087 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R10088 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R10089 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R10090 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R10091 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R10092 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R10093 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R10094 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R10095 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R10096 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R10097 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R10098 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R10099 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R10100 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R10101 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R10102 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R10103 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R10104 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R10105 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R10106 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R10107 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R10108 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R10109 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R10110 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R10111 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R10112 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R10113 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R10114 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R10115 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R10116 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R10117 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R10118 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R10119 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R10120 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R10121 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R10122 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R10123 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R10124 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R10125 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R10126 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R10127 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R10128 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R10129 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R10130 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R10131 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R10132 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R10133 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R10134 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R10135 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R10136 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R10137 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R10138 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R10139 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R10140 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R10141 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R10142 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R10143 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R10144 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R10145 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R10146 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R10147 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R10148 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R10149 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R10150 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R10151 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R10152 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R10153 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R10154 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R10155 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R10156 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R10157 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R10158 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R10159 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R10160 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R10161 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R10162 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R10163 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R10164 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R10165 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R10166 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R10167 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R10168 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R10169 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R10170 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R10171 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R10172 n1_m1_32000_0 n1_m4_32000_0 15.000000
R10173 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R10174 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R10175 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R10176 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R10177 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R10178 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R10179 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R10180 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R10181 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R10182 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R10183 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R10184 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R10185 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R10186 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R10187 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R10188 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R10189 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R10190 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R10191 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R10192 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R10193 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R10194 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R10195 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R10196 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R10197 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R10198 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R10199 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R10200 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R10201 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R10202 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R10203 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R10204 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R10205 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R10206 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R10207 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R10208 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R10209 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R10210 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R10211 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R10212 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R10213 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R10214 n1_m1_32000_403200 n1_m4_32000_403200 15.000000
R10215 n1_m1_32000_408000 n1_m4_32000_408000 15.000000
R10216 n1_m1_60000_0 n1_m4_60000_0 15.000000
R10217 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R10218 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R10219 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R10220 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R10221 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R10222 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R10223 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R10224 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R10225 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R10226 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R10227 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R10228 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R10229 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R10230 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R10231 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R10232 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R10233 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R10234 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R10235 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R10236 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R10237 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R10238 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R10239 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R10240 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R10241 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R10242 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R10243 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R10244 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R10245 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R10246 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R10247 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R10248 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R10249 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R10250 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R10251 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R10252 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R10253 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R10254 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R10255 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R10256 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R10257 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R10258 n1_m1_60000_403200 n1_m4_60000_403200 15.000000
R10259 n1_m1_60000_408000 n1_m4_60000_408000 15.000000
R10260 n1_m1_88000_0 n1_m4_88000_0 15.000000
R10261 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R10262 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R10263 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R10264 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R10265 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R10266 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R10267 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R10268 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R10269 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R10270 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R10271 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R10272 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R10273 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R10274 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R10275 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R10276 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R10277 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R10278 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R10279 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R10280 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R10281 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R10282 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R10283 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R10284 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R10285 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R10286 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R10287 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R10288 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R10289 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R10290 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R10291 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R10292 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R10293 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R10294 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R10295 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R10296 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R10297 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R10298 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R10299 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R10300 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R10301 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R10302 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R10303 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R10304 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R10305 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R10306 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R10307 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R10308 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R10309 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R10310 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R10311 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R10312 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R10313 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R10314 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R10315 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R10316 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R10317 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R10318 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R10319 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R10320 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R10321 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R10322 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R10323 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R10324 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R10325 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R10326 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R10327 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R10328 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R10329 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R10330 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R10331 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R10332 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R10333 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R10334 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R10335 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R10336 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R10337 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R10338 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R10339 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R10340 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R10341 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R10342 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R10343 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R10344 n1_m1_88000_403200 n1_m4_88000_403200 15.000000
R10345 n1_m1_88000_408000 n1_m4_88000_408000 15.000000
R10346 n1_m1_116000_0 n1_m4_116000_0 15.000000
R10347 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R10348 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R10349 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R10350 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R10351 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R10352 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R10353 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R10354 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R10355 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R10356 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R10357 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R10358 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R10359 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R10360 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R10361 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R10362 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R10363 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R10364 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R10365 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R10366 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R10367 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R10368 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R10369 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R10370 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R10371 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R10372 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R10373 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R10374 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R10375 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R10376 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R10377 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R10378 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R10379 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R10380 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R10381 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R10382 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R10383 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R10384 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R10385 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R10386 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R10387 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R10388 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R10389 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R10390 n1_m1_144000_0 n1_m4_144000_0 15.000000
R10391 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R10392 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R10393 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R10394 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R10395 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R10396 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R10397 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R10398 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R10399 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R10400 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R10401 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R10402 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R10403 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R10404 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R10405 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R10406 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R10407 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R10408 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R10409 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R10410 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R10411 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R10412 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R10413 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R10414 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R10415 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R10416 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R10417 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R10418 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R10419 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R10420 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R10421 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R10422 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R10423 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R10424 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R10425 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R10426 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R10427 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R10428 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R10429 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R10430 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R10431 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R10432 n1_m1_144000_403200 n1_m4_144000_403200 15.000000
R10433 n1_m1_144000_408000 n1_m4_144000_408000 15.000000
R10434 n1_m1_172000_0 n1_m4_172000_0 15.000000
R10435 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R10436 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R10437 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R10438 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R10439 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R10440 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R10441 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R10442 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R10443 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R10444 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R10445 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R10446 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R10447 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R10448 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R10449 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R10450 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R10451 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R10452 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R10453 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R10454 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R10455 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R10456 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R10457 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R10458 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R10459 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R10460 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R10461 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R10462 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R10463 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R10464 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R10465 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R10466 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R10467 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R10468 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R10469 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R10470 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R10471 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R10472 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R10473 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R10474 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R10475 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R10476 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R10477 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R10478 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R10479 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R10480 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R10481 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R10482 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R10483 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R10484 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R10485 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R10486 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R10487 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R10488 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R10489 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R10490 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R10491 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R10492 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R10493 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R10494 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R10495 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R10496 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R10497 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R10498 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R10499 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R10500 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R10501 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R10502 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R10503 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R10504 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R10505 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R10506 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R10507 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R10508 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R10509 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R10510 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R10511 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R10512 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R10513 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R10514 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R10515 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R10516 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R10517 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R10518 n1_m1_172000_403200 n1_m4_172000_403200 15.000000
R10519 n1_m1_172000_408000 n1_m4_172000_408000 15.000000
R10520 n1_m1_200000_0 n1_m4_200000_0 15.000000
R10521 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R10522 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R10523 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R10524 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R10525 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R10526 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R10527 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R10528 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R10529 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R10530 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R10531 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R10532 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R10533 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R10534 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R10535 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R10536 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R10537 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R10538 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R10539 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R10540 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R10541 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R10542 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R10543 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R10544 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R10545 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R10546 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R10547 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R10548 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R10549 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R10550 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R10551 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R10552 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R10553 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R10554 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R10555 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R10556 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R10557 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R10558 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R10559 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R10560 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R10561 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R10562 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R10563 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R10564 n1_m1_228000_0 n1_m4_228000_0 15.000000
R10565 n1_m1_228000_403200 n1_m4_228000_403200 15.000000
R10566 n1_m1_228000_408000 n1_m4_228000_408000 15.000000
R10567 n1_m1_256000_0 n1_m4_256000_0 15.000000
R10568 n1_m1_256000_4800 n1_m4_256000_4800 15.000000
R10569 n1_m1_256000_9600 n1_m4_256000_9600 15.000000
R10570 n1_m1_256000_14400 n1_m4_256000_14400 15.000000
R10571 n1_m1_256000_19200 n1_m4_256000_19200 15.000000
R10572 n1_m1_256000_24000 n1_m4_256000_24000 15.000000
R10573 n1_m1_256000_28800 n1_m4_256000_28800 15.000000
R10574 n1_m1_256000_33600 n1_m4_256000_33600 15.000000
R10575 n1_m1_256000_38400 n1_m4_256000_38400 15.000000
R10576 n1_m1_256000_43200 n1_m4_256000_43200 15.000000
R10577 n1_m1_256000_48000 n1_m4_256000_48000 15.000000
R10578 n1_m1_256000_52800 n1_m4_256000_52800 15.000000
R10579 n1_m1_256000_57600 n1_m4_256000_57600 15.000000
R10580 n1_m1_256000_62400 n1_m4_256000_62400 15.000000
R10581 n1_m1_256000_67200 n1_m4_256000_67200 15.000000
R10582 n1_m1_256000_72000 n1_m4_256000_72000 15.000000
R10583 n1_m1_256000_76800 n1_m4_256000_76800 15.000000
R10584 n1_m1_256000_81600 n1_m4_256000_81600 15.000000
R10585 n1_m1_256000_86400 n1_m4_256000_86400 15.000000
R10586 n1_m1_256000_91200 n1_m4_256000_91200 15.000000
R10587 n1_m1_256000_96000 n1_m4_256000_96000 15.000000
R10588 n1_m1_256000_100800 n1_m4_256000_100800 15.000000
R10589 n1_m1_256000_105600 n1_m4_256000_105600 15.000000
R10590 n1_m1_256000_110400 n1_m4_256000_110400 15.000000
R10591 n1_m1_256000_115200 n1_m4_256000_115200 15.000000
R10592 n1_m1_256000_120000 n1_m4_256000_120000 15.000000
R10593 n1_m1_256000_124800 n1_m4_256000_124800 15.000000
R10594 n1_m1_256000_129600 n1_m4_256000_129600 15.000000
R10595 n1_m1_256000_134400 n1_m4_256000_134400 15.000000
R10596 n1_m1_256000_139200 n1_m4_256000_139200 15.000000
R10597 n1_m1_256000_144000 n1_m4_256000_144000 15.000000
R10598 n1_m1_256000_148800 n1_m4_256000_148800 15.000000
R10599 n1_m1_256000_153600 n1_m4_256000_153600 15.000000
R10600 n1_m1_256000_158400 n1_m4_256000_158400 15.000000
R10601 n1_m1_256000_163200 n1_m4_256000_163200 15.000000
R10602 n1_m1_256000_168000 n1_m4_256000_168000 15.000000
R10603 n1_m1_256000_172800 n1_m4_256000_172800 15.000000
R10604 n1_m1_256000_177600 n1_m4_256000_177600 15.000000
R10605 n1_m1_256000_182400 n1_m4_256000_182400 15.000000
R10606 n1_m1_256000_187200 n1_m4_256000_187200 15.000000
R10607 n1_m1_256000_192000 n1_m4_256000_192000 15.000000
R10608 n1_m1_256000_196800 n1_m4_256000_196800 15.000000
R10609 n1_m1_256000_403200 n1_m4_256000_403200 15.000000
R10610 n1_m1_256000_408000 n1_m4_256000_408000 15.000000
R10611 n1_m1_284000_0 n1_m4_284000_0 15.000000
R10612 n1_m1_284000_403200 n1_m4_284000_403200 15.000000
R10613 n1_m1_284000_408000 n1_m4_284000_408000 15.000000
R10614 n1_m1_312000_0 n1_m4_312000_0 15.000000
R10615 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R10616 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R10617 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R10618 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R10619 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R10620 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R10621 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R10622 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R10623 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R10624 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R10625 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R10626 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R10627 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R10628 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R10629 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R10630 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R10631 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R10632 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R10633 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R10634 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R10635 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R10636 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R10637 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R10638 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R10639 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R10640 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R10641 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R10642 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R10643 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R10644 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R10645 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R10646 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R10647 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R10648 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R10649 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R10650 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R10651 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R10652 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R10653 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R10654 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R10655 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R10656 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R10657 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R10658 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R10659 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R10660 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R10661 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R10662 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R10663 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R10664 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R10665 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R10666 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R10667 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R10668 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R10669 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R10670 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R10671 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R10672 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R10673 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R10674 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R10675 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R10676 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R10677 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R10678 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R10679 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R10680 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R10681 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R10682 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R10683 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R10684 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R10685 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R10686 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R10687 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R10688 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R10689 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R10690 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R10691 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R10692 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R10693 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R10694 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R10695 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R10696 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R10697 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R10698 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R10699 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R10700 n1_m1_340000_0 n1_m4_340000_0 15.000000
R10701 n1_m1_340000_403200 n1_m4_340000_403200 15.000000
R10702 n1_m1_340000_408000 n1_m4_340000_408000 15.000000
R10703 n1_m1_368000_0 n1_m4_368000_0 15.000000
R10704 n1_m1_368000_4800 n1_m4_368000_4800 15.000000
R10705 n1_m1_368000_9600 n1_m4_368000_9600 15.000000
R10706 n1_m1_368000_14400 n1_m4_368000_14400 15.000000
R10707 n1_m1_368000_19200 n1_m4_368000_19200 15.000000
R10708 n1_m1_368000_24000 n1_m4_368000_24000 15.000000
R10709 n1_m1_368000_28800 n1_m4_368000_28800 15.000000
R10710 n1_m1_368000_33600 n1_m4_368000_33600 15.000000
R10711 n1_m1_368000_38400 n1_m4_368000_38400 15.000000
R10712 n1_m1_368000_43200 n1_m4_368000_43200 15.000000
R10713 n1_m1_368000_48000 n1_m4_368000_48000 15.000000
R10714 n1_m1_368000_52800 n1_m4_368000_52800 15.000000
R10715 n1_m1_368000_57600 n1_m4_368000_57600 15.000000
R10716 n1_m1_368000_62400 n1_m4_368000_62400 15.000000
R10717 n1_m1_368000_67200 n1_m4_368000_67200 15.000000
R10718 n1_m1_368000_72000 n1_m4_368000_72000 15.000000
R10719 n1_m1_368000_76800 n1_m4_368000_76800 15.000000
R10720 n1_m1_368000_81600 n1_m4_368000_81600 15.000000
R10721 n1_m1_368000_86400 n1_m4_368000_86400 15.000000
R10722 n1_m1_368000_91200 n1_m4_368000_91200 15.000000
R10723 n1_m1_368000_96000 n1_m4_368000_96000 15.000000
R10724 n1_m1_368000_100800 n1_m4_368000_100800 15.000000
R10725 n1_m1_368000_105600 n1_m4_368000_105600 15.000000
R10726 n1_m1_368000_110400 n1_m4_368000_110400 15.000000
R10727 n1_m1_368000_115200 n1_m4_368000_115200 15.000000
R10728 n1_m1_368000_120000 n1_m4_368000_120000 15.000000
R10729 n1_m1_368000_124800 n1_m4_368000_124800 15.000000
R10730 n1_m1_368000_129600 n1_m4_368000_129600 15.000000
R10731 n1_m1_368000_134400 n1_m4_368000_134400 15.000000
R10732 n1_m1_368000_139200 n1_m4_368000_139200 15.000000
R10733 n1_m1_368000_144000 n1_m4_368000_144000 15.000000
R10734 n1_m1_368000_148800 n1_m4_368000_148800 15.000000
R10735 n1_m1_368000_153600 n1_m4_368000_153600 15.000000
R10736 n1_m1_368000_158400 n1_m4_368000_158400 15.000000
R10737 n1_m1_368000_163200 n1_m4_368000_163200 15.000000
R10738 n1_m1_368000_168000 n1_m4_368000_168000 15.000000
R10739 n1_m1_368000_172800 n1_m4_368000_172800 15.000000
R10740 n1_m1_368000_177600 n1_m4_368000_177600 15.000000
R10741 n1_m1_368000_182400 n1_m4_368000_182400 15.000000
R10742 n1_m1_368000_187200 n1_m4_368000_187200 15.000000
R10743 n1_m1_368000_192000 n1_m4_368000_192000 15.000000
R10744 n1_m1_368000_196800 n1_m4_368000_196800 15.000000
R10745 n1_m1_368000_403200 n1_m4_368000_403200 15.000000
R10746 n1_m1_368000_408000 n1_m4_368000_408000 15.000000
R10747 n1_m1_396000_0 n1_m4_396000_0 15.000000
R10748 n1_m1_396000_403200 n1_m4_396000_403200 15.000000
R10749 n1_m1_396000_408000 n1_m4_396000_408000 15.000000
R10750 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R10751 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R10752 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R10753 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R10754 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R10755 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R10756 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R10757 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R10758 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R10759 n1_m4_32000_404000 n1_m7_32000_404000 9.000000
R10760 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R10761 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R10762 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R10763 n1_m4_60000_404000 n1_m7_60000_404000 9.000000
R10764 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R10765 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R10766 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R10767 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R10768 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R10769 n1_m4_88000_404000 n1_m7_88000_404000 9.000000
R10770 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R10771 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R10772 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R10773 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R10774 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R10775 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R10776 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R10777 n1_m4_144000_404000 n1_m7_144000_404000 9.000000
R10778 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R10779 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R10780 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R10781 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R10782 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R10783 n1_m4_172000_404000 n1_m7_172000_404000 9.000000
R10784 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R10785 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R10786 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R10787 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R10788 n1_m4_228000_404000 n1_m7_228000_404000 9.000000
R10789 n1_m4_256000_4000 n1_m7_256000_4000 9.000000
R10790 n1_m4_256000_84000 n1_m7_256000_84000 9.000000
R10791 n1_m4_256000_164000 n1_m7_256000_164000 9.000000
R10792 n1_m4_256000_404000 n1_m7_256000_404000 9.000000
R10793 n1_m4_284000_404000 n1_m7_284000_404000 9.000000
R10794 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R10795 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R10796 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R10797 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R10798 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R10799 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R10800 n1_m4_340000_404000 n1_m7_340000_404000 9.000000
R10801 n1_m4_368000_4000 n1_m7_368000_4000 9.000000
R10802 n1_m4_368000_84000 n1_m7_368000_84000 9.000000
R10803 n1_m4_368000_164000 n1_m7_368000_164000 9.000000
R10804 n1_m4_368000_404000 n1_m7_368000_404000 9.000000
R10805 n1_m4_396000_404000 n1_m7_396000_404000 9.000000
R10806 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R10807 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R10808 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R10809 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R10810 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R10811 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R10812 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R10813 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R10814 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R10815 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R10816 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R10817 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R10818 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R10819 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R10820 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R10821 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R10822 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R10823 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R10824 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R10825 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R10826 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R10827 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R10828 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R10829 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R10830 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R10831 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R10832 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R10833 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R10834 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R10835 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R10836 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R10837 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R10838 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R10839 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R10840 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R10841 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R10842 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R10843 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R10844 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R10845 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R10846 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R10847 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R10848 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R10849 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R10850 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R10851 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R10852 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R10853 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R10854 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R10855 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R10856 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R10857 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R10858 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R10859 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R10860 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R10861 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R10862 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R10863 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R10864 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R10865 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R10866 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R10867 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R10868 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R10869 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R10870 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R10871 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R10872 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R10873 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R10874 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R10875 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R10876 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R10877 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R10878 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R10879 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R10880 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R10881 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R10882 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R10883 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R10884 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R10885 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R10886 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R10887 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R10888 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R10889 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R10890 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R10891 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R10892 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R10893 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R10894 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R10895 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R10896 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R10897 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R10898 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R10899 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R10900 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R10901 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R10902 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R10903 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R10904 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R10905 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R10906 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R10907 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R10908 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R10909 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R10910 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R10911 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R10912 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R10913 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R10914 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R10915 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R10916 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R10917 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R10918 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R10919 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R10920 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R10921 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R10922 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R10923 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R10924 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R10925 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R10926 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R10927 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R10928 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R10929 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R10930 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R10931 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R10932 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R10933 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R10934 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R10935 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R10936 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R10937 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R10938 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R10939 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R10940 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R10941 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R10942 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R10943 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R10944 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R10945 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R10946 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R10947 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R10948 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R10949 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R10950 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R10951 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R10952 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R10953 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R10954 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R10955 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R10956 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R10957 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R10958 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R10959 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R10960 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R10961 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R10962 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R10963 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R10964 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R10965 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R10966 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R10967 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R10968 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R10969 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R10970 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R10971 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R10972 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R10973 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R10974 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R10975 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R10976 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R10977 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R10978 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R10979 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R10980 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R10981 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R10982 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R10983 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R10984 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R10985 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R10986 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R10987 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R10988 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R10989 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R10990 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R10991 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R10992 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R10993 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R10994 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R10995 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R10996 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R10997 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R10998 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R10999 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R11000 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R11001 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R11002 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R11003 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R11004 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R11005 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R11006 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R11007 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R11008 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R11009 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R11010 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R11011 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R11012 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R11013 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R11014 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R11015 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R11016 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R11017 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R11018 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R11019 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R11020 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R11021 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R11022 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R11023 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R11024 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R11025 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R11026 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R11027 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R11028 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R11029 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R11030 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R11031 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R11032 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R11033 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R11034 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R11035 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R11036 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R11037 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R11038 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R11039 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R11040 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R11041 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R11042 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R11043 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R11044 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R11045 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R11046 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R11047 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R11048 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R11049 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R11050 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R11051 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R11052 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R11053 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R11054 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R11055 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R11056 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R11057 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R11058 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R11059 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R11060 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R11061 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R11062 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R11063 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R11064 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R11065 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R11066 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R11067 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R11068 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R11069 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R11070 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R11071 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R11072 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R11073 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R11074 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R11075 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R11076 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R11077 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R11078 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R11079 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R11080 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R11081 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R11082 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R11083 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R11084 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R11085 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R11086 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R11087 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R11088 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R11089 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R11090 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R11091 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R11092 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R11093 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R11094 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R11095 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R11096 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R11097 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R11098 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R11099 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R11100 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R11101 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R11102 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R11103 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R11104 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R11105 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R11106 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R11107 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R11108 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R11109 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R11110 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R11111 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R11112 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R11113 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R11114 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R11115 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R11116 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R11117 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R11118 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R11119 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R11120 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R11121 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R11122 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R11123 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R11124 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R11125 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R11126 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R11127 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R11128 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R11129 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R11130 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R11131 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R11132 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R11133 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R11134 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R11135 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R11136 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R11137 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R11138 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R11139 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R11140 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R11141 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R11142 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R11143 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R11144 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R11145 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R11146 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R11147 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R11148 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R11149 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R11150 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R11151 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R11152 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R11153 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R11154 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R11155 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R11156 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R11157 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R11158 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R11159 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R11160 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R11161 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R11162 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R11163 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R11164 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R11165 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R11166 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R11167 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R11168 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R11169 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R11170 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R11171 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R11172 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R11173 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R11174 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R11175 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R11176 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R11177 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R11178 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R11179 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R11180 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R11181 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R11182 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R11183 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R11184 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R11185 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R11186 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R11187 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R11188 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R11189 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R11190 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R11191 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R11192 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R11193 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R11194 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R11195 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R11196 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R11197 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R11198 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R11199 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R11200 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R11201 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R11202 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R11203 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R11204 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R11205 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R11206 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R11207 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R11208 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R11209 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R11210 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R11211 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R11212 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R11213 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R11214 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R11215 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R11216 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R11217 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R11218 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R11219 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R11220 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R11221 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R11222 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R11223 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R11224 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R11225 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R11226 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R11227 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R11228 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R11229 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R11230 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R11231 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R11232 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R11233 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R11234 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R11235 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R11236 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R11237 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R11238 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R11239 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R11240 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R11241 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R11242 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R11243 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R11244 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R11245 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R11246 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R11247 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R11248 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R11249 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R11250 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R11251 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R11252 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R11253 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R11254 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R11255 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R11256 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R11257 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R11258 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R11259 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R11260 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R11261 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R11262 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R11263 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R11264 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R11265 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R11266 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R11267 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R11268 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R11269 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R11270 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R11271 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R11272 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R11273 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R11274 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R11275 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R11276 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R11277 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R11278 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R11279 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R11280 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_340000_250400 0 1.100000
V2 n1_m9_48800_340000 0 1.100000
V3 n1_m9_340000_340000 0 1.100000
R11281 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R11282 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R11283 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R11284 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R11285 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R11286 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R11287 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R11288 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R11289 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R11290 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R11291 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R11292 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R11293 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R11294 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R11295 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R11296 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R11297 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R11298 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R11299 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R11300 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R11301 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R11302 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R11303 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R11304 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R11305 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R11306 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R11307 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R11308 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R11309 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R11310 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R11311 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R11312 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R11313 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R11314 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R11315 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R11316 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R11317 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R11318 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R11319 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R11320 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R11321 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R11322 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R11323 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R11324 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R11325 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R11326 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R11327 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R11328 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R11329 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R11330 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R11331 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R11332 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R11333 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R11334 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R11335 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R11336 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R11337 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R11338 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R11339 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R11340 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R11341 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R11342 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R11343 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R11344 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R11345 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R11346 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R11347 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R11348 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R11349 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R11350 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R11351 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R11352 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R11353 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R11354 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R11355 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R11356 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R11357 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R11358 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R11359 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R11360 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R11361 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R11362 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R11363 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R11364 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R11365 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R11366 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R11367 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R11368 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
I0 n1_m1_0_0 0 1.676242e-07
I1 n1_m1_0_4800 0 1.574042e-07
I2 n1_m1_0_9600 0 2.311219e-07
I3 n1_m1_0_14400 0 1.588402e-07
I4 n1_m1_0_19200 0 1.582728e-07
I5 n1_m1_0_24000 0 2.305743e-07
I6 n1_m1_0_28800 0 1.532282e-07
I7 n1_m1_0_33600 0 2.298422e-07
I8 n1_m1_0_38400 0 1.532282e-07
I9 n1_m1_0_43200 0 1.532282e-07
I10 n1_m1_0_48000 0 2.314529e-07
I11 n1_m1_0_52800 0 1.556168e-07
I12 n1_m1_0_57600 0 2.390806e-07
I13 n1_m1_0_62400 0 1.497265e-07
I14 n1_m1_0_67200 0 1.550962e-07
I15 n1_m1_0_72000 0 2.284222e-07
I16 n1_m1_0_76800 0 1.531232e-07
I17 n1_m1_0_81600 0 2.334203e-07
I18 n1_m1_0_86400 0 1.629861e-07
I19 n1_m1_0_91200 0 1.585245e-07
I20 n1_m1_0_96000 0 2.258351e-07
I21 n1_m1_0_100800 0 1.573220e-07
I22 n1_m1_0_105600 0 2.411922e-07
I23 n1_m1_0_110400 0 1.553080e-07
I24 n1_m1_0_115200 0 1.585212e-07
I25 n1_m1_0_120000 0 2.398354e-07
I26 n1_m1_0_124800 0 1.560568e-07
I27 n1_m1_0_129600 0 2.298607e-07
I28 n1_m1_0_134400 0 1.590800e-07
I29 n1_m1_0_139200 0 1.598903e-07
I30 n1_m1_0_144000 0 2.383426e-07
I31 n1_m1_0_148800 0 1.634789e-07
I32 n1_m1_0_153600 0 2.515428e-07
I33 n1_m1_0_158400 0 1.672023e-07
I34 n1_m1_0_163200 0 1.599715e-07
I35 n1_m1_0_168000 0 2.547742e-07
I36 n1_m1_0_172800 0 1.584346e-07
I37 n1_m1_0_177600 0 2.329940e-07
I38 n1_m1_0_182400 0 1.634100e-07
I39 n1_m1_0_187200 0 1.666766e-07
I40 n1_m1_0_192000 0 2.418632e-07
I41 n1_m1_0_196800 0 1.644725e-07
I42 n1_m1_0_201600 0 2.488942e-07
I43 n1_m1_0_206400 0 1.653968e-07
I44 n1_m1_0_211200 0 1.567335e-07
I45 n1_m1_0_216000 0 2.533822e-07
I46 n1_m1_0_220800 0 1.644105e-07
I47 n1_m1_0_225600 0 2.414667e-07
I48 n1_m1_0_230400 0 1.564711e-07
I49 n1_m1_0_235200 0 1.689498e-07
I50 n1_m1_0_240000 0 2.400343e-07
I51 n1_m1_0_244800 0 1.724686e-07
I52 n1_m1_0_249600 0 2.454138e-07
I53 n1_m1_0_254400 0 1.658371e-07
I54 n1_m1_0_259200 0 1.619143e-07
I55 n1_m1_0_264000 0 2.335126e-07
I56 n1_m1_0_268800 0 1.648815e-07
I57 n1_m1_0_273600 0 2.389886e-07
I58 n1_m1_0_278400 0 1.703148e-07
I59 n1_m1_0_283200 0 1.786282e-07
I60 n1_m1_0_288000 0 2.383997e-07
I61 n1_m1_0_292800 0 1.579535e-07
I62 n1_m1_0_297600 0 2.423784e-07
I63 n1_m1_0_302400 0 1.653196e-07
I64 n1_m1_0_307200 0 1.575332e-07
I65 n1_m1_0_312000 0 2.351487e-07
I66 n1_m1_0_316800 0 1.607463e-07
I67 n1_m1_0_321600 0 2.416007e-07
I68 n1_m1_0_326400 0 1.596696e-07
I69 n1_m1_0_331200 0 1.578830e-07
I70 n1_m1_0_336000 0 2.360819e-07
I71 n1_m1_0_340800 0 1.573879e-07
I72 n1_m1_0_345600 0 2.339614e-07
I73 n1_m1_0_350400 0 1.553080e-07
I74 n1_m1_0_355200 0 1.553080e-07
I75 n1_m1_0_360000 0 2.345727e-07
I76 n1_m1_0_364800 0 1.537202e-07
I77 n1_m1_0_369600 0 2.270344e-07
I78 n1_m1_0_374400 0 1.513537e-07
I79 n1_m1_0_379200 0 1.535072e-07
I80 n1_m1_0_384000 0 2.282517e-07
I81 n1_m1_0_388800 0 1.479848e-07
I82 n1_m1_0_393600 0 2.206473e-07
I83 n1_m1_0_398400 0 1.433686e-07
I84 n1_m1_0_403200 0 1.960636e-07
I85 n1_m1_0_408000 0 3.621338e-07
I86 n1_m1_4800_0 0 7.995325e-08
I87 n1_m1_4800_4800 0 7.641909e-08
I88 n1_m1_4800_9600 0 1.121342e-07
I89 n1_m1_4800_14400 0 7.713300e-08
I90 n1_m1_4800_19200 0 7.684785e-08
I91 n1_m1_4800_24000 0 1.132701e-07
I92 n1_m1_4800_28800 0 7.661408e-08
I93 n1_m1_4800_33600 0 1.133509e-07
I94 n1_m1_4800_38400 0 7.624379e-08
I95 n1_m1_4800_43200 0 7.661408e-08
I96 n1_m1_4800_48000 0 1.162144e-07
I97 n1_m1_4800_52800 0 7.927284e-08
I98 n1_m1_4800_57600 0 1.239421e-07
I99 n1_m1_4800_62400 0 8.291057e-08
I100 n1_m1_4800_67200 0 7.787584e-08
I101 n1_m1_4800_72000 0 1.118564e-07
I102 n1_m1_4800_76800 0 7.847709e-08
I103 n1_m1_4800_81600 0 1.121950e-07
I104 n1_m1_4800_86400 0 7.914302e-08
I105 n1_m1_4800_91200 0 8.038608e-08
I106 n1_m1_4800_96000 0 1.224710e-07
I107 n1_m1_4800_100800 0 8.546167e-08
I108 n1_m1_4800_105600 0 1.246369e-07
I109 n1_m1_4800_110400 0 8.222811e-08
I110 n1_m1_4800_115200 0 8.222811e-08
I111 n1_m1_4800_120000 0 1.233422e-07
I112 n1_m1_4800_124800 0 8.205828e-08
I113 n1_m1_4800_129600 0 1.201516e-07
I114 n1_m1_4800_134400 0 7.806584e-08
I115 n1_m1_4800_139200 0 7.825516e-08
I116 n1_m1_4800_144000 0 1.213680e-07
I117 n1_m1_4800_148800 0 8.252446e-08
I118 n1_m1_4800_153600 0 1.260944e-07
I119 n1_m1_4800_158400 0 8.234830e-08
I120 n1_m1_4800_163200 0 8.155600e-08
I121 n1_m1_4800_168000 0 1.291151e-07
I122 n1_m1_4800_172800 0 8.307811e-08
I123 n1_m1_4800_177600 0 1.249284e-07
I124 n1_m1_4800_182400 0 8.683463e-08
I125 n1_m1_4800_187200 0 8.576634e-08
I126 n1_m1_4800_192000 0 1.256454e-07
I127 n1_m1_4800_196800 0 8.294642e-08
I128 n1_m1_4800_201600 0 1.267199e-07
I129 n1_m1_4800_206400 0 8.440582e-08
I130 n1_m1_4800_211200 0 8.522941e-08
I131 n1_m1_4800_216000 0 1.297127e-07
I132 n1_m1_4800_220800 0 8.576111e-08
I133 n1_m1_4800_225600 0 1.260605e-07
I134 n1_m1_4800_230400 0 8.452773e-08
I135 n1_m1_4800_235200 0 8.620973e-08
I136 n1_m1_4800_240000 0 1.277482e-07
I137 n1_m1_4800_244800 0 8.557482e-08
I138 n1_m1_4800_249600 0 1.246235e-07
I139 n1_m1_4800_254400 0 8.459585e-08
I140 n1_m1_4800_259200 0 8.480745e-08
I141 n1_m1_4800_264000 0 1.263008e-07
I142 n1_m1_4800_268800 0 8.339589e-08
I143 n1_m1_4800_273600 0 1.258117e-07
I144 n1_m1_4800_278400 0 8.272863e-08
I145 n1_m1_4800_283200 0 9.002911e-08
I146 n1_m1_4800_288000 0 1.203414e-07
I147 n1_m1_4800_292800 0 8.421268e-08
I148 n1_m1_4800_297600 0 1.238584e-07
I149 n1_m1_4800_302400 0 8.130192e-08
I150 n1_m1_4800_307200 0 8.327618e-08
I151 n1_m1_4800_312000 0 1.237060e-07
I152 n1_m1_4800_316800 0 8.099319e-08
I153 n1_m1_4800_321600 0 1.208073e-07
I154 n1_m1_4800_326400 0 7.983393e-08
I155 n1_m1_4800_331200 0 7.946583e-08
I156 n1_m1_4800_336000 0 1.214898e-07
I157 n1_m1_4800_340800 0 8.099319e-08
I158 n1_m1_4800_345600 0 1.199006e-07
I159 n1_m1_4800_350400 0 7.766214e-08
I160 n1_m1_4800_355200 0 7.766214e-08
I161 n1_m1_4800_360000 0 1.190727e-07
I162 n1_m1_4800_364800 0 7.677573e-08
I163 n1_m1_4800_369600 0 1.104242e-07
I164 n1_m1_4800_374400 0 7.361208e-08
I165 n1_m1_4800_379200 0 7.655143e-08
I166 n1_m1_4800_384000 0 1.174446e-07
I167 n1_m1_4800_388800 0 7.346990e-08
I168 n1_m1_4800_393600 0 1.114834e-07
I169 n1_m1_4800_398400 0 7.050881e-08
I170 n1_m1_4800_403200 0 6.963987e-08
I171 n1_m1_4800_408000 0 7.369663e-08
I172 n1_m1_9600_0 0 2.292410e-07
I173 n1_m1_9600_4800 0 2.207335e-07
I174 n1_m1_9600_9600 0 3.282058e-07
I175 n1_m1_9600_14400 0 2.260685e-07
I176 n1_m1_9600_19200 0 2.257006e-07
I177 n1_m1_9600_24000 0 3.366397e-07
I178 n1_m1_9600_28800 0 2.293425e-07
I179 n1_m1_9600_33600 0 3.404970e-07
I180 n1_m1_9600_38400 0 2.312943e-07
I181 n1_m1_9600_43200 0 2.332432e-07
I182 n1_m1_9600_48000 0 3.567469e-07
I183 n1_m1_9600_52800 0 2.514050e-07
I184 n1_m1_9600_57600 0 3.710383e-07
I185 n1_m1_9600_62400 0 2.586115e-07
I186 n1_m1_9600_67200 0 2.443695e-07
I187 n1_m1_9600_72000 0 3.589492e-07
I188 n1_m1_9600_76800 0 2.408701e-07
I189 n1_m1_9600_81600 0 3.581133e-07
I190 n1_m1_9600_86400 0 2.473649e-07
I191 n1_m1_9600_91200 0 2.486736e-07
I192 n1_m1_9600_96000 0 3.709733e-07
I193 n1_m1_9600_100800 0 2.440064e-07
I194 n1_m1_9600_105600 0 3.650166e-07
I195 n1_m1_9600_110400 0 2.479680e-07
I196 n1_m1_9600_115200 0 2.441067e-07
I197 n1_m1_9600_120000 0 3.742729e-07
I198 n1_m1_9600_124800 0 2.538391e-07
I199 n1_m1_9600_129600 0 3.657436e-07
I200 n1_m1_9600_134400 0 2.689293e-07
I201 n1_m1_9600_139200 0 2.654293e-07
I202 n1_m1_9600_144000 0 3.667925e-07
I203 n1_m1_9600_148800 0 2.514604e-07
I204 n1_m1_9600_153600 0 3.896433e-07
I205 n1_m1_9600_158400 0 2.461589e-07
I206 n1_m1_9600_163200 0 2.473659e-07
I207 n1_m1_9600_168000 0 3.847999e-07
I208 n1_m1_9600_172800 0 3.085762e-07
I209 n1_m1_9600_177600 0 5.230736e-07
I210 n1_m1_9600_182400 0 2.702266e-07
I211 n1_m1_9600_187200 0 2.520482e-07
I212 n1_m1_9600_192000 0 3.868326e-07
I213 n1_m1_9600_196800 0 2.660613e-07
I214 n1_m1_9600_201600 0 4.051083e-07
I215 n1_m1_9600_206400 0 2.533791e-07
I216 n1_m1_9600_211200 0 2.630840e-07
I217 n1_m1_9600_216000 0 3.823947e-07
I218 n1_m1_9600_220800 0 2.579348e-07
I219 n1_m1_9600_225600 0 3.841983e-07
I220 n1_m1_9600_230400 0 2.571375e-07
I221 n1_m1_9600_235200 0 2.534010e-07
I222 n1_m1_9600_240000 0 3.949639e-07
I223 n1_m1_9600_244800 0 2.583861e-07
I224 n1_m1_9600_249600 0 4.012435e-07
I225 n1_m1_9600_254400 0 2.630796e-07
I226 n1_m1_9600_259200 0 2.652537e-07
I227 n1_m1_9600_264000 0 3.972879e-07
I228 n1_m1_9600_268800 0 2.535738e-07
I229 n1_m1_9600_273600 0 3.869546e-07
I230 n1_m1_9600_278400 0 2.467239e-07
I231 n1_m1_9600_283200 0 2.603675e-07
I232 n1_m1_9600_288000 0 4.707487e-07
I233 n1_m1_9600_292800 0 2.610989e-07
I234 n1_m1_9600_297600 0 3.963421e-07
I235 n1_m1_9600_302400 0 2.690427e-07
I236 n1_m1_9600_307200 0 2.487157e-07
I237 n1_m1_9600_312000 0 3.649887e-07
I238 n1_m1_9600_316800 0 2.475954e-07
I239 n1_m1_9600_321600 0 3.961403e-07
I240 n1_m1_9600_326400 0 2.913872e-07
I241 n1_m1_9600_331200 0 3.014220e-07
I242 n1_m1_9600_336000 0 3.653346e-07
I243 n1_m1_9600_340800 0 2.435564e-07
I244 n1_m1_9600_345600 0 3.647603e-07
I245 n1_m1_9600_350400 0 2.410378e-07
I246 n1_m1_9600_355200 0 2.410378e-07
I247 n1_m1_9600_360000 0 3.538722e-07
I248 n1_m1_9600_364800 0 2.375417e-07
I249 n1_m1_9600_369600 0 3.589397e-07
I250 n1_m1_9600_374400 0 2.373673e-07
I251 n1_m1_9600_379200 0 2.321440e-07
I252 n1_m1_9600_384000 0 3.407310e-07
I253 n1_m1_9600_388800 0 2.205190e-07
I254 n1_m1_9600_393600 0 3.472811e-07
I255 n1_m1_9600_398400 0 2.253819e-07
I256 n1_m1_9600_403200 0 2.117648e-07
I257 n1_m1_9600_408000 0 2.148974e-07
I258 n1_m1_14400_0 0 1.511483e-07
I259 n1_m1_14400_4800 0 1.440800e-07
I260 n1_m1_14400_9600 0 2.144961e-07
I261 n1_m1_14400_14400 0 1.498646e-07
I262 n1_m1_14400_19200 0 1.531338e-07
I263 n1_m1_14400_24000 0 2.274098e-07
I264 n1_m1_14400_28800 0 1.560842e-07
I265 n1_m1_14400_33600 0 2.441649e-07
I266 n1_m1_14400_38400 0 1.664874e-07
I267 n1_m1_14400_43200 0 1.655823e-07
I268 n1_m1_14400_48000 0 2.722801e-07
I269 n1_m1_14400_52800 0 2.725687e-07
I270 n1_m1_14400_57600 0 3.581460e-07
I271 n1_m1_14400_62400 0 1.750568e-07
I272 n1_m1_14400_67200 0 1.674630e-07
I273 n1_m1_14400_72000 0 2.473715e-07
I274 n1_m1_14400_76800 0 1.673215e-07
I275 n1_m1_14400_81600 0 2.636455e-07
I276 n1_m1_14400_86400 0 1.733029e-07
I277 n1_m1_14400_91200 0 1.691664e-07
I278 n1_m1_14400_96000 0 2.497654e-07
I279 n1_m1_14400_100800 0 1.653530e-07
I280 n1_m1_14400_105600 0 2.411789e-07
I281 n1_m1_14400_110400 0 1.598903e-07
I282 n1_m1_14400_115200 0 1.622033e-07
I283 n1_m1_14400_120000 0 2.447832e-07
I284 n1_m1_14400_124800 0 1.655023e-07
I285 n1_m1_14400_129600 0 2.576301e-07
I286 n1_m1_14400_134400 0 2.370578e-07
I287 n1_m1_14400_139200 0 2.164226e-07
I288 n1_m1_14400_144000 0 2.477428e-07
I289 n1_m1_14400_148800 0 1.654474e-07
I290 n1_m1_14400_153600 0 2.540083e-07
I291 n1_m1_14400_158400 0 1.680407e-07
I292 n1_m1_14400_163200 0 1.698714e-07
I293 n1_m1_14400_168000 0 2.668103e-07
I294 n1_m1_14400_172800 0 3.644395e-07
I295 n1_m1_14400_177600 0 7.783460e-07
I296 n1_m1_14400_182400 0 2.500369e-07
I297 n1_m1_14400_187200 0 1.646806e-07
I298 n1_m1_14400_192000 0 2.529750e-07
I299 n1_m1_14400_196800 0 1.687135e-07
I300 n1_m1_14400_201600 0 2.644811e-07
I301 n1_m1_14400_206400 0 1.684108e-07
I302 n1_m1_14400_211200 0 1.711183e-07
I303 n1_m1_14400_216000 0 2.721187e-07
I304 n1_m1_14400_220800 0 1.812634e-07
I305 n1_m1_14400_225600 0 2.629472e-07
I306 n1_m1_14400_230400 0 1.742728e-07
I307 n1_m1_14400_235200 0 1.673486e-07
I308 n1_m1_14400_240000 0 2.660652e-07
I309 n1_m1_14400_244800 0 1.911551e-07
I310 n1_m1_14400_249600 0 4.058321e-07
I311 n1_m1_14400_254400 0 1.798491e-07
I312 n1_m1_14400_259200 0 1.843236e-07
I313 n1_m1_14400_264000 0 2.980201e-07
I314 n1_m1_14400_268800 0 1.863201e-07
I315 n1_m1_14400_273600 0 2.607147e-07
I316 n1_m1_14400_278400 0 1.724515e-07
I317 n1_m1_14400_283200 0 2.191917e-07
I318 n1_m1_14400_288000 0 6.081783e-07
I319 n1_m1_14400_292800 0 1.834201e-07
I320 n1_m1_14400_297600 0 2.830790e-07
I321 n1_m1_14400_302400 0 2.003145e-07
I322 n1_m1_14400_307200 0 1.665747e-07
I323 n1_m1_14400_312000 0 2.523588e-07
I324 n1_m1_14400_316800 0 1.717387e-07
I325 n1_m1_14400_321600 0 2.799045e-07
I326 n1_m1_14400_326400 0 2.209183e-07
I327 n1_m1_14400_331200 0 2.304518e-07
I328 n1_m1_14400_336000 0 2.598217e-07
I329 n1_m1_14400_340800 0 1.732144e-07
I330 n1_m1_14400_345600 0 2.598217e-07
I331 n1_m1_14400_350400 0 1.732144e-07
I332 n1_m1_14400_355200 0 1.732144e-07
I333 n1_m1_14400_360000 0 2.597379e-07
I334 n1_m1_14400_364800 0 1.707560e-07
I335 n1_m1_14400_369600 0 2.547764e-07
I336 n1_m1_14400_374400 0 1.691928e-07
I337 n1_m1_14400_379200 0 1.637819e-07
I338 n1_m1_14400_384000 0 2.354043e-07
I339 n1_m1_14400_388800 0 1.509129e-07
I340 n1_m1_14400_393600 0 2.317517e-07
I341 n1_m1_14400_398400 0 1.461394e-07
I342 n1_m1_14400_403200 0 1.461883e-07
I343 n1_m1_14400_408000 0 1.659450e-07
I344 n1_m1_19200_0 0 1.511483e-07
I345 n1_m1_19200_4800 0 1.458597e-07
I346 n1_m1_19200_9600 0 2.204653e-07
I347 n1_m1_19200_14400 0 1.523649e-07
I348 n1_m1_19200_19200 0 1.534150e-07
I349 n1_m1_19200_24000 0 2.331807e-07
I350 n1_m1_19200_28800 0 1.682400e-07
I351 n1_m1_19200_33600 0 2.918018e-07
I352 n1_m1_19200_38400 0 2.175679e-07
I353 n1_m1_19200_43200 0 1.940539e-07
I354 n1_m1_19200_48000 0 3.015952e-07
I355 n1_m1_19200_52800 0 4.180527e-07
I356 n1_m1_19200_57600 0 7.957414e-07
I357 n1_m1_19200_62400 0 2.435785e-07
I358 n1_m1_19200_67200 0 1.667134e-07
I359 n1_m1_19200_72000 0 2.603446e-07
I360 n1_m1_19200_76800 0 2.724850e-07
I361 n1_m1_19200_81600 0 4.192894e-07
I362 n1_m1_19200_86400 0 1.898158e-07
I363 n1_m1_19200_91200 0 1.641799e-07
I364 n1_m1_19200_96000 0 2.599539e-07
I365 n1_m1_19200_100800 0 1.725634e-07
I366 n1_m1_19200_105600 0 2.444915e-07
I367 n1_m1_19200_110400 0 1.621120e-07
I368 n1_m1_19200_115200 0 1.740174e-07
I369 n1_m1_19200_120000 0 2.766145e-07
I370 n1_m1_19200_124800 0 1.738142e-07
I371 n1_m1_19200_129600 0 2.535707e-07
I372 n1_m1_19200_134400 0 1.899953e-07
I373 n1_m1_19200_139200 0 1.841896e-07
I374 n1_m1_19200_144000 0 2.686258e-07
I375 n1_m1_19200_148800 0 1.843670e-07
I376 n1_m1_19200_153600 0 2.723435e-07
I377 n1_m1_19200_158400 0 1.696610e-07
I378 n1_m1_19200_163200 0 1.732144e-07
I379 n1_m1_19200_168000 0 2.629696e-07
I380 n1_m1_19200_172800 0 3.494016e-07
I381 n1_m1_19200_177600 0 9.457456e-07
I382 n1_m1_19200_182400 0 3.739684e-07
I383 n1_m1_19200_187200 0 1.798887e-07
I384 n1_m1_19200_192000 0 2.613922e-07
I385 n1_m1_19200_196800 0 1.671406e-07
I386 n1_m1_19200_201600 0 2.527980e-07
I387 n1_m1_19200_206400 0 1.734956e-07
I388 n1_m1_19200_211200 0 1.745738e-07
I389 n1_m1_19200_216000 0 5.205184e-07
I390 n1_m1_19200_220800 0 3.012318e-07
I391 n1_m1_19200_225600 0 2.804004e-07
I392 n1_m1_19200_230400 0 1.818198e-07
I393 n1_m1_19200_235200 0 1.820044e-07
I394 n1_m1_19200_240000 0 3.103367e-07
I395 n1_m1_19200_244800 0 3.416970e-07
I396 n1_m1_19200_249600 0 9.950732e-07
I397 n1_m1_19200_254400 0 2.648866e-07
I398 n1_m1_19200_259200 0 1.879221e-07
I399 n1_m1_19200_264000 0 4.623349e-07
I400 n1_m1_19200_268800 0 3.433855e-07
I401 n1_m1_19200_273600 0 2.843938e-07
I402 n1_m1_19200_278400 0 1.770408e-07
I403 n1_m1_19200_283200 0 2.018405e-07
I404 n1_m1_19200_288000 0 4.319172e-07
I405 n1_m1_19200_292800 0 1.755632e-07
I406 n1_m1_19200_297600 0 2.542075e-07
I407 n1_m1_19200_302400 0 1.705321e-07
I408 n1_m1_19200_307200 0 1.661525e-07
I409 n1_m1_19200_312000 0 2.516598e-07
I410 n1_m1_19200_316800 0 1.683135e-07
I411 n1_m1_19200_321600 0 2.531069e-07
I412 n1_m1_19200_326400 0 1.703359e-07
I413 n1_m1_19200_331200 0 1.713909e-07
I414 n1_m1_19200_336000 0 2.570924e-07
I415 n1_m1_19200_340800 0 1.734519e-07
I416 n1_m1_19200_345600 0 2.614698e-07
I417 n1_m1_19200_350400 0 1.783573e-07
I418 n1_m1_19200_355200 0 1.785970e-07
I419 n1_m1_19200_360000 0 3.045951e-07
I420 n1_m1_19200_364800 0 3.253860e-07
I421 n1_m1_19200_369600 0 6.529650e-07
I422 n1_m1_19200_374400 0 3.858083e-07
I423 n1_m1_19200_379200 0 2.684147e-07
I424 n1_m1_19200_384000 0 2.746506e-07
I425 n1_m1_19200_388800 0 1.602534e-07
I426 n1_m1_19200_393600 0 2.284542e-07
I427 n1_m1_19200_398400 0 1.444212e-07
I428 n1_m1_19200_403200 0 1.413472e-07
I429 n1_m1_19200_408000 0 1.534953e-07
I430 n1_m1_24000_0 0 2.226114e-07
I431 n1_m1_24000_4800 0 2.157381e-07
I432 n1_m1_24000_9600 0 3.298622e-07
I433 n1_m1_24000_14400 0 2.301521e-07
I434 n1_m1_24000_19200 0 2.379489e-07
I435 n1_m1_24000_24000 0 4.091932e-07
I436 n1_m1_24000_28800 0 2.930181e-07
I437 n1_m1_24000_33600 0 5.162021e-07
I438 n1_m1_24000_38400 0 3.821514e-07
I439 n1_m1_24000_43200 0 3.344737e-07
I440 n1_m1_24000_48000 0 4.310317e-07
I441 n1_m1_24000_52800 0 4.957982e-07
I442 n1_m1_24000_57600 0 1.223669e-06
I443 n1_m1_24000_62400 0 4.083206e-07
I444 n1_m1_24000_67200 0 2.598617e-07
I445 n1_m1_24000_72000 0 4.371003e-07
I446 n1_m1_24000_76800 0 7.282421e-07
I447 n1_m1_24000_81600 0 1.540765e-06
I448 n1_m1_24000_86400 0 7.148919e-07
I449 n1_m1_24000_91200 0 2.777664e-07
I450 n1_m1_24000_96000 0 3.916326e-07
I451 n1_m1_24000_100800 0 2.515997e-07
I452 n1_m1_24000_105600 0 3.656328e-07
I453 n1_m1_24000_110400 0 2.486017e-07
I454 n1_m1_24000_115200 0 2.965946e-07
I455 n1_m1_24000_120000 0 5.712268e-07
I456 n1_m1_24000_124800 0 3.460400e-07
I457 n1_m1_24000_129600 0 3.942766e-07
I458 n1_m1_24000_134400 0 2.524698e-07
I459 n1_m1_24000_139200 0 2.818372e-07
I460 n1_m1_24000_144000 0 6.081334e-07
I461 n1_m1_24000_148800 0 5.167461e-07
I462 n1_m1_24000_153600 0 5.822734e-07
I463 n1_m1_24000_158400 0 2.656046e-07
I464 n1_m1_24000_163200 0 2.639327e-07
I465 n1_m1_24000_168000 0 3.907813e-07
I466 n1_m1_24000_172800 0 2.983652e-07
I467 n1_m1_24000_177600 0 9.711085e-07
I468 n1_m1_24000_182400 0 8.752109e-07
I469 n1_m1_24000_187200 0 5.861886e-07
I470 n1_m1_24000_192000 0 4.345624e-07
I471 n1_m1_24000_196800 0 2.591519e-07
I472 n1_m1_24000_201600 0 4.025164e-07
I473 n1_m1_24000_206400 0 2.884087e-07
I474 n1_m1_24000_211200 0 2.786920e-07
I475 n1_m1_24000_216000 0 9.018597e-07
I476 n1_m1_24000_220800 0 5.096456e-07
I477 n1_m1_24000_225600 0 4.464767e-07
I478 n1_m1_24000_230400 0 2.778029e-07
I479 n1_m1_24000_235200 0 2.922998e-07
I480 n1_m1_24000_240000 0 5.949672e-07
I481 n1_m1_24000_244800 0 7.005989e-07
I482 n1_m1_24000_249600 0 1.679376e-06
I483 n1_m1_24000_254400 0 5.512243e-07
I484 n1_m1_24000_259200 0 2.687049e-07
I485 n1_m1_24000_264000 0 7.195897e-07
I486 n1_m1_24000_268800 0 6.234682e-07
I487 n1_m1_24000_273600 0 4.504819e-07
I488 n1_m1_24000_278400 0 2.703248e-07
I489 n1_m1_24000_283200 0 2.830919e-07
I490 n1_m1_24000_288000 0 4.273012e-07
I491 n1_m1_24000_292800 0 2.691721e-07
I492 n1_m1_24000_297600 0 4.045167e-07
I493 n1_m1_24000_302400 0 2.582832e-07
I494 n1_m1_24000_307200 0 2.604142e-07
I495 n1_m1_24000_312000 0 3.981910e-07
I496 n1_m1_24000_316800 0 2.716117e-07
I497 n1_m1_24000_321600 0 3.963012e-07
I498 n1_m1_24000_326400 0 2.554936e-07
I499 n1_m1_24000_331200 0 2.555939e-07
I500 n1_m1_24000_336000 0 3.919568e-07
I501 n1_m1_24000_340800 0 2.756247e-07
I502 n1_m1_24000_345600 0 4.061240e-07
I503 n1_m1_24000_350400 0 3.142335e-07
I504 n1_m1_24000_355200 0 3.573032e-07
I505 n1_m1_24000_360000 0 6.866130e-07
I506 n1_m1_24000_364800 0 8.657543e-07
I507 n1_m1_24000_369600 0 1.752180e-06
I508 n1_m1_24000_374400 0 1.104549e-06
I509 n1_m1_24000_379200 0 7.750898e-07
I510 n1_m1_24000_384000 0 5.869175e-07
I511 n1_m1_24000_388800 0 2.532680e-07
I512 n1_m1_24000_393600 0 3.496628e-07
I513 n1_m1_24000_398400 0 2.313720e-07
I514 n1_m1_24000_403200 0 2.246937e-07
I515 n1_m1_24000_408000 0 2.243599e-07
I516 n1_m1_28800_0 0 1.448941e-07
I517 n1_m1_28800_4800 0 1.399040e-07
I518 n1_m1_28800_9600 0 2.187758e-07
I519 n1_m1_28800_14400 0 1.530648e-07
I520 n1_m1_28800_19200 0 1.663044e-07
I521 n1_m1_28800_24000 0 2.854867e-07
I522 n1_m1_28800_28800 0 1.835438e-07
I523 n1_m1_28800_33600 0 2.638535e-07
I524 n1_m1_28800_38400 0 1.744383e-07
I525 n1_m1_28800_43200 0 1.741081e-07
I526 n1_m1_28800_48000 0 2.579653e-07
I527 n1_m1_28800_52800 0 1.707482e-07
I528 n1_m1_28800_57600 0 2.838725e-07
I529 n1_m1_28800_62400 0 1.756529e-07
I530 n1_m1_28800_67200 0 1.741390e-07
I531 n1_m1_28800_72000 0 2.631440e-07
I532 n1_m1_28800_76800 0 2.196207e-07
I533 n1_m1_28800_81600 0 1.106985e-06
I534 n1_m1_28800_86400 0 1.036967e-06
I535 n1_m1_28800_91200 0 5.112010e-07
I536 n1_m1_28800_96000 0 3.046110e-07
I537 n1_m1_28800_100800 0 1.660478e-07
I538 n1_m1_28800_105600 0 2.487245e-07
I539 n1_m1_28800_110400 0 1.648340e-07
I540 n1_m1_28800_115200 0 1.675713e-07
I541 n1_m1_28800_120000 0 2.780474e-07
I542 n1_m1_28800_124800 0 2.550596e-07
I543 n1_m1_28800_129600 0 3.353229e-07
I544 n1_m1_28800_134400 0 1.690147e-07
I545 n1_m1_28800_139200 0 1.742522e-07
I546 n1_m1_28800_144000 0 2.628773e-07
I547 n1_m1_28800_148800 0 1.930630e-07
I548 n1_m1_28800_153600 0 2.906066e-07
I549 n1_m1_28800_158400 0 1.755171e-07
I550 n1_m1_28800_163200 0 1.747012e-07
I551 n1_m1_28800_168000 0 2.608597e-07
I552 n1_m1_28800_172800 0 1.734761e-07
I553 n1_m1_28800_177600 0 3.322526e-07
I554 n1_m1_28800_182400 0 9.695412e-07
I555 n1_m1_28800_187200 0 1.113621e-06
I556 n1_m1_28800_192000 0 8.598907e-07
I557 n1_m1_28800_196800 0 1.957948e-07
I558 n1_m1_28800_201600 0 2.992053e-07
I559 n1_m1_28800_206400 0 2.185939e-07
I560 n1_m1_28800_211200 0 1.852307e-07
I561 n1_m1_28800_216000 0 3.132726e-07
I562 n1_m1_28800_220800 0 1.909954e-07
I563 n1_m1_28800_225600 0 2.825539e-07
I564 n1_m1_28800_230400 0 1.846884e-07
I565 n1_m1_28800_235200 0 1.800783e-07
I566 n1_m1_28800_240000 0 2.760352e-07
I567 n1_m1_28800_244800 0 2.110528e-07
I568 n1_m1_28800_249600 0 3.278669e-07
I569 n1_m1_28800_254400 0 1.898805e-07
I570 n1_m1_28800_259200 0 1.760926e-07
I571 n1_m1_28800_264000 0 2.587152e-07
I572 n1_m1_28800_268800 0 1.860496e-07
I573 n1_m1_28800_273600 0 2.646829e-07
I574 n1_m1_28800_278400 0 2.686396e-07
I575 n1_m1_28800_283200 0 3.241876e-07
I576 n1_m1_28800_288000 0 2.858561e-07
I577 n1_m1_28800_292800 0 1.701971e-07
I578 n1_m1_28800_297600 0 2.590284e-07
I579 n1_m1_28800_302400 0 1.700789e-07
I580 n1_m1_28800_307200 0 1.760169e-07
I581 n1_m1_28800_312000 0 4.771443e-07
I582 n1_m1_28800_316800 0 4.279191e-07
I583 n1_m1_28800_321600 0 4.055545e-07
I584 n1_m1_28800_326400 0 1.730881e-07
I585 n1_m1_28800_331200 0 1.674061e-07
I586 n1_m1_28800_336000 0 2.544591e-07
I587 n1_m1_28800_340800 0 1.766206e-07
I588 n1_m1_28800_345600 0 3.774926e-07
I589 n1_m1_28800_350400 0 7.306360e-07
I590 n1_m1_28800_355200 0 9.917103e-07
I591 n1_m1_28800_360000 0 1.141966e-06
I592 n1_m1_28800_364800 0 4.945288e-07
I593 n1_m1_28800_369600 0 3.911210e-07
I594 n1_m1_28800_374400 0 2.280343e-07
I595 n1_m1_28800_379200 0 2.118478e-07
I596 n1_m1_28800_384000 0 3.212636e-07
I597 n1_m1_28800_388800 0 2.424825e-07
I598 n1_m1_28800_393600 0 2.964579e-07
I599 n1_m1_28800_398400 0 1.554524e-07
I600 n1_m1_28800_403200 0 1.511464e-07
I601 n1_m1_28800_408000 0 1.570105e-07
I602 n1_m1_33600_0 0 1.490043e-07
I603 n1_m1_33600_4800 0 1.400746e-07
I604 n1_m1_33600_9600 0 2.192555e-07
I605 n1_m1_33600_14400 0 1.598253e-07
I606 n1_m1_33600_19200 0 1.714821e-07
I607 n1_m1_33600_24000 0 2.731835e-07
I608 n1_m1_33600_28800 0 1.829169e-07
I609 n1_m1_33600_33600 0 2.579636e-07
I610 n1_m1_33600_38400 0 1.676096e-07
I611 n1_m1_33600_43200 0 1.678187e-07
I612 n1_m1_33600_48000 0 2.507795e-07
I613 n1_m1_33600_52800 0 1.714146e-07
I614 n1_m1_33600_57600 0 2.518838e-07
I615 n1_m1_33600_62400 0 1.667230e-07
I616 n1_m1_33600_67200 0 1.699696e-07
I617 n1_m1_33600_72000 0 2.569578e-07
I618 n1_m1_33600_76800 0 1.967583e-07
I619 n1_m1_33600_81600 0 9.488628e-07
I620 n1_m1_33600_86400 0 7.091161e-07
I621 n1_m1_33600_91200 0 4.241451e-07
I622 n1_m1_33600_96000 0 2.864648e-07
I623 n1_m1_33600_100800 0 1.746910e-07
I624 n1_m1_33600_105600 0 2.605742e-07
I625 n1_m1_33600_110400 0 1.729545e-07
I626 n1_m1_33600_115200 0 1.746753e-07
I627 n1_m1_33600_120000 0 4.639494e-07
I628 n1_m1_33600_124800 0 5.754612e-07
I629 n1_m1_33600_129600 0 5.679175e-07
I630 n1_m1_33600_134400 0 1.775513e-07
I631 n1_m1_33600_139200 0 1.682829e-07
I632 n1_m1_33600_144000 0 2.579962e-07
I633 n1_m1_33600_148800 0 1.719338e-07
I634 n1_m1_33600_153600 0 2.662846e-07
I635 n1_m1_33600_158400 0 1.756354e-07
I636 n1_m1_33600_163200 0 1.764835e-07
I637 n1_m1_33600_168000 0 2.569646e-07
I638 n1_m1_33600_172800 0 1.714561e-07
I639 n1_m1_33600_177600 0 3.006231e-07
I640 n1_m1_33600_182400 0 1.046878e-06
I641 n1_m1_33600_187200 0 1.342168e-06
I642 n1_m1_33600_192000 0 1.878889e-06
I643 n1_m1_33600_196800 0 7.926912e-07
I644 n1_m1_33600_201600 0 6.140220e-07
I645 n1_m1_33600_206400 0 3.694304e-07
I646 n1_m1_33600_211200 0 2.195880e-07
I647 n1_m1_33600_216000 0 3.233171e-07
I648 n1_m1_33600_220800 0 7.702354e-07
I649 n1_m1_33600_225600 0 1.103242e-06
I650 n1_m1_33600_230400 0 2.296470e-07
I651 n1_m1_33600_235200 0 1.782428e-07
I652 n1_m1_33600_240000 0 2.658382e-07
I653 n1_m1_33600_244800 0 1.797582e-07
I654 n1_m1_33600_249600 0 2.662785e-07
I655 n1_m1_33600_254400 0 1.695690e-07
I656 n1_m1_33600_259200 0 1.710770e-07
I657 n1_m1_33600_264000 0 2.588760e-07
I658 n1_m1_33600_268800 0 1.754657e-07
I659 n1_m1_33600_273600 0 4.668711e-07
I660 n1_m1_33600_278400 0 9.666909e-07
I661 n1_m1_33600_283200 0 1.121516e-06
I662 n1_m1_33600_288000 0 4.880280e-07
I663 n1_m1_33600_292800 0 1.800455e-07
I664 n1_m1_33600_297600 0 2.569459e-07
I665 n1_m1_33600_302400 0 1.799250e-07
I666 n1_m1_33600_307200 0 1.699929e-07
I667 n1_m1_33600_312000 0 3.671299e-07
I668 n1_m1_33600_316800 0 2.969099e-07
I669 n1_m1_33600_321600 0 3.082707e-07
I670 n1_m1_33600_326400 0 1.680142e-07
I671 n1_m1_33600_331200 0 1.704714e-07
I672 n1_m1_33600_336000 0 2.544291e-07
I673 n1_m1_33600_340800 0 1.788213e-07
I674 n1_m1_33600_345600 0 2.745397e-07
I675 n1_m1_33600_350400 0 2.592064e-07
I676 n1_m1_33600_355200 0 3.354296e-07
I677 n1_m1_33600_360000 0 3.646194e-07
I678 n1_m1_33600_364800 0 1.983517e-07
I679 n1_m1_33600_369600 0 2.716167e-07
I680 n1_m1_33600_374400 0 1.877459e-07
I681 n1_m1_33600_379200 0 1.832797e-07
I682 n1_m1_33600_384000 0 2.971135e-07
I683 n1_m1_33600_388800 0 2.977693e-07
I684 n1_m1_33600_393600 0 4.367577e-07
I685 n1_m1_33600_398400 0 1.657232e-07
I686 n1_m1_33600_403200 0 1.492228e-07
I687 n1_m1_33600_408000 0 1.569796e-07
I688 n1_m1_38400_0 0 1.465966e-07
I689 n1_m1_38400_4800 0 1.464848e-07
I690 n1_m1_38400_9600 0 2.216789e-07
I691 n1_m1_38400_14400 0 1.603200e-07
I692 n1_m1_38400_19200 0 1.753784e-07
I693 n1_m1_38400_24000 0 2.923186e-07
I694 n1_m1_38400_28800 0 1.900194e-07
I695 n1_m1_38400_33600 0 2.601812e-07
I696 n1_m1_38400_38400 0 1.674708e-07
I697 n1_m1_38400_43200 0 1.652950e-07
I698 n1_m1_38400_48000 0 2.498426e-07
I699 n1_m1_38400_52800 0 1.757955e-07
I700 n1_m1_38400_57600 0 2.571262e-07
I701 n1_m1_38400_62400 0 1.716147e-07
I702 n1_m1_38400_67200 0 1.728995e-07
I703 n1_m1_38400_72000 0 2.610257e-07
I704 n1_m1_38400_76800 0 1.733934e-07
I705 n1_m1_38400_81600 0 3.775229e-07
I706 n1_m1_38400_86400 0 2.238655e-07
I707 n1_m1_38400_91200 0 1.831947e-07
I708 n1_m1_38400_96000 0 2.646258e-07
I709 n1_m1_38400_100800 0 1.799145e-07
I710 n1_m1_38400_105600 0 2.632262e-07
I711 n1_m1_38400_110400 0 1.767730e-07
I712 n1_m1_38400_115200 0 1.734309e-07
I713 n1_m1_38400_120000 0 3.065982e-07
I714 n1_m1_38400_124800 0 3.065972e-07
I715 n1_m1_38400_129600 0 3.682679e-07
I716 n1_m1_38400_134400 0 1.704100e-07
I717 n1_m1_38400_139200 0 1.687106e-07
I718 n1_m1_38400_144000 0 2.585189e-07
I719 n1_m1_38400_148800 0 1.732144e-07
I720 n1_m1_38400_153600 0 2.576529e-07
I721 n1_m1_38400_158400 0 1.697451e-07
I722 n1_m1_38400_163200 0 1.768095e-07
I723 n1_m1_38400_168000 0 2.638398e-07
I724 n1_m1_38400_172800 0 1.872557e-07
I725 n1_m1_38400_177600 0 3.137076e-07
I726 n1_m1_38400_182400 0 6.051822e-07
I727 n1_m1_38400_187200 0 1.134406e-06
I728 n1_m1_38400_192000 0 1.807305e-06
I729 n1_m1_38400_196800 0 6.816699e-07
I730 n1_m1_38400_201600 0 4.977453e-07
I731 n1_m1_38400_206400 0 2.810873e-07
I732 n1_m1_38400_211200 0 1.943487e-07
I733 n1_m1_38400_216000 0 2.853502e-07
I734 n1_m1_38400_220800 0 7.703845e-07
I735 n1_m1_38400_225600 0 1.204684e-06
I736 n1_m1_38400_230400 0 2.339751e-07
I737 n1_m1_38400_235200 0 1.740301e-07
I738 n1_m1_38400_240000 0 2.606416e-07
I739 n1_m1_38400_244800 0 1.750103e-07
I740 n1_m1_38400_249600 0 2.691656e-07
I741 n1_m1_38400_254400 0 1.784777e-07
I742 n1_m1_38400_259200 0 1.731877e-07
I743 n1_m1_38400_264000 0 2.634010e-07
I744 n1_m1_38400_268800 0 1.872444e-07
I745 n1_m1_38400_273600 0 3.858852e-07
I746 n1_m1_38400_278400 0 7.686673e-07
I747 n1_m1_38400_283200 0 9.753423e-07
I748 n1_m1_38400_288000 0 4.437515e-07
I749 n1_m1_38400_292800 0 2.421515e-07
I750 n1_m1_38400_297600 0 3.373410e-07
I751 n1_m1_38400_302400 0 3.111874e-07
I752 n1_m1_38400_307200 0 1.895726e-07
I753 n1_m1_38400_312000 0 2.656863e-07
I754 n1_m1_38400_316800 0 1.755922e-07
I755 n1_m1_38400_321600 0 2.566503e-07
I756 n1_m1_38400_326400 0 1.728346e-07
I757 n1_m1_38400_331200 0 1.775492e-07
I758 n1_m1_38400_336000 0 2.594897e-07
I759 n1_m1_38400_340800 0 1.712978e-07
I760 n1_m1_38400_345600 0 2.562146e-07
I761 n1_m1_38400_350400 0 1.762382e-07
I762 n1_m1_38400_355200 0 1.788277e-07
I763 n1_m1_38400_360000 0 2.608108e-07
I764 n1_m1_38400_364800 0 1.742565e-07
I765 n1_m1_38400_369600 0 2.619037e-07
I766 n1_m1_38400_374400 0 2.153042e-07
I767 n1_m1_38400_379200 0 2.543076e-07
I768 n1_m1_38400_384000 0 2.987356e-07
I769 n1_m1_38400_388800 0 1.903508e-07
I770 n1_m1_38400_393600 0 2.917156e-07
I771 n1_m1_38400_398400 0 1.675250e-07
I772 n1_m1_38400_403200 0 1.550066e-07
I773 n1_m1_38400_408000 0 1.529467e-07
I774 n1_m1_43200_0 0 1.441583e-07
I775 n1_m1_43200_4800 0 1.536585e-07
I776 n1_m1_43200_9600 0 2.253346e-07
I777 n1_m1_43200_14400 0 1.684475e-07
I778 n1_m1_43200_19200 0 2.557750e-07
I779 n1_m1_43200_24000 0 4.198310e-07
I780 n1_m1_43200_28800 0 1.812245e-07
I781 n1_m1_43200_33600 0 2.558782e-07
I782 n1_m1_43200_38400 0 1.653359e-07
I783 n1_m1_43200_43200 0 1.664141e-07
I784 n1_m1_43200_48000 0 2.507719e-07
I785 n1_m1_43200_52800 0 1.699051e-07
I786 n1_m1_43200_57600 0 2.502063e-07
I787 n1_m1_43200_62400 0 1.690059e-07
I788 n1_m1_43200_67200 0 1.714622e-07
I789 n1_m1_43200_72000 0 2.850942e-07
I790 n1_m1_43200_76800 0 1.820965e-07
I791 n1_m1_43200_81600 0 2.551655e-07
I792 n1_m1_43200_86400 0 1.741850e-07
I793 n1_m1_43200_91200 0 1.887793e-07
I794 n1_m1_43200_96000 0 4.073898e-07
I795 n1_m1_43200_100800 0 2.441592e-07
I796 n1_m1_43200_105600 0 3.184102e-07
I797 n1_m1_43200_110400 0 1.777494e-07
I798 n1_m1_43200_115200 0 1.700013e-07
I799 n1_m1_43200_120000 0 2.571604e-07
I800 n1_m1_43200_124800 0 1.778165e-07
I801 n1_m1_43200_129600 0 2.583952e-07
I802 n1_m1_43200_134400 0 1.978319e-07
I803 n1_m1_43200_139200 0 1.952680e-07
I804 n1_m1_43200_144000 0 2.544834e-07
I805 n1_m1_43200_148800 0 1.719883e-07
I806 n1_m1_43200_153600 0 2.498771e-07
I807 n1_m1_43200_158400 0 1.659794e-07
I808 n1_m1_43200_163200 0 1.720353e-07
I809 n1_m1_43200_168000 0 2.864723e-07
I810 n1_m1_43200_172800 0 2.451511e-07
I811 n1_m1_43200_177600 0 3.908134e-07
I812 n1_m1_43200_182400 0 2.243625e-07
I813 n1_m1_43200_187200 0 4.453839e-07
I814 n1_m1_43200_192000 0 7.894437e-07
I815 n1_m1_43200_196800 0 2.082340e-07
I816 n1_m1_43200_201600 0 3.032042e-07
I817 n1_m1_43200_206400 0 2.005684e-07
I818 n1_m1_43200_211200 0 1.814958e-07
I819 n1_m1_43200_216000 0 2.879259e-07
I820 n1_m1_43200_220800 0 2.236654e-07
I821 n1_m1_43200_225600 0 4.239499e-07
I822 n1_m1_43200_230400 0 1.844097e-07
I823 n1_m1_43200_235200 0 1.732144e-07
I824 n1_m1_43200_240000 0 2.589890e-07
I825 n1_m1_43200_244800 0 1.701399e-07
I826 n1_m1_43200_249600 0 2.602606e-07
I827 n1_m1_43200_254400 0 1.762104e-07
I828 n1_m1_43200_259200 0 1.753251e-07
I829 n1_m1_43200_264000 0 2.832345e-07
I830 n1_m1_43200_268800 0 2.422702e-07
I831 n1_m1_43200_273600 0 3.088463e-07
I832 n1_m1_43200_278400 0 4.812706e-07
I833 n1_m1_43200_283200 0 7.265864e-07
I834 n1_m1_43200_288000 0 3.556316e-07
I835 n1_m1_43200_292800 0 2.293325e-07
I836 n1_m1_43200_297600 0 6.463160e-07
I837 n1_m1_43200_302400 0 4.449923e-07
I838 n1_m1_43200_307200 0 1.789813e-07
I839 n1_m1_43200_312000 0 2.607549e-07
I840 n1_m1_43200_316800 0 1.730299e-07
I841 n1_m1_43200_321600 0 2.625919e-07
I842 n1_m1_43200_326400 0 1.736994e-07
I843 n1_m1_43200_331200 0 1.755748e-07
I844 n1_m1_43200_336000 0 2.688673e-07
I845 n1_m1_43200_340800 0 1.782311e-07
I846 n1_m1_43200_345600 0 2.670446e-07
I847 n1_m1_43200_350400 0 1.713759e-07
I848 n1_m1_43200_355200 0 1.702852e-07
I849 n1_m1_43200_360000 0 2.540718e-07
I850 n1_m1_43200_364800 0 1.704602e-07
I851 n1_m1_43200_369600 0 2.590565e-07
I852 n1_m1_43200_374400 0 2.586417e-07
I853 n1_m1_43200_379200 0 3.281750e-07
I854 n1_m1_43200_384000 0 3.501853e-07
I855 n1_m1_43200_388800 0 1.682286e-07
I856 n1_m1_43200_393600 0 2.450985e-07
I857 n1_m1_43200_398400 0 1.654768e-07
I858 n1_m1_43200_403200 0 1.592522e-07
I859 n1_m1_43200_408000 0 1.506472e-07
I860 n1_m1_48000_0 0 2.166235e-07
I861 n1_m1_48000_4800 0 2.321659e-07
I862 n1_m1_48000_9600 0 3.451410e-07
I863 n1_m1_48000_14400 0 3.132660e-07
I864 n1_m1_48000_19200 0 7.346498e-07
I865 n1_m1_48000_24000 0 1.150875e-06
I866 n1_m1_48000_28800 0 2.823205e-07
I867 n1_m1_48000_33600 0 3.837412e-07
I868 n1_m1_48000_38400 0 2.429372e-07
I869 n1_m1_48000_43200 0 2.449887e-07
I870 n1_m1_48000_48000 0 3.758312e-07
I871 n1_m1_48000_52800 0 2.554915e-07
I872 n1_m1_48000_57600 0 3.845897e-07
I873 n1_m1_48000_62400 0 2.557178e-07
I874 n1_m1_48000_67200 0 2.519605e-07
I875 n1_m1_48000_72000 0 5.385957e-07
I876 n1_m1_48000_76800 0 3.387697e-07
I877 n1_m1_48000_81600 0 4.527080e-07
I878 n1_m1_48000_86400 0 2.765034e-07
I879 n1_m1_48000_91200 0 5.792308e-07
I880 n1_m1_48000_96000 0 2.284803e-06
I881 n1_m1_48000_100800 0 1.338591e-06
I882 n1_m1_48000_105600 0 1.015349e-06
I883 n1_m1_48000_110400 0 3.336048e-07
I884 n1_m1_48000_115200 0 2.588549e-07
I885 n1_m1_48000_120000 0 3.939813e-07
I886 n1_m1_48000_124800 0 2.636225e-07
I887 n1_m1_48000_129600 0 5.389451e-07
I888 n1_m1_48000_134400 0 6.583776e-07
I889 n1_m1_48000_139200 0 6.387390e-07
I890 n1_m1_48000_144000 0 4.938539e-07
I891 n1_m1_48000_148800 0 2.592036e-07
I892 n1_m1_48000_153600 0 4.038573e-07
I893 n1_m1_48000_158400 0 2.670406e-07
I894 n1_m1_48000_163200 0 2.787512e-07
I895 n1_m1_48000_168000 0 4.511801e-07
I896 n1_m1_48000_172800 0 3.377799e-07
I897 n1_m1_48000_177600 0 5.522920e-07
I898 n1_m1_48000_182400 0 2.782498e-07
I899 n1_m1_48000_187200 0 2.821135e-07
I900 n1_m1_48000_192000 0 4.148820e-07
I901 n1_m1_48000_196800 0 3.113961e-07
I902 n1_m1_48000_201600 0 5.312081e-07
I903 n1_m1_48000_206400 0 4.504835e-07
I904 n1_m1_48000_211200 0 3.341145e-07
I905 n1_m1_48000_216000 0 4.406254e-07
I906 n1_m1_48000_220800 0 2.769612e-07
I907 n1_m1_48000_225600 0 4.186619e-07
I908 n1_m1_48000_230400 0 2.651354e-07
I909 n1_m1_48000_235200 0 2.594771e-07
I910 n1_m1_48000_240000 0 3.876242e-07
I911 n1_m1_48000_244800 0 2.588464e-07
I912 n1_m1_48000_249600 0 3.925776e-07
I913 n1_m1_48000_254400 0 2.915931e-07
I914 n1_m1_48000_259200 0 2.925354e-07
I915 n1_m1_48000_264000 0 5.627155e-07
I916 n1_m1_48000_268800 0 5.318318e-07
I917 n1_m1_48000_273600 0 4.922286e-07
I918 n1_m1_48000_278400 0 6.680650e-07
I919 n1_m1_48000_283200 0 1.610099e-06
I920 n1_m1_48000_288000 0 1.970032e-06
I921 n1_m1_48000_292800 0 5.541600e-07
I922 n1_m1_48000_297600 0 8.708381e-07
I923 n1_m1_48000_302400 0 7.481916e-07
I924 n1_m1_48000_307200 0 3.453522e-07
I925 n1_m1_48000_312000 0 4.016311e-07
I926 n1_m1_48000_316800 0 2.600000e-07
I927 n1_m1_48000_321600 0 3.877198e-07
I928 n1_m1_48000_326400 0 2.698636e-07
I929 n1_m1_48000_331200 0 2.949263e-07
I930 n1_m1_48000_336000 0 4.108576e-07
I931 n1_m1_48000_340800 0 2.693630e-07
I932 n1_m1_48000_345600 0 4.053677e-07
I933 n1_m1_48000_350400 0 2.594375e-07
I934 n1_m1_48000_355200 0 2.562195e-07
I935 n1_m1_48000_360000 0 3.901120e-07
I936 n1_m1_48000_364800 0 2.584104e-07
I937 n1_m1_48000_369600 0 3.814026e-07
I938 n1_m1_48000_374400 0 2.603217e-07
I939 n1_m1_48000_379200 0 2.634124e-07
I940 n1_m1_48000_384000 0 5.790829e-07
I941 n1_m1_48000_388800 0 3.012651e-07
I942 n1_m1_48000_393600 0 3.746072e-07
I943 n1_m1_48000_398400 0 2.411315e-07
I944 n1_m1_48000_403200 0 2.396430e-07
I945 n1_m1_48000_408000 0 2.348107e-07
I946 n1_m1_52800_0 0 1.473118e-07
I947 n1_m1_52800_4800 0 1.505494e-07
I948 n1_m1_52800_9600 0 2.391773e-07
I949 n1_m1_52800_14400 0 1.719668e-07
I950 n1_m1_52800_19200 0 1.826836e-07
I951 n1_m1_52800_24000 0 2.790018e-07
I952 n1_m1_52800_28800 0 1.726814e-07
I953 n1_m1_52800_33600 0 2.550688e-07
I954 n1_m1_52800_38400 0 1.659113e-07
I955 n1_m1_52800_43200 0 1.636130e-07
I956 n1_m1_52800_48000 0 2.516782e-07
I957 n1_m1_52800_52800 0 1.680846e-07
I958 n1_m1_52800_57600 0 2.562388e-07
I959 n1_m1_52800_62400 0 1.687725e-07
I960 n1_m1_52800_67200 0 1.667791e-07
I961 n1_m1_52800_72000 0 2.761419e-07
I962 n1_m1_52800_76800 0 3.639702e-07
I963 n1_m1_52800_81600 0 6.868980e-07
I964 n1_m1_52800_86400 0 2.990236e-07
I965 n1_m1_52800_91200 0 3.993322e-07
I966 n1_m1_52800_96000 0 1.456726e-06
I967 n1_m1_52800_100800 0 1.061179e-06
I968 n1_m1_52800_105600 0 5.119800e-07
I969 n1_m1_52800_110400 0 2.525820e-07
I970 n1_m1_52800_115200 0 1.717025e-07
I971 n1_m1_52800_120000 0 2.736325e-07
I972 n1_m1_52800_124800 0 1.992266e-07
I973 n1_m1_52800_129600 0 2.929500e-07
I974 n1_m1_52800_134400 0 3.074065e-07
I975 n1_m1_52800_139200 0 5.496105e-07
I976 n1_m1_52800_144000 0 4.775239e-07
I977 n1_m1_52800_148800 0 1.731623e-07
I978 n1_m1_52800_153600 0 2.642888e-07
I979 n1_m1_52800_158400 0 1.708692e-07
I980 n1_m1_52800_163200 0 2.314347e-07
I981 n1_m1_52800_168000 0 3.582313e-07
I982 n1_m1_52800_172800 0 1.814356e-07
I983 n1_m1_52800_177600 0 2.943287e-07
I984 n1_m1_52800_182400 0 1.765009e-07
I985 n1_m1_52800_187200 0 1.734698e-07
I986 n1_m1_52800_192000 0 2.566061e-07
I987 n1_m1_52800_196800 0 1.732144e-07
I988 n1_m1_52800_201600 0 2.739136e-07
I989 n1_m1_52800_206400 0 2.392406e-07
I990 n1_m1_52800_211200 0 2.509903e-07
I991 n1_m1_52800_216000 0 2.665155e-07
I992 n1_m1_52800_220800 0 1.751255e-07
I993 n1_m1_52800_225600 0 2.650224e-07
I994 n1_m1_52800_230400 0 1.723962e-07
I995 n1_m1_52800_235200 0 1.715814e-07
I996 n1_m1_52800_240000 0 2.498285e-07
I997 n1_m1_52800_244800 0 1.685916e-07
I998 n1_m1_52800_249600 0 2.614384e-07
I999 n1_m1_52800_254400 0 1.834829e-07
I1000 n1_m1_52800_259200 0 1.884235e-07
I1001 n1_m1_52800_264000 0 2.937776e-07
I1002 n1_m1_52800_268800 0 1.969705e-07
I1003 n1_m1_52800_273600 0 3.169648e-07
I1004 n1_m1_52800_278400 0 2.975234e-07
I1005 n1_m1_52800_283200 0 7.750294e-07
I1006 n1_m1_52800_288000 0 1.361431e-06
I1007 n1_m1_52800_292800 0 4.038256e-07
I1008 n1_m1_52800_297600 0 3.130800e-07
I1009 n1_m1_52800_302400 0 3.217853e-07
I1010 n1_m1_52800_307200 0 2.993366e-07
I1011 n1_m1_52800_312000 0 3.339651e-07
I1012 n1_m1_52800_316800 0 2.239692e-07
I1013 n1_m1_52800_321600 0 3.072397e-07
I1014 n1_m1_52800_326400 0 1.823072e-07
I1015 n1_m1_52800_331200 0 1.811229e-07
I1016 n1_m1_52800_336000 0 2.655179e-07
I1017 n1_m1_52800_340800 0 1.720575e-07
I1018 n1_m1_52800_345600 0 2.524955e-07
I1019 n1_m1_52800_350400 0 1.732144e-07
I1020 n1_m1_52800_355200 0 1.704732e-07
I1021 n1_m1_52800_360000 0 2.589201e-07
I1022 n1_m1_52800_364800 0 1.686322e-07
I1023 n1_m1_52800_369600 0 2.561019e-07
I1024 n1_m1_52800_374400 0 1.677202e-07
I1025 n1_m1_52800_379200 0 1.755949e-07
I1026 n1_m1_52800_384000 0 8.867783e-07
I1027 n1_m1_52800_388800 0 2.987312e-07
I1028 n1_m1_52800_393600 0 2.588061e-07
I1029 n1_m1_52800_398400 0 1.589872e-07
I1030 n1_m1_52800_403200 0 1.658536e-07
I1031 n1_m1_52800_408000 0 1.557827e-07
I1032 n1_m1_57600_0 0 1.514288e-07
I1033 n1_m1_57600_4800 0 1.532282e-07
I1034 n1_m1_57600_9600 0 2.346379e-07
I1035 n1_m1_57600_14400 0 1.658049e-07
I1036 n1_m1_57600_19200 0 1.740109e-07
I1037 n1_m1_57600_24000 0 2.599124e-07
I1038 n1_m1_57600_28800 0 1.689448e-07
I1039 n1_m1_57600_33600 0 2.546692e-07
I1040 n1_m1_57600_38400 0 1.665524e-07
I1041 n1_m1_57600_43200 0 1.665524e-07
I1042 n1_m1_57600_48000 0 2.518544e-07
I1043 n1_m1_57600_52800 0 1.665524e-07
I1044 n1_m1_57600_57600 0 2.498285e-07
I1045 n1_m1_57600_62400 0 1.665524e-07
I1046 n1_m1_57600_67200 0 1.666905e-07
I1047 n1_m1_57600_72000 0 2.602846e-07
I1048 n1_m1_57600_76800 0 4.348333e-07
I1049 n1_m1_57600_81600 0 1.125408e-06
I1050 n1_m1_57600_86400 0 4.345633e-07
I1051 n1_m1_57600_91200 0 1.990721e-07
I1052 n1_m1_57600_96000 0 5.879097e-07
I1053 n1_m1_57600_100800 0 5.415027e-07
I1054 n1_m1_57600_105600 0 3.245091e-07
I1055 n1_m1_57600_110400 0 1.804776e-07
I1056 n1_m1_57600_115200 0 1.753205e-07
I1057 n1_m1_57600_120000 0 3.021186e-07
I1058 n1_m1_57600_124800 0 2.752992e-07
I1059 n1_m1_57600_129600 0 2.700155e-07
I1060 n1_m1_57600_134400 0 2.305874e-07
I1061 n1_m1_57600_139200 0 3.592398e-07
I1062 n1_m1_57600_144000 0 3.832563e-07
I1063 n1_m1_57600_148800 0 1.732144e-07
I1064 n1_m1_57600_153600 0 2.686101e-07
I1065 n1_m1_57600_158400 0 1.732144e-07
I1066 n1_m1_57600_163200 0 1.969826e-07
I1067 n1_m1_57600_168000 0 2.892492e-07
I1068 n1_m1_57600_172800 0 1.697908e-07
I1069 n1_m1_57600_177600 0 2.611325e-07
I1070 n1_m1_57600_182400 0 1.732508e-07
I1071 n1_m1_57600_187200 0 1.770187e-07
I1072 n1_m1_57600_192000 0 2.620815e-07
I1073 n1_m1_57600_196800 0 1.732144e-07
I1074 n1_m1_57600_201600 0 2.665488e-07
I1075 n1_m1_57600_206400 0 1.841574e-07
I1076 n1_m1_57600_211200 0 1.825622e-07
I1077 n1_m1_57600_216000 0 2.520768e-07
I1078 n1_m1_57600_220800 0 1.716890e-07
I1079 n1_m1_57600_225600 0 2.643839e-07
I1080 n1_m1_57600_230400 0 1.739891e-07
I1081 n1_m1_57600_235200 0 1.715814e-07
I1082 n1_m1_57600_240000 0 2.498285e-07
I1083 n1_m1_57600_244800 0 1.685916e-07
I1084 n1_m1_57600_249600 0 2.614384e-07
I1085 n1_m1_57600_254400 0 1.781693e-07
I1086 n1_m1_57600_259200 0 1.785443e-07
I1087 n1_m1_57600_264000 0 2.645402e-07
I1088 n1_m1_57600_268800 0 1.758305e-07
I1089 n1_m1_57600_273600 0 2.654877e-07
I1090 n1_m1_57600_278400 0 1.895563e-07
I1091 n1_m1_57600_283200 0 2.483899e-07
I1092 n1_m1_57600_288000 0 4.598489e-07
I1093 n1_m1_57600_292800 0 2.453923e-07
I1094 n1_m1_57600_297600 0 2.691968e-07
I1095 n1_m1_57600_302400 0 2.064452e-07
I1096 n1_m1_57600_307200 0 2.632801e-07
I1097 n1_m1_57600_312000 0 3.871182e-07
I1098 n1_m1_57600_316800 0 3.424535e-07
I1099 n1_m1_57600_321600 0 3.770240e-07
I1100 n1_m1_57600_326400 0 1.719798e-07
I1101 n1_m1_57600_331200 0 1.848312e-07
I1102 n1_m1_57600_336000 0 2.598217e-07
I1103 n1_m1_57600_340800 0 1.732144e-07
I1104 n1_m1_57600_345600 0 2.577511e-07
I1105 n1_m1_57600_350400 0 1.748032e-07
I1106 n1_m1_57600_355200 0 1.824512e-07
I1107 n1_m1_57600_360000 0 2.623825e-07
I1108 n1_m1_57600_364800 0 1.684793e-07
I1109 n1_m1_57600_369600 0 2.559359e-07
I1110 n1_m1_57600_374400 0 1.714151e-07
I1111 n1_m1_57600_379200 0 1.759551e-07
I1112 n1_m1_57600_384000 0 6.686716e-07
I1113 n1_m1_57600_388800 0 2.254470e-07
I1114 n1_m1_57600_393600 0 2.596992e-07
I1115 n1_m1_57600_398400 0 1.598881e-07
I1116 n1_m1_57600_403200 0 1.615802e-07
I1117 n1_m1_57600_408000 0 1.601708e-07
I1118 n1_m1_62400_0 0 1.532282e-07
I1119 n1_m1_62400_4800 0 1.532282e-07
I1120 n1_m1_62400_9600 0 2.344002e-07
I1121 n1_m1_62400_14400 0 1.598903e-07
I1122 n1_m1_62400_19200 0 1.624576e-07
I1123 n1_m1_62400_24000 0 2.493171e-07
I1124 n1_m1_62400_28800 0 1.665524e-07
I1125 n1_m1_62400_33600 0 2.496579e-07
I1126 n1_m1_62400_38400 0 1.614900e-07
I1127 n1_m1_62400_43200 0 1.640988e-07
I1128 n1_m1_62400_48000 0 2.549876e-07
I1129 n1_m1_62400_52800 0 1.689410e-07
I1130 n1_m1_62400_57600 0 2.624957e-07
I1131 n1_m1_62400_62400 0 1.700134e-07
I1132 n1_m1_62400_67200 0 1.665524e-07
I1133 n1_m1_62400_72000 0 2.538420e-07
I1134 n1_m1_62400_76800 0 2.104630e-07
I1135 n1_m1_62400_81600 0 8.182989e-07
I1136 n1_m1_62400_86400 0 4.715444e-07
I1137 n1_m1_62400_91200 0 2.415384e-07
I1138 n1_m1_62400_96000 0 2.789435e-07
I1139 n1_m1_62400_100800 0 1.719551e-07
I1140 n1_m1_62400_105600 0 2.809205e-07
I1141 n1_m1_62400_110400 0 1.780456e-07
I1142 n1_m1_62400_115200 0 1.984861e-07
I1143 n1_m1_62400_120000 0 5.783177e-07
I1144 n1_m1_62400_124800 0 1.853093e-07
I1145 n1_m1_62400_129600 0 2.590931e-07
I1146 n1_m1_62400_134400 0 1.699321e-07
I1147 n1_m1_62400_139200 0 1.675517e-07
I1148 n1_m1_62400_144000 0 2.647398e-07
I1149 n1_m1_62400_148800 0 1.809696e-07
I1150 n1_m1_62400_153600 0 2.632990e-07
I1151 n1_m1_62400_158400 0 1.684517e-07
I1152 n1_m1_62400_163200 0 1.689540e-07
I1153 n1_m1_62400_168000 0 2.530363e-07
I1154 n1_m1_62400_172800 0 1.667671e-07
I1155 n1_m1_62400_177600 0 2.890049e-07
I1156 n1_m1_62400_182400 0 2.487317e-07
I1157 n1_m1_62400_187200 0 2.623240e-07
I1158 n1_m1_62400_192000 0 3.307973e-07
I1159 n1_m1_62400_196800 0 1.798765e-07
I1160 n1_m1_62400_201600 0 2.689496e-07
I1161 n1_m1_62400_206400 0 1.721094e-07
I1162 n1_m1_62400_211200 0 1.665524e-07
I1163 n1_m1_62400_216000 0 2.561538e-07
I1164 n1_m1_62400_220800 0 1.680428e-07
I1165 n1_m1_62400_225600 0 2.499703e-07
I1166 n1_m1_62400_230400 0 1.726016e-07
I1167 n1_m1_62400_235200 0 1.732144e-07
I1168 n1_m1_62400_240000 0 2.598217e-07
I1169 n1_m1_62400_244800 0 1.732144e-07
I1170 n1_m1_62400_249600 0 2.598217e-07
I1171 n1_m1_62400_254400 0 1.745651e-07
I1172 n1_m1_62400_259200 0 1.764155e-07
I1173 n1_m1_62400_264000 0 2.665057e-07
I1174 n1_m1_62400_268800 0 1.822461e-07
I1175 n1_m1_62400_273600 0 2.746164e-07
I1176 n1_m1_62400_278400 0 1.831071e-07
I1177 n1_m1_62400_283200 0 1.824952e-07
I1178 n1_m1_62400_288000 0 2.730173e-07
I1179 n1_m1_62400_292800 0 1.835941e-07
I1180 n1_m1_62400_297600 0 2.723017e-07
I1181 n1_m1_62400_302400 0 1.790602e-07
I1182 n1_m1_62400_307200 0 4.104309e-07
I1183 n1_m1_62400_312000 0 8.389566e-07
I1184 n1_m1_62400_316800 0 3.736334e-07
I1185 n1_m1_62400_321600 0 2.958345e-07
I1186 n1_m1_62400_326400 0 1.762107e-07
I1187 n1_m1_62400_331200 0 1.773708e-07
I1188 n1_m1_62400_336000 0 2.638352e-07
I1189 n1_m1_62400_340800 0 1.770980e-07
I1190 n1_m1_62400_345600 0 3.297987e-07
I1191 n1_m1_62400_350400 0 2.749645e-07
I1192 n1_m1_62400_355200 0 3.318091e-07
I1193 n1_m1_62400_360000 0 2.998113e-07
I1194 n1_m1_62400_364800 0 1.705821e-07
I1195 n1_m1_62400_369600 0 2.545497e-07
I1196 n1_m1_62400_374400 0 1.763904e-07
I1197 n1_m1_62400_379200 0 1.817701e-07
I1198 n1_m1_62400_384000 0 3.148674e-07
I1199 n1_m1_62400_388800 0 1.797309e-07
I1200 n1_m1_62400_393600 0 2.583511e-07
I1201 n1_m1_62400_398400 0 1.615152e-07
I1202 n1_m1_62400_403200 0 1.553976e-07
I1203 n1_m1_62400_408000 0 1.634731e-07
I1204 n1_m1_67200_0 0 1.532282e-07
I1205 n1_m1_67200_4800 0 1.549897e-07
I1206 n1_m1_67200_9600 0 2.392563e-07
I1207 n1_m1_67200_14400 0 1.600284e-07
I1208 n1_m1_67200_19200 0 1.600828e-07
I1209 n1_m1_67200_24000 0 2.454726e-07
I1210 n1_m1_67200_28800 0 1.665524e-07
I1211 n1_m1_67200_33600 0 2.496615e-07
I1212 n1_m1_67200_38400 0 1.610865e-07
I1213 n1_m1_67200_43200 0 1.618185e-07
I1214 n1_m1_67200_48000 0 2.550459e-07
I1215 n1_m1_67200_52800 0 1.691181e-07
I1216 n1_m1_67200_57600 0 2.614062e-07
I1217 n1_m1_67200_62400 0 1.700080e-07
I1218 n1_m1_67200_67200 0 1.667883e-07
I1219 n1_m1_67200_72000 0 2.540900e-07
I1220 n1_m1_67200_76800 0 2.135114e-07
I1221 n1_m1_67200_81600 0 1.119547e-06
I1222 n1_m1_67200_86400 0 6.754283e-07
I1223 n1_m1_67200_91200 0 2.541779e-07
I1224 n1_m1_67200_96000 0 2.630739e-07
I1225 n1_m1_67200_100800 0 1.884419e-07
I1226 n1_m1_67200_105600 0 2.774389e-07
I1227 n1_m1_67200_110400 0 1.854660e-07
I1228 n1_m1_67200_115200 0 1.970061e-07
I1229 n1_m1_67200_120000 0 4.404982e-07
I1230 n1_m1_67200_124800 0 2.918105e-07
I1231 n1_m1_67200_129600 0 3.884131e-07
I1232 n1_m1_67200_134400 0 1.914539e-07
I1233 n1_m1_67200_139200 0 1.722431e-07
I1234 n1_m1_67200_144000 0 2.642272e-07
I1235 n1_m1_67200_148800 0 1.788455e-07
I1236 n1_m1_67200_153600 0 2.544404e-07
I1237 n1_m1_67200_158400 0 1.666905e-07
I1238 n1_m1_67200_163200 0 1.666905e-07
I1239 n1_m1_67200_168000 0 2.500357e-07
I1240 n1_m1_67200_172800 0 1.702797e-07
I1241 n1_m1_67200_177600 0 2.657742e-07
I1242 n1_m1_67200_182400 0 1.948298e-07
I1243 n1_m1_67200_187200 0 2.033569e-07
I1244 n1_m1_67200_192000 0 2.828606e-07
I1245 n1_m1_67200_196800 0 1.750615e-07
I1246 n1_m1_67200_201600 0 2.627343e-07
I1247 n1_m1_67200_206400 0 1.714602e-07
I1248 n1_m1_67200_211200 0 1.665958e-07
I1249 n1_m1_67200_216000 0 2.508863e-07
I1250 n1_m1_67200_220800 0 1.709638e-07
I1251 n1_m1_67200_225600 0 2.505466e-07
I1252 n1_m1_67200_230400 0 1.720182e-07
I1253 n1_m1_67200_235200 0 1.732144e-07
I1254 n1_m1_67200_240000 0 2.598217e-07
I1255 n1_m1_67200_244800 0 1.732144e-07
I1256 n1_m1_67200_249600 0 2.598217e-07
I1257 n1_m1_67200_254400 0 1.740338e-07
I1258 n1_m1_67200_259200 0 1.751562e-07
I1259 n1_m1_67200_264000 0 2.627343e-07
I1260 n1_m1_67200_268800 0 1.799855e-07
I1261 n1_m1_67200_273600 0 2.727042e-07
I1262 n1_m1_67200_278400 0 1.844152e-07
I1263 n1_m1_67200_283200 0 1.776005e-07
I1264 n1_m1_67200_288000 0 2.648103e-07
I1265 n1_m1_67200_292800 0 1.724936e-07
I1266 n1_m1_67200_297600 0 2.708801e-07
I1267 n1_m1_67200_302400 0 1.809477e-07
I1268 n1_m1_67200_307200 0 4.895724e-07
I1269 n1_m1_67200_312000 0 1.256288e-06
I1270 n1_m1_67200_316800 0 4.920280e-07
I1271 n1_m1_67200_321600 0 3.248586e-07
I1272 n1_m1_67200_326400 0 1.995392e-07
I1273 n1_m1_67200_331200 0 1.758852e-07
I1274 n1_m1_67200_336000 0 2.623927e-07
I1275 n1_m1_67200_340800 0 1.774060e-07
I1276 n1_m1_67200_345600 0 3.678904e-07
I1277 n1_m1_67200_350400 0 3.999632e-07
I1278 n1_m1_67200_355200 0 4.391311e-07
I1279 n1_m1_67200_360000 0 3.234584e-07
I1280 n1_m1_67200_364800 0 1.742578e-07
I1281 n1_m1_67200_369600 0 2.550688e-07
I1282 n1_m1_67200_374400 0 1.826581e-07
I1283 n1_m1_67200_379200 0 1.850109e-07
I1284 n1_m1_67200_384000 0 2.682183e-07
I1285 n1_m1_67200_388800 0 1.870549e-07
I1286 n1_m1_67200_393600 0 2.533538e-07
I1287 n1_m1_67200_398400 0 1.632997e-07
I1288 n1_m1_67200_403200 0 1.520308e-07
I1289 n1_m1_67200_408000 0 1.609189e-07
I1290 n1_m1_72000_0 0 2.298422e-07
I1291 n1_m1_72000_4800 0 2.335714e-07
I1292 n1_m1_72000_9600 0 3.697161e-07
I1293 n1_m1_72000_14400 0 2.487155e-07
I1294 n1_m1_72000_19200 0 2.487155e-07
I1295 n1_m1_72000_24000 0 3.737600e-07
I1296 n1_m1_72000_28800 0 2.498285e-07
I1297 n1_m1_72000_33600 0 3.747143e-07
I1298 n1_m1_72000_38400 0 2.488960e-07
I1299 n1_m1_72000_43200 0 2.490209e-07
I1300 n1_m1_72000_48000 0 3.997764e-07
I1301 n1_m1_72000_52800 0 3.088742e-07
I1302 n1_m1_72000_57600 0 3.882084e-07
I1303 n1_m1_72000_62400 0 2.702577e-07
I1304 n1_m1_72000_67200 0 3.293145e-07
I1305 n1_m1_72000_72000 0 4.472006e-07
I1306 n1_m1_72000_76800 0 2.980422e-07
I1307 n1_m1_72000_81600 0 1.177187e-06
I1308 n1_m1_72000_86400 0 6.566772e-07
I1309 n1_m1_72000_91200 0 3.011185e-07
I1310 n1_m1_72000_96000 0 4.006791e-07
I1311 n1_m1_72000_100800 0 2.631961e-07
I1312 n1_m1_72000_105600 0 9.473895e-07
I1313 n1_m1_72000_110400 0 1.005481e-06
I1314 n1_m1_72000_115200 0 4.840811e-07
I1315 n1_m1_72000_120000 0 1.345194e-06
I1316 n1_m1_72000_124800 0 1.020475e-06
I1317 n1_m1_72000_129600 0 8.237663e-07
I1318 n1_m1_72000_134400 0 2.956589e-07
I1319 n1_m1_72000_139200 0 2.568800e-07
I1320 n1_m1_72000_144000 0 3.840461e-07
I1321 n1_m1_72000_148800 0 2.575360e-07
I1322 n1_m1_72000_153600 0 3.933123e-07
I1323 n1_m1_72000_158400 0 2.627221e-07
I1324 n1_m1_72000_163200 0 2.626976e-07
I1325 n1_m1_72000_168000 0 3.910926e-07
I1326 n1_m1_72000_172800 0 2.605326e-07
I1327 n1_m1_72000_177600 0 3.883771e-07
I1328 n1_m1_72000_182400 0 2.583922e-07
I1329 n1_m1_72000_187200 0 2.562415e-07
I1330 n1_m1_72000_192000 0 3.792758e-07
I1331 n1_m1_72000_196800 0 2.537356e-07
I1332 n1_m1_72000_201600 0 3.897325e-07
I1333 n1_m1_72000_206400 0 2.610880e-07
I1334 n1_m1_72000_211200 0 2.566360e-07
I1335 n1_m1_72000_216000 0 3.812829e-07
I1336 n1_m1_72000_220800 0 3.885294e-07
I1337 n1_m1_72000_225600 0 6.127003e-07
I1338 n1_m1_72000_230400 0 2.760725e-07
I1339 n1_m1_72000_235200 0 2.598217e-07
I1340 n1_m1_72000_240000 0 3.897325e-07
I1341 n1_m1_72000_244800 0 2.598217e-07
I1342 n1_m1_72000_249600 0 3.897325e-07
I1343 n1_m1_72000_254400 0 2.615152e-07
I1344 n1_m1_72000_259200 0 2.638352e-07
I1345 n1_m1_72000_264000 0 3.935698e-07
I1346 n1_m1_72000_268800 0 2.638270e-07
I1347 n1_m1_72000_273600 0 4.093802e-07
I1348 n1_m1_72000_278400 0 2.897268e-07
I1349 n1_m1_72000_283200 0 2.876895e-07
I1350 n1_m1_72000_288000 0 4.411621e-07
I1351 n1_m1_72000_292800 0 5.717502e-07
I1352 n1_m1_72000_297600 0 7.125454e-07
I1353 n1_m1_72000_302400 0 2.611410e-07
I1354 n1_m1_72000_307200 0 3.609620e-07
I1355 n1_m1_72000_312000 0 1.714832e-06
I1356 n1_m1_72000_316800 0 1.236058e-06
I1357 n1_m1_72000_321600 0 7.973395e-07
I1358 n1_m1_72000_326400 0 2.917204e-07
I1359 n1_m1_72000_331200 0 2.691684e-07
I1360 n1_m1_72000_336000 0 6.140934e-07
I1361 n1_m1_72000_340800 0 4.936864e-07
I1362 n1_m1_72000_345600 0 4.749061e-07
I1363 n1_m1_72000_350400 0 5.293776e-07
I1364 n1_m1_72000_355200 0 6.192497e-07
I1365 n1_m1_72000_360000 0 4.783095e-07
I1366 n1_m1_72000_364800 0 2.621859e-07
I1367 n1_m1_72000_369600 0 3.851582e-07
I1368 n1_m1_72000_374400 0 3.019135e-07
I1369 n1_m1_72000_379200 0 2.913971e-07
I1370 n1_m1_72000_384000 0 4.238435e-07
I1371 n1_m1_72000_388800 0 3.972981e-07
I1372 n1_m1_72000_393600 0 3.831863e-07
I1373 n1_m1_72000_398400 0 2.475679e-07
I1374 n1_m1_72000_403200 0 2.288051e-07
I1375 n1_m1_72000_408000 0 2.404691e-07
I1376 n1_m1_76800_0 0 1.445755e-07
I1377 n1_m1_76800_4800 0 1.505877e-07
I1378 n1_m1_76800_9600 0 2.338683e-07
I1379 n1_m1_76800_14400 0 1.588375e-07
I1380 n1_m1_76800_19200 0 1.614411e-07
I1381 n1_m1_76800_24000 0 2.432041e-07
I1382 n1_m1_76800_28800 0 1.676723e-07
I1383 n1_m1_76800_33600 0 2.656805e-07
I1384 n1_m1_76800_38400 0 1.681818e-07
I1385 n1_m1_76800_43200 0 1.729316e-07
I1386 n1_m1_76800_48000 0 2.781253e-07
I1387 n1_m1_76800_52800 0 2.347840e-07
I1388 n1_m1_76800_57600 0 2.648671e-07
I1389 n1_m1_76800_62400 0 1.783791e-07
I1390 n1_m1_76800_67200 0 2.054017e-07
I1391 n1_m1_76800_72000 0 2.942662e-07
I1392 n1_m1_76800_76800 0 1.816408e-07
I1393 n1_m1_76800_81600 0 4.040584e-07
I1394 n1_m1_76800_86400 0 2.401688e-07
I1395 n1_m1_76800_91200 0 1.770191e-07
I1396 n1_m1_76800_96000 0 2.548160e-07
I1397 n1_m1_76800_100800 0 1.716559e-07
I1398 n1_m1_76800_105600 0 1.019307e-06
I1399 n1_m1_76800_110400 0 1.234352e-06
I1400 n1_m1_76800_115200 0 5.387631e-07
I1401 n1_m1_76800_120000 0 5.370311e-07
I1402 n1_m1_76800_124800 0 3.439611e-07
I1403 n1_m1_76800_129600 0 3.157713e-07
I1404 n1_m1_76800_134400 0 1.941673e-07
I1405 n1_m1_76800_139200 0 1.754892e-07
I1406 n1_m1_76800_144000 0 3.108984e-07
I1407 n1_m1_76800_148800 0 2.213601e-07
I1408 n1_m1_76800_153600 0 2.787142e-07
I1409 n1_m1_76800_158400 0 1.836157e-07
I1410 n1_m1_76800_163200 0 1.806795e-07
I1411 n1_m1_76800_168000 0 2.613575e-07
I1412 n1_m1_76800_172800 0 1.850678e-07
I1413 n1_m1_76800_177600 0 3.062431e-07
I1414 n1_m1_76800_182400 0 2.025895e-07
I1415 n1_m1_76800_187200 0 1.889273e-07
I1416 n1_m1_76800_192000 0 2.628651e-07
I1417 n1_m1_76800_196800 0 1.705491e-07
I1418 n1_m1_76800_201600 0 2.544229e-07
I1419 n1_m1_76800_206400 0 1.763975e-07
I1420 n1_m1_76800_211200 0 1.683340e-07
I1421 n1_m1_76800_216000 0 2.869384e-07
I1422 n1_m1_76800_220800 0 7.155868e-07
I1423 n1_m1_76800_225600 0 1.320035e-06
I1424 n1_m1_76800_230400 0 3.064436e-07
I1425 n1_m1_76800_235200 0 1.832816e-07
I1426 n1_m1_76800_240000 0 2.645570e-07
I1427 n1_m1_76800_244800 0 1.739978e-07
I1428 n1_m1_76800_249600 0 2.598217e-07
I1429 n1_m1_76800_254400 0 1.835297e-07
I1430 n1_m1_76800_259200 0 1.884408e-07
I1431 n1_m1_76800_264000 0 2.750531e-07
I1432 n1_m1_76800_268800 0 1.849915e-07
I1433 n1_m1_76800_273600 0 2.689661e-07
I1434 n1_m1_76800_278400 0 2.051991e-07
I1435 n1_m1_76800_283200 0 1.947333e-07
I1436 n1_m1_76800_288000 0 2.733975e-07
I1437 n1_m1_76800_292800 0 3.227180e-07
I1438 n1_m1_76800_297600 0 5.252661e-07
I1439 n1_m1_76800_302400 0 1.871161e-07
I1440 n1_m1_76800_307200 0 1.932837e-07
I1441 n1_m1_76800_312000 0 6.556978e-07
I1442 n1_m1_76800_316800 0 6.578586e-07
I1443 n1_m1_76800_321600 0 6.540061e-07
I1444 n1_m1_76800_326400 0 2.036581e-07
I1445 n1_m1_76800_331200 0 1.768279e-07
I1446 n1_m1_76800_336000 0 3.927260e-07
I1447 n1_m1_76800_340800 0 3.815516e-07
I1448 n1_m1_76800_345600 0 3.323570e-07
I1449 n1_m1_76800_350400 0 2.024382e-07
I1450 n1_m1_76800_355200 0 2.248407e-07
I1451 n1_m1_76800_360000 0 4.125011e-07
I1452 n1_m1_76800_364800 0 1.779799e-07
I1453 n1_m1_76800_369600 0 2.615599e-07
I1454 n1_m1_76800_374400 0 1.841308e-07
I1455 n1_m1_76800_379200 0 2.084150e-07
I1456 n1_m1_76800_384000 0 3.417220e-07
I1457 n1_m1_76800_388800 0 2.020093e-07
I1458 n1_m1_76800_393600 0 2.601719e-07
I1459 n1_m1_76800_398400 0 1.702852e-07
I1460 n1_m1_76800_403200 0 1.609957e-07
I1461 n1_m1_76800_408000 0 1.570059e-07
I1462 n1_m1_81600_0 0 2.130596e-07
I1463 n1_m1_81600_4800 0 2.235783e-07
I1464 n1_m1_81600_9600 0 3.447634e-07
I1465 n1_m1_81600_14400 0 2.347901e-07
I1466 n1_m1_81600_19200 0 2.399673e-07
I1467 n1_m1_81600_24000 0 3.773680e-07
I1468 n1_m1_81600_28800 0 2.869851e-07
I1469 n1_m1_81600_33600 0 4.286377e-07
I1470 n1_m1_81600_38400 0 3.584027e-07
I1471 n1_m1_81600_43200 0 2.626220e-07
I1472 n1_m1_81600_48000 0 4.042690e-07
I1473 n1_m1_81600_52800 0 3.382893e-07
I1474 n1_m1_81600_57600 0 4.255097e-07
I1475 n1_m1_81600_62400 0 2.623288e-07
I1476 n1_m1_81600_67200 0 2.574903e-07
I1477 n1_m1_81600_72000 0 3.875574e-07
I1478 n1_m1_81600_76800 0 2.601101e-07
I1479 n1_m1_81600_81600 0 3.989813e-07
I1480 n1_m1_81600_86400 0 2.674262e-07
I1481 n1_m1_81600_91200 0 2.698342e-07
I1482 n1_m1_81600_96000 0 4.017569e-07
I1483 n1_m1_81600_100800 0 2.704261e-07
I1484 n1_m1_81600_105600 0 7.574430e-07
I1485 n1_m1_81600_110400 0 1.093431e-06
I1486 n1_m1_81600_115200 0 5.724386e-07
I1487 n1_m1_81600_120000 0 4.204479e-07
I1488 n1_m1_81600_124800 0 2.749951e-07
I1489 n1_m1_81600_129600 0 4.760273e-07
I1490 n1_m1_81600_134400 0 2.832199e-07
I1491 n1_m1_81600_139200 0 3.065158e-07
I1492 n1_m1_81600_144000 0 4.451118e-07
I1493 n1_m1_81600_148800 0 3.232419e-07
I1494 n1_m1_81600_153600 0 4.304214e-07
I1495 n1_m1_81600_158400 0 2.660613e-07
I1496 n1_m1_81600_163200 0 2.690566e-07
I1497 n1_m1_81600_168000 0 5.497060e-07
I1498 n1_m1_81600_172800 0 5.882161e-07
I1499 n1_m1_81600_177600 0 1.114470e-06
I1500 n1_m1_81600_182400 0 6.688287e-07
I1501 n1_m1_81600_187200 0 4.576047e-07
I1502 n1_m1_81600_192000 0 4.279859e-07
I1503 n1_m1_81600_196800 0 2.582794e-07
I1504 n1_m1_81600_201600 0 3.837017e-07
I1505 n1_m1_81600_206400 0 2.626170e-07
I1506 n1_m1_81600_211200 0 2.703390e-07
I1507 n1_m1_81600_216000 0 4.957476e-07
I1508 n1_m1_81600_220800 0 5.804903e-07
I1509 n1_m1_81600_225600 0 1.442019e-06
I1510 n1_m1_81600_230400 0 3.874839e-07
I1511 n1_m1_81600_235200 0 2.677107e-07
I1512 n1_m1_81600_240000 0 4.098733e-07
I1513 n1_m1_81600_244800 0 2.725444e-07
I1514 n1_m1_81600_249600 0 3.859405e-07
I1515 n1_m1_81600_254400 0 2.845146e-07
I1516 n1_m1_81600_259200 0 3.107733e-07
I1517 n1_m1_81600_264000 0 4.127108e-07
I1518 n1_m1_81600_268800 0 2.673166e-07
I1519 n1_m1_81600_273600 0 4.034030e-07
I1520 n1_m1_81600_278400 0 2.822571e-07
I1521 n1_m1_81600_283200 0 2.654436e-07
I1522 n1_m1_81600_288000 0 4.142415e-07
I1523 n1_m1_81600_292800 0 3.476294e-07
I1524 n1_m1_81600_297600 0 4.739773e-07
I1525 n1_m1_81600_302400 0 2.713741e-07
I1526 n1_m1_81600_307200 0 2.655777e-07
I1527 n1_m1_81600_312000 0 4.574988e-07
I1528 n1_m1_81600_316800 0 4.174391e-07
I1529 n1_m1_81600_321600 0 5.421787e-07
I1530 n1_m1_81600_326400 0 2.665774e-07
I1531 n1_m1_81600_331200 0 2.588711e-07
I1532 n1_m1_81600_336000 0 4.008725e-07
I1533 n1_m1_81600_340800 0 3.010785e-07
I1534 n1_m1_81600_345600 0 4.068278e-07
I1535 n1_m1_81600_350400 0 2.628004e-07
I1536 n1_m1_81600_355200 0 2.607722e-07
I1537 n1_m1_81600_360000 0 5.766227e-07
I1538 n1_m1_81600_364800 0 2.847783e-07
I1539 n1_m1_81600_369600 0 4.219281e-07
I1540 n1_m1_81600_374400 0 3.027144e-07
I1541 n1_m1_81600_379200 0 2.859631e-07
I1542 n1_m1_81600_384000 0 3.958541e-07
I1543 n1_m1_81600_388800 0 2.624059e-07
I1544 n1_m1_81600_393600 0 4.034792e-07
I1545 n1_m1_81600_398400 0 2.652082e-07
I1546 n1_m1_81600_403200 0 2.527290e-07
I1547 n1_m1_81600_408000 0 2.421265e-07
I1548 n1_m1_86400_0 0 7.250629e-08
I1549 n1_m1_86400_4800 0 7.452608e-08
I1550 n1_m1_86400_9600 0 1.149211e-07
I1551 n1_m1_86400_14400 0 7.826336e-08
I1552 n1_m1_86400_19200 0 8.000689e-08
I1553 n1_m1_86400_24000 0 1.249592e-07
I1554 n1_m1_86400_28800 0 1.067229e-07
I1555 n1_m1_86400_33600 0 2.974928e-07
I1556 n1_m1_86400_38400 0 3.623848e-07
I1557 n1_m1_86400_43200 0 1.984575e-07
I1558 n1_m1_86400_48000 0 1.327917e-07
I1559 n1_m1_86400_52800 0 9.810605e-08
I1560 n1_m1_86400_57600 0 1.473884e-07
I1561 n1_m1_86400_62400 0 8.948157e-08
I1562 n1_m1_86400_67200 0 8.424705e-08
I1563 n1_m1_86400_72000 0 1.255946e-07
I1564 n1_m1_86400_76800 0 9.289485e-08
I1565 n1_m1_86400_81600 0 1.317955e-07
I1566 n1_m1_86400_86400 0 9.119371e-08
I1567 n1_m1_86400_91200 0 1.190409e-07
I1568 n1_m1_86400_96000 0 1.705788e-07
I1569 n1_m1_86400_100800 0 8.856683e-08
I1570 n1_m1_86400_105600 0 1.329470e-07
I1571 n1_m1_86400_110400 0 1.326267e-07
I1572 n1_m1_86400_115200 0 1.164941e-07
I1573 n1_m1_86400_120000 0 1.369760e-07
I1574 n1_m1_86400_124800 0 9.762365e-08
I1575 n1_m1_86400_129600 0 1.422492e-07
I1576 n1_m1_86400_134400 0 1.034536e-07
I1577 n1_m1_86400_139200 0 1.073601e-07
I1578 n1_m1_86400_144000 0 1.350166e-07
I1579 n1_m1_86400_148800 0 9.417748e-08
I1580 n1_m1_86400_153600 0 1.487382e-07
I1581 n1_m1_86400_158400 0 9.275975e-08
I1582 n1_m1_86400_163200 0 9.311298e-08
I1583 n1_m1_86400_168000 0 2.366596e-07
I1584 n1_m1_86400_172800 0 3.558032e-07
I1585 n1_m1_86400_177600 0 5.502417e-07
I1586 n1_m1_86400_182400 0 1.934778e-07
I1587 n1_m1_86400_187200 0 1.344114e-07
I1588 n1_m1_86400_192000 0 1.397082e-07
I1589 n1_m1_86400_196800 0 8.880896e-08
I1590 n1_m1_86400_201600 0 1.374884e-07
I1591 n1_m1_86400_206400 0 9.440720e-08
I1592 n1_m1_86400_211200 0 9.863694e-08
I1593 n1_m1_86400_216000 0 3.161427e-07
I1594 n1_m1_86400_220800 0 1.617119e-07
I1595 n1_m1_86400_225600 0 2.136778e-07
I1596 n1_m1_86400_230400 0 9.421654e-08
I1597 n1_m1_86400_235200 0 8.705407e-08
I1598 n1_m1_86400_240000 0 1.320042e-07
I1599 n1_m1_86400_244800 0 8.817448e-08
I1600 n1_m1_86400_249600 0 1.272257e-07
I1601 n1_m1_86400_254400 0 9.232537e-08
I1602 n1_m1_86400_259200 0 9.864397e-08
I1603 n1_m1_86400_264000 0 1.341837e-07
I1604 n1_m1_86400_268800 0 9.020787e-08
I1605 n1_m1_86400_273600 0 1.327628e-07
I1606 n1_m1_86400_278400 0 9.116439e-08
I1607 n1_m1_86400_283200 0 8.781941e-08
I1608 n1_m1_86400_288000 0 1.594384e-07
I1609 n1_m1_86400_292800 0 1.306439e-07
I1610 n1_m1_86400_297600 0 1.434886e-07
I1611 n1_m1_86400_302400 0 9.349680e-08
I1612 n1_m1_86400_307200 0 9.254463e-08
I1613 n1_m1_86400_312000 0 1.308076e-07
I1614 n1_m1_86400_316800 0 8.821166e-08
I1615 n1_m1_86400_321600 0 1.295967e-07
I1616 n1_m1_86400_326400 0 8.386234e-08
I1617 n1_m1_86400_331200 0 8.633505e-08
I1618 n1_m1_86400_336000 0 1.287180e-07
I1619 n1_m1_86400_340800 0 8.506944e-08
I1620 n1_m1_86400_345600 0 1.311726e-07
I1621 n1_m1_86400_350400 0 9.083197e-08
I1622 n1_m1_86400_355200 0 8.739663e-08
I1623 n1_m1_86400_360000 0 1.349087e-07
I1624 n1_m1_86400_364800 0 1.723378e-07
I1625 n1_m1_86400_369600 0 2.433260e-07
I1626 n1_m1_86400_374400 0 8.727380e-08
I1627 n1_m1_86400_379200 0 9.820664e-08
I1628 n1_m1_86400_384000 0 1.305726e-07
I1629 n1_m1_86400_388800 0 8.692811e-08
I1630 n1_m1_86400_393600 0 1.316048e-07
I1631 n1_m1_86400_398400 0 8.647723e-08
I1632 n1_m1_86400_403200 0 8.231748e-08
I1633 n1_m1_86400_408000 0 7.878332e-08
I1634 n1_m1_91200_0 0 1.465661e-07
I1635 n1_m1_91200_4800 0 1.490522e-07
I1636 n1_m1_91200_9600 0 2.298422e-07
I1637 n1_m1_91200_14400 0 1.565267e-07
I1638 n1_m1_91200_19200 0 1.627530e-07
I1639 n1_m1_91200_24000 0 2.534902e-07
I1640 n1_m1_91200_28800 0 1.759463e-07
I1641 n1_m1_91200_33600 0 5.485918e-07
I1642 n1_m1_91200_38400 0 8.542638e-07
I1643 n1_m1_91200_43200 0 4.910669e-07
I1644 n1_m1_91200_48000 0 2.553749e-07
I1645 n1_m1_91200_52800 0 1.754586e-07
I1646 n1_m1_91200_57600 0 2.721780e-07
I1647 n1_m1_91200_62400 0 1.750524e-07
I1648 n1_m1_91200_67200 0 1.679755e-07
I1649 n1_m1_91200_72000 0 2.536609e-07
I1650 n1_m1_91200_76800 0 1.748680e-07
I1651 n1_m1_91200_81600 0 4.124378e-07
I1652 n1_m1_91200_86400 0 3.901265e-07
I1653 n1_m1_91200_91200 0 3.811046e-07
I1654 n1_m1_91200_96000 0 6.357858e-07
I1655 n1_m1_91200_100800 0 3.861827e-07
I1656 n1_m1_91200_105600 0 2.690561e-07
I1657 n1_m1_91200_110400 0 1.782138e-07
I1658 n1_m1_91200_115200 0 2.281587e-07
I1659 n1_m1_91200_120000 0 4.347506e-07
I1660 n1_m1_91200_124800 0 2.087505e-07
I1661 n1_m1_91200_129600 0 2.665157e-07
I1662 n1_m1_91200_134400 0 2.691758e-07
I1663 n1_m1_91200_139200 0 5.003884e-07
I1664 n1_m1_91200_144000 0 6.782817e-07
I1665 n1_m1_91200_148800 0 2.588086e-07
I1666 n1_m1_91200_153600 0 4.373339e-07
I1667 n1_m1_91200_158400 0 3.904665e-07
I1668 n1_m1_91200_163200 0 3.523472e-07
I1669 n1_m1_91200_168000 0 3.103519e-07
I1670 n1_m1_91200_172800 0 3.554673e-07
I1671 n1_m1_91200_177600 0 7.942242e-07
I1672 n1_m1_91200_182400 0 3.384550e-07
I1673 n1_m1_91200_187200 0 2.653966e-07
I1674 n1_m1_91200_192000 0 3.006422e-07
I1675 n1_m1_91200_196800 0 1.750720e-07
I1676 n1_m1_91200_201600 0 2.558667e-07
I1677 n1_m1_91200_206400 0 1.990715e-07
I1678 n1_m1_91200_211200 0 3.461642e-07
I1679 n1_m1_91200_216000 0 1.020361e-06
I1680 n1_m1_91200_220800 0 4.442627e-07
I1681 n1_m1_91200_225600 0 5.629137e-07
I1682 n1_m1_91200_230400 0 2.910278e-07
I1683 n1_m1_91200_235200 0 1.998765e-07
I1684 n1_m1_91200_240000 0 2.608415e-07
I1685 n1_m1_91200_244800 0 1.718118e-07
I1686 n1_m1_91200_249600 0 2.675375e-07
I1687 n1_m1_91200_254400 0 2.900212e-07
I1688 n1_m1_91200_259200 0 3.661353e-07
I1689 n1_m1_91200_264000 0 5.459006e-07
I1690 n1_m1_91200_268800 0 3.813259e-07
I1691 n1_m1_91200_273600 0 3.692453e-07
I1692 n1_m1_91200_278400 0 1.832580e-07
I1693 n1_m1_91200_283200 0 1.774288e-07
I1694 n1_m1_91200_288000 0 2.862578e-07
I1695 n1_m1_91200_292800 0 2.330180e-07
I1696 n1_m1_91200_297600 0 3.004840e-07
I1697 n1_m1_91200_302400 0 1.894640e-07
I1698 n1_m1_91200_307200 0 1.894450e-07
I1699 n1_m1_91200_312000 0 2.631061e-07
I1700 n1_m1_91200_316800 0 1.732144e-07
I1701 n1_m1_91200_321600 0 2.566419e-07
I1702 n1_m1_91200_326400 0 1.676259e-07
I1703 n1_m1_91200_331200 0 1.722600e-07
I1704 n1_m1_91200_336000 0 2.586995e-07
I1705 n1_m1_91200_340800 0 1.730077e-07
I1706 n1_m1_91200_345600 0 2.599588e-07
I1707 n1_m1_91200_350400 0 1.736976e-07
I1708 n1_m1_91200_355200 0 1.774029e-07
I1709 n1_m1_91200_360000 0 2.707612e-07
I1710 n1_m1_91200_364800 0 6.705462e-07
I1711 n1_m1_91200_369600 0 1.327113e-06
I1712 n1_m1_91200_374400 0 2.691814e-07
I1713 n1_m1_91200_379200 0 1.718035e-07
I1714 n1_m1_91200_384000 0 2.576526e-07
I1715 n1_m1_91200_388800 0 1.749937e-07
I1716 n1_m1_91200_393600 0 2.620978e-07
I1717 n1_m1_91200_398400 0 1.689635e-07
I1718 n1_m1_91200_403200 0 1.606664e-07
I1719 n1_m1_91200_408000 0 1.565318e-07
I1720 n1_m1_96000_0 0 2.202727e-07
I1721 n1_m1_96000_4800 0 2.244287e-07
I1722 n1_m1_96000_9600 0 3.465694e-07
I1723 n1_m1_96000_14400 0 2.419290e-07
I1724 n1_m1_96000_19200 0 2.625424e-07
I1725 n1_m1_96000_24000 0 4.186317e-07
I1726 n1_m1_96000_28800 0 2.506003e-07
I1727 n1_m1_96000_33600 0 3.890358e-07
I1728 n1_m1_96000_38400 0 4.098224e-07
I1729 n1_m1_96000_43200 0 3.095272e-07
I1730 n1_m1_96000_48000 0 4.010854e-07
I1731 n1_m1_96000_52800 0 2.597301e-07
I1732 n1_m1_96000_57600 0 3.794312e-07
I1733 n1_m1_96000_62400 0 2.516603e-07
I1734 n1_m1_96000_67200 0 2.542766e-07
I1735 n1_m1_96000_72000 0 3.771301e-07
I1736 n1_m1_96000_76800 0 2.698472e-07
I1737 n1_m1_96000_81600 0 7.368767e-07
I1738 n1_m1_96000_86400 0 5.603256e-07
I1739 n1_m1_96000_91200 0 3.250416e-07
I1740 n1_m1_96000_96000 0 4.840055e-07
I1741 n1_m1_96000_100800 0 4.255873e-07
I1742 n1_m1_96000_105600 0 4.193897e-07
I1743 n1_m1_96000_110400 0 2.544839e-07
I1744 n1_m1_96000_115200 0 4.942521e-07
I1745 n1_m1_96000_120000 0 1.199792e-06
I1746 n1_m1_96000_124800 0 5.210915e-07
I1747 n1_m1_96000_129600 0 4.273893e-07
I1748 n1_m1_96000_134400 0 3.220076e-07
I1749 n1_m1_96000_139200 0 6.525126e-07
I1750 n1_m1_96000_144000 0 1.457606e-06
I1751 n1_m1_96000_148800 0 6.049281e-07
I1752 n1_m1_96000_153600 0 7.684765e-07
I1753 n1_m1_96000_158400 0 7.375727e-07
I1754 n1_m1_96000_163200 0 6.629454e-07
I1755 n1_m1_96000_168000 0 5.016933e-07
I1756 n1_m1_96000_172800 0 2.916659e-07
I1757 n1_m1_96000_177600 0 5.722675e-07
I1758 n1_m1_96000_182400 0 3.866867e-07
I1759 n1_m1_96000_187200 0 3.765631e-07
I1760 n1_m1_96000_192000 0 5.137591e-07
I1761 n1_m1_96000_196800 0 2.992507e-07
I1762 n1_m1_96000_201600 0 4.533946e-07
I1763 n1_m1_96000_206400 0 5.087357e-07
I1764 n1_m1_96000_211200 0 7.360008e-07
I1765 n1_m1_96000_216000 0 1.634259e-06
I1766 n1_m1_96000_220800 0 9.780834e-07
I1767 n1_m1_96000_225600 0 1.006202e-06
I1768 n1_m1_96000_230400 0 4.561552e-07
I1769 n1_m1_96000_235200 0 3.170820e-07
I1770 n1_m1_96000_240000 0 3.996655e-07
I1771 n1_m1_96000_244800 0 2.666958e-07
I1772 n1_m1_96000_249600 0 4.980873e-07
I1773 n1_m1_96000_254400 0 1.042239e-06
I1774 n1_m1_96000_259200 0 1.770289e-06
I1775 n1_m1_96000_264000 0 2.725837e-06
I1776 n1_m1_96000_268800 0 1.837644e-06
I1777 n1_m1_96000_273600 0 2.086774e-06
I1778 n1_m1_96000_278400 0 6.238115e-07
I1779 n1_m1_96000_283200 0 3.171484e-07
I1780 n1_m1_96000_288000 0 3.928876e-07
I1781 n1_m1_96000_292800 0 2.731595e-07
I1782 n1_m1_96000_297600 0 4.010800e-07
I1783 n1_m1_96000_302400 0 2.658098e-07
I1784 n1_m1_96000_307200 0 2.961706e-07
I1785 n1_m1_96000_312000 0 4.054084e-07
I1786 n1_m1_96000_316800 0 2.598217e-07
I1787 n1_m1_96000_321600 0 3.888489e-07
I1788 n1_m1_96000_326400 0 2.525248e-07
I1789 n1_m1_96000_331200 0 2.560814e-07
I1790 n1_m1_96000_336000 0 3.845296e-07
I1791 n1_m1_96000_340800 0 2.598217e-07
I1792 n1_m1_96000_345600 0 3.911158e-07
I1793 n1_m1_96000_350400 0 2.606457e-07
I1794 n1_m1_96000_355200 0 2.620835e-07
I1795 n1_m1_96000_360000 0 3.986614e-07
I1796 n1_m1_96000_364800 0 4.277212e-07
I1797 n1_m1_96000_369600 0 1.002792e-06
I1798 n1_m1_96000_374400 0 3.304311e-07
I1799 n1_m1_96000_379200 0 2.552411e-07
I1800 n1_m1_96000_384000 0 4.088733e-07
I1801 n1_m1_96000_388800 0 2.730875e-07
I1802 n1_m1_96000_393600 0 3.964740e-07
I1803 n1_m1_96000_398400 0 2.546870e-07
I1804 n1_m1_96000_403200 0 2.422077e-07
I1805 n1_m1_96000_408000 0 2.384786e-07
I1806 n1_m1_100800_0 0 1.502218e-07
I1807 n1_m1_100800_4800 0 1.532282e-07
I1808 n1_m1_100800_9600 0 2.336334e-07
I1809 n1_m1_100800_14400 0 1.653530e-07
I1810 n1_m1_100800_19200 0 1.794344e-07
I1811 n1_m1_100800_24000 0 3.001801e-07
I1812 n1_m1_100800_28800 0 1.766857e-07
I1813 n1_m1_100800_33600 0 2.735139e-07
I1814 n1_m1_100800_38400 0 2.041841e-07
I1815 n1_m1_100800_43200 0 2.908027e-07
I1816 n1_m1_100800_48000 0 5.085248e-07
I1817 n1_m1_100800_52800 0 2.319032e-07
I1818 n1_m1_100800_57600 0 2.512157e-07
I1819 n1_m1_100800_62400 0 1.688435e-07
I1820 n1_m1_100800_67200 0 1.686507e-07
I1821 n1_m1_100800_72000 0 2.489230e-07
I1822 n1_m1_100800_76800 0 1.711995e-07
I1823 n1_m1_100800_81600 0 2.709929e-07
I1824 n1_m1_100800_86400 0 1.869343e-07
I1825 n1_m1_100800_91200 0 1.765170e-07
I1826 n1_m1_100800_96000 0 2.656930e-07
I1827 n1_m1_100800_100800 0 1.710619e-07
I1828 n1_m1_100800_105600 0 2.974869e-07
I1829 n1_m1_100800_110400 0 1.708797e-07
I1830 n1_m1_100800_115200 0 1.798083e-07
I1831 n1_m1_100800_120000 0 3.838727e-07
I1832 n1_m1_100800_124800 0 2.338954e-07
I1833 n1_m1_100800_129600 0 2.623809e-07
I1834 n1_m1_100800_134400 0 1.732144e-07
I1835 n1_m1_100800_139200 0 1.778109e-07
I1836 n1_m1_100800_144000 0 3.749420e-07
I1837 n1_m1_100800_148800 0 2.630780e-07
I1838 n1_m1_100800_153600 0 3.029454e-07
I1839 n1_m1_100800_158400 0 1.713498e-07
I1840 n1_m1_100800_163200 0 1.728196e-07
I1841 n1_m1_100800_168000 0 2.801930e-07
I1842 n1_m1_100800_172800 0 1.969352e-07
I1843 n1_m1_100800_177600 0 3.122042e-07
I1844 n1_m1_100800_182400 0 1.990375e-07
I1845 n1_m1_100800_187200 0 1.821840e-07
I1846 n1_m1_100800_192000 0 2.709458e-07
I1847 n1_m1_100800_196800 0 1.768025e-07
I1848 n1_m1_100800_201600 0 4.096066e-07
I1849 n1_m1_100800_206400 0 7.388967e-07
I1850 n1_m1_100800_211200 0 1.102226e-06
I1851 n1_m1_100800_216000 0 1.666818e-06
I1852 n1_m1_100800_220800 0 6.986874e-07
I1853 n1_m1_100800_225600 0 5.450710e-07
I1854 n1_m1_100800_230400 0 2.054230e-07
I1855 n1_m1_100800_235200 0 1.916882e-07
I1856 n1_m1_100800_240000 0 3.328222e-07
I1857 n1_m1_100800_244800 0 1.878684e-07
I1858 n1_m1_100800_249600 0 4.555977e-07
I1859 n1_m1_100800_254400 0 8.703915e-07
I1860 n1_m1_100800_259200 0 1.338813e-06
I1861 n1_m1_100800_264000 0 1.883396e-06
I1862 n1_m1_100800_268800 0 1.361340e-06
I1863 n1_m1_100800_273600 0 2.066312e-06
I1864 n1_m1_100800_278400 0 9.618200e-07
I1865 n1_m1_100800_283200 0 2.637476e-07
I1866 n1_m1_100800_288000 0 2.644999e-07
I1867 n1_m1_100800_292800 0 1.775268e-07
I1868 n1_m1_100800_297600 0 2.663781e-07
I1869 n1_m1_100800_302400 0 1.802130e-07
I1870 n1_m1_100800_307200 0 2.638014e-07
I1871 n1_m1_100800_312000 0 3.391905e-07
I1872 n1_m1_100800_316800 0 1.917948e-07
I1873 n1_m1_100800_321600 0 2.639910e-07
I1874 n1_m1_100800_326400 0 1.711346e-07
I1875 n1_m1_100800_331200 0 1.716140e-07
I1876 n1_m1_100800_336000 0 2.635517e-07
I1877 n1_m1_100800_340800 0 1.755531e-07
I1878 n1_m1_100800_345600 0 2.648563e-07
I1879 n1_m1_100800_350400 0 1.762769e-07
I1880 n1_m1_100800_355200 0 1.748573e-07
I1881 n1_m1_100800_360000 0 2.643206e-07
I1882 n1_m1_100800_364800 0 1.787848e-07
I1883 n1_m1_100800_369600 0 2.677022e-07
I1884 n1_m1_100800_374400 0 1.711530e-07
I1885 n1_m1_100800_379200 0 1.727925e-07
I1886 n1_m1_100800_384000 0 2.762952e-07
I1887 n1_m1_100800_388800 0 2.089247e-07
I1888 n1_m1_100800_393600 0 2.834639e-07
I1889 n1_m1_100800_398400 0 1.634749e-07
I1890 n1_m1_100800_403200 0 1.594415e-07
I1891 n1_m1_100800_408000 0 1.546587e-07
I1892 n1_m1_105600_0 0 2.248353e-07
I1893 n1_m1_105600_4800 0 2.305002e-07
I1894 n1_m1_105600_9600 0 3.560040e-07
I1895 n1_m1_105600_14400 0 2.502215e-07
I1896 n1_m1_105600_19200 0 2.574831e-07
I1897 n1_m1_105600_24000 0 4.008974e-07
I1898 n1_m1_105600_28800 0 2.617487e-07
I1899 n1_m1_105600_33600 0 4.240569e-07
I1900 n1_m1_105600_38400 0 7.775026e-07
I1901 n1_m1_105600_43200 0 1.608581e-06
I1902 n1_m1_105600_48000 0 2.628034e-06
I1903 n1_m1_105600_52800 0 1.435760e-06
I1904 n1_m1_105600_57600 0 1.283356e-06
I1905 n1_m1_105600_62400 0 3.170415e-07
I1906 n1_m1_105600_67200 0 2.652175e-07
I1907 n1_m1_105600_72000 0 3.932205e-07
I1908 n1_m1_105600_76800 0 2.894988e-07
I1909 n1_m1_105600_81600 0 5.230912e-07
I1910 n1_m1_105600_86400 0 3.207677e-07
I1911 n1_m1_105600_91200 0 3.048947e-07
I1912 n1_m1_105600_96000 0 6.301333e-07
I1913 n1_m1_105600_100800 0 2.665408e-07
I1914 n1_m1_105600_105600 0 3.810015e-07
I1915 n1_m1_105600_110400 0 2.590004e-07
I1916 n1_m1_105600_115200 0 2.568629e-07
I1917 n1_m1_105600_120000 0 7.720843e-07
I1918 n1_m1_105600_124800 0 4.789322e-07
I1919 n1_m1_105600_129600 0 4.115517e-07
I1920 n1_m1_105600_134400 0 2.598217e-07
I1921 n1_m1_105600_139200 0 2.612314e-07
I1922 n1_m1_105600_144000 0 3.968077e-07
I1923 n1_m1_105600_148800 0 2.565312e-07
I1924 n1_m1_105600_153600 0 3.762436e-07
I1925 n1_m1_105600_158400 0 2.566392e-07
I1926 n1_m1_105600_163200 0 3.172318e-07
I1927 n1_m1_105600_168000 0 6.896190e-07
I1928 n1_m1_105600_172800 0 3.997135e-07
I1929 n1_m1_105600_177600 0 4.554302e-07
I1930 n1_m1_105600_182400 0 2.736272e-07
I1931 n1_m1_105600_187200 0 3.022622e-07
I1932 n1_m1_105600_192000 0 4.160573e-07
I1933 n1_m1_105600_196800 0 4.107358e-07
I1934 n1_m1_105600_201600 0 1.162136e-06
I1935 n1_m1_105600_206400 0 1.721893e-06
I1936 n1_m1_105600_211200 0 1.876917e-06
I1937 n1_m1_105600_216000 0 2.085917e-06
I1938 n1_m1_105600_220800 0 5.206453e-07
I1939 n1_m1_105600_225600 0 5.386064e-07
I1940 n1_m1_105600_230400 0 4.236662e-07
I1941 n1_m1_105600_235200 0 5.860899e-07
I1942 n1_m1_105600_240000 0 1.269937e-06
I1943 n1_m1_105600_244800 0 6.551561e-07
I1944 n1_m1_105600_249600 0 1.016647e-06
I1945 n1_m1_105600_254400 0 9.758233e-07
I1946 n1_m1_105600_259200 0 7.759690e-07
I1947 n1_m1_105600_264000 0 1.275977e-06
I1948 n1_m1_105600_268800 0 1.119201e-06
I1949 n1_m1_105600_273600 0 1.429625e-06
I1950 n1_m1_105600_278400 0 5.492479e-07
I1951 n1_m1_105600_283200 0 2.931397e-07
I1952 n1_m1_105600_288000 0 3.859567e-07
I1953 n1_m1_105600_292800 0 2.597240e-07
I1954 n1_m1_105600_297600 0 3.897325e-07
I1955 n1_m1_105600_302400 0 2.587164e-07
I1956 n1_m1_105600_307200 0 2.790963e-07
I1957 n1_m1_105600_312000 0 4.451543e-07
I1958 n1_m1_105600_316800 0 2.817574e-07
I1959 n1_m1_105600_321600 0 7.043294e-07
I1960 n1_m1_105600_326400 0 5.710598e-07
I1961 n1_m1_105600_331200 0 3.202038e-07
I1962 n1_m1_105600_336000 0 4.805292e-07
I1963 n1_m1_105600_340800 0 4.554396e-07
I1964 n1_m1_105600_345600 0 6.132665e-07
I1965 n1_m1_105600_350400 0 3.874689e-07
I1966 n1_m1_105600_355200 0 2.736867e-07
I1967 n1_m1_105600_360000 0 3.908964e-07
I1968 n1_m1_105600_364800 0 2.598217e-07
I1969 n1_m1_105600_369600 0 3.891274e-07
I1970 n1_m1_105600_374400 0 2.608314e-07
I1971 n1_m1_105600_379200 0 2.611898e-07
I1972 n1_m1_105600_384000 0 4.292450e-07
I1973 n1_m1_105600_388800 0 4.607246e-07
I1974 n1_m1_105600_393600 0 5.339578e-07
I1975 n1_m1_105600_398400 0 2.492373e-07
I1976 n1_m1_105600_403200 0 2.532865e-07
I1977 n1_m1_105600_408000 0 2.415984e-07
I1978 n1_m1_110400_0 0 1.486459e-07
I1979 n1_m1_110400_4800 0 1.557143e-07
I1980 n1_m1_110400_9600 0 2.491704e-07
I1981 n1_m1_110400_14400 0 1.732144e-07
I1982 n1_m1_110400_19200 0 1.709928e-07
I1983 n1_m1_110400_24000 0 2.526897e-07
I1984 n1_m1_110400_28800 0 2.165626e-07
I1985 n1_m1_110400_33600 0 3.454493e-07
I1986 n1_m1_110400_38400 0 5.801758e-07
I1987 n1_m1_110400_43200 0 1.203811e-06
I1988 n1_m1_110400_48000 0 1.855107e-06
I1989 n1_m1_110400_52800 0 9.716408e-07
I1990 n1_m1_110400_57600 0 1.016298e-06
I1991 n1_m1_110400_62400 0 2.299739e-07
I1992 n1_m1_110400_67200 0 2.960029e-07
I1993 n1_m1_110400_72000 0 4.701250e-07
I1994 n1_m1_110400_76800 0 2.735781e-07
I1995 n1_m1_110400_81600 0 7.252436e-07
I1996 n1_m1_110400_86400 0 3.958049e-07
I1997 n1_m1_110400_91200 0 1.889250e-07
I1998 n1_m1_110400_96000 0 3.014519e-07
I1999 n1_m1_110400_100800 0 1.948771e-07
I2000 n1_m1_110400_105600 0 2.812814e-07
I2001 n1_m1_110400_110400 0 1.732144e-07
I2002 n1_m1_110400_115200 0 1.685054e-07
I2003 n1_m1_110400_120000 0 4.480733e-07
I2004 n1_m1_110400_124800 0 3.198255e-07
I2005 n1_m1_110400_129600 0 2.747969e-07
I2006 n1_m1_110400_134400 0 1.732144e-07
I2007 n1_m1_110400_139200 0 1.732144e-07
I2008 n1_m1_110400_144000 0 2.592123e-07
I2009 n1_m1_110400_148800 0 1.699611e-07
I2010 n1_m1_110400_153600 0 2.823825e-07
I2011 n1_m1_110400_158400 0 1.848886e-07
I2012 n1_m1_110400_163200 0 1.938449e-07
I2013 n1_m1_110400_168000 0 3.440982e-07
I2014 n1_m1_110400_172800 0 2.005197e-07
I2015 n1_m1_110400_177600 0 2.668910e-07
I2016 n1_m1_110400_182400 0 1.788231e-07
I2017 n1_m1_110400_187200 0 1.730544e-07
I2018 n1_m1_110400_192000 0 4.792430e-07
I2019 n1_m1_110400_196800 0 8.936608e-07
I2020 n1_m1_110400_201600 0 1.320789e-06
I2021 n1_m1_110400_206400 0 6.356841e-07
I2022 n1_m1_110400_211200 0 6.284591e-07
I2023 n1_m1_110400_216000 0 6.712954e-07
I2024 n1_m1_110400_220800 0 4.434556e-07
I2025 n1_m1_110400_225600 0 1.160531e-06
I2026 n1_m1_110400_230400 0 8.374223e-07
I2027 n1_m1_110400_235200 0 1.071807e-06
I2028 n1_m1_110400_240000 0 1.834359e-06
I2029 n1_m1_110400_244800 0 7.513988e-07
I2030 n1_m1_110400_249600 0 3.677440e-07
I2031 n1_m1_110400_254400 0 2.788066e-07
I2032 n1_m1_110400_259200 0 2.271758e-07
I2033 n1_m1_110400_264000 0 2.892235e-07
I2034 n1_m1_110400_268800 0 2.148852e-07
I2035 n1_m1_110400_273600 0 2.995966e-07
I2036 n1_m1_110400_278400 0 2.111795e-07
I2037 n1_m1_110400_283200 0 1.789875e-07
I2038 n1_m1_110400_288000 0 2.571962e-07
I2039 n1_m1_110400_292800 0 1.731667e-07
I2040 n1_m1_110400_297600 0 2.598217e-07
I2041 n1_m1_110400_302400 0 1.732144e-07
I2042 n1_m1_110400_307200 0 1.688435e-07
I2043 n1_m1_110400_312000 0 2.874923e-07
I2044 n1_m1_110400_316800 0 1.819849e-07
I2045 n1_m1_110400_321600 0 3.965407e-07
I2046 n1_m1_110400_326400 0 3.363254e-07
I2047 n1_m1_110400_331200 0 2.138989e-07
I2048 n1_m1_110400_336000 0 8.703906e-07
I2049 n1_m1_110400_340800 0 1.023859e-06
I2050 n1_m1_110400_345600 0 1.015656e-06
I2051 n1_m1_110400_350400 0 6.329795e-07
I2052 n1_m1_110400_355200 0 3.150763e-07
I2053 n1_m1_110400_360000 0 2.825231e-07
I2054 n1_m1_110400_364800 0 1.732144e-07
I2055 n1_m1_110400_369600 0 2.640627e-07
I2056 n1_m1_110400_374400 0 1.792185e-07
I2057 n1_m1_110400_379200 0 1.738075e-07
I2058 n1_m1_110400_384000 0 2.816304e-07
I2059 n1_m1_110400_388800 0 2.706819e-07
I2060 n1_m1_110400_393600 0 3.311175e-07
I2061 n1_m1_110400_398400 0 1.675923e-07
I2062 n1_m1_110400_403200 0 1.615034e-07
I2063 n1_m1_110400_408000 0 1.533154e-07
I2064 n1_m1_115200_0 0 7.432297e-08
I2065 n1_m1_115200_4800 0 7.785713e-08
I2066 n1_m1_115200_9600 0 1.245852e-07
I2067 n1_m1_115200_14400 0 8.594349e-08
I2068 n1_m1_115200_19200 0 8.288214e-08
I2069 n1_m1_115200_24000 0 1.257862e-07
I2070 n1_m1_115200_28800 0 1.203647e-07
I2071 n1_m1_115200_33600 0 1.972436e-07
I2072 n1_m1_115200_38400 0 1.832214e-07
I2073 n1_m1_115200_43200 0 3.816089e-07
I2074 n1_m1_115200_48000 0 5.353922e-07
I2075 n1_m1_115200_52800 0 2.100373e-07
I2076 n1_m1_115200_57600 0 2.332142e-07
I2077 n1_m1_115200_62400 0 9.469338e-08
I2078 n1_m1_115200_67200 0 1.814305e-07
I2079 n1_m1_115200_72000 0 3.140404e-07
I2080 n1_m1_115200_76800 0 1.340642e-07
I2081 n1_m1_115200_81600 0 2.814955e-07
I2082 n1_m1_115200_86400 0 1.808549e-07
I2083 n1_m1_115200_91200 0 9.390783e-08
I2084 n1_m1_115200_96000 0 1.337501e-07
I2085 n1_m1_115200_100800 0 1.029658e-07
I2086 n1_m1_115200_105600 0 1.498321e-07
I2087 n1_m1_115200_110400 0 8.838649e-08
I2088 n1_m1_115200_115200 0 8.439622e-08
I2089 n1_m1_115200_120000 0 1.633924e-07
I2090 n1_m1_115200_124800 0 1.081888e-07
I2091 n1_m1_115200_129600 0 1.314911e-07
I2092 n1_m1_115200_134400 0 8.660722e-08
I2093 n1_m1_115200_139200 0 8.660722e-08
I2094 n1_m1_115200_144000 0 1.292568e-07
I2095 n1_m1_115200_148800 0 8.393159e-08
I2096 n1_m1_115200_153600 0 1.437626e-07
I2097 n1_m1_115200_158400 0 9.151809e-08
I2098 n1_m1_115200_163200 0 8.722469e-08
I2099 n1_m1_115200_168000 0 1.316781e-07
I2100 n1_m1_115200_172800 0 8.794777e-08
I2101 n1_m1_115200_177600 0 1.300727e-07
I2102 n1_m1_115200_182400 0 8.696376e-08
I2103 n1_m1_115200_187200 0 9.052512e-08
I2104 n1_m1_115200_192000 0 2.743125e-07
I2105 n1_m1_115200_196800 0 5.369048e-07
I2106 n1_m1_115200_201600 0 8.778741e-07
I2107 n1_m1_115200_206400 0 2.124990e-07
I2108 n1_m1_115200_211200 0 1.008646e-07
I2109 n1_m1_115200_216000 0 2.520295e-07
I2110 n1_m1_115200_220800 0 3.626077e-07
I2111 n1_m1_115200_225600 0 9.112215e-07
I2112 n1_m1_115200_230400 0 4.864370e-07
I2113 n1_m1_115200_235200 0 5.835835e-07
I2114 n1_m1_115200_240000 0 9.619573e-07
I2115 n1_m1_115200_244800 0 3.920424e-07
I2116 n1_m1_115200_249600 0 1.702030e-07
I2117 n1_m1_115200_254400 0 1.148609e-07
I2118 n1_m1_115200_259200 0 1.025833e-07
I2119 n1_m1_115200_264000 0 1.323592e-07
I2120 n1_m1_115200_268800 0 9.859964e-08
I2121 n1_m1_115200_273600 0 1.457352e-07
I2122 n1_m1_115200_278400 0 8.972168e-08
I2123 n1_m1_115200_283200 0 8.909476e-08
I2124 n1_m1_115200_288000 0 1.299108e-07
I2125 n1_m1_115200_292800 0 8.660722e-08
I2126 n1_m1_115200_297600 0 1.305419e-07
I2127 n1_m1_115200_302400 0 8.928831e-08
I2128 n1_m1_115200_307200 0 8.622329e-08
I2129 n1_m1_115200_312000 0 1.446211e-07
I2130 n1_m1_115200_316800 0 9.284536e-08
I2131 n1_m1_115200_321600 0 1.318216e-07
I2132 n1_m1_115200_326400 0 9.513032e-08
I2133 n1_m1_115200_331200 0 1.057796e-07
I2134 n1_m1_115200_336000 0 5.428844e-07
I2135 n1_m1_115200_340800 0 6.267376e-07
I2136 n1_m1_115200_345600 0 5.619265e-07
I2137 n1_m1_115200_350400 0 3.309225e-07
I2138 n1_m1_115200_355200 0 1.732044e-07
I2139 n1_m1_115200_360000 0 1.475196e-07
I2140 n1_m1_115200_364800 0 8.697506e-08
I2141 n1_m1_115200_369600 0 1.311780e-07
I2142 n1_m1_115200_374400 0 8.945556e-08
I2143 n1_m1_115200_379200 0 8.812497e-08
I2144 n1_m1_115200_384000 0 1.339817e-07
I2145 n1_m1_115200_388800 0 1.008482e-07
I2146 n1_m1_115200_393600 0 1.429705e-07
I2147 n1_m1_115200_398400 0 8.201688e-08
I2148 n1_m1_115200_403200 0 7.869742e-08
I2149 n1_m1_115200_408000 0 7.566351e-08
I2150 n1_m1_120000_0 0 1.513394e-07
I2151 n1_m1_120000_4800 0 1.557143e-07
I2152 n1_m1_120000_9600 0 2.447769e-07
I2153 n1_m1_120000_14400 0 1.692984e-07
I2154 n1_m1_120000_19200 0 1.674425e-07
I2155 n1_m1_120000_24000 0 2.567715e-07
I2156 n1_m1_120000_28800 0 1.698546e-07
I2157 n1_m1_120000_33600 0 2.993530e-07
I2158 n1_m1_120000_38400 0 1.800528e-07
I2159 n1_m1_120000_43200 0 1.742282e-07
I2160 n1_m1_120000_48000 0 2.791090e-07
I2161 n1_m1_120000_52800 0 1.978491e-07
I2162 n1_m1_120000_57600 0 2.578592e-07
I2163 n1_m1_120000_62400 0 1.717878e-07
I2164 n1_m1_120000_67200 0 1.712687e-07
I2165 n1_m1_120000_72000 0 2.604209e-07
I2166 n1_m1_120000_76800 0 1.774957e-07
I2167 n1_m1_120000_81600 0 2.807007e-07
I2168 n1_m1_120000_86400 0 1.770038e-07
I2169 n1_m1_120000_91200 0 2.071974e-07
I2170 n1_m1_120000_96000 0 6.069557e-07
I2171 n1_m1_120000_100800 0 3.385633e-07
I2172 n1_m1_120000_105600 0 2.667914e-07
I2173 n1_m1_120000_110400 0 1.732144e-07
I2174 n1_m1_120000_115200 0 1.685797e-07
I2175 n1_m1_120000_120000 0 2.596866e-07
I2176 n1_m1_120000_124800 0 1.705078e-07
I2177 n1_m1_120000_129600 0 2.691943e-07
I2178 n1_m1_120000_134400 0 1.864860e-07
I2179 n1_m1_120000_139200 0 1.812502e-07
I2180 n1_m1_120000_144000 0 2.592825e-07
I2181 n1_m1_120000_148800 0 1.713726e-07
I2182 n1_m1_120000_153600 0 2.568613e-07
I2183 n1_m1_120000_158400 0 1.717074e-07
I2184 n1_m1_120000_163200 0 1.779973e-07
I2185 n1_m1_120000_168000 0 3.329181e-07
I2186 n1_m1_120000_172800 0 2.916212e-07
I2187 n1_m1_120000_177600 0 4.300314e-07
I2188 n1_m1_120000_182400 0 1.851788e-07
I2189 n1_m1_120000_187200 0 1.760918e-07
I2190 n1_m1_120000_192000 0 2.620055e-07
I2191 n1_m1_120000_196800 0 1.872464e-07
I2192 n1_m1_120000_201600 0 4.227566e-07
I2193 n1_m1_120000_206400 0 6.457828e-07
I2194 n1_m1_120000_211200 0 9.817862e-07
I2195 n1_m1_120000_216000 0 1.030073e-06
I2196 n1_m1_120000_220800 0 6.534736e-07
I2197 n1_m1_120000_225600 0 9.015535e-07
I2198 n1_m1_120000_230400 0 3.288851e-07
I2199 n1_m1_120000_235200 0 2.140538e-07
I2200 n1_m1_120000_240000 0 3.570942e-07
I2201 n1_m1_120000_244800 0 2.347688e-07
I2202 n1_m1_120000_249600 0 2.708839e-07
I2203 n1_m1_120000_254400 0 1.787066e-07
I2204 n1_m1_120000_259200 0 1.868589e-07
I2205 n1_m1_120000_264000 0 2.975803e-07
I2206 n1_m1_120000_268800 0 1.771976e-07
I2207 n1_m1_120000_273600 0 2.587554e-07
I2208 n1_m1_120000_278400 0 1.841794e-07
I2209 n1_m1_120000_283200 0 2.073068e-07
I2210 n1_m1_120000_288000 0 2.742202e-07
I2211 n1_m1_120000_292800 0 1.732670e-07
I2212 n1_m1_120000_297600 0 2.711400e-07
I2213 n1_m1_120000_302400 0 2.106658e-07
I2214 n1_m1_120000_307200 0 2.445372e-07
I2215 n1_m1_120000_312000 0 2.827301e-07
I2216 n1_m1_120000_316800 0 1.836643e-07
I2217 n1_m1_120000_321600 0 2.812865e-07
I2218 n1_m1_120000_326400 0 1.748788e-07
I2219 n1_m1_120000_331200 0 1.885597e-07
I2220 n1_m1_120000_336000 0 3.130575e-07
I2221 n1_m1_120000_340800 0 2.557269e-07
I2222 n1_m1_120000_345600 0 3.007445e-07
I2223 n1_m1_120000_350400 0 1.754716e-07
I2224 n1_m1_120000_355200 0 2.325486e-07
I2225 n1_m1_120000_360000 0 3.341206e-07
I2226 n1_m1_120000_364800 0 1.986487e-07
I2227 n1_m1_120000_369600 0 2.712509e-07
I2228 n1_m1_120000_374400 0 1.743214e-07
I2229 n1_m1_120000_379200 0 1.772028e-07
I2230 n1_m1_120000_384000 0 2.695235e-07
I2231 n1_m1_120000_388800 0 1.809122e-07
I2232 n1_m1_120000_393600 0 2.742183e-07
I2233 n1_m1_120000_398400 0 1.746119e-07
I2234 n1_m1_120000_403200 0 1.638377e-07
I2235 n1_m1_120000_408000 0 1.625837e-07
I2236 n1_m1_124800_0 0 1.548134e-07
I2237 n1_m1_124800_4800 0 1.607921e-07
I2238 n1_m1_124800_9600 0 2.484506e-07
I2239 n1_m1_124800_14400 0 1.670479e-07
I2240 n1_m1_124800_19200 0 1.675757e-07
I2241 n1_m1_124800_24000 0 2.561407e-07
I2242 n1_m1_124800_28800 0 1.678840e-07
I2243 n1_m1_124800_33600 0 2.691892e-07
I2244 n1_m1_124800_38400 0 1.811527e-07
I2245 n1_m1_124800_43200 0 2.152505e-07
I2246 n1_m1_124800_48000 0 3.514958e-07
I2247 n1_m1_124800_52800 0 2.547486e-07
I2248 n1_m1_124800_57600 0 4.799279e-07
I2249 n1_m1_124800_62400 0 2.308342e-07
I2250 n1_m1_124800_67200 0 1.776709e-07
I2251 n1_m1_124800_72000 0 2.615148e-07
I2252 n1_m1_124800_76800 0 1.869630e-07
I2253 n1_m1_124800_81600 0 2.805447e-07
I2254 n1_m1_124800_86400 0 2.074476e-07
I2255 n1_m1_124800_91200 0 5.735646e-07
I2256 n1_m1_124800_96000 0 1.695533e-06
I2257 n1_m1_124800_100800 0 7.939013e-07
I2258 n1_m1_124800_105600 0 2.818161e-07
I2259 n1_m1_124800_110400 0 1.731806e-07
I2260 n1_m1_124800_115200 0 1.686909e-07
I2261 n1_m1_124800_120000 0 2.549671e-07
I2262 n1_m1_124800_124800 0 1.702304e-07
I2263 n1_m1_124800_129600 0 2.718707e-07
I2264 n1_m1_124800_134400 0 1.965672e-07
I2265 n1_m1_124800_139200 0 1.839843e-07
I2266 n1_m1_124800_144000 0 2.600912e-07
I2267 n1_m1_124800_148800 0 1.732144e-07
I2268 n1_m1_124800_153600 0 2.650166e-07
I2269 n1_m1_124800_158400 0 1.748763e-07
I2270 n1_m1_124800_163200 0 1.742197e-07
I2271 n1_m1_124800_168000 0 4.985803e-07
I2272 n1_m1_124800_172800 0 6.849094e-07
I2273 n1_m1_124800_177600 0 9.050373e-07
I2274 n1_m1_124800_182400 0 2.772814e-07
I2275 n1_m1_124800_187200 0 2.586135e-07
I2276 n1_m1_124800_192000 0 2.746690e-07
I2277 n1_m1_124800_196800 0 1.762685e-07
I2278 n1_m1_124800_201600 0 3.149637e-07
I2279 n1_m1_124800_206400 0 4.503725e-07
I2280 n1_m1_124800_211200 0 9.261073e-07
I2281 n1_m1_124800_216000 0 1.188454e-06
I2282 n1_m1_124800_220800 0 5.887281e-07
I2283 n1_m1_124800_225600 0 5.452740e-07
I2284 n1_m1_124800_230400 0 2.525300e-07
I2285 n1_m1_124800_235200 0 1.873819e-07
I2286 n1_m1_124800_240000 0 2.709032e-07
I2287 n1_m1_124800_244800 0 1.754912e-07
I2288 n1_m1_124800_249600 0 2.557137e-07
I2289 n1_m1_124800_254400 0 1.751479e-07
I2290 n1_m1_124800_259200 0 1.788593e-07
I2291 n1_m1_124800_264000 0 2.622361e-07
I2292 n1_m1_124800_268800 0 1.721814e-07
I2293 n1_m1_124800_273600 0 2.648370e-07
I2294 n1_m1_124800_278400 0 1.921610e-07
I2295 n1_m1_124800_283200 0 3.161524e-07
I2296 n1_m1_124800_288000 0 3.648966e-07
I2297 n1_m1_124800_292800 0 1.768540e-07
I2298 n1_m1_124800_297600 0 2.615791e-07
I2299 n1_m1_124800_302400 0 1.824149e-07
I2300 n1_m1_124800_307200 0 1.880711e-07
I2301 n1_m1_124800_312000 0 2.913472e-07
I2302 n1_m1_124800_316800 0 1.883399e-07
I2303 n1_m1_124800_321600 0 2.680695e-07
I2304 n1_m1_124800_326400 0 1.792315e-07
I2305 n1_m1_124800_331200 0 1.835843e-07
I2306 n1_m1_124800_336000 0 2.802561e-07
I2307 n1_m1_124800_340800 0 1.775982e-07
I2308 n1_m1_124800_345600 0 2.639471e-07
I2309 n1_m1_124800_350400 0 1.868012e-07
I2310 n1_m1_124800_355200 0 2.039360e-07
I2311 n1_m1_124800_360000 0 3.285732e-07
I2312 n1_m1_124800_364800 0 2.878551e-07
I2313 n1_m1_124800_369600 0 3.495430e-07
I2314 n1_m1_124800_374400 0 1.753790e-07
I2315 n1_m1_124800_379200 0 1.742981e-07
I2316 n1_m1_124800_384000 0 2.685429e-07
I2317 n1_m1_124800_388800 0 1.806537e-07
I2318 n1_m1_124800_393600 0 2.698341e-07
I2319 n1_m1_124800_398400 0 1.700522e-07
I2320 n1_m1_124800_403200 0 1.582004e-07
I2321 n1_m1_124800_408000 0 1.570795e-07
I2322 n1_m1_129600_0 0 2.315087e-07
I2323 n1_m1_129600_4800 0 2.389365e-07
I2324 n1_m1_129600_9600 0 3.795132e-07
I2325 n1_m1_129600_14400 0 2.591023e-07
I2326 n1_m1_129600_19200 0 2.657188e-07
I2327 n1_m1_129600_24000 0 3.944663e-07
I2328 n1_m1_129600_28800 0 2.581773e-07
I2329 n1_m1_129600_33600 0 3.884916e-07
I2330 n1_m1_129600_38400 0 3.377431e-07
I2331 n1_m1_129600_43200 0 6.778844e-07
I2332 n1_m1_129600_48000 0 1.259394e-06
I2333 n1_m1_129600_52800 0 5.288305e-07
I2334 n1_m1_129600_57600 0 1.477298e-06
I2335 n1_m1_129600_62400 0 5.209935e-07
I2336 n1_m1_129600_67200 0 2.826439e-07
I2337 n1_m1_129600_72000 0 3.830477e-07
I2338 n1_m1_129600_76800 0 2.953180e-07
I2339 n1_m1_129600_81600 0 5.389267e-07
I2340 n1_m1_129600_86400 0 3.858964e-07
I2341 n1_m1_129600_91200 0 6.653736e-07
I2342 n1_m1_129600_96000 0 2.656287e-06
I2343 n1_m1_129600_100800 0 1.399655e-06
I2344 n1_m1_129600_105600 0 5.480925e-07
I2345 n1_m1_129600_110400 0 2.623033e-07
I2346 n1_m1_129600_115200 0 2.832037e-07
I2347 n1_m1_129600_120000 0 8.725237e-07
I2348 n1_m1_129600_124800 0 3.477795e-07
I2349 n1_m1_129600_129600 0 3.860254e-07
I2350 n1_m1_129600_134400 0 2.679044e-07
I2351 n1_m1_129600_139200 0 2.743632e-07
I2352 n1_m1_129600_144000 0 4.065834e-07
I2353 n1_m1_129600_148800 0 2.696451e-07
I2354 n1_m1_129600_153600 0 4.184810e-07
I2355 n1_m1_129600_158400 0 3.826068e-07
I2356 n1_m1_129600_163200 0 3.519820e-07
I2357 n1_m1_129600_168000 0 7.381748e-07
I2358 n1_m1_129600_172800 0 9.951374e-07
I2359 n1_m1_129600_177600 0 1.372844e-06
I2360 n1_m1_129600_182400 0 4.589950e-07
I2361 n1_m1_129600_187200 0 4.266651e-07
I2362 n1_m1_129600_192000 0 5.963916e-07
I2363 n1_m1_129600_196800 0 4.103411e-07
I2364 n1_m1_129600_201600 0 4.372234e-07
I2365 n1_m1_129600_206400 0 4.063473e-07
I2366 n1_m1_129600_211200 0 9.476128e-07
I2367 n1_m1_129600_216000 0 2.078476e-06
I2368 n1_m1_129600_220800 0 7.372087e-07
I2369 n1_m1_129600_225600 0 6.814493e-07
I2370 n1_m1_129600_230400 0 3.689608e-07
I2371 n1_m1_129600_235200 0 3.072371e-07
I2372 n1_m1_129600_240000 0 4.006928e-07
I2373 n1_m1_129600_244800 0 2.686533e-07
I2374 n1_m1_129600_249600 0 3.941241e-07
I2375 n1_m1_129600_254400 0 2.629046e-07
I2376 n1_m1_129600_259200 0 2.605523e-07
I2377 n1_m1_129600_264000 0 3.923828e-07
I2378 n1_m1_129600_268800 0 2.648808e-07
I2379 n1_m1_129600_273600 0 3.978333e-07
I2380 n1_m1_129600_278400 0 2.661841e-07
I2381 n1_m1_129600_283200 0 2.773156e-07
I2382 n1_m1_129600_288000 0 3.991151e-07
I2383 n1_m1_129600_292800 0 2.544183e-07
I2384 n1_m1_129600_297600 0 3.769719e-07
I2385 n1_m1_129600_302400 0 2.574136e-07
I2386 n1_m1_129600_307200 0 2.813021e-07
I2387 n1_m1_129600_312000 0 4.449657e-07
I2388 n1_m1_129600_316800 0 2.858840e-07
I2389 n1_m1_129600_321600 0 4.268381e-07
I2390 n1_m1_129600_326400 0 2.849157e-07
I2391 n1_m1_129600_331200 0 3.244325e-07
I2392 n1_m1_129600_336000 0 3.923242e-07
I2393 n1_m1_129600_340800 0 2.662111e-07
I2394 n1_m1_129600_345600 0 4.124719e-07
I2395 n1_m1_129600_350400 0 2.980820e-07
I2396 n1_m1_129600_355200 0 3.123664e-07
I2397 n1_m1_129600_360000 0 4.939814e-07
I2398 n1_m1_129600_364800 0 6.010466e-07
I2399 n1_m1_129600_369600 0 6.724955e-07
I2400 n1_m1_129600_374400 0 2.767128e-07
I2401 n1_m1_129600_379200 0 2.675793e-07
I2402 n1_m1_129600_384000 0 4.087723e-07
I2403 n1_m1_129600_388800 0 2.681323e-07
I2404 n1_m1_129600_393600 0 3.863816e-07
I2405 n1_m1_129600_398400 0 2.436706e-07
I2406 n1_m1_129600_403200 0 2.394076e-07
I2407 n1_m1_129600_408000 0 2.453557e-07
I2408 n1_m1_134400_0 0 1.526079e-07
I2409 n1_m1_134400_4800 0 1.577607e-07
I2410 n1_m1_134400_9600 0 2.558650e-07
I2411 n1_m1_134400_14400 0 1.754832e-07
I2412 n1_m1_134400_19200 0 1.785115e-07
I2413 n1_m1_134400_24000 0 2.644214e-07
I2414 n1_m1_134400_28800 0 1.772839e-07
I2415 n1_m1_134400_33600 0 2.587443e-07
I2416 n1_m1_134400_38400 0 1.861773e-07
I2417 n1_m1_134400_43200 0 2.776589e-07
I2418 n1_m1_134400_48000 0 5.539168e-07
I2419 n1_m1_134400_52800 0 1.969083e-07
I2420 n1_m1_134400_57600 0 3.614599e-07
I2421 n1_m1_134400_62400 0 1.910144e-07
I2422 n1_m1_134400_67200 0 1.779581e-07
I2423 n1_m1_134400_72000 0 2.632552e-07
I2424 n1_m1_134400_76800 0 1.810612e-07
I2425 n1_m1_134400_81600 0 3.680709e-07
I2426 n1_m1_134400_86400 0 2.677504e-07
I2427 n1_m1_134400_91200 0 1.885489e-07
I2428 n1_m1_134400_96000 0 6.160682e-07
I2429 n1_m1_134400_100800 0 6.082946e-07
I2430 n1_m1_134400_105600 0 4.801861e-07
I2431 n1_m1_134400_110400 0 2.115663e-07
I2432 n1_m1_134400_115200 0 2.114937e-07
I2433 n1_m1_134400_120000 0 3.963437e-07
I2434 n1_m1_134400_124800 0 2.057610e-07
I2435 n1_m1_134400_129600 0 2.605587e-07
I2436 n1_m1_134400_134400 0 1.727536e-07
I2437 n1_m1_134400_139200 0 1.772042e-07
I2438 n1_m1_134400_144000 0 3.068626e-07
I2439 n1_m1_134400_148800 0 2.225853e-07
I2440 n1_m1_134400_153600 0 3.901688e-07
I2441 n1_m1_134400_158400 0 2.335903e-07
I2442 n1_m1_134400_163200 0 2.098496e-07
I2443 n1_m1_134400_168000 0 2.911004e-07
I2444 n1_m1_134400_172800 0 2.336053e-07
I2445 n1_m1_134400_177600 0 3.784244e-07
I2446 n1_m1_134400_182400 0 1.804635e-07
I2447 n1_m1_134400_187200 0 1.732174e-07
I2448 n1_m1_134400_192000 0 3.305291e-07
I2449 n1_m1_134400_196800 0 2.538226e-07
I2450 n1_m1_134400_201600 0 2.775159e-07
I2451 n1_m1_134400_206400 0 1.783747e-07
I2452 n1_m1_134400_211200 0 2.401485e-07
I2453 n1_m1_134400_216000 0 1.122297e-06
I2454 n1_m1_134400_220800 0 4.463037e-07
I2455 n1_m1_134400_225600 0 3.460745e-07
I2456 n1_m1_134400_230400 0 2.042526e-07
I2457 n1_m1_134400_235200 0 1.816530e-07
I2458 n1_m1_134400_240000 0 2.593614e-07
I2459 n1_m1_134400_244800 0 1.715097e-07
I2460 n1_m1_134400_249600 0 2.688554e-07
I2461 n1_m1_134400_254400 0 1.829300e-07
I2462 n1_m1_134400_259200 0 1.716388e-07
I2463 n1_m1_134400_264000 0 2.636372e-07
I2464 n1_m1_134400_268800 0 2.125465e-07
I2465 n1_m1_134400_273600 0 2.783207e-07
I2466 n1_m1_134400_278400 0 1.744051e-07
I2467 n1_m1_134400_283200 0 1.680374e-07
I2468 n1_m1_134400_288000 0 2.510240e-07
I2469 n1_m1_134400_292800 0 1.665644e-07
I2470 n1_m1_134400_297600 0 2.520519e-07
I2471 n1_m1_134400_302400 0 1.730507e-07
I2472 n1_m1_134400_307200 0 2.609486e-07
I2473 n1_m1_134400_312000 0 3.185517e-07
I2474 n1_m1_134400_316800 0 1.956213e-07
I2475 n1_m1_134400_321600 0 2.951123e-07
I2476 n1_m1_134400_326400 0 2.532247e-07
I2477 n1_m1_134400_331200 0 4.807095e-07
I2478 n1_m1_134400_336000 0 2.870985e-07
I2479 n1_m1_134400_340800 0 1.737448e-07
I2480 n1_m1_134400_345600 0 2.726529e-07
I2481 n1_m1_134400_350400 0 2.135479e-07
I2482 n1_m1_134400_355200 0 2.211705e-07
I2483 n1_m1_134400_360000 0 2.740744e-07
I2484 n1_m1_134400_364800 0 1.756315e-07
I2485 n1_m1_134400_369600 0 2.587661e-07
I2486 n1_m1_134400_374400 0 1.808169e-07
I2487 n1_m1_134400_379200 0 1.736828e-07
I2488 n1_m1_134400_384000 0 2.559475e-07
I2489 n1_m1_134400_388800 0 1.696987e-07
I2490 n1_m1_134400_393600 0 2.644513e-07
I2491 n1_m1_134400_398400 0 1.645438e-07
I2492 n1_m1_134400_403200 0 1.645662e-07
I2493 n1_m1_134400_408000 0 1.581119e-07
I2494 n1_m1_139200_0 0 1.494265e-07
I2495 n1_m1_139200_4800 0 1.592851e-07
I2496 n1_m1_139200_9600 0 2.573031e-07
I2497 n1_m1_139200_14400 0 1.733874e-07
I2498 n1_m1_139200_19200 0 1.735055e-07
I2499 n1_m1_139200_24000 0 2.567059e-07
I2500 n1_m1_139200_28800 0 1.702257e-07
I2501 n1_m1_139200_33600 0 2.583684e-07
I2502 n1_m1_139200_38400 0 1.744985e-07
I2503 n1_m1_139200_43200 0 1.757031e-07
I2504 n1_m1_139200_48000 0 2.688531e-07
I2505 n1_m1_139200_52800 0 1.809433e-07
I2506 n1_m1_139200_57600 0 2.520350e-07
I2507 n1_m1_139200_62400 0 1.708339e-07
I2508 n1_m1_139200_67200 0 1.722358e-07
I2509 n1_m1_139200_72000 0 2.603000e-07
I2510 n1_m1_139200_76800 0 2.063145e-07
I2511 n1_m1_139200_81600 0 2.693125e-07
I2512 n1_m1_139200_86400 0 1.772540e-07
I2513 n1_m1_139200_91200 0 1.803241e-07
I2514 n1_m1_139200_96000 0 2.762204e-07
I2515 n1_m1_139200_100800 0 4.552594e-07
I2516 n1_m1_139200_105600 0 7.631111e-07
I2517 n1_m1_139200_110400 0 3.683259e-07
I2518 n1_m1_139200_115200 0 3.382239e-07
I2519 n1_m1_139200_120000 0 2.897857e-07
I2520 n1_m1_139200_124800 0 2.345142e-07
I2521 n1_m1_139200_129600 0 2.719674e-07
I2522 n1_m1_139200_134400 0 1.686383e-07
I2523 n1_m1_139200_139200 0 1.730649e-07
I2524 n1_m1_139200_144000 0 2.905970e-07
I2525 n1_m1_139200_148800 0 2.071514e-07
I2526 n1_m1_139200_153600 0 3.696089e-07
I2527 n1_m1_139200_158400 0 1.796809e-07
I2528 n1_m1_139200_163200 0 2.044864e-07
I2529 n1_m1_139200_168000 0 3.003547e-07
I2530 n1_m1_139200_172800 0 1.708069e-07
I2531 n1_m1_139200_177600 0 2.662631e-07
I2532 n1_m1_139200_182400 0 1.779244e-07
I2533 n1_m1_139200_187200 0 1.839144e-07
I2534 n1_m1_139200_192000 0 2.720078e-07
I2535 n1_m1_139200_196800 0 1.834366e-07
I2536 n1_m1_139200_201600 0 2.603868e-07
I2537 n1_m1_139200_206400 0 1.691434e-07
I2538 n1_m1_139200_211200 0 1.742361e-07
I2539 n1_m1_139200_216000 0 3.114490e-07
I2540 n1_m1_139200_220800 0 2.546593e-07
I2541 n1_m1_139200_225600 0 2.918236e-07
I2542 n1_m1_139200_230400 0 1.729999e-07
I2543 n1_m1_139200_235200 0 1.719542e-07
I2544 n1_m1_139200_240000 0 2.548505e-07
I2545 n1_m1_139200_244800 0 1.754256e-07
I2546 n1_m1_139200_249600 0 2.771435e-07
I2547 n1_m1_139200_254400 0 1.871214e-07
I2548 n1_m1_139200_259200 0 1.747487e-07
I2549 n1_m1_139200_264000 0 2.855422e-07
I2550 n1_m1_139200_268800 0 2.756562e-07
I2551 n1_m1_139200_273600 0 3.131527e-07
I2552 n1_m1_139200_278400 0 1.803059e-07
I2553 n1_m1_139200_283200 0 1.739009e-07
I2554 n1_m1_139200_288000 0 2.592140e-07
I2555 n1_m1_139200_292800 0 1.666370e-07
I2556 n1_m1_139200_297600 0 2.575175e-07
I2557 n1_m1_139200_302400 0 1.759303e-07
I2558 n1_m1_139200_307200 0 3.831283e-07
I2559 n1_m1_139200_312000 0 6.304668e-07
I2560 n1_m1_139200_316800 0 3.604413e-07
I2561 n1_m1_139200_321600 0 3.144065e-07
I2562 n1_m1_139200_326400 0 3.543086e-07
I2563 n1_m1_139200_331200 0 6.719581e-07
I2564 n1_m1_139200_336000 0 4.323786e-07
I2565 n1_m1_139200_340800 0 1.757852e-07
I2566 n1_m1_139200_345600 0 2.615415e-07
I2567 n1_m1_139200_350400 0 1.838281e-07
I2568 n1_m1_139200_355200 0 1.897824e-07
I2569 n1_m1_139200_360000 0 2.753439e-07
I2570 n1_m1_139200_364800 0 1.824286e-07
I2571 n1_m1_139200_369600 0 2.567955e-07
I2572 n1_m1_139200_374400 0 1.766712e-07
I2573 n1_m1_139200_379200 0 1.789943e-07
I2574 n1_m1_139200_384000 0 2.624752e-07
I2575 n1_m1_139200_388800 0 1.805959e-07
I2576 n1_m1_139200_393600 0 2.874194e-07
I2577 n1_m1_139200_398400 0 1.727330e-07
I2578 n1_m1_139200_403200 0 1.727347e-07
I2579 n1_m1_139200_408000 0 1.581685e-07
I2580 n1_m1_144000_0 0 2.269884e-07
I2581 n1_m1_144000_4800 0 2.435645e-07
I2582 n1_m1_144000_9600 0 3.873681e-07
I2583 n1_m1_144000_14400 0 2.623771e-07
I2584 n1_m1_144000_19200 0 2.595414e-07
I2585 n1_m1_144000_24000 0 3.788410e-07
I2586 n1_m1_144000_28800 0 2.443090e-07
I2587 n1_m1_144000_33600 0 3.769851e-07
I2588 n1_m1_144000_38400 0 2.754662e-07
I2589 n1_m1_144000_43200 0 3.215676e-07
I2590 n1_m1_144000_48000 0 5.999317e-07
I2591 n1_m1_144000_52800 0 2.803287e-07
I2592 n1_m1_144000_57600 0 3.854285e-07
I2593 n1_m1_144000_62400 0 2.591421e-07
I2594 n1_m1_144000_67200 0 2.581811e-07
I2595 n1_m1_144000_72000 0 3.854713e-07
I2596 n1_m1_144000_76800 0 2.601782e-07
I2597 n1_m1_144000_81600 0 4.232385e-07
I2598 n1_m1_144000_86400 0 2.589097e-07
I2599 n1_m1_144000_91200 0 2.595174e-07
I2600 n1_m1_144000_96000 0 4.040731e-07
I2601 n1_m1_144000_100800 0 4.321046e-07
I2602 n1_m1_144000_105600 0 6.936195e-07
I2603 n1_m1_144000_110400 0 3.755044e-07
I2604 n1_m1_144000_115200 0 3.176411e-07
I2605 n1_m1_144000_120000 0 5.202161e-07
I2606 n1_m1_144000_124800 0 3.141171e-07
I2607 n1_m1_144000_129600 0 4.065065e-07
I2608 n1_m1_144000_134400 0 2.561537e-07
I2609 n1_m1_144000_139200 0 2.520035e-07
I2610 n1_m1_144000_144000 0 3.836425e-07
I2611 n1_m1_144000_148800 0 2.570756e-07
I2612 n1_m1_144000_153600 0 3.977592e-07
I2613 n1_m1_144000_158400 0 2.640675e-07
I2614 n1_m1_144000_163200 0 3.725627e-07
I2615 n1_m1_144000_168000 0 5.736337e-07
I2616 n1_m1_144000_172800 0 2.744950e-07
I2617 n1_m1_144000_177600 0 4.089016e-07
I2618 n1_m1_144000_182400 0 2.602569e-07
I2619 n1_m1_144000_187200 0 2.640355e-07
I2620 n1_m1_144000_192000 0 3.978620e-07
I2621 n1_m1_144000_196800 0 2.739071e-07
I2622 n1_m1_144000_201600 0 4.071835e-07
I2623 n1_m1_144000_206400 0 2.579114e-07
I2624 n1_m1_144000_211200 0 2.608127e-07
I2625 n1_m1_144000_216000 0 4.143820e-07
I2626 n1_m1_144000_220800 0 2.711467e-07
I2627 n1_m1_144000_225600 0 3.883133e-07
I2628 n1_m1_144000_230400 0 2.601028e-07
I2629 n1_m1_144000_235200 0 2.637229e-07
I2630 n1_m1_144000_240000 0 3.829085e-07
I2631 n1_m1_144000_244800 0 2.631439e-07
I2632 n1_m1_144000_249600 0 4.103135e-07
I2633 n1_m1_144000_254400 0 2.702155e-07
I2634 n1_m1_144000_259200 0 2.629703e-07
I2635 n1_m1_144000_264000 0 4.274748e-07
I2636 n1_m1_144000_268800 0 3.796733e-07
I2637 n1_m1_144000_273600 0 4.958453e-07
I2638 n1_m1_144000_278400 0 2.717981e-07
I2639 n1_m1_144000_283200 0 2.572180e-07
I2640 n1_m1_144000_288000 0 3.901197e-07
I2641 n1_m1_144000_292800 0 2.503534e-07
I2642 n1_m1_144000_297600 0 3.936414e-07
I2643 n1_m1_144000_302400 0 2.672306e-07
I2644 n1_m1_144000_307200 0 2.759591e-07
I2645 n1_m1_144000_312000 0 1.549215e-06
I2646 n1_m1_144000_316800 0 1.481424e-06
I2647 n1_m1_144000_321600 0 1.829259e-06
I2648 n1_m1_144000_326400 0 7.226286e-07
I2649 n1_m1_144000_331200 0 4.001873e-07
I2650 n1_m1_144000_336000 0 4.918666e-07
I2651 n1_m1_144000_340800 0 2.650448e-07
I2652 n1_m1_144000_345600 0 4.118696e-07
I2653 n1_m1_144000_350400 0 2.852617e-07
I2654 n1_m1_144000_355200 0 2.846745e-07
I2655 n1_m1_144000_360000 0 6.157005e-07
I2656 n1_m1_144000_364800 0 4.509952e-07
I2657 n1_m1_144000_369600 0 4.472267e-07
I2658 n1_m1_144000_374400 0 2.680648e-07
I2659 n1_m1_144000_379200 0 2.650571e-07
I2660 n1_m1_144000_384000 0 4.695171e-07
I2661 n1_m1_144000_388800 0 7.035807e-07
I2662 n1_m1_144000_393600 0 6.751323e-07
I2663 n1_m1_144000_398400 0 2.595352e-07
I2664 n1_m1_144000_403200 0 2.483077e-07
I2665 n1_m1_144000_408000 0 2.337149e-07
I2666 n1_m1_148800_0 0 1.575017e-07
I2667 n1_m1_148800_4800 0 1.645700e-07
I2668 n1_m1_148800_9600 0 2.605935e-07
I2669 n1_m1_148800_14400 0 1.743220e-07
I2670 n1_m1_148800_19200 0 1.730276e-07
I2671 n1_m1_148800_24000 0 2.577612e-07
I2672 n1_m1_148800_28800 0 1.690364e-07
I2673 n1_m1_148800_33600 0 2.530729e-07
I2674 n1_m1_148800_38400 0 1.740252e-07
I2675 n1_m1_148800_43200 0 1.736389e-07
I2676 n1_m1_148800_48000 0 3.118439e-07
I2677 n1_m1_148800_52800 0 2.033207e-07
I2678 n1_m1_148800_57600 0 2.694134e-07
I2679 n1_m1_148800_62400 0 1.697534e-07
I2680 n1_m1_148800_67200 0 1.812252e-07
I2681 n1_m1_148800_72000 0 2.787918e-07
I2682 n1_m1_148800_76800 0 1.812820e-07
I2683 n1_m1_148800_81600 0 3.219426e-07
I2684 n1_m1_148800_86400 0 2.652164e-07
I2685 n1_m1_148800_91200 0 1.883049e-07
I2686 n1_m1_148800_96000 0 2.586441e-07
I2687 n1_m1_148800_100800 0 1.912386e-07
I2688 n1_m1_148800_105600 0 6.590870e-07
I2689 n1_m1_148800_110400 0 4.934844e-07
I2690 n1_m1_148800_115200 0 3.749709e-07
I2691 n1_m1_148800_120000 0 9.681214e-07
I2692 n1_m1_148800_124800 0 4.934225e-07
I2693 n1_m1_148800_129600 0 2.936952e-07
I2694 n1_m1_148800_134400 0 1.747232e-07
I2695 n1_m1_148800_139200 0 1.715990e-07
I2696 n1_m1_148800_144000 0 2.498285e-07
I2697 n1_m1_148800_148800 0 1.672746e-07
I2698 n1_m1_148800_153600 0 2.709583e-07
I2699 n1_m1_148800_158400 0 1.685320e-07
I2700 n1_m1_148800_163200 0 1.979781e-07
I2701 n1_m1_148800_168000 0 5.197131e-07
I2702 n1_m1_148800_172800 0 2.432451e-07
I2703 n1_m1_148800_177600 0 2.670026e-07
I2704 n1_m1_148800_182400 0 1.780846e-07
I2705 n1_m1_148800_187200 0 1.939300e-07
I2706 n1_m1_148800_192000 0 2.572846e-07
I2707 n1_m1_148800_196800 0 1.708839e-07
I2708 n1_m1_148800_201600 0 2.770021e-07
I2709 n1_m1_148800_206400 0 1.771517e-07
I2710 n1_m1_148800_211200 0 1.776110e-07
I2711 n1_m1_148800_216000 0 2.597198e-07
I2712 n1_m1_148800_220800 0 1.822044e-07
I2713 n1_m1_148800_225600 0 2.705163e-07
I2714 n1_m1_148800_230400 0 1.770922e-07
I2715 n1_m1_148800_235200 0 1.797294e-07
I2716 n1_m1_148800_240000 0 2.686043e-07
I2717 n1_m1_148800_244800 0 1.718873e-07
I2718 n1_m1_148800_249600 0 2.508183e-07
I2719 n1_m1_148800_254400 0 1.665524e-07
I2720 n1_m1_148800_259200 0 1.857341e-07
I2721 n1_m1_148800_264000 0 3.049704e-07
I2722 n1_m1_148800_268800 0 1.848461e-07
I2723 n1_m1_148800_273600 0 3.636475e-07
I2724 n1_m1_148800_278400 0 1.886063e-07
I2725 n1_m1_148800_283200 0 1.694802e-07
I2726 n1_m1_148800_288000 0 2.599493e-07
I2727 n1_m1_148800_292800 0 1.692876e-07
I2728 n1_m1_148800_297600 0 3.331367e-07
I2729 n1_m1_148800_302400 0 2.257338e-07
I2730 n1_m1_148800_307200 0 1.961299e-07
I2731 n1_m1_148800_312000 0 7.327316e-07
I2732 n1_m1_148800_316800 0 6.201583e-07
I2733 n1_m1_148800_321600 0 1.007721e-06
I2734 n1_m1_148800_326400 0 5.164833e-07
I2735 n1_m1_148800_331200 0 2.616350e-07
I2736 n1_m1_148800_336000 0 2.598479e-07
I2737 n1_m1_148800_340800 0 1.766178e-07
I2738 n1_m1_148800_345600 0 3.121204e-07
I2739 n1_m1_148800_350400 0 3.058585e-07
I2740 n1_m1_148800_355200 0 3.793423e-07
I2741 n1_m1_148800_360000 0 7.038935e-07
I2742 n1_m1_148800_364800 0 4.340785e-07
I2743 n1_m1_148800_369600 0 3.920976e-07
I2744 n1_m1_148800_374400 0 2.455355e-07
I2745 n1_m1_148800_379200 0 2.269078e-07
I2746 n1_m1_148800_384000 0 4.755955e-07
I2747 n1_m1_148800_388800 0 1.065880e-06
I2748 n1_m1_148800_393600 0 7.938877e-07
I2749 n1_m1_148800_398400 0 1.899816e-07
I2750 n1_m1_148800_403200 0 1.595227e-07
I2751 n1_m1_148800_408000 0 1.625063e-07
I2752 n1_m1_153600_0 0 2.380153e-07
I2753 n1_m1_153600_4800 0 2.555981e-07
I2754 n1_m1_153600_9600 0 4.010057e-07
I2755 n1_m1_153600_14400 0 2.612409e-07
I2756 n1_m1_153600_19200 0 2.597428e-07
I2757 n1_m1_153600_24000 0 3.876996e-07
I2758 n1_m1_153600_28800 0 2.574853e-07
I2759 n1_m1_153600_33600 0 3.832239e-07
I2760 n1_m1_153600_38400 0 2.554275e-07
I2761 n1_m1_153600_43200 0 2.557725e-07
I2762 n1_m1_153600_48000 0 3.929404e-07
I2763 n1_m1_153600_52800 0 2.755913e-07
I2764 n1_m1_153600_57600 0 3.955556e-07
I2765 n1_m1_153600_62400 0 2.564336e-07
I2766 n1_m1_153600_67200 0 3.441820e-07
I2767 n1_m1_153600_72000 0 6.037595e-07
I2768 n1_m1_153600_76800 0 2.803523e-07
I2769 n1_m1_153600_81600 0 4.551082e-07
I2770 n1_m1_153600_86400 0 3.737549e-07
I2771 n1_m1_153600_91200 0 2.799568e-07
I2772 n1_m1_153600_96000 0 3.905033e-07
I2773 n1_m1_153600_100800 0 3.523550e-07
I2774 n1_m1_153600_105600 0 2.255189e-06
I2775 n1_m1_153600_110400 0 1.734162e-06
I2776 n1_m1_153600_115200 0 9.385184e-07
I2777 n1_m1_153600_120000 0 1.885109e-06
I2778 n1_m1_153600_124800 0 1.092469e-06
I2779 n1_m1_153600_129600 0 4.872849e-07
I2780 n1_m1_153600_134400 0 2.579944e-07
I2781 n1_m1_153600_139200 0 2.603725e-07
I2782 n1_m1_153600_144000 0 3.926440e-07
I2783 n1_m1_153600_148800 0 2.543354e-07
I2784 n1_m1_153600_153600 0 3.665846e-07
I2785 n1_m1_153600_158400 0 2.533995e-07
I2786 n1_m1_153600_163200 0 3.501024e-07
I2787 n1_m1_153600_168000 0 1.510748e-06
I2788 n1_m1_153600_172800 0 5.501927e-07
I2789 n1_m1_153600_177600 0 5.230681e-07
I2790 n1_m1_153600_182400 0 2.597713e-07
I2791 n1_m1_153600_187200 0 2.502577e-07
I2792 n1_m1_153600_192000 0 3.867786e-07
I2793 n1_m1_153600_196800 0 2.724931e-07
I2794 n1_m1_153600_201600 0 4.204908e-07
I2795 n1_m1_153600_206400 0 2.980060e-07
I2796 n1_m1_153600_211200 0 2.612971e-07
I2797 n1_m1_153600_216000 0 3.995024e-07
I2798 n1_m1_153600_220800 0 2.660275e-07
I2799 n1_m1_153600_225600 0 4.097377e-07
I2800 n1_m1_153600_230400 0 2.589561e-07
I2801 n1_m1_153600_235200 0 2.633028e-07
I2802 n1_m1_153600_240000 0 3.955788e-07
I2803 n1_m1_153600_244800 0 2.560780e-07
I2804 n1_m1_153600_249600 0 3.863683e-07
I2805 n1_m1_153600_254400 0 2.613573e-07
I2806 n1_m1_153600_259200 0 4.041507e-07
I2807 n1_m1_153600_264000 0 7.533077e-07
I2808 n1_m1_153600_268800 0 3.047767e-07
I2809 n1_m1_153600_273600 0 4.880822e-07
I2810 n1_m1_153600_278400 0 2.878936e-07
I2811 n1_m1_153600_283200 0 2.575641e-07
I2812 n1_m1_153600_288000 0 3.836465e-07
I2813 n1_m1_153600_292800 0 2.570211e-07
I2814 n1_m1_153600_297600 0 4.743162e-07
I2815 n1_m1_153600_302400 0 3.823299e-07
I2816 n1_m1_153600_307200 0 2.955511e-07
I2817 n1_m1_153600_312000 0 6.550024e-07
I2818 n1_m1_153600_316800 0 5.307841e-07
I2819 n1_m1_153600_321600 0 5.483628e-07
I2820 n1_m1_153600_326400 0 2.962514e-07
I2821 n1_m1_153600_331200 0 2.672729e-07
I2822 n1_m1_153600_336000 0 3.948626e-07
I2823 n1_m1_153600_340800 0 2.679872e-07
I2824 n1_m1_153600_345600 0 4.182971e-07
I2825 n1_m1_153600_350400 0 3.474941e-07
I2826 n1_m1_153600_355200 0 4.357685e-07
I2827 n1_m1_153600_360000 0 7.313716e-07
I2828 n1_m1_153600_364800 0 3.057178e-07
I2829 n1_m1_153600_369600 0 4.231862e-07
I2830 n1_m1_153600_374400 0 3.795247e-07
I2831 n1_m1_153600_379200 0 3.722557e-07
I2832 n1_m1_153600_384000 0 5.331363e-07
I2833 n1_m1_153600_388800 0 7.149170e-07
I2834 n1_m1_153600_393600 0 7.902094e-07
I2835 n1_m1_153600_398400 0 3.177230e-07
I2836 n1_m1_153600_403200 0 2.541720e-07
I2837 n1_m1_153600_408000 0 2.500068e-07
I2838 n1_m1_158400_0 0 1.585170e-07
I2839 n1_m1_158400_4800 0 1.660324e-07
I2840 n1_m1_158400_9600 0 2.617661e-07
I2841 n1_m1_158400_14400 0 1.717261e-07
I2842 n1_m1_158400_19200 0 1.702084e-07
I2843 n1_m1_158400_24000 0 2.571675e-07
I2844 n1_m1_158400_28800 0 1.728890e-07
I2845 n1_m1_158400_33600 0 2.546988e-07
I2846 n1_m1_158400_38400 0 1.691075e-07
I2847 n1_m1_158400_43200 0 1.676692e-07
I2848 n1_m1_158400_48000 0 2.625114e-07
I2849 n1_m1_158400_52800 0 1.798765e-07
I2850 n1_m1_158400_57600 0 2.606260e-07
I2851 n1_m1_158400_62400 0 1.665524e-07
I2852 n1_m1_158400_67200 0 1.763912e-07
I2853 n1_m1_158400_72000 0 2.623778e-07
I2854 n1_m1_158400_76800 0 1.700070e-07
I2855 n1_m1_158400_81600 0 2.595007e-07
I2856 n1_m1_158400_86400 0 1.762507e-07
I2857 n1_m1_158400_91200 0 1.758940e-07
I2858 n1_m1_158400_96000 0 2.598217e-07
I2859 n1_m1_158400_100800 0 2.172205e-07
I2860 n1_m1_158400_105600 0 1.019847e-06
I2861 n1_m1_158400_110400 0 7.365304e-07
I2862 n1_m1_158400_115200 0 3.264808e-07
I2863 n1_m1_158400_120000 0 3.674276e-07
I2864 n1_m1_158400_124800 0 2.049302e-07
I2865 n1_m1_158400_129600 0 2.744164e-07
I2866 n1_m1_158400_134400 0 1.900961e-07
I2867 n1_m1_158400_139200 0 1.784531e-07
I2868 n1_m1_158400_144000 0 2.604119e-07
I2869 n1_m1_158400_148800 0 1.782001e-07
I2870 n1_m1_158400_153600 0 2.598528e-07
I2871 n1_m1_158400_158400 0 1.778702e-07
I2872 n1_m1_158400_163200 0 2.932559e-07
I2873 n1_m1_158400_168000 0 1.435888e-06
I2874 n1_m1_158400_172800 0 8.086703e-07
I2875 n1_m1_158400_177600 0 5.008692e-07
I2876 n1_m1_158400_182400 0 1.748150e-07
I2877 n1_m1_158400_187200 0 1.677093e-07
I2878 n1_m1_158400_192000 0 2.606097e-07
I2879 n1_m1_158400_196800 0 1.773708e-07
I2880 n1_m1_158400_201600 0 2.950576e-07
I2881 n1_m1_158400_206400 0 2.809151e-07
I2882 n1_m1_158400_211200 0 2.873144e-07
I2883 n1_m1_158400_216000 0 2.921603e-07
I2884 n1_m1_158400_220800 0 1.740829e-07
I2885 n1_m1_158400_225600 0 2.732761e-07
I2886 n1_m1_158400_230400 0 1.715567e-07
I2887 n1_m1_158400_235200 0 1.727676e-07
I2888 n1_m1_158400_240000 0 2.598217e-07
I2889 n1_m1_158400_244800 0 1.750547e-07
I2890 n1_m1_158400_249600 0 2.640704e-07
I2891 n1_m1_158400_254400 0 1.726437e-07
I2892 n1_m1_158400_259200 0 2.221547e-07
I2893 n1_m1_158400_264000 0 4.077445e-07
I2894 n1_m1_158400_268800 0 1.869531e-07
I2895 n1_m1_158400_273600 0 2.622560e-07
I2896 n1_m1_158400_278400 0 1.806234e-07
I2897 n1_m1_158400_283200 0 1.836200e-07
I2898 n1_m1_158400_288000 0 2.942961e-07
I2899 n1_m1_158400_292800 0 1.741933e-07
I2900 n1_m1_158400_297600 0 2.620826e-07
I2901 n1_m1_158400_302400 0 1.955015e-07
I2902 n1_m1_158400_307200 0 3.098179e-07
I2903 n1_m1_158400_312000 0 3.058041e-07
I2904 n1_m1_158400_316800 0 2.088023e-07
I2905 n1_m1_158400_321600 0 2.696858e-07
I2906 n1_m1_158400_326400 0 1.747216e-07
I2907 n1_m1_158400_331200 0 1.709985e-07
I2908 n1_m1_158400_336000 0 2.598217e-07
I2909 n1_m1_158400_340800 0 1.732144e-07
I2910 n1_m1_158400_345600 0 2.598217e-07
I2911 n1_m1_158400_350400 0 1.732144e-07
I2912 n1_m1_158400_355200 0 1.755597e-07
I2913 n1_m1_158400_360000 0 2.983125e-07
I2914 n1_m1_158400_364800 0 1.808832e-07
I2915 n1_m1_158400_369600 0 2.695467e-07
I2916 n1_m1_158400_374400 0 1.857503e-07
I2917 n1_m1_158400_379200 0 1.794878e-07
I2918 n1_m1_158400_384000 0 2.598217e-07
I2919 n1_m1_158400_388800 0 1.761463e-07
I2920 n1_m1_158400_393600 0 3.052895e-07
I2921 n1_m1_158400_398400 0 1.940072e-07
I2922 n1_m1_158400_403200 0 1.720445e-07
I2923 n1_m1_158400_408000 0 1.674908e-07
I2924 n1_m1_163200_0 0 1.584750e-07
I2925 n1_m1_163200_4800 0 1.577535e-07
I2926 n1_m1_163200_9600 0 2.516485e-07
I2927 n1_m1_163200_14400 0 1.698954e-07
I2928 n1_m1_163200_19200 0 1.667122e-07
I2929 n1_m1_163200_24000 0 2.548712e-07
I2930 n1_m1_163200_28800 0 1.692230e-07
I2931 n1_m1_163200_33600 0 2.626461e-07
I2932 n1_m1_163200_38400 0 1.761161e-07
I2933 n1_m1_163200_43200 0 1.670054e-07
I2934 n1_m1_163200_48000 0 2.532664e-07
I2935 n1_m1_163200_52800 0 1.752131e-07
I2936 n1_m1_163200_57600 0 2.600519e-07
I2937 n1_m1_163200_62400 0 1.711752e-07
I2938 n1_m1_163200_67200 0 1.725778e-07
I2939 n1_m1_163200_72000 0 2.571035e-07
I2940 n1_m1_163200_76800 0 1.727165e-07
I2941 n1_m1_163200_81600 0 2.598747e-07
I2942 n1_m1_163200_86400 0 1.732841e-07
I2943 n1_m1_163200_91200 0 1.732290e-07
I2944 n1_m1_163200_96000 0 2.624354e-07
I2945 n1_m1_163200_100800 0 1.818337e-07
I2946 n1_m1_163200_105600 0 3.176328e-07
I2947 n1_m1_163200_110400 0 2.381081e-07
I2948 n1_m1_163200_115200 0 2.026683e-07
I2949 n1_m1_163200_120000 0 2.833089e-07
I2950 n1_m1_163200_124800 0 1.822393e-07
I2951 n1_m1_163200_129600 0 3.675765e-07
I2952 n1_m1_163200_134400 0 3.319988e-07
I2953 n1_m1_163200_139200 0 2.705834e-07
I2954 n1_m1_163200_144000 0 2.653613e-07
I2955 n1_m1_163200_148800 0 1.811363e-07
I2956 n1_m1_163200_153600 0 2.665501e-07
I2957 n1_m1_163200_158400 0 1.705009e-07
I2958 n1_m1_163200_163200 0 2.073580e-07
I2959 n1_m1_163200_168000 0 1.200931e-06
I2960 n1_m1_163200_172800 0 1.113752e-06
I2961 n1_m1_163200_177600 0 7.417688e-07
I2962 n1_m1_163200_182400 0 1.848690e-07
I2963 n1_m1_163200_187200 0 1.778755e-07
I2964 n1_m1_163200_192000 0 2.817100e-07
I2965 n1_m1_163200_196800 0 1.940044e-07
I2966 n1_m1_163200_201600 0 3.529888e-07
I2967 n1_m1_163200_206400 0 5.664126e-07
I2968 n1_m1_163200_211200 0 6.715734e-07
I2969 n1_m1_163200_216000 0 5.082347e-07
I2970 n1_m1_163200_220800 0 1.769650e-07
I2971 n1_m1_163200_225600 0 2.605513e-07
I2972 n1_m1_163200_230400 0 1.676886e-07
I2973 n1_m1_163200_235200 0 1.684828e-07
I2974 n1_m1_163200_240000 0 2.588217e-07
I2975 n1_m1_163200_244800 0 2.048775e-07
I2976 n1_m1_163200_249600 0 3.678109e-07
I2977 n1_m1_163200_254400 0 1.866226e-07
I2978 n1_m1_163200_259200 0 1.804458e-07
I2979 n1_m1_163200_264000 0 2.993925e-07
I2980 n1_m1_163200_268800 0 1.772052e-07
I2981 n1_m1_163200_273600 0 2.597946e-07
I2982 n1_m1_163200_278400 0 1.808545e-07
I2983 n1_m1_163200_283200 0 2.710873e-07
I2984 n1_m1_163200_288000 0 4.438473e-07
I2985 n1_m1_163200_292800 0 1.740654e-07
I2986 n1_m1_163200_297600 0 2.650599e-07
I2987 n1_m1_163200_302400 0 2.864901e-07
I2988 n1_m1_163200_307200 0 6.813846e-07
I2989 n1_m1_163200_312000 0 4.773398e-07
I2990 n1_m1_163200_316800 0 1.759220e-07
I2991 n1_m1_163200_321600 0 2.542753e-07
I2992 n1_m1_163200_326400 0 1.728223e-07
I2993 n1_m1_163200_331200 0 1.795830e-07
I2994 n1_m1_163200_336000 0 2.598758e-07
I2995 n1_m1_163200_340800 0 1.732153e-07
I2996 n1_m1_163200_345600 0 2.608666e-07
I2997 n1_m1_163200_350400 0 1.777967e-07
I2998 n1_m1_163200_355200 0 1.748573e-07
I2999 n1_m1_163200_360000 0 2.658539e-07
I3000 n1_m1_163200_364800 0 1.745331e-07
I3001 n1_m1_163200_369600 0 2.611518e-07
I3002 n1_m1_163200_374400 0 1.750929e-07
I3003 n1_m1_163200_379200 0 1.744592e-07
I3004 n1_m1_163200_384000 0 2.694094e-07
I3005 n1_m1_163200_388800 0 1.741497e-07
I3006 n1_m1_163200_393600 0 2.660340e-07
I3007 n1_m1_163200_398400 0 1.793972e-07
I3008 n1_m1_163200_403200 0 1.710522e-07
I3009 n1_m1_163200_408000 0 1.639408e-07
I3010 n1_m1_168000_0 0 2.439484e-07
I3011 n1_m1_168000_4800 0 2.359650e-07
I3012 n1_m1_168000_9600 0 3.713030e-07
I3013 n1_m1_168000_14400 0 2.523303e-07
I3014 n1_m1_168000_19200 0 2.655505e-07
I3015 n1_m1_168000_24000 0 8.276189e-07
I3016 n1_m1_168000_28800 0 5.963084e-07
I3017 n1_m1_168000_33600 0 4.511658e-07
I3018 n1_m1_168000_38400 0 2.568971e-07
I3019 n1_m1_168000_43200 0 2.508956e-07
I3020 n1_m1_168000_48000 0 3.826050e-07
I3021 n1_m1_168000_52800 0 2.534885e-07
I3022 n1_m1_168000_57600 0 3.830939e-07
I3023 n1_m1_168000_62400 0 2.579869e-07
I3024 n1_m1_168000_67200 0 2.560032e-07
I3025 n1_m1_168000_72000 0 3.886056e-07
I3026 n1_m1_168000_76800 0 2.549731e-07
I3027 n1_m1_168000_81600 0 4.064562e-07
I3028 n1_m1_168000_86400 0 2.766176e-07
I3029 n1_m1_168000_91200 0 2.722919e-07
I3030 n1_m1_168000_96000 0 6.416074e-07
I3031 n1_m1_168000_100800 0 5.405931e-07
I3032 n1_m1_168000_105600 0 4.467694e-07
I3033 n1_m1_168000_110400 0 2.802948e-07
I3034 n1_m1_168000_115200 0 2.696251e-07
I3035 n1_m1_168000_120000 0 4.283899e-07
I3036 n1_m1_168000_124800 0 2.848715e-07
I3037 n1_m1_168000_129600 0 5.047223e-07
I3038 n1_m1_168000_134400 0 5.224498e-07
I3039 n1_m1_168000_139200 0 4.688430e-07
I3040 n1_m1_168000_144000 0 4.232348e-07
I3041 n1_m1_168000_148800 0 2.626520e-07
I3042 n1_m1_168000_153600 0 3.939882e-07
I3043 n1_m1_168000_158400 0 2.591573e-07
I3044 n1_m1_168000_163200 0 2.646476e-07
I3045 n1_m1_168000_168000 0 9.784088e-07
I3046 n1_m1_168000_172800 0 1.408237e-06
I3047 n1_m1_168000_177600 0 1.064164e-06
I3048 n1_m1_168000_182400 0 2.709552e-07
I3049 n1_m1_168000_187200 0 2.676273e-07
I3050 n1_m1_168000_192000 0 4.199989e-07
I3051 n1_m1_168000_196800 0 2.886851e-07
I3052 n1_m1_168000_201600 0 4.746072e-07
I3053 n1_m1_168000_206400 0 6.211116e-07
I3054 n1_m1_168000_211200 0 7.663797e-07
I3055 n1_m1_168000_216000 0 6.528786e-07
I3056 n1_m1_168000_220800 0 2.637365e-07
I3057 n1_m1_168000_225600 0 3.890649e-07
I3058 n1_m1_168000_230400 0 2.520711e-07
I3059 n1_m1_168000_235200 0 2.558692e-07
I3060 n1_m1_168000_240000 0 3.797046e-07
I3061 n1_m1_168000_244800 0 3.015615e-07
I3062 n1_m1_168000_249600 0 5.474953e-07
I3063 n1_m1_168000_254400 0 2.866292e-07
I3064 n1_m1_168000_259200 0 2.723686e-07
I3065 n1_m1_168000_264000 0 4.188200e-07
I3066 n1_m1_168000_268800 0 2.712579e-07
I3067 n1_m1_168000_273600 0 3.874610e-07
I3068 n1_m1_168000_278400 0 2.611754e-07
I3069 n1_m1_168000_283200 0 3.365809e-07
I3070 n1_m1_168000_288000 0 5.625579e-07
I3071 n1_m1_168000_292800 0 2.566579e-07
I3072 n1_m1_168000_297600 0 3.940530e-07
I3073 n1_m1_168000_302400 0 4.048797e-07
I3074 n1_m1_168000_307200 0 8.551801e-07
I3075 n1_m1_168000_312000 0 6.068738e-07
I3076 n1_m1_168000_316800 0 2.662609e-07
I3077 n1_m1_168000_321600 0 3.868642e-07
I3078 n1_m1_168000_326400 0 2.590723e-07
I3079 n1_m1_168000_331200 0 2.703398e-07
I3080 n1_m1_168000_336000 0 4.014391e-07
I3081 n1_m1_168000_340800 0 2.600037e-07
I3082 n1_m1_168000_345600 0 3.900086e-07
I3083 n1_m1_168000_350400 0 2.625317e-07
I3084 n1_m1_168000_355200 0 2.640742e-07
I3085 n1_m1_168000_360000 0 4.074509e-07
I3086 n1_m1_168000_364800 0 2.677988e-07
I3087 n1_m1_168000_369600 0 4.012230e-07
I3088 n1_m1_168000_374400 0 2.750492e-07
I3089 n1_m1_168000_379200 0 2.730329e-07
I3090 n1_m1_168000_384000 0 4.646257e-07
I3091 n1_m1_168000_388800 0 3.492298e-07
I3092 n1_m1_168000_393600 0 4.470861e-07
I3093 n1_m1_168000_398400 0 2.645933e-07
I3094 n1_m1_168000_403200 0 2.442340e-07
I3095 n1_m1_168000_408000 0 2.269398e-07
I3096 n1_m1_172800_0 0 7.994513e-08
I3097 n1_m1_172800_4800 0 7.994513e-08
I3098 n1_m1_172800_9600 0 1.264620e-07
I3099 n1_m1_172800_14400 0 8.492545e-08
I3100 n1_m1_172800_19200 0 1.224555e-07
I3101 n1_m1_172800_24000 0 6.233243e-07
I3102 n1_m1_172800_28800 0 4.875161e-07
I3103 n1_m1_172800_33600 0 2.373771e-07
I3104 n1_m1_172800_38400 0 8.786439e-08
I3105 n1_m1_172800_43200 0 8.405058e-08
I3106 n1_m1_172800_48000 0 1.263198e-07
I3107 n1_m1_172800_52800 0 8.874397e-08
I3108 n1_m1_172800_57600 0 1.300324e-07
I3109 n1_m1_172800_62400 0 8.545354e-08
I3110 n1_m1_172800_67200 0 8.380135e-08
I3111 n1_m1_172800_72000 0 1.404092e-07
I3112 n1_m1_172800_76800 0 1.402084e-07
I3113 n1_m1_172800_81600 0 1.862134e-07
I3114 n1_m1_172800_86400 0 9.738146e-08
I3115 n1_m1_172800_91200 0 1.048529e-07
I3116 n1_m1_172800_96000 0 2.353126e-07
I3117 n1_m1_172800_100800 0 1.664624e-07
I3118 n1_m1_172800_105600 0 1.681711e-07
I3119 n1_m1_172800_110400 0 9.739131e-08
I3120 n1_m1_172800_115200 0 8.494279e-08
I3121 n1_m1_172800_120000 0 1.306705e-07
I3122 n1_m1_172800_124800 0 8.524305e-08
I3123 n1_m1_172800_129600 0 1.308954e-07
I3124 n1_m1_172800_134400 0 8.906043e-08
I3125 n1_m1_172800_139200 0 8.949142e-08
I3126 n1_m1_172800_144000 0 1.340103e-07
I3127 n1_m1_172800_148800 0 8.646009e-08
I3128 n1_m1_172800_153600 0 1.273551e-07
I3129 n1_m1_172800_158400 0 8.510419e-08
I3130 n1_m1_172800_163200 0 9.052051e-08
I3131 n1_m1_172800_168000 0 1.398059e-07
I3132 n1_m1_172800_172800 0 1.310791e-07
I3133 n1_m1_172800_177600 0 1.448748e-07
I3134 n1_m1_172800_182400 0 8.724093e-08
I3135 n1_m1_172800_187200 0 8.380927e-08
I3136 n1_m1_172800_192000 0 1.258801e-07
I3137 n1_m1_172800_196800 0 8.765528e-08
I3138 n1_m1_172800_201600 0 1.328457e-07
I3139 n1_m1_172800_206400 0 9.077420e-08
I3140 n1_m1_172800_211200 0 8.779588e-08
I3141 n1_m1_172800_216000 0 1.299108e-07
I3142 n1_m1_172800_220800 0 8.675287e-08
I3143 n1_m1_172800_225600 0 1.352174e-07
I3144 n1_m1_172800_230400 0 8.533499e-08
I3145 n1_m1_172800_235200 0 8.638380e-08
I3146 n1_m1_172800_240000 0 1.268235e-07
I3147 n1_m1_172800_244800 0 8.429580e-08
I3148 n1_m1_172800_249600 0 1.303795e-07
I3149 n1_m1_172800_254400 0 8.948805e-08
I3150 n1_m1_172800_259200 0 8.865371e-08
I3151 n1_m1_172800_264000 0 1.335344e-07
I3152 n1_m1_172800_268800 0 1.006061e-07
I3153 n1_m1_172800_273600 0 1.352238e-07
I3154 n1_m1_172800_278400 0 8.906875e-08
I3155 n1_m1_172800_283200 0 8.483331e-08
I3156 n1_m1_172800_288000 0 1.282934e-07
I3157 n1_m1_172800_292800 0 8.678106e-08
I3158 n1_m1_172800_297600 0 1.299130e-07
I3159 n1_m1_172800_302400 0 8.731891e-08
I3160 n1_m1_172800_307200 0 9.201141e-08
I3161 n1_m1_172800_312000 0 1.326992e-07
I3162 n1_m1_172800_316800 0 9.308439e-08
I3163 n1_m1_172800_321600 0 1.306027e-07
I3164 n1_m1_172800_326400 0 8.951575e-08
I3165 n1_m1_172800_331200 0 8.756710e-08
I3166 n1_m1_172800_336000 0 1.320924e-07
I3167 n1_m1_172800_340800 0 8.723484e-08
I3168 n1_m1_172800_345600 0 1.362277e-07
I3169 n1_m1_172800_350400 0 1.439821e-07
I3170 n1_m1_172800_355200 0 2.527258e-07
I3171 n1_m1_172800_360000 0 3.309654e-07
I3172 n1_m1_172800_364800 0 1.339904e-07
I3173 n1_m1_172800_369600 0 1.385648e-07
I3174 n1_m1_172800_374400 0 8.906543e-08
I3175 n1_m1_172800_379200 0 9.157491e-08
I3176 n1_m1_172800_384000 0 2.144942e-07
I3177 n1_m1_172800_388800 0 2.319022e-07
I3178 n1_m1_172800_393600 0 2.647769e-07
I3179 n1_m1_172800_398400 0 9.425466e-08
I3180 n1_m1_172800_403200 0 8.496607e-08
I3181 n1_m1_172800_408000 0 7.914080e-08
I3182 n1_m1_177600_0 0 2.398186e-07
I3183 n1_m1_177600_4800 0 2.398354e-07
I3184 n1_m1_177600_9600 0 3.716221e-07
I3185 n1_m1_177600_14400 0 2.547764e-07
I3186 n1_m1_177600_19200 0 3.475118e-07
I3187 n1_m1_177600_24000 0 1.275882e-06
I3188 n1_m1_177600_28800 0 8.527117e-07
I3189 n1_m1_177600_33600 0 5.163417e-07
I3190 n1_m1_177600_38400 0 2.684613e-07
I3191 n1_m1_177600_43200 0 2.628504e-07
I3192 n1_m1_177600_48000 0 4.146077e-07
I3193 n1_m1_177600_52800 0 2.677091e-07
I3194 n1_m1_177600_57600 0 3.956391e-07
I3195 n1_m1_177600_62400 0 2.594352e-07
I3196 n1_m1_177600_67200 0 2.908525e-07
I3197 n1_m1_177600_72000 0 6.185666e-07
I3198 n1_m1_177600_76800 0 7.295059e-07
I3199 n1_m1_177600_81600 0 1.186468e-06
I3200 n1_m1_177600_86400 0 5.330103e-07
I3201 n1_m1_177600_91200 0 3.221900e-07
I3202 n1_m1_177600_96000 0 5.953927e-07
I3203 n1_m1_177600_100800 0 5.144234e-07
I3204 n1_m1_177600_105600 0 5.679873e-07
I3205 n1_m1_177600_110400 0 2.741378e-07
I3206 n1_m1_177600_115200 0 2.604535e-07
I3207 n1_m1_177600_120000 0 5.468606e-07
I3208 n1_m1_177600_124800 0 3.481256e-07
I3209 n1_m1_177600_129600 0 4.188611e-07
I3210 n1_m1_177600_134400 0 2.683182e-07
I3211 n1_m1_177600_139200 0 2.835476e-07
I3212 n1_m1_177600_144000 0 3.951849e-07
I3213 n1_m1_177600_148800 0 2.599022e-07
I3214 n1_m1_177600_153600 0 3.852289e-07
I3215 n1_m1_177600_158400 0 2.615349e-07
I3216 n1_m1_177600_163200 0 2.756845e-07
I3217 n1_m1_177600_168000 0 4.062459e-07
I3218 n1_m1_177600_172800 0 2.929652e-07
I3219 n1_m1_177600_177600 0 4.124923e-07
I3220 n1_m1_177600_182400 0 2.647061e-07
I3221 n1_m1_177600_187200 0 2.570196e-07
I3222 n1_m1_177600_192000 0 3.843936e-07
I3223 n1_m1_177600_196800 0 2.675481e-07
I3224 n1_m1_177600_201600 0 4.306229e-07
I3225 n1_m1_177600_206400 0 3.273507e-07
I3226 n1_m1_177600_211200 0 2.743291e-07
I3227 n1_m1_177600_216000 0 3.909936e-07
I3228 n1_m1_177600_220800 0 2.596006e-07
I3229 n1_m1_177600_225600 0 3.819452e-07
I3230 n1_m1_177600_230400 0 2.692780e-07
I3231 n1_m1_177600_235200 0 2.535278e-07
I3232 n1_m1_177600_240000 0 3.812445e-07
I3233 n1_m1_177600_244800 0 2.515202e-07
I3234 n1_m1_177600_249600 0 3.926192e-07
I3235 n1_m1_177600_254400 0 2.650827e-07
I3236 n1_m1_177600_259200 0 2.618601e-07
I3237 n1_m1_177600_264000 0 4.130195e-07
I3238 n1_m1_177600_268800 0 4.531278e-07
I3239 n1_m1_177600_273600 0 7.823164e-07
I3240 n1_m1_177600_278400 0 4.034120e-07
I3241 n1_m1_177600_283200 0 2.739371e-07
I3242 n1_m1_177600_288000 0 4.045824e-07
I3243 n1_m1_177600_292800 0 2.680851e-07
I3244 n1_m1_177600_297600 0 3.860833e-07
I3245 n1_m1_177600_302400 0 2.671395e-07
I3246 n1_m1_177600_307200 0 2.775176e-07
I3247 n1_m1_177600_312000 0 4.185677e-07
I3248 n1_m1_177600_316800 0 2.723194e-07
I3249 n1_m1_177600_321600 0 3.789364e-07
I3250 n1_m1_177600_326400 0 2.693972e-07
I3251 n1_m1_177600_331200 0 2.779147e-07
I3252 n1_m1_177600_336000 0 4.366347e-07
I3253 n1_m1_177600_340800 0 3.362257e-07
I3254 n1_m1_177600_345600 0 5.246387e-07
I3255 n1_m1_177600_350400 0 1.015391e-06
I3256 n1_m1_177600_355200 0 1.587376e-06
I3257 n1_m1_177600_360000 0 2.489195e-06
I3258 n1_m1_177600_364800 0 1.261900e-06
I3259 n1_m1_177600_369600 0 6.871486e-07
I3260 n1_m1_177600_374400 0 2.826339e-07
I3261 n1_m1_177600_379200 0 2.682283e-07
I3262 n1_m1_177600_384000 0 7.553823e-07
I3263 n1_m1_177600_388800 0 1.362309e-06
I3264 n1_m1_177600_393600 0 1.604355e-06
I3265 n1_m1_177600_398400 0 3.793642e-07
I3266 n1_m1_177600_403200 0 2.542297e-07
I3267 n1_m1_177600_408000 0 2.410293e-07
I3268 n1_m1_182400_0 0 1.552988e-07
I3269 n1_m1_182400_4800 0 1.593555e-07
I3270 n1_m1_182400_9600 0 2.416959e-07
I3271 n1_m1_182400_14400 0 1.698509e-07
I3272 n1_m1_182400_19200 0 1.775941e-07
I3273 n1_m1_182400_24000 0 2.812540e-07
I3274 n1_m1_182400_28800 0 1.919414e-07
I3275 n1_m1_182400_33600 0 2.737438e-07
I3276 n1_m1_182400_38400 0 1.770066e-07
I3277 n1_m1_182400_43200 0 2.340457e-07
I3278 n1_m1_182400_48000 0 5.936107e-07
I3279 n1_m1_182400_52800 0 2.211777e-07
I3280 n1_m1_182400_57600 0 2.714129e-07
I3281 n1_m1_182400_62400 0 1.730203e-07
I3282 n1_m1_182400_67200 0 1.897326e-07
I3283 n1_m1_182400_72000 0 3.390023e-07
I3284 n1_m1_182400_76800 0 3.042469e-07
I3285 n1_m1_182400_81600 0 7.734077e-07
I3286 n1_m1_182400_86400 0 3.824735e-07
I3287 n1_m1_182400_91200 0 1.955938e-07
I3288 n1_m1_182400_96000 0 3.416229e-07
I3289 n1_m1_182400_100800 0 3.091508e-07
I3290 n1_m1_182400_105600 0 3.075790e-07
I3291 n1_m1_182400_110400 0 1.793117e-07
I3292 n1_m1_182400_115200 0 1.832326e-07
I3293 n1_m1_182400_120000 0 8.401680e-07
I3294 n1_m1_182400_124800 0 6.351803e-07
I3295 n1_m1_182400_129600 0 8.432157e-07
I3296 n1_m1_182400_134400 0 3.957483e-07
I3297 n1_m1_182400_139200 0 2.962632e-07
I3298 n1_m1_182400_144000 0 2.634096e-07
I3299 n1_m1_182400_148800 0 1.785627e-07
I3300 n1_m1_182400_153600 0 2.633531e-07
I3301 n1_m1_182400_158400 0 1.832556e-07
I3302 n1_m1_182400_163200 0 3.890184e-07
I3303 n1_m1_182400_168000 0 5.587614e-07
I3304 n1_m1_182400_172800 0 2.060675e-07
I3305 n1_m1_182400_177600 0 2.617870e-07
I3306 n1_m1_182400_182400 0 1.732144e-07
I3307 n1_m1_182400_187200 0 1.717480e-07
I3308 n1_m1_182400_192000 0 2.533612e-07
I3309 n1_m1_182400_196800 0 1.765374e-07
I3310 n1_m1_182400_201600 0 3.628579e-07
I3311 n1_m1_182400_206400 0 5.158485e-07
I3312 n1_m1_182400_211200 0 3.999899e-07
I3313 n1_m1_182400_216000 0 3.495629e-07
I3314 n1_m1_182400_220800 0 1.744771e-07
I3315 n1_m1_182400_225600 0 2.515299e-07
I3316 n1_m1_182400_230400 0 1.681741e-07
I3317 n1_m1_182400_235200 0 1.703179e-07
I3318 n1_m1_182400_240000 0 2.648735e-07
I3319 n1_m1_182400_244800 0 1.699029e-07
I3320 n1_m1_182400_249600 0 2.894326e-07
I3321 n1_m1_182400_254400 0 1.727213e-07
I3322 n1_m1_182400_259200 0 1.732144e-07
I3323 n1_m1_182400_264000 0 2.605471e-07
I3324 n1_m1_182400_268800 0 2.809681e-07
I3325 n1_m1_182400_273600 0 7.305494e-07
I3326 n1_m1_182400_278400 0 5.451520e-07
I3327 n1_m1_182400_283200 0 2.483680e-07
I3328 n1_m1_182400_288000 0 2.807588e-07
I3329 n1_m1_182400_292800 0 1.730456e-07
I3330 n1_m1_182400_297600 0 2.567071e-07
I3331 n1_m1_182400_302400 0 1.769473e-07
I3332 n1_m1_182400_307200 0 1.793725e-07
I3333 n1_m1_182400_312000 0 2.818073e-07
I3334 n1_m1_182400_316800 0 1.887443e-07
I3335 n1_m1_182400_321600 0 2.578661e-07
I3336 n1_m1_182400_326400 0 1.728146e-07
I3337 n1_m1_182400_331200 0 1.881490e-07
I3338 n1_m1_182400_336000 0 2.969333e-07
I3339 n1_m1_182400_340800 0 2.118612e-07
I3340 n1_m1_182400_345600 0 6.508406e-07
I3341 n1_m1_182400_350400 0 1.205207e-06
I3342 n1_m1_182400_355200 0 1.341293e-06
I3343 n1_m1_182400_360000 0 1.993330e-06
I3344 n1_m1_182400_364800 0 1.282179e-06
I3345 n1_m1_182400_369600 0 7.475025e-07
I3346 n1_m1_182400_374400 0 1.903668e-07
I3347 n1_m1_182400_379200 0 2.196406e-07
I3348 n1_m1_182400_384000 0 6.842479e-07
I3349 n1_m1_182400_388800 0 1.348061e-06
I3350 n1_m1_182400_393600 0 1.654565e-06
I3351 n1_m1_182400_398400 0 4.031593e-07
I3352 n1_m1_182400_403200 0 1.893255e-07
I3353 n1_m1_182400_408000 0 1.709703e-07
I3354 n1_m1_187200_0 0 1.490440e-07
I3355 n1_m1_187200_4800 0 1.559638e-07
I3356 n1_m1_187200_9600 0 2.431131e-07
I3357 n1_m1_187200_14400 0 1.698509e-07
I3358 n1_m1_187200_19200 0 1.736391e-07
I3359 n1_m1_187200_24000 0 2.689637e-07
I3360 n1_m1_187200_28800 0 1.946373e-07
I3361 n1_m1_187200_33600 0 2.820403e-07
I3362 n1_m1_187200_38400 0 1.693102e-07
I3363 n1_m1_187200_43200 0 1.927790e-07
I3364 n1_m1_187200_48000 0 4.709531e-07
I3365 n1_m1_187200_52800 0 2.335153e-07
I3366 n1_m1_187200_57600 0 2.652008e-07
I3367 n1_m1_187200_62400 0 1.764687e-07
I3368 n1_m1_187200_67200 0 2.569682e-07
I3369 n1_m1_187200_72000 0 7.136661e-07
I3370 n1_m1_187200_76800 0 2.740680e-07
I3371 n1_m1_187200_81600 0 4.545439e-07
I3372 n1_m1_187200_86400 0 2.430081e-07
I3373 n1_m1_187200_91200 0 1.839565e-07
I3374 n1_m1_187200_96000 0 2.728125e-07
I3375 n1_m1_187200_100800 0 1.889213e-07
I3376 n1_m1_187200_105600 0 2.808728e-07
I3377 n1_m1_187200_110400 0 1.843514e-07
I3378 n1_m1_187200_115200 0 1.880760e-07
I3379 n1_m1_187200_120000 0 8.270767e-07
I3380 n1_m1_187200_124800 0 5.598599e-07
I3381 n1_m1_187200_129600 0 4.902312e-07
I3382 n1_m1_187200_134400 0 2.361346e-07
I3383 n1_m1_187200_139200 0 1.960900e-07
I3384 n1_m1_187200_144000 0 2.560353e-07
I3385 n1_m1_187200_148800 0 1.740746e-07
I3386 n1_m1_187200_153600 0 2.821155e-07
I3387 n1_m1_187200_158400 0 3.319632e-07
I3388 n1_m1_187200_163200 0 5.108273e-07
I3389 n1_m1_187200_168000 0 5.772893e-07
I3390 n1_m1_187200_172800 0 2.703730e-07
I3391 n1_m1_187200_177600 0 3.019111e-07
I3392 n1_m1_187200_182400 0 1.732144e-07
I3393 n1_m1_187200_187200 0 1.735385e-07
I3394 n1_m1_187200_192000 0 2.637237e-07
I3395 n1_m1_187200_196800 0 1.819433e-07
I3396 n1_m1_187200_201600 0 3.647956e-07
I3397 n1_m1_187200_206400 0 4.416870e-07
I3398 n1_m1_187200_211200 0 3.707682e-07
I3399 n1_m1_187200_216000 0 3.545689e-07
I3400 n1_m1_187200_220800 0 1.756548e-07
I3401 n1_m1_187200_225600 0 2.518260e-07
I3402 n1_m1_187200_230400 0 1.755458e-07
I3403 n1_m1_187200_235200 0 2.523998e-07
I3404 n1_m1_187200_240000 0 4.036343e-07
I3405 n1_m1_187200_244800 0 1.721278e-07
I3406 n1_m1_187200_249600 0 2.773464e-07
I3407 n1_m1_187200_254400 0 1.695936e-07
I3408 n1_m1_187200_259200 0 1.743425e-07
I3409 n1_m1_187200_264000 0 2.599126e-07
I3410 n1_m1_187200_268800 0 1.734622e-07
I3411 n1_m1_187200_273600 0 3.651562e-07
I3412 n1_m1_187200_278400 0 3.864530e-07
I3413 n1_m1_187200_283200 0 2.369720e-07
I3414 n1_m1_187200_288000 0 2.615449e-07
I3415 n1_m1_187200_292800 0 1.770516e-07
I3416 n1_m1_187200_297600 0 2.882407e-07
I3417 n1_m1_187200_302400 0 1.738505e-07
I3418 n1_m1_187200_307200 0 1.731711e-07
I3419 n1_m1_187200_312000 0 2.842619e-07
I3420 n1_m1_187200_316800 0 2.034480e-07
I3421 n1_m1_187200_321600 0 2.708505e-07
I3422 n1_m1_187200_326400 0 1.748504e-07
I3423 n1_m1_187200_331200 0 2.123813e-07
I3424 n1_m1_187200_336000 0 5.648780e-07
I3425 n1_m1_187200_340800 0 3.748621e-07
I3426 n1_m1_187200_345600 0 6.777480e-07
I3427 n1_m1_187200_350400 0 1.185991e-06
I3428 n1_m1_187200_355200 0 9.833222e-07
I3429 n1_m1_187200_360000 0 1.320073e-06
I3430 n1_m1_187200_364800 0 9.691664e-07
I3431 n1_m1_187200_369600 0 6.698348e-07
I3432 n1_m1_187200_374400 0 4.178653e-07
I3433 n1_m1_187200_379200 0 5.693010e-07
I3434 n1_m1_187200_384000 0 1.028388e-06
I3435 n1_m1_187200_388800 0 1.393469e-06
I3436 n1_m1_187200_393600 0 1.532383e-06
I3437 n1_m1_187200_398400 0 2.421199e-07
I3438 n1_m1_187200_403200 0 1.652416e-07
I3439 n1_m1_187200_408000 0 1.607917e-07
I3440 n1_m1_192000_0 0 2.229689e-07
I3441 n1_m1_192000_4800 0 2.335714e-07
I3442 n1_m1_192000_9600 0 3.699037e-07
I3443 n1_m1_192000_14400 0 2.547764e-07
I3444 n1_m1_192000_19200 0 2.598217e-07
I3445 n1_m1_192000_24000 0 4.112701e-07
I3446 n1_m1_192000_28800 0 3.637953e-07
I3447 n1_m1_192000_33600 0 5.803646e-07
I3448 n1_m1_192000_38400 0 2.737277e-07
I3449 n1_m1_192000_43200 0 2.503306e-07
I3450 n1_m1_192000_48000 0 3.969361e-07
I3451 n1_m1_192000_52800 0 2.705653e-07
I3452 n1_m1_192000_57600 0 3.901303e-07
I3453 n1_m1_192000_62400 0 2.619996e-07
I3454 n1_m1_192000_67200 0 5.495097e-07
I3455 n1_m1_192000_72000 0 2.076574e-06
I3456 n1_m1_192000_76800 0 7.260720e-07
I3457 n1_m1_192000_81600 0 5.871507e-07
I3458 n1_m1_192000_86400 0 2.879616e-07
I3459 n1_m1_192000_91200 0 2.717864e-07
I3460 n1_m1_192000_96000 0 3.943550e-07
I3461 n1_m1_192000_100800 0 2.870468e-07
I3462 n1_m1_192000_105600 0 7.938265e-07
I3463 n1_m1_192000_110400 0 4.539233e-07
I3464 n1_m1_192000_115200 0 3.012865e-07
I3465 n1_m1_192000_120000 0 7.908294e-07
I3466 n1_m1_192000_124800 0 5.400235e-07
I3467 n1_m1_192000_129600 0 4.972621e-07
I3468 n1_m1_192000_134400 0 3.117491e-07
I3469 n1_m1_192000_139200 0 2.949299e-07
I3470 n1_m1_192000_144000 0 5.222417e-07
I3471 n1_m1_192000_148800 0 5.691881e-07
I3472 n1_m1_192000_153600 0 7.600585e-07
I3473 n1_m1_192000_158400 0 8.560370e-07
I3474 n1_m1_192000_163200 0 8.683100e-07
I3475 n1_m1_192000_168000 0 5.206973e-07
I3476 n1_m1_192000_172800 0 2.740115e-07
I3477 n1_m1_192000_177600 0 3.901036e-07
I3478 n1_m1_192000_182400 0 2.566057e-07
I3479 n1_m1_192000_187200 0 2.636281e-07
I3480 n1_m1_192000_192000 0 4.291764e-07
I3481 n1_m1_192000_196800 0 2.904250e-07
I3482 n1_m1_192000_201600 0 5.417541e-07
I3483 n1_m1_192000_206400 0 3.170519e-07
I3484 n1_m1_192000_211200 0 2.964823e-07
I3485 n1_m1_192000_216000 0 4.228122e-07
I3486 n1_m1_192000_220800 0 2.574332e-07
I3487 n1_m1_192000_225600 0 3.820195e-07
I3488 n1_m1_192000_230400 0 2.679543e-07
I3489 n1_m1_192000_235200 0 3.821935e-07
I3490 n1_m1_192000_240000 0 6.923328e-07
I3491 n1_m1_192000_244800 0 2.679156e-07
I3492 n1_m1_192000_249600 0 4.243128e-07
I3493 n1_m1_192000_254400 0 2.638149e-07
I3494 n1_m1_192000_259200 0 2.639914e-07
I3495 n1_m1_192000_264000 0 4.094345e-07
I3496 n1_m1_192000_268800 0 2.634482e-07
I3497 n1_m1_192000_273600 0 3.967048e-07
I3498 n1_m1_192000_278400 0 2.697659e-07
I3499 n1_m1_192000_283200 0 2.652498e-07
I3500 n1_m1_192000_288000 0 3.927472e-07
I3501 n1_m1_192000_292800 0 3.326051e-07
I3502 n1_m1_192000_297600 0 6.365369e-07
I3503 n1_m1_192000_302400 0 2.753303e-07
I3504 n1_m1_192000_307200 0 2.564249e-07
I3505 n1_m1_192000_312000 0 4.008917e-07
I3506 n1_m1_192000_316800 0 2.843962e-07
I3507 n1_m1_192000_321600 0 4.091197e-07
I3508 n1_m1_192000_326400 0 2.632027e-07
I3509 n1_m1_192000_331200 0 3.422866e-07
I3510 n1_m1_192000_336000 0 1.406302e-06
I3511 n1_m1_192000_340800 0 9.935206e-07
I3512 n1_m1_192000_345600 0 7.542905e-07
I3513 n1_m1_192000_350400 0 9.777658e-07
I3514 n1_m1_192000_355200 0 6.706153e-07
I3515 n1_m1_192000_360000 0 6.024243e-07
I3516 n1_m1_192000_364800 0 3.150904e-07
I3517 n1_m1_192000_369600 0 6.226706e-07
I3518 n1_m1_192000_374400 0 1.131591e-06
I3519 n1_m1_192000_379200 0 1.715946e-06
I3520 n1_m1_192000_384000 0 1.915172e-06
I3521 n1_m1_192000_388800 0 1.214546e-06
I3522 n1_m1_192000_393600 0 1.161890e-06
I3523 n1_m1_192000_398400 0 3.031472e-07
I3524 n1_m1_192000_403200 0 2.534236e-07
I3525 n1_m1_192000_408000 0 2.373866e-07
I3526 n1_m1_196800_0 0 1.507421e-07
I3527 n1_m1_196800_4800 0 1.570282e-07
I3528 n1_m1_196800_9600 0 2.416959e-07
I3529 n1_m1_196800_14400 0 1.688131e-07
I3530 n1_m1_196800_19200 0 1.726188e-07
I3531 n1_m1_196800_24000 0 2.639327e-07
I3532 n1_m1_196800_28800 0 1.838276e-07
I3533 n1_m1_196800_33600 0 3.033122e-07
I3534 n1_m1_196800_38400 0 1.794429e-07
I3535 n1_m1_196800_43200 0 1.712909e-07
I3536 n1_m1_196800_48000 0 2.580042e-07
I3537 n1_m1_196800_52800 0 1.775407e-07
I3538 n1_m1_196800_57600 0 2.701727e-07
I3539 n1_m1_196800_62400 0 1.733926e-07
I3540 n1_m1_196800_67200 0 1.888051e-07
I3541 n1_m1_196800_72000 0 5.927182e-07
I3542 n1_m1_196800_76800 0 2.830123e-07
I3543 n1_m1_196800_81600 0 2.776730e-07
I3544 n1_m1_196800_86400 0 1.728591e-07
I3545 n1_m1_196800_91200 0 1.732144e-07
I3546 n1_m1_196800_96000 0 2.606755e-07
I3547 n1_m1_196800_100800 0 2.302028e-07
I3548 n1_m1_196800_105600 0 6.883682e-07
I3549 n1_m1_196800_110400 0 3.584136e-07
I3550 n1_m1_196800_115200 0 2.173131e-07
I3551 n1_m1_196800_120000 0 2.619474e-07
I3552 n1_m1_196800_124800 0 1.870665e-07
I3553 n1_m1_196800_129600 0 3.397019e-07
I3554 n1_m1_196800_134400 0 1.942371e-07
I3555 n1_m1_196800_139200 0 2.324848e-07
I3556 n1_m1_196800_144000 0 7.180548e-07
I3557 n1_m1_196800_148800 0 1.085636e-06
I3558 n1_m1_196800_153600 0 1.272643e-06
I3559 n1_m1_196800_158400 0 2.668573e-07
I3560 n1_m1_196800_163200 0 2.784815e-07
I3561 n1_m1_196800_168000 0 3.430673e-07
I3562 n1_m1_196800_172800 0 1.756843e-07
I3563 n1_m1_196800_177600 0 2.664009e-07
I3564 n1_m1_196800_182400 0 1.744412e-07
I3565 n1_m1_196800_187200 0 1.765780e-07
I3566 n1_m1_196800_192000 0 2.772894e-07
I3567 n1_m1_196800_196800 0 1.732144e-07
I3568 n1_m1_196800_201600 0 3.425982e-07
I3569 n1_m1_196800_206400 0 3.900486e-07
I3570 n1_m1_196800_211200 0 2.289570e-07
I3571 n1_m1_196800_216000 0 2.780680e-07
I3572 n1_m1_196800_220800 0 1.713576e-07
I3573 n1_m1_196800_225600 0 2.560568e-07
I3574 n1_m1_196800_230400 0 1.713657e-07
I3575 n1_m1_196800_235200 0 1.699083e-07
I3576 n1_m1_196800_240000 0 2.654451e-07
I3577 n1_m1_196800_244800 0 1.973845e-07
I3578 n1_m1_196800_249600 0 4.275419e-07
I3579 n1_m1_196800_254400 0 2.097762e-07
I3580 n1_m1_196800_259200 0 1.820702e-07
I3581 n1_m1_196800_264000 0 2.611297e-07
I3582 n1_m1_196800_268800 0 1.734539e-07
I3583 n1_m1_196800_273600 0 2.690928e-07
I3584 n1_m1_196800_278400 0 1.890029e-07
I3585 n1_m1_196800_283200 0 2.310997e-07
I3586 n1_m1_196800_288000 0 2.905553e-07
I3587 n1_m1_196800_292800 0 1.754010e-07
I3588 n1_m1_196800_297600 0 2.740226e-07
I3589 n1_m1_196800_302400 0 1.792443e-07
I3590 n1_m1_196800_307200 0 1.717890e-07
I3591 n1_m1_196800_312000 0 2.588918e-07
I3592 n1_m1_196800_316800 0 1.732144e-07
I3593 n1_m1_196800_321600 0 2.641602e-07
I3594 n1_m1_196800_326400 0 1.760292e-07
I3595 n1_m1_196800_331200 0 1.796140e-07
I3596 n1_m1_196800_336000 0 2.883956e-07
I3597 n1_m1_196800_340800 0 1.869124e-07
I3598 n1_m1_196800_345600 0 2.796492e-07
I3599 n1_m1_196800_350400 0 1.795734e-07
I3600 n1_m1_196800_355200 0 1.836910e-07
I3601 n1_m1_196800_360000 0 3.635440e-07
I3602 n1_m1_196800_364800 0 1.792769e-07
I3603 n1_m1_196800_369600 0 2.831827e-07
I3604 n1_m1_196800_374400 0 2.854563e-07
I3605 n1_m1_196800_379200 0 4.107592e-07
I3606 n1_m1_196800_384000 0 4.654113e-07
I3607 n1_m1_196800_388800 0 1.885619e-07
I3608 n1_m1_196800_393600 0 3.104893e-07
I3609 n1_m1_196800_398400 0 1.923007e-07
I3610 n1_m1_196800_403200 0 1.682562e-07
I3611 n1_m1_196800_408000 0 1.679941e-07
I3612 n1_m1_201600_0 0 1.584597e-07
I3613 n1_m1_201600_4800 0 1.605118e-07
I3614 n1_m1_201600_9600 0 2.441942e-07
I3615 n1_m1_201600_14400 0 1.704866e-07
I3616 n1_m1_201600_19200 0 1.730967e-07
I3617 n1_m1_201600_24000 0 2.639327e-07
I3618 n1_m1_201600_28800 0 1.937677e-07
I3619 n1_m1_201600_33600 0 2.547993e-07
I3620 n1_m1_201600_38400 0 1.702803e-07
I3621 n1_m1_201600_43200 0 1.757813e-07
I3622 n1_m1_201600_48000 0 2.651250e-07
I3623 n1_m1_201600_52800 0 1.769134e-07
I3624 n1_m1_201600_57600 0 2.631405e-07
I3625 n1_m1_201600_62400 0 1.761026e-07
I3626 n1_m1_201600_67200 0 2.138956e-07
I3627 n1_m1_201600_72000 0 2.752650e-07
I3628 n1_m1_201600_76800 0 1.842020e-07
I3629 n1_m1_201600_81600 0 2.760691e-07
I3630 n1_m1_201600_86400 0 1.811440e-07
I3631 n1_m1_201600_91200 0 1.834817e-07
I3632 n1_m1_201600_96000 0 2.733607e-07
I3633 n1_m1_201600_100800 0 1.968458e-07
I3634 n1_m1_201600_105600 0 2.733639e-07
I3635 n1_m1_201600_110400 0 1.742848e-07
I3636 n1_m1_201600_115200 0 2.162726e-07
I3637 n1_m1_201600_120000 0 2.677523e-07
I3638 n1_m1_201600_124800 0 1.749153e-07
I3639 n1_m1_201600_129600 0 2.949998e-07
I3640 n1_m1_201600_134400 0 2.344839e-07
I3641 n1_m1_201600_139200 0 2.829087e-07
I3642 n1_m1_201600_144000 0 3.079239e-07
I3643 n1_m1_201600_148800 0 3.959314e-07
I3644 n1_m1_201600_153600 0 7.568631e-07
I3645 n1_m1_201600_158400 0 1.847564e-07
I3646 n1_m1_201600_163200 0 1.707366e-07
I3647 n1_m1_201600_168000 0 2.814375e-07
I3648 n1_m1_201600_172800 0 2.357820e-07
I3649 n1_m1_201600_177600 0 3.151352e-07
I3650 n1_m1_201600_182400 0 1.701391e-07
I3651 n1_m1_201600_187200 0 1.789335e-07
I3652 n1_m1_201600_192000 0 2.993355e-07
I3653 n1_m1_201600_196800 0 1.973727e-07
I3654 n1_m1_201600_201600 0 6.592696e-07
I3655 n1_m1_201600_206400 0 9.760208e-07
I3656 n1_m1_201600_211200 0 5.036227e-07
I3657 n1_m1_201600_216000 0 3.409945e-07
I3658 n1_m1_201600_220800 0 1.697804e-07
I3659 n1_m1_201600_225600 0 2.535637e-07
I3660 n1_m1_201600_230400 0 1.710636e-07
I3661 n1_m1_201600_235200 0 1.779694e-07
I3662 n1_m1_201600_240000 0 2.587466e-07
I3663 n1_m1_201600_244800 0 3.599131e-07
I3664 n1_m1_201600_249600 0 1.257320e-06
I3665 n1_m1_201600_254400 0 5.049908e-07
I3666 n1_m1_201600_259200 0 2.134193e-07
I3667 n1_m1_201600_264000 0 3.459194e-07
I3668 n1_m1_201600_268800 0 1.987912e-07
I3669 n1_m1_201600_273600 0 2.637311e-07
I3670 n1_m1_201600_278400 0 2.112020e-07
I3671 n1_m1_201600_283200 0 4.389606e-07
I3672 n1_m1_201600_288000 0 6.397160e-07
I3673 n1_m1_201600_292800 0 2.415050e-07
I3674 n1_m1_201600_297600 0 2.555400e-07
I3675 n1_m1_201600_302400 0 1.722905e-07
I3676 n1_m1_201600_307200 0 1.726417e-07
I3677 n1_m1_201600_312000 0 2.589402e-07
I3678 n1_m1_201600_316800 0 1.716241e-07
I3679 n1_m1_201600_321600 0 2.598539e-07
I3680 n1_m1_201600_326400 0 1.772227e-07
I3681 n1_m1_201600_331200 0 1.769654e-07
I3682 n1_m1_201600_336000 0 2.860484e-07
I3683 n1_m1_201600_340800 0 1.838199e-07
I3684 n1_m1_201600_345600 0 2.653937e-07
I3685 n1_m1_201600_350400 0 1.815910e-07
I3686 n1_m1_201600_355200 0 1.751231e-07
I3687 n1_m1_201600_360000 0 2.691528e-07
I3688 n1_m1_201600_364800 0 1.907599e-07
I3689 n1_m1_201600_369600 0 2.623056e-07
I3690 n1_m1_201600_374400 0 2.185280e-07
I3691 n1_m1_201600_379200 0 1.779149e-07
I3692 n1_m1_201600_384000 0 2.817091e-07
I3693 n1_m1_201600_388800 0 1.749222e-07
I3694 n1_m1_201600_393600 0 2.665629e-07
I3695 n1_m1_201600_398400 0 1.740937e-07
I3696 n1_m1_201600_403200 0 1.649676e-07
I3697 n1_m1_201600_408000 0 1.488435e-07
I3698 n1_m1_206400_0 0 1.573086e-07
I3699 n1_m1_206400_4800 0 1.623764e-07
I3700 n1_m1_206400_9600 0 2.541400e-07
I3701 n1_m1_206400_14400 0 1.732144e-07
I3702 n1_m1_206400_19200 0 1.732144e-07
I3703 n1_m1_206400_24000 0 2.621379e-07
I3704 n1_m1_206400_28800 0 2.324624e-07
I3705 n1_m1_206400_33600 0 2.698750e-07
I3706 n1_m1_206400_38400 0 1.831876e-07
I3707 n1_m1_206400_43200 0 1.810227e-07
I3708 n1_m1_206400_48000 0 2.591622e-07
I3709 n1_m1_206400_52800 0 1.708067e-07
I3710 n1_m1_206400_57600 0 2.639780e-07
I3711 n1_m1_206400_62400 0 1.751644e-07
I3712 n1_m1_206400_67200 0 1.712139e-07
I3713 n1_m1_206400_72000 0 2.615970e-07
I3714 n1_m1_206400_76800 0 1.741200e-07
I3715 n1_m1_206400_81600 0 2.840094e-07
I3716 n1_m1_206400_86400 0 1.723402e-07
I3717 n1_m1_206400_91200 0 1.819927e-07
I3718 n1_m1_206400_96000 0 2.716733e-07
I3719 n1_m1_206400_100800 0 1.810484e-07
I3720 n1_m1_206400_105600 0 2.602367e-07
I3721 n1_m1_206400_110400 0 1.734094e-07
I3722 n1_m1_206400_115200 0 1.820687e-07
I3723 n1_m1_206400_120000 0 3.361668e-07
I3724 n1_m1_206400_124800 0 2.529400e-07
I3725 n1_m1_206400_129600 0 2.794501e-07
I3726 n1_m1_206400_134400 0 1.913751e-07
I3727 n1_m1_206400_139200 0 1.824900e-07
I3728 n1_m1_206400_144000 0 2.626002e-07
I3729 n1_m1_206400_148800 0 1.794398e-07
I3730 n1_m1_206400_153600 0 3.064981e-07
I3731 n1_m1_206400_158400 0 1.753567e-07
I3732 n1_m1_206400_163200 0 1.723975e-07
I3733 n1_m1_206400_168000 0 3.066759e-07
I3734 n1_m1_206400_172800 0 3.994344e-07
I3735 n1_m1_206400_177600 0 5.696366e-07
I3736 n1_m1_206400_182400 0 1.737500e-07
I3737 n1_m1_206400_187200 0 1.746829e-07
I3738 n1_m1_206400_192000 0 3.264353e-07
I3739 n1_m1_206400_196800 0 3.866536e-07
I3740 n1_m1_206400_201600 0 1.109983e-06
I3741 n1_m1_206400_206400 0 7.117844e-07
I3742 n1_m1_206400_211200 0 3.825969e-07
I3743 n1_m1_206400_216000 0 2.906335e-07
I3744 n1_m1_206400_220800 0 1.676737e-07
I3745 n1_m1_206400_225600 0 2.557982e-07
I3746 n1_m1_206400_230400 0 1.716073e-07
I3747 n1_m1_206400_235200 0 1.759751e-07
I3748 n1_m1_206400_240000 0 2.622391e-07
I3749 n1_m1_206400_244800 0 2.528131e-07
I3750 n1_m1_206400_249600 0 1.043113e-06
I3751 n1_m1_206400_254400 0 8.968552e-07
I3752 n1_m1_206400_259200 0 5.133825e-07
I3753 n1_m1_206400_264000 0 4.460189e-07
I3754 n1_m1_206400_268800 0 2.182650e-07
I3755 n1_m1_206400_273600 0 3.487201e-07
I3756 n1_m1_206400_278400 0 1.918274e-07
I3757 n1_m1_206400_283200 0 2.130577e-07
I3758 n1_m1_206400_288000 0 4.450355e-07
I3759 n1_m1_206400_292800 0 2.079374e-07
I3760 n1_m1_206400_297600 0 2.641845e-07
I3761 n1_m1_206400_302400 0 1.745941e-07
I3762 n1_m1_206400_307200 0 1.710156e-07
I3763 n1_m1_206400_312000 0 2.572427e-07
I3764 n1_m1_206400_316800 0 1.697615e-07
I3765 n1_m1_206400_321600 0 2.613398e-07
I3766 n1_m1_206400_326400 0 1.729059e-07
I3767 n1_m1_206400_331200 0 1.712139e-07
I3768 n1_m1_206400_336000 0 2.598217e-07
I3769 n1_m1_206400_340800 0 1.743085e-07
I3770 n1_m1_206400_345600 0 2.654520e-07
I3771 n1_m1_206400_350400 0 1.754940e-07
I3772 n1_m1_206400_355200 0 1.732144e-07
I3773 n1_m1_206400_360000 0 2.669124e-07
I3774 n1_m1_206400_364800 0 1.742444e-07
I3775 n1_m1_206400_369600 0 2.598217e-07
I3776 n1_m1_206400_374400 0 1.732144e-07
I3777 n1_m1_206400_379200 0 1.740521e-07
I3778 n1_m1_206400_384000 0 2.621379e-07
I3779 n1_m1_206400_388800 0 1.751075e-07
I3780 n1_m1_206400_393600 0 2.698148e-07
I3781 n1_m1_206400_398400 0 1.773579e-07
I3782 n1_m1_206400_403200 0 1.648625e-07
I3783 n1_m1_206400_408000 0 1.507258e-07
I3784 n1_m1_211200_0 0 1.598903e-07
I3785 n1_m1_211200_4800 0 1.623764e-07
I3786 n1_m1_211200_9600 0 2.534554e-07
I3787 n1_m1_211200_14400 0 1.732144e-07
I3788 n1_m1_211200_19200 0 1.732144e-07
I3789 n1_m1_211200_24000 0 2.570041e-07
I3790 n1_m1_211200_28800 0 1.795202e-07
I3791 n1_m1_211200_33600 0 2.701455e-07
I3792 n1_m1_211200_38400 0 1.810194e-07
I3793 n1_m1_211200_43200 0 1.845472e-07
I3794 n1_m1_211200_48000 0 2.582835e-07
I3795 n1_m1_211200_52800 0 1.732144e-07
I3796 n1_m1_211200_57600 0 2.598217e-07
I3797 n1_m1_211200_62400 0 1.732144e-07
I3798 n1_m1_211200_67200 0 1.686322e-07
I3799 n1_m1_211200_72000 0 2.614593e-07
I3800 n1_m1_211200_76800 0 1.808904e-07
I3801 n1_m1_211200_81600 0 2.636740e-07
I3802 n1_m1_211200_86400 0 1.732144e-07
I3803 n1_m1_211200_91200 0 1.737743e-07
I3804 n1_m1_211200_96000 0 2.664683e-07
I3805 n1_m1_211200_100800 0 1.800213e-07
I3806 n1_m1_211200_105600 0 2.694810e-07
I3807 n1_m1_211200_110400 0 1.699677e-07
I3808 n1_m1_211200_115200 0 1.737519e-07
I3809 n1_m1_211200_120000 0 3.418928e-07
I3810 n1_m1_211200_124800 0 2.851918e-07
I3811 n1_m1_211200_129600 0 2.804882e-07
I3812 n1_m1_211200_134400 0 1.753106e-07
I3813 n1_m1_211200_139200 0 1.747661e-07
I3814 n1_m1_211200_144000 0 2.589252e-07
I3815 n1_m1_211200_148800 0 1.686485e-07
I3816 n1_m1_211200_153600 0 2.631302e-07
I3817 n1_m1_211200_158400 0 1.730099e-07
I3818 n1_m1_211200_163200 0 1.784383e-07
I3819 n1_m1_211200_168000 0 2.608180e-07
I3820 n1_m1_211200_172800 0 2.573288e-07
I3821 n1_m1_211200_177600 0 4.706237e-07
I3822 n1_m1_211200_182400 0 1.845643e-07
I3823 n1_m1_211200_187200 0 1.714051e-07
I3824 n1_m1_211200_192000 0 3.240337e-07
I3825 n1_m1_211200_196800 0 3.773267e-07
I3826 n1_m1_211200_201600 0 8.399140e-07
I3827 n1_m1_211200_206400 0 2.868706e-07
I3828 n1_m1_211200_211200 0 1.900550e-07
I3829 n1_m1_211200_216000 0 2.590471e-07
I3830 n1_m1_211200_220800 0 1.678302e-07
I3831 n1_m1_211200_225600 0 2.572378e-07
I3832 n1_m1_211200_230400 0 1.713697e-07
I3833 n1_m1_211200_235200 0 1.678862e-07
I3834 n1_m1_211200_240000 0 2.649320e-07
I3835 n1_m1_211200_244800 0 1.739095e-07
I3836 n1_m1_211200_249600 0 4.889129e-07
I3837 n1_m1_211200_254400 0 7.793521e-07
I3838 n1_m1_211200_259200 0 5.918159e-07
I3839 n1_m1_211200_264000 0 3.063886e-07
I3840 n1_m1_211200_268800 0 1.835576e-07
I3841 n1_m1_211200_273600 0 3.264024e-07
I3842 n1_m1_211200_278400 0 1.812054e-07
I3843 n1_m1_211200_283200 0 1.742114e-07
I3844 n1_m1_211200_288000 0 2.865196e-07
I3845 n1_m1_211200_292800 0 2.031972e-07
I3846 n1_m1_211200_297600 0 2.661453e-07
I3847 n1_m1_211200_302400 0 1.726044e-07
I3848 n1_m1_211200_307200 0 1.725600e-07
I3849 n1_m1_211200_312000 0 2.653138e-07
I3850 n1_m1_211200_316800 0 1.776690e-07
I3851 n1_m1_211200_321600 0 2.619532e-07
I3852 n1_m1_211200_326400 0 1.734765e-07
I3853 n1_m1_211200_331200 0 1.759656e-07
I3854 n1_m1_211200_336000 0 2.659078e-07
I3855 n1_m1_211200_340800 0 1.733091e-07
I3856 n1_m1_211200_345600 0 2.562079e-07
I3857 n1_m1_211200_350400 0 1.732144e-07
I3858 n1_m1_211200_355200 0 1.761433e-07
I3859 n1_m1_211200_360000 0 2.624082e-07
I3860 n1_m1_211200_364800 0 1.732144e-07
I3861 n1_m1_211200_369600 0 2.598217e-07
I3862 n1_m1_211200_374400 0 1.732144e-07
I3863 n1_m1_211200_379200 0 1.732144e-07
I3864 n1_m1_211200_384000 0 2.598217e-07
I3865 n1_m1_211200_388800 0 1.738101e-07
I3866 n1_m1_211200_393600 0 2.629659e-07
I3867 n1_m1_211200_398400 0 1.745181e-07
I3868 n1_m1_211200_403200 0 1.648625e-07
I3869 n1_m1_211200_408000 0 1.507258e-07
I3870 n1_m1_216000_0 0 2.398354e-07
I3871 n1_m1_216000_4800 0 2.403053e-07
I3872 n1_m1_216000_9600 0 3.742317e-07
I3873 n1_m1_216000_14400 0 2.598217e-07
I3874 n1_m1_216000_19200 0 2.598217e-07
I3875 n1_m1_216000_24000 0 4.050284e-07
I3876 n1_m1_216000_28800 0 2.782229e-07
I3877 n1_m1_216000_33600 0 5.258998e-07
I3878 n1_m1_216000_38400 0 2.714604e-07
I3879 n1_m1_216000_43200 0 2.816242e-07
I3880 n1_m1_216000_48000 0 4.238741e-07
I3881 n1_m1_216000_52800 0 2.598217e-07
I3882 n1_m1_216000_57600 0 3.897325e-07
I3883 n1_m1_216000_62400 0 2.616096e-07
I3884 n1_m1_216000_67200 0 2.600401e-07
I3885 n1_m1_216000_72000 0 3.902808e-07
I3886 n1_m1_216000_76800 0 2.706092e-07
I3887 n1_m1_216000_81600 0 5.074957e-07
I3888 n1_m1_216000_86400 0 4.851618e-07
I3889 n1_m1_216000_91200 0 2.804115e-07
I3890 n1_m1_216000_96000 0 3.973980e-07
I3891 n1_m1_216000_100800 0 2.611209e-07
I3892 n1_m1_216000_105600 0 3.946253e-07
I3893 n1_m1_216000_110400 0 2.859052e-07
I3894 n1_m1_216000_115200 0 3.280110e-07
I3895 n1_m1_216000_120000 0 4.459866e-07
I3896 n1_m1_216000_124800 0 2.724732e-07
I3897 n1_m1_216000_129600 0 3.946707e-07
I3898 n1_m1_216000_134400 0 2.661020e-07
I3899 n1_m1_216000_139200 0 2.618047e-07
I3900 n1_m1_216000_144000 0 3.829195e-07
I3901 n1_m1_216000_148800 0 2.510537e-07
I3902 n1_m1_216000_153600 0 3.838517e-07
I3903 n1_m1_216000_158400 0 2.561248e-07
I3904 n1_m1_216000_163200 0 2.975284e-07
I3905 n1_m1_216000_168000 0 4.391235e-07
I3906 n1_m1_216000_172800 0 2.779079e-07
I3907 n1_m1_216000_177600 0 4.651753e-07
I3908 n1_m1_216000_182400 0 2.617284e-07
I3909 n1_m1_216000_187200 0 2.559738e-07
I3910 n1_m1_216000_192000 0 3.946247e-07
I3911 n1_m1_216000_196800 0 2.839176e-07
I3912 n1_m1_216000_201600 0 5.218591e-07
I3913 n1_m1_216000_206400 0 3.078728e-07
I3914 n1_m1_216000_211200 0 2.718105e-07
I3915 n1_m1_216000_216000 0 3.991713e-07
I3916 n1_m1_216000_220800 0 2.523512e-07
I3917 n1_m1_216000_225600 0 3.781318e-07
I3918 n1_m1_216000_230400 0 2.572050e-07
I3919 n1_m1_216000_235200 0 2.649999e-07
I3920 n1_m1_216000_240000 0 3.832466e-07
I3921 n1_m1_216000_244800 0 2.656488e-07
I3922 n1_m1_216000_249600 0 4.784586e-07
I3923 n1_m1_216000_254400 0 3.751506e-07
I3924 n1_m1_216000_259200 0 3.394872e-07
I3925 n1_m1_216000_264000 0 4.424940e-07
I3926 n1_m1_216000_268800 0 2.734848e-07
I3927 n1_m1_216000_273600 0 3.834760e-07
I3928 n1_m1_216000_278400 0 2.729666e-07
I3929 n1_m1_216000_283200 0 2.692089e-07
I3930 n1_m1_216000_288000 0 4.375564e-07
I3931 n1_m1_216000_292800 0 4.128133e-07
I3932 n1_m1_216000_297600 0 4.507692e-07
I3933 n1_m1_216000_302400 0 2.709609e-07
I3934 n1_m1_216000_307200 0 2.737922e-07
I3935 n1_m1_216000_312000 0 3.962311e-07
I3936 n1_m1_216000_316800 0 2.607980e-07
I3937 n1_m1_216000_321600 0 3.831082e-07
I3938 n1_m1_216000_326400 0 2.599858e-07
I3939 n1_m1_216000_331200 0 2.690292e-07
I3940 n1_m1_216000_336000 0 3.987145e-07
I3941 n1_m1_216000_340800 0 2.635956e-07
I3942 n1_m1_216000_345600 0 3.905237e-07
I3943 n1_m1_216000_350400 0 2.598217e-07
I3944 n1_m1_216000_355200 0 2.606295e-07
I3945 n1_m1_216000_360000 0 3.899982e-07
I3946 n1_m1_216000_364800 0 2.601519e-07
I3947 n1_m1_216000_369600 0 4.015232e-07
I3948 n1_m1_216000_374400 0 2.676928e-07
I3949 n1_m1_216000_379200 0 2.594805e-07
I3950 n1_m1_216000_384000 0 3.866392e-07
I3951 n1_m1_216000_388800 0 2.598217e-07
I3952 n1_m1_216000_393600 0 3.897325e-07
I3953 n1_m1_216000_398400 0 2.584149e-07
I3954 n1_m1_216000_403200 0 2.459051e-07
I3955 n1_m1_216000_408000 0 2.260887e-07
I3956 n1_m1_220800_0 0 1.564648e-07
I3957 n1_m1_220800_4800 0 1.618973e-07
I3958 n1_m1_220800_9600 0 2.558472e-07
I3959 n1_m1_220800_14400 0 1.736125e-07
I3960 n1_m1_220800_19200 0 1.733276e-07
I3961 n1_m1_220800_24000 0 2.704050e-07
I3962 n1_m1_220800_28800 0 2.196259e-07
I3963 n1_m1_220800_33600 0 4.906024e-07
I3964 n1_m1_220800_38400 0 2.047007e-07
I3965 n1_m1_220800_43200 0 1.811340e-07
I3966 n1_m1_220800_48000 0 2.728839e-07
I3967 n1_m1_220800_52800 0 1.720823e-07
I3968 n1_m1_220800_57600 0 2.537537e-07
I3969 n1_m1_220800_62400 0 1.738157e-07
I3970 n1_m1_220800_67200 0 1.737046e-07
I3971 n1_m1_220800_72000 0 2.573010e-07
I3972 n1_m1_220800_76800 0 2.981633e-07
I3973 n1_m1_220800_81600 0 7.657147e-07
I3974 n1_m1_220800_86400 0 5.096779e-07
I3975 n1_m1_220800_91200 0 2.335068e-07
I3976 n1_m1_220800_96000 0 2.680704e-07
I3977 n1_m1_220800_100800 0 1.737495e-07
I3978 n1_m1_220800_105600 0 2.609207e-07
I3979 n1_m1_220800_110400 0 1.838965e-07
I3980 n1_m1_220800_115200 0 2.025926e-07
I3981 n1_m1_220800_120000 0 2.850776e-07
I3982 n1_m1_220800_124800 0 1.744599e-07
I3983 n1_m1_220800_129600 0 2.683552e-07
I3984 n1_m1_220800_134400 0 1.954147e-07
I3985 n1_m1_220800_139200 0 1.807408e-07
I3986 n1_m1_220800_144000 0 2.500451e-07
I3987 n1_m1_220800_148800 0 1.702547e-07
I3988 n1_m1_220800_153600 0 2.619735e-07
I3989 n1_m1_220800_158400 0 1.998736e-07
I3990 n1_m1_220800_163200 0 2.496502e-07
I3991 n1_m1_220800_168000 0 3.238093e-07
I3992 n1_m1_220800_172800 0 1.876247e-07
I3993 n1_m1_220800_177600 0 2.765061e-07
I3994 n1_m1_220800_182400 0 1.680145e-07
I3995 n1_m1_220800_187200 0 1.788568e-07
I3996 n1_m1_220800_192000 0 2.684023e-07
I3997 n1_m1_220800_196800 0 1.769923e-07
I3998 n1_m1_220800_201600 0 3.223053e-07
I3999 n1_m1_220800_206400 0 2.523441e-07
I4000 n1_m1_220800_211200 0 1.813477e-07
I4001 n1_m1_220800_216000 0 2.573376e-07
I4002 n1_m1_220800_220800 0 1.670774e-07
I4003 n1_m1_220800_225600 0 2.540911e-07
I4004 n1_m1_220800_230400 0 1.729523e-07
I4005 n1_m1_220800_235200 0 1.705701e-07
I4006 n1_m1_220800_240000 0 2.654181e-07
I4007 n1_m1_220800_244800 0 1.850214e-07
I4008 n1_m1_220800_249600 0 2.652543e-07
I4009 n1_m1_220800_254400 0 1.862040e-07
I4010 n1_m1_220800_259200 0 1.773644e-07
I4011 n1_m1_220800_264000 0 2.697878e-07
I4012 n1_m1_220800_268800 0 1.703305e-07
I4013 n1_m1_220800_273600 0 2.704835e-07
I4014 n1_m1_220800_278400 0 1.798039e-07
I4015 n1_m1_220800_283200 0 1.791901e-07
I4016 n1_m1_220800_288000 0 2.771085e-07
I4017 n1_m1_220800_292800 0 2.153572e-07
I4018 n1_m1_220800_297600 0 2.860223e-07
I4019 n1_m1_220800_302400 0 1.834264e-07
I4020 n1_m1_220800_307200 0 1.787019e-07
I4021 n1_m1_220800_312000 0 2.893691e-07
I4022 n1_m1_220800_316800 0 2.905631e-07
I4023 n1_m1_220800_321600 0 4.710483e-07
I4024 n1_m1_220800_326400 0 2.036098e-07
I4025 n1_m1_220800_331200 0 1.707655e-07
I4026 n1_m1_220800_336000 0 2.601026e-07
I4027 n1_m1_220800_340800 0 1.761969e-07
I4028 n1_m1_220800_345600 0 2.664581e-07
I4029 n1_m1_220800_350400 0 1.732144e-07
I4030 n1_m1_220800_355200 0 1.732144e-07
I4031 n1_m1_220800_360000 0 2.598217e-07
I4032 n1_m1_220800_364800 0 1.734513e-07
I4033 n1_m1_220800_369600 0 2.682781e-07
I4034 n1_m1_220800_374400 0 1.788597e-07
I4035 n1_m1_220800_379200 0 1.737721e-07
I4036 n1_m1_220800_384000 0 2.634869e-07
I4037 n1_m1_220800_388800 0 1.736280e-07
I4038 n1_m1_220800_393600 0 2.598217e-07
I4039 n1_m1_220800_398400 0 1.706958e-07
I4040 n1_m1_220800_403200 0 1.621268e-07
I4041 n1_m1_220800_408000 0 1.506015e-07
I4042 n1_m1_225600_0 0 1.556910e-07
I4043 n1_m1_225600_4800 0 1.657709e-07
I4044 n1_m1_225600_9600 0 2.699184e-07
I4045 n1_m1_225600_14400 0 1.821084e-07
I4046 n1_m1_225600_19200 0 1.760574e-07
I4047 n1_m1_225600_24000 0 3.214621e-07
I4048 n1_m1_225600_28800 0 3.799486e-07
I4049 n1_m1_225600_33600 0 4.594205e-07
I4050 n1_m1_225600_38400 0 1.897852e-07
I4051 n1_m1_225600_43200 0 1.810662e-07
I4052 n1_m1_225600_48000 0 3.955480e-07
I4053 n1_m1_225600_52800 0 1.950588e-07
I4054 n1_m1_225600_57600 0 2.548117e-07
I4055 n1_m1_225600_62400 0 1.701966e-07
I4056 n1_m1_225600_67200 0 1.750292e-07
I4057 n1_m1_225600_72000 0 2.743497e-07
I4058 n1_m1_225600_76800 0 4.355097e-07
I4059 n1_m1_225600_81600 0 9.341786e-07
I4060 n1_m1_225600_86400 0 3.396816e-07
I4061 n1_m1_225600_91200 0 2.030302e-07
I4062 n1_m1_225600_96000 0 2.815262e-07
I4063 n1_m1_225600_100800 0 1.809823e-07
I4064 n1_m1_225600_105600 0 2.673488e-07
I4065 n1_m1_225600_110400 0 1.720487e-07
I4066 n1_m1_225600_115200 0 1.774486e-07
I4067 n1_m1_225600_120000 0 2.762702e-07
I4068 n1_m1_225600_124800 0 1.770502e-07
I4069 n1_m1_225600_129600 0 2.741488e-07
I4070 n1_m1_225600_134400 0 1.856589e-07
I4071 n1_m1_225600_139200 0 1.780223e-07
I4072 n1_m1_225600_144000 0 2.539201e-07
I4073 n1_m1_225600_148800 0 1.686229e-07
I4074 n1_m1_225600_153600 0 2.679624e-07
I4075 n1_m1_225600_158400 0 2.505816e-07
I4076 n1_m1_225600_163200 0 2.494739e-07
I4077 n1_m1_225600_168000 0 3.793591e-07
I4078 n1_m1_225600_172800 0 2.483196e-07
I4079 n1_m1_225600_177600 0 2.702554e-07
I4080 n1_m1_225600_182400 0 1.678405e-07
I4081 n1_m1_225600_187200 0 1.701480e-07
I4082 n1_m1_225600_192000 0 2.975188e-07
I4083 n1_m1_225600_196800 0 2.468240e-07
I4084 n1_m1_225600_201600 0 4.795185e-07
I4085 n1_m1_225600_206400 0 4.093802e-07
I4086 n1_m1_225600_211200 0 2.163934e-07
I4087 n1_m1_225600_216000 0 2.592883e-07
I4088 n1_m1_225600_220800 0 1.688626e-07
I4089 n1_m1_225600_225600 0 2.514009e-07
I4090 n1_m1_225600_230400 0 1.886691e-07
I4091 n1_m1_225600_235200 0 1.964471e-07
I4092 n1_m1_225600_240000 0 3.515798e-07
I4093 n1_m1_225600_244800 0 2.471834e-07
I4094 n1_m1_225600_249600 0 2.676508e-07
I4095 n1_m1_225600_254400 0 1.697801e-07
I4096 n1_m1_225600_259200 0 1.998394e-07
I4097 n1_m1_225600_264000 0 4.504864e-07
I4098 n1_m1_225600_268800 0 1.951918e-07
I4099 n1_m1_225600_273600 0 3.445484e-07
I4100 n1_m1_225600_278400 0 1.910218e-07
I4101 n1_m1_225600_283200 0 1.916703e-07
I4102 n1_m1_225600_288000 0 2.944469e-07
I4103 n1_m1_225600_292800 0 1.791198e-07
I4104 n1_m1_225600_297600 0 2.688170e-07
I4105 n1_m1_225600_302400 0 1.777905e-07
I4106 n1_m1_225600_307200 0 1.723539e-07
I4107 n1_m1_225600_312000 0 2.838922e-07
I4108 n1_m1_225600_316800 0 3.091011e-07
I4109 n1_m1_225600_321600 0 5.866598e-07
I4110 n1_m1_225600_326400 0 2.377158e-07
I4111 n1_m1_225600_331200 0 1.715929e-07
I4112 n1_m1_225600_336000 0 2.598217e-07
I4113 n1_m1_225600_340800 0 1.734631e-07
I4114 n1_m1_225600_345600 0 2.609067e-07
I4115 n1_m1_225600_350400 0 1.736962e-07
I4116 n1_m1_225600_355200 0 1.752282e-07
I4117 n1_m1_225600_360000 0 2.612893e-07
I4118 n1_m1_225600_364800 0 1.732467e-07
I4119 n1_m1_225600_369600 0 2.609733e-07
I4120 n1_m1_225600_374400 0 1.739833e-07
I4121 n1_m1_225600_379200 0 1.735642e-07
I4122 n1_m1_225600_384000 0 2.674077e-07
I4123 n1_m1_225600_388800 0 1.786236e-07
I4124 n1_m1_225600_393600 0 2.604291e-07
I4125 n1_m1_225600_398400 0 1.706958e-07
I4126 n1_m1_225600_403200 0 1.587351e-07
I4127 n1_m1_225600_408000 0 1.489123e-07
I4128 n1_m1_230400_0 0 1.500291e-07
I4129 n1_m1_230400_4800 0 1.661958e-07
I4130 n1_m1_230400_9600 0 2.882971e-07
I4131 n1_m1_230400_14400 0 2.658451e-07
I4132 n1_m1_230400_19200 0 2.007853e-07
I4133 n1_m1_230400_24000 0 3.235248e-07
I4134 n1_m1_230400_28800 0 3.769619e-07
I4135 n1_m1_230400_33600 0 4.830942e-07
I4136 n1_m1_230400_38400 0 1.873883e-07
I4137 n1_m1_230400_43200 0 1.745889e-07
I4138 n1_m1_230400_48000 0 3.521303e-07
I4139 n1_m1_230400_52800 0 2.812525e-07
I4140 n1_m1_230400_57600 0 2.613800e-07
I4141 n1_m1_230400_62400 0 1.751400e-07
I4142 n1_m1_230400_67200 0 1.799180e-07
I4143 n1_m1_230400_72000 0 2.822250e-07
I4144 n1_m1_230400_76800 0 2.645571e-07
I4145 n1_m1_230400_81600 0 3.927821e-07
I4146 n1_m1_230400_86400 0 2.119697e-07
I4147 n1_m1_230400_91200 0 2.393473e-07
I4148 n1_m1_230400_96000 0 3.187828e-07
I4149 n1_m1_230400_100800 0 1.753174e-07
I4150 n1_m1_230400_105600 0 2.626817e-07
I4151 n1_m1_230400_110400 0 1.738087e-07
I4152 n1_m1_230400_115200 0 1.750124e-07
I4153 n1_m1_230400_120000 0 2.790267e-07
I4154 n1_m1_230400_124800 0 1.907286e-07
I4155 n1_m1_230400_129600 0 3.229786e-07
I4156 n1_m1_230400_134400 0 1.840670e-07
I4157 n1_m1_230400_139200 0 1.835691e-07
I4158 n1_m1_230400_144000 0 2.732418e-07
I4159 n1_m1_230400_148800 0 1.701555e-07
I4160 n1_m1_230400_153600 0 2.764092e-07
I4161 n1_m1_230400_158400 0 2.845001e-07
I4162 n1_m1_230400_163200 0 3.219170e-07
I4163 n1_m1_230400_168000 0 3.482404e-07
I4164 n1_m1_230400_172800 0 1.810961e-07
I4165 n1_m1_230400_177600 0 2.576639e-07
I4166 n1_m1_230400_182400 0 1.721738e-07
I4167 n1_m1_230400_187200 0 1.760531e-07
I4168 n1_m1_230400_192000 0 4.210421e-07
I4169 n1_m1_230400_196800 0 4.098301e-07
I4170 n1_m1_230400_201600 0 6.056257e-07
I4171 n1_m1_230400_206400 0 3.129685e-07
I4172 n1_m1_230400_211200 0 1.883755e-07
I4173 n1_m1_230400_216000 0 2.528547e-07
I4174 n1_m1_230400_220800 0 1.679547e-07
I4175 n1_m1_230400_225600 0 2.545253e-07
I4176 n1_m1_230400_230400 0 1.764175e-07
I4177 n1_m1_230400_235200 0 2.743986e-07
I4178 n1_m1_230400_240000 0 6.877451e-07
I4179 n1_m1_230400_244800 0 3.520933e-07
I4180 n1_m1_230400_249600 0 3.078240e-07
I4181 n1_m1_230400_254400 0 1.778390e-07
I4182 n1_m1_230400_259200 0 2.765738e-07
I4183 n1_m1_230400_264000 0 5.337890e-07
I4184 n1_m1_230400_268800 0 2.164457e-07
I4185 n1_m1_230400_273600 0 3.465338e-07
I4186 n1_m1_230400_278400 0 2.071868e-07
I4187 n1_m1_230400_283200 0 1.914035e-07
I4188 n1_m1_230400_288000 0 2.676615e-07
I4189 n1_m1_230400_292800 0 2.463904e-07
I4190 n1_m1_230400_297600 0 5.276534e-07
I4191 n1_m1_230400_302400 0 1.808924e-07
I4192 n1_m1_230400_307200 0 1.732780e-07
I4193 n1_m1_230400_312000 0 2.563713e-07
I4194 n1_m1_230400_316800 0 1.979071e-07
I4195 n1_m1_230400_321600 0 5.195554e-07
I4196 n1_m1_230400_326400 0 1.934770e-07
I4197 n1_m1_230400_331200 0 1.750030e-07
I4198 n1_m1_230400_336000 0 2.598217e-07
I4199 n1_m1_230400_340800 0 1.732144e-07
I4200 n1_m1_230400_345600 0 2.598217e-07
I4201 n1_m1_230400_350400 0 1.737153e-07
I4202 n1_m1_230400_355200 0 1.787635e-07
I4203 n1_m1_230400_360000 0 2.751251e-07
I4204 n1_m1_230400_364800 0 1.767237e-07
I4205 n1_m1_230400_369600 0 2.604543e-07
I4206 n1_m1_230400_374400 0 1.780532e-07
I4207 n1_m1_230400_379200 0 1.821163e-07
I4208 n1_m1_230400_384000 0 2.766825e-07
I4209 n1_m1_230400_388800 0 1.808642e-07
I4210 n1_m1_230400_393600 0 2.777975e-07
I4211 n1_m1_230400_398400 0 1.790839e-07
I4212 n1_m1_230400_403200 0 1.617230e-07
I4213 n1_m1_230400_408000 0 1.600781e-07
I4214 n1_m1_235200_0 0 1.513738e-07
I4215 n1_m1_235200_4800 0 1.574648e-07
I4216 n1_m1_235200_9600 0 3.044022e-07
I4217 n1_m1_235200_14400 0 3.611812e-07
I4218 n1_m1_235200_19200 0 2.391923e-07
I4219 n1_m1_235200_24000 0 2.623960e-07
I4220 n1_m1_235200_28800 0 1.920789e-07
I4221 n1_m1_235200_33600 0 2.931684e-07
I4222 n1_m1_235200_38400 0 1.709424e-07
I4223 n1_m1_235200_43200 0 1.703430e-07
I4224 n1_m1_235200_48000 0 2.752262e-07
I4225 n1_m1_235200_52800 0 2.470466e-07
I4226 n1_m1_235200_57600 0 2.620339e-07
I4227 n1_m1_235200_62400 0 1.764155e-07
I4228 n1_m1_235200_67200 0 1.765960e-07
I4229 n1_m1_235200_72000 0 2.610340e-07
I4230 n1_m1_235200_76800 0 1.849122e-07
I4231 n1_m1_235200_81600 0 2.800426e-07
I4232 n1_m1_235200_86400 0 2.351835e-07
I4233 n1_m1_235200_91200 0 3.111165e-07
I4234 n1_m1_235200_96000 0 4.242398e-07
I4235 n1_m1_235200_100800 0 1.863744e-07
I4236 n1_m1_235200_105600 0 2.681139e-07
I4237 n1_m1_235200_110400 0 1.740867e-07
I4238 n1_m1_235200_115200 0 1.741356e-07
I4239 n1_m1_235200_120000 0 2.733884e-07
I4240 n1_m1_235200_124800 0 2.023892e-07
I4241 n1_m1_235200_129600 0 4.142683e-07
I4242 n1_m1_235200_134400 0 1.970627e-07
I4243 n1_m1_235200_139200 0 2.131918e-07
I4244 n1_m1_235200_144000 0 2.748598e-07
I4245 n1_m1_235200_148800 0 1.687743e-07
I4246 n1_m1_235200_153600 0 2.573286e-07
I4247 n1_m1_235200_158400 0 2.132413e-07
I4248 n1_m1_235200_163200 0 3.262156e-07
I4249 n1_m1_235200_168000 0 4.865650e-07
I4250 n1_m1_235200_172800 0 2.113117e-07
I4251 n1_m1_235200_177600 0 2.658432e-07
I4252 n1_m1_235200_182400 0 1.733061e-07
I4253 n1_m1_235200_187200 0 1.720174e-07
I4254 n1_m1_235200_192000 0 2.824140e-07
I4255 n1_m1_235200_196800 0 2.134399e-07
I4256 n1_m1_235200_201600 0 3.020189e-07
I4257 n1_m1_235200_206400 0 2.207359e-07
I4258 n1_m1_235200_211200 0 1.740073e-07
I4259 n1_m1_235200_216000 0 2.589272e-07
I4260 n1_m1_235200_220800 0 1.692445e-07
I4261 n1_m1_235200_225600 0 2.545711e-07
I4262 n1_m1_235200_230400 0 1.823877e-07
I4263 n1_m1_235200_235200 0 1.864967e-07
I4264 n1_m1_235200_240000 0 4.130393e-07
I4265 n1_m1_235200_244800 0 4.166389e-07
I4266 n1_m1_235200_249600 0 4.030761e-07
I4267 n1_m1_235200_254400 0 1.724590e-07
I4268 n1_m1_235200_259200 0 1.972134e-07
I4269 n1_m1_235200_264000 0 3.473880e-07
I4270 n1_m1_235200_268800 0 1.893394e-07
I4271 n1_m1_235200_273600 0 2.772616e-07
I4272 n1_m1_235200_278400 0 1.838984e-07
I4273 n1_m1_235200_283200 0 1.759875e-07
I4274 n1_m1_235200_288000 0 2.811899e-07
I4275 n1_m1_235200_292800 0 2.156235e-07
I4276 n1_m1_235200_297600 0 4.323418e-07
I4277 n1_m1_235200_302400 0 1.730937e-07
I4278 n1_m1_235200_307200 0 1.796493e-07
I4279 n1_m1_235200_312000 0 2.675261e-07
I4280 n1_m1_235200_316800 0 2.359631e-07
I4281 n1_m1_235200_321600 0 6.530876e-07
I4282 n1_m1_235200_326400 0 2.190429e-07
I4283 n1_m1_235200_331200 0 1.893107e-07
I4284 n1_m1_235200_336000 0 2.598217e-07
I4285 n1_m1_235200_340800 0 1.732144e-07
I4286 n1_m1_235200_345600 0 2.598217e-07
I4287 n1_m1_235200_350400 0 1.732144e-07
I4288 n1_m1_235200_355200 0 1.774879e-07
I4289 n1_m1_235200_360000 0 2.687764e-07
I4290 n1_m1_235200_364800 0 1.822686e-07
I4291 n1_m1_235200_369600 0 2.639159e-07
I4292 n1_m1_235200_374400 0 2.035108e-07
I4293 n1_m1_235200_379200 0 2.145144e-07
I4294 n1_m1_235200_384000 0 3.094561e-07
I4295 n1_m1_235200_388800 0 2.160133e-07
I4296 n1_m1_235200_393600 0 3.563102e-07
I4297 n1_m1_235200_398400 0 1.967078e-07
I4298 n1_m1_235200_403200 0 1.715457e-07
I4299 n1_m1_235200_408000 0 2.308087e-07
I4300 n1_m1_240000_0 0 2.378553e-07
I4301 n1_m1_240000_4800 0 2.479111e-07
I4302 n1_m1_240000_9600 0 3.933431e-07
I4303 n1_m1_240000_14400 0 3.068662e-07
I4304 n1_m1_240000_19200 0 2.697687e-07
I4305 n1_m1_240000_24000 0 4.008382e-07
I4306 n1_m1_240000_28800 0 2.649585e-07
I4307 n1_m1_240000_33600 0 3.926447e-07
I4308 n1_m1_240000_38400 0 2.565677e-07
I4309 n1_m1_240000_43200 0 2.633082e-07
I4310 n1_m1_240000_48000 0 3.968582e-07
I4311 n1_m1_240000_52800 0 2.651262e-07
I4312 n1_m1_240000_57600 0 3.903205e-07
I4313 n1_m1_240000_62400 0 2.652521e-07
I4314 n1_m1_240000_67200 0 2.696076e-07
I4315 n1_m1_240000_72000 0 3.906728e-07
I4316 n1_m1_240000_76800 0 2.628866e-07
I4317 n1_m1_240000_81600 0 4.101904e-07
I4318 n1_m1_240000_86400 0 3.255586e-07
I4319 n1_m1_240000_91200 0 4.085284e-07
I4320 n1_m1_240000_96000 0 5.267127e-07
I4321 n1_m1_240000_100800 0 2.718239e-07
I4322 n1_m1_240000_105600 0 3.974822e-07
I4323 n1_m1_240000_110400 0 2.618613e-07
I4324 n1_m1_240000_115200 0 2.661142e-07
I4325 n1_m1_240000_120000 0 4.197829e-07
I4326 n1_m1_240000_124800 0 3.341703e-07
I4327 n1_m1_240000_129600 0 9.157676e-07
I4328 n1_m1_240000_134400 0 5.316812e-07
I4329 n1_m1_240000_139200 0 6.339806e-07
I4330 n1_m1_240000_144000 0 5.599959e-07
I4331 n1_m1_240000_148800 0 2.499315e-07
I4332 n1_m1_240000_153600 0 3.925485e-07
I4333 n1_m1_240000_158400 0 3.458482e-07
I4334 n1_m1_240000_163200 0 4.962610e-07
I4335 n1_m1_240000_168000 0 6.652260e-07
I4336 n1_m1_240000_172800 0 2.919921e-07
I4337 n1_m1_240000_177600 0 3.948590e-07
I4338 n1_m1_240000_182400 0 2.594002e-07
I4339 n1_m1_240000_187200 0 2.512583e-07
I4340 n1_m1_240000_192000 0 3.775426e-07
I4341 n1_m1_240000_196800 0 2.602025e-07
I4342 n1_m1_240000_201600 0 3.890943e-07
I4343 n1_m1_240000_206400 0 2.576102e-07
I4344 n1_m1_240000_211200 0 2.498285e-07
I4345 n1_m1_240000_216000 0 3.869327e-07
I4346 n1_m1_240000_220800 0 2.597382e-07
I4347 n1_m1_240000_225600 0 4.054074e-07
I4348 n1_m1_240000_230400 0 2.745058e-07
I4349 n1_m1_240000_235200 0 2.869971e-07
I4350 n1_m1_240000_240000 0 4.387404e-07
I4351 n1_m1_240000_244800 0 3.326561e-07
I4352 n1_m1_240000_249600 0 4.402732e-07
I4353 n1_m1_240000_254400 0 2.623190e-07
I4354 n1_m1_240000_259200 0 2.711187e-07
I4355 n1_m1_240000_264000 0 4.003235e-07
I4356 n1_m1_240000_268800 0 2.619700e-07
I4357 n1_m1_240000_273600 0 4.008650e-07
I4358 n1_m1_240000_278400 0 2.793418e-07
I4359 n1_m1_240000_283200 0 3.417883e-07
I4360 n1_m1_240000_288000 0 4.743822e-07
I4361 n1_m1_240000_292800 0 3.755382e-07
I4362 n1_m1_240000_297600 0 6.430184e-07
I4363 n1_m1_240000_302400 0 2.642021e-07
I4364 n1_m1_240000_307200 0 2.604177e-07
I4365 n1_m1_240000_312000 0 3.793368e-07
I4366 n1_m1_240000_316800 0 2.716134e-07
I4367 n1_m1_240000_321600 0 5.513875e-07
I4368 n1_m1_240000_326400 0 2.709619e-07
I4369 n1_m1_240000_331200 0 2.568344e-07
I4370 n1_m1_240000_336000 0 3.897325e-07
I4371 n1_m1_240000_340800 0 2.598217e-07
I4372 n1_m1_240000_345600 0 3.897325e-07
I4373 n1_m1_240000_350400 0 2.598217e-07
I4374 n1_m1_240000_355200 0 2.662319e-07
I4375 n1_m1_240000_360000 0 4.040448e-07
I4376 n1_m1_240000_364800 0 2.723629e-07
I4377 n1_m1_240000_369600 0 4.010235e-07
I4378 n1_m1_240000_374400 0 2.715420e-07
I4379 n1_m1_240000_379200 0 3.519475e-07
I4380 n1_m1_240000_384000 0 1.057650e-06
I4381 n1_m1_240000_388800 0 1.160712e-06
I4382 n1_m1_240000_393600 0 1.352047e-06
I4383 n1_m1_240000_398400 0 3.529288e-07
I4384 n1_m1_240000_403200 0 2.615242e-07
I4385 n1_m1_240000_408000 0 2.485588e-07
I4386 n1_m1_244800_0 0 1.523110e-07
I4387 n1_m1_244800_4800 0 1.566388e-07
I4388 n1_m1_244800_9600 0 2.616695e-07
I4389 n1_m1_244800_14400 0 1.922156e-07
I4390 n1_m1_244800_19200 0 1.735877e-07
I4391 n1_m1_244800_24000 0 2.814611e-07
I4392 n1_m1_244800_28800 0 1.808805e-07
I4393 n1_m1_244800_33600 0 2.832373e-07
I4394 n1_m1_244800_38400 0 1.867501e-07
I4395 n1_m1_244800_43200 0 1.771173e-07
I4396 n1_m1_244800_48000 0 2.644152e-07
I4397 n1_m1_244800_52800 0 1.847529e-07
I4398 n1_m1_244800_57600 0 2.749223e-07
I4399 n1_m1_244800_62400 0 1.778162e-07
I4400 n1_m1_244800_67200 0 1.777837e-07
I4401 n1_m1_244800_72000 0 2.593232e-07
I4402 n1_m1_244800_76800 0 1.721616e-07
I4403 n1_m1_244800_81600 0 2.651248e-07
I4404 n1_m1_244800_86400 0 2.094530e-07
I4405 n1_m1_244800_91200 0 2.496268e-07
I4406 n1_m1_244800_96000 0 3.620065e-07
I4407 n1_m1_244800_100800 0 1.895983e-07
I4408 n1_m1_244800_105600 0 2.598382e-07
I4409 n1_m1_244800_110400 0 1.732144e-07
I4410 n1_m1_244800_115200 0 1.733323e-07
I4411 n1_m1_244800_120000 0 2.714313e-07
I4412 n1_m1_244800_124800 0 2.081669e-07
I4413 n1_m1_244800_129600 0 6.018260e-07
I4414 n1_m1_244800_134400 0 2.675976e-07
I4415 n1_m1_244800_139200 0 2.267750e-07
I4416 n1_m1_244800_144000 0 2.602490e-07
I4417 n1_m1_244800_148800 0 1.905556e-07
I4418 n1_m1_244800_153600 0 2.801268e-07
I4419 n1_m1_244800_158400 0 1.786626e-07
I4420 n1_m1_244800_163200 0 1.871506e-07
I4421 n1_m1_244800_168000 0 2.787592e-07
I4422 n1_m1_244800_172800 0 1.789976e-07
I4423 n1_m1_244800_177600 0 2.635315e-07
I4424 n1_m1_244800_182400 0 1.732092e-07
I4425 n1_m1_244800_187200 0 1.720195e-07
I4426 n1_m1_244800_192000 0 2.572091e-07
I4427 n1_m1_244800_196800 0 1.746562e-07
I4428 n1_m1_244800_201600 0 2.660593e-07
I4429 n1_m1_244800_206400 0 1.723451e-07
I4430 n1_m1_244800_211200 0 1.671940e-07
I4431 n1_m1_244800_216000 0 2.551145e-07
I4432 n1_m1_244800_220800 0 1.740058e-07
I4433 n1_m1_244800_225600 0 3.300424e-07
I4434 n1_m1_244800_230400 0 2.225965e-07
I4435 n1_m1_244800_235200 0 2.755417e-07
I4436 n1_m1_244800_240000 0 3.928528e-07
I4437 n1_m1_244800_244800 0 1.791243e-07
I4438 n1_m1_244800_249600 0 2.666419e-07
I4439 n1_m1_244800_254400 0 1.839718e-07
I4440 n1_m1_244800_259200 0 1.785088e-07
I4441 n1_m1_244800_264000 0 2.618385e-07
I4442 n1_m1_244800_268800 0 1.800504e-07
I4443 n1_m1_244800_273600 0 2.687275e-07
I4444 n1_m1_244800_278400 0 1.998125e-07
I4445 n1_m1_244800_283200 0 3.018251e-07
I4446 n1_m1_244800_288000 0 6.922402e-07
I4447 n1_m1_244800_292800 0 8.542263e-07
I4448 n1_m1_244800_297600 0 1.260880e-06
I4449 n1_m1_244800_302400 0 2.743521e-07
I4450 n1_m1_244800_307200 0 1.959253e-07
I4451 n1_m1_244800_312000 0 2.561762e-07
I4452 n1_m1_244800_316800 0 1.813677e-07
I4453 n1_m1_244800_321600 0 2.587384e-07
I4454 n1_m1_244800_326400 0 1.732481e-07
I4455 n1_m1_244800_331200 0 1.763349e-07
I4456 n1_m1_244800_336000 0 2.598217e-07
I4457 n1_m1_244800_340800 0 1.732144e-07
I4458 n1_m1_244800_345600 0 2.598217e-07
I4459 n1_m1_244800_350400 0 1.732144e-07
I4460 n1_m1_244800_355200 0 1.774879e-07
I4461 n1_m1_244800_360000 0 2.762723e-07
I4462 n1_m1_244800_364800 0 1.745067e-07
I4463 n1_m1_244800_369600 0 2.906081e-07
I4464 n1_m1_244800_374400 0 1.921186e-07
I4465 n1_m1_244800_379200 0 4.333139e-07
I4466 n1_m1_244800_384000 0 1.387552e-06
I4467 n1_m1_244800_388800 0 4.621198e-07
I4468 n1_m1_244800_393600 0 3.819205e-07
I4469 n1_m1_244800_398400 0 2.769396e-07
I4470 n1_m1_244800_403200 0 1.588905e-07
I4471 n1_m1_244800_408000 0 1.639313e-07
I4472 n1_m1_249600_0 0 2.351271e-07
I4473 n1_m1_249600_4800 0 2.351611e-07
I4474 n1_m1_249600_9600 0 3.784082e-07
I4475 n1_m1_249600_14400 0 2.829058e-07
I4476 n1_m1_249600_19200 0 3.377994e-07
I4477 n1_m1_249600_24000 0 1.068391e-06
I4478 n1_m1_249600_28800 0 6.223755e-07
I4479 n1_m1_249600_33600 0 4.667216e-07
I4480 n1_m1_249600_38400 0 2.786227e-07
I4481 n1_m1_249600_43200 0 2.687496e-07
I4482 n1_m1_249600_48000 0 4.360738e-07
I4483 n1_m1_249600_52800 0 4.443826e-07
I4484 n1_m1_249600_57600 0 5.789549e-07
I4485 n1_m1_249600_62400 0 2.781766e-07
I4486 n1_m1_249600_67200 0 2.589013e-07
I4487 n1_m1_249600_72000 0 3.990866e-07
I4488 n1_m1_249600_76800 0 2.647532e-07
I4489 n1_m1_249600_81600 0 3.974430e-07
I4490 n1_m1_249600_86400 0 2.743136e-07
I4491 n1_m1_249600_91200 0 2.834802e-07
I4492 n1_m1_249600_96000 0 4.416503e-07
I4493 n1_m1_249600_100800 0 2.819484e-07
I4494 n1_m1_249600_105600 0 3.897325e-07
I4495 n1_m1_249600_110400 0 2.598217e-07
I4496 n1_m1_249600_115200 0 2.598620e-07
I4497 n1_m1_249600_120000 0 3.968741e-07
I4498 n1_m1_249600_124800 0 2.652876e-07
I4499 n1_m1_249600_129600 0 4.287931e-07
I4500 n1_m1_249600_134400 0 2.956221e-07
I4501 n1_m1_249600_139200 0 2.655888e-07
I4502 n1_m1_249600_144000 0 3.818146e-07
I4503 n1_m1_249600_148800 0 2.496911e-07
I4504 n1_m1_249600_153600 0 3.956226e-07
I4505 n1_m1_249600_158400 0 2.686082e-07
I4506 n1_m1_249600_163200 0 2.623529e-07
I4507 n1_m1_249600_168000 0 3.835796e-07
I4508 n1_m1_249600_172800 0 2.576139e-07
I4509 n1_m1_249600_177600 0 3.865096e-07
I4510 n1_m1_249600_182400 0 2.537293e-07
I4511 n1_m1_249600_187200 0 2.594041e-07
I4512 n1_m1_249600_192000 0 3.897325e-07
I4513 n1_m1_249600_196800 0 2.603304e-07
I4514 n1_m1_249600_201600 0 3.921008e-07
I4515 n1_m1_249600_206400 0 2.598986e-07
I4516 n1_m1_249600_211200 0 2.572527e-07
I4517 n1_m1_249600_216000 0 3.903808e-07
I4518 n1_m1_249600_220800 0 2.556961e-07
I4519 n1_m1_249600_225600 0 4.508557e-07
I4520 n1_m1_249600_230400 0 3.366411e-07
I4521 n1_m1_249600_235200 0 3.185487e-07
I4522 n1_m1_249600_240000 0 4.392747e-07
I4523 n1_m1_249600_244800 0 2.733563e-07
I4524 n1_m1_249600_249600 0 3.967731e-07
I4525 n1_m1_249600_254400 0 2.628031e-07
I4526 n1_m1_249600_259200 0 2.631121e-07
I4527 n1_m1_249600_264000 0 3.989681e-07
I4528 n1_m1_249600_268800 0 2.824784e-07
I4529 n1_m1_249600_273600 0 4.039006e-07
I4530 n1_m1_249600_278400 0 3.267321e-07
I4531 n1_m1_249600_283200 0 8.144925e-07
I4532 n1_m1_249600_288000 0 2.414464e-06
I4533 n1_m1_249600_292800 0 1.807615e-06
I4534 n1_m1_249600_297600 0 2.052496e-06
I4535 n1_m1_249600_302400 0 6.105702e-07
I4536 n1_m1_249600_307200 0 4.687432e-07
I4537 n1_m1_249600_312000 0 4.498124e-07
I4538 n1_m1_249600_316800 0 2.902398e-07
I4539 n1_m1_249600_321600 0 4.113708e-07
I4540 n1_m1_249600_326400 0 3.098857e-07
I4541 n1_m1_249600_331200 0 2.624769e-07
I4542 n1_m1_249600_336000 0 3.897325e-07
I4543 n1_m1_249600_340800 0 2.598217e-07
I4544 n1_m1_249600_345600 0 3.897325e-07
I4545 n1_m1_249600_350400 0 2.598217e-07
I4546 n1_m1_249600_355200 0 2.662319e-07
I4547 n1_m1_249600_360000 0 4.126296e-07
I4548 n1_m1_249600_364800 0 2.632606e-07
I4549 n1_m1_249600_369600 0 4.066853e-07
I4550 n1_m1_249600_374400 0 2.702911e-07
I4551 n1_m1_249600_379200 0 3.950269e-07
I4552 n1_m1_249600_384000 0 8.903097e-07
I4553 n1_m1_249600_388800 0 3.375017e-07
I4554 n1_m1_249600_393600 0 4.160057e-07
I4555 n1_m1_249600_398400 0 2.864612e-07
I4556 n1_m1_249600_403200 0 2.694437e-07
I4557 n1_m1_249600_408000 0 2.580569e-07
I4558 n1_m1_254400_0 0 7.422587e-08
I4559 n1_m1_254400_4800 0 8.461196e-08
I4560 n1_m1_254400_9600 0 1.261374e-07
I4561 n1_m1_254400_14400 0 8.492902e-08
I4562 n1_m1_254400_19200 0 2.229644e-07
I4563 n1_m1_254400_24000 0 8.941383e-07
I4564 n1_m1_254400_28800 0 5.541754e-07
I4565 n1_m1_254400_33600 0 2.609914e-07
I4566 n1_m1_254400_38400 0 9.040137e-08
I4567 n1_m1_254400_43200 0 9.699515e-08
I4568 n1_m1_254400_48000 0 2.205602e-07
I4569 n1_m1_254400_52800 0 3.934755e-07
I4570 n1_m1_254400_57600 0 4.814151e-07
I4571 n1_m1_254400_62400 0 1.419576e-07
I4572 n1_m1_254400_67200 0 8.853714e-08
I4573 n1_m1_254400_72000 0 1.299108e-07
I4574 n1_m1_254400_76800 0 8.711015e-08
I4575 n1_m1_254400_81600 0 1.324549e-07
I4576 n1_m1_254400_86400 0 9.513949e-08
I4577 n1_m1_254400_91200 0 1.017769e-07
I4578 n1_m1_254400_96000 0 2.013299e-07
I4579 n1_m1_254400_100800 0 1.276518e-07
I4580 n1_m1_254400_105600 0 1.302136e-07
I4581 n1_m1_254400_110400 0 8.643691e-08
I4582 n1_m1_254400_115200 0 8.652251e-08
I4583 n1_m1_254400_120000 0 1.353427e-07
I4584 n1_m1_254400_124800 0 9.400825e-08
I4585 n1_m1_254400_129600 0 1.746744e-07
I4586 n1_m1_254400_134400 0 1.320114e-07
I4587 n1_m1_254400_139200 0 9.088577e-08
I4588 n1_m1_254400_144000 0 1.319143e-07
I4589 n1_m1_254400_148800 0 8.960883e-08
I4590 n1_m1_254400_153600 0 1.251626e-07
I4591 n1_m1_254400_158400 0 8.497985e-08
I4592 n1_m1_254400_163200 0 8.635576e-08
I4593 n1_m1_254400_168000 0 1.351065e-07
I4594 n1_m1_254400_172800 0 1.102266e-07
I4595 n1_m1_254400_177600 0 1.656852e-07
I4596 n1_m1_254400_182400 0 8.562213e-08
I4597 n1_m1_254400_187200 0 8.612996e-08
I4598 n1_m1_254400_192000 0 1.295006e-07
I4599 n1_m1_254400_196800 0 8.802089e-08
I4600 n1_m1_254400_201600 0 1.334929e-07
I4601 n1_m1_254400_206400 0 8.364178e-08
I4602 n1_m1_254400_211200 0 8.868105e-08
I4603 n1_m1_254400_216000 0 1.506599e-07
I4604 n1_m1_254400_220800 0 8.694533e-08
I4605 n1_m1_254400_225600 0 1.330378e-07
I4606 n1_m1_254400_230400 0 1.075844e-07
I4607 n1_m1_254400_235200 0 1.233670e-07
I4608 n1_m1_254400_240000 0 1.611497e-07
I4609 n1_m1_254400_244800 0 8.948776e-08
I4610 n1_m1_254400_249600 0 1.341604e-07
I4611 n1_m1_254400_254400 0 9.215537e-08
I4612 n1_m1_254400_259200 0 8.818110e-08
I4613 n1_m1_254400_264000 0 1.327871e-07
I4614 n1_m1_254400_268800 0 9.238261e-08
I4615 n1_m1_254400_273600 0 1.327859e-07
I4616 n1_m1_254400_278400 0 1.210604e-07
I4617 n1_m1_254400_283200 0 3.620777e-07
I4618 n1_m1_254400_288000 0 9.683893e-07
I4619 n1_m1_254400_292800 0 4.434182e-07
I4620 n1_m1_254400_297600 0 2.555176e-07
I4621 n1_m1_254400_302400 0 1.148296e-07
I4622 n1_m1_254400_307200 0 2.265324e-07
I4623 n1_m1_254400_312000 0 2.241324e-07
I4624 n1_m1_254400_316800 0 1.322886e-07
I4625 n1_m1_254400_321600 0 1.851056e-07
I4626 n1_m1_254400_326400 0 1.751335e-07
I4627 n1_m1_254400_331200 0 1.055737e-07
I4628 n1_m1_254400_336000 0 1.297517e-07
I4629 n1_m1_254400_340800 0 8.707181e-08
I4630 n1_m1_254400_345600 0 1.310076e-07
I4631 n1_m1_254400_350400 0 8.733843e-08
I4632 n1_m1_254400_355200 0 8.924065e-08
I4633 n1_m1_254400_360000 0 1.350409e-07
I4634 n1_m1_254400_364800 0 1.014861e-07
I4635 n1_m1_254400_369600 0 1.429028e-07
I4636 n1_m1_254400_374400 0 9.341457e-08
I4637 n1_m1_254400_379200 0 9.127609e-08
I4638 n1_m1_254400_384000 0 2.136951e-07
I4639 n1_m1_254400_388800 0 9.641033e-08
I4640 n1_m1_254400_393600 0 1.326041e-07
I4641 n1_m1_254400_398400 0 8.774515e-08
I4642 n1_m1_254400_403200 0 8.079176e-08
I4643 n1_m1_254400_408000 0 7.743624e-08
I4644 n1_m1_259200_0 0 1.581286e-07
I4645 n1_m1_259200_4800 0 1.645924e-07
I4646 n1_m1_259200_9600 0 2.457928e-07
I4647 n1_m1_259200_14400 0 1.721719e-07
I4648 n1_m1_259200_19200 0 2.827992e-07
I4649 n1_m1_259200_24000 0 1.450688e-06
I4650 n1_m1_259200_28800 0 1.114963e-06
I4651 n1_m1_259200_33600 0 6.836816e-07
I4652 n1_m1_259200_38400 0 2.053803e-07
I4653 n1_m1_259200_43200 0 3.684697e-07
I4654 n1_m1_259200_48000 0 1.222264e-06
I4655 n1_m1_259200_52800 0 7.197188e-07
I4656 n1_m1_259200_57600 0 1.111507e-06
I4657 n1_m1_259200_62400 0 3.683581e-07
I4658 n1_m1_259200_67200 0 2.146093e-07
I4659 n1_m1_259200_72000 0 2.840604e-07
I4660 n1_m1_259200_76800 0 1.745536e-07
I4661 n1_m1_259200_81600 0 3.862465e-07
I4662 n1_m1_259200_86400 0 4.041085e-07
I4663 n1_m1_259200_91200 0 2.421347e-07
I4664 n1_m1_259200_96000 0 2.932957e-07
I4665 n1_m1_259200_100800 0 1.961446e-07
I4666 n1_m1_259200_105600 0 2.598180e-07
I4667 n1_m1_259200_110400 0 1.721925e-07
I4668 n1_m1_259200_115200 0 1.834850e-07
I4669 n1_m1_259200_120000 0 4.907861e-07
I4670 n1_m1_259200_124800 0 4.043878e-07
I4671 n1_m1_259200_129600 0 2.981029e-07
I4672 n1_m1_259200_134400 0 1.798765e-07
I4673 n1_m1_259200_139200 0 1.787158e-07
I4674 n1_m1_259200_144000 0 2.610148e-07
I4675 n1_m1_259200_148800 0 1.732144e-07
I4676 n1_m1_259200_153600 0 2.566535e-07
I4677 n1_m1_259200_158400 0 2.164279e-07
I4678 n1_m1_259200_163200 0 2.038133e-07
I4679 n1_m1_259200_168000 0 2.816530e-07
I4680 n1_m1_259200_172800 0 4.039251e-07
I4681 n1_m1_259200_177600 0 7.003634e-07
I4682 n1_m1_259200_182400 0 2.004850e-07
I4683 n1_m1_259200_187200 0 1.708201e-07
I4684 n1_m1_259200_192000 0 2.565540e-07
I4685 n1_m1_259200_196800 0 1.864411e-07
I4686 n1_m1_259200_201600 0 2.766435e-07
I4687 n1_m1_259200_206400 0 1.790671e-07
I4688 n1_m1_259200_211200 0 3.700383e-07
I4689 n1_m1_259200_216000 0 1.005087e-06
I4690 n1_m1_259200_220800 0 3.652882e-07
I4691 n1_m1_259200_225600 0 2.886169e-07
I4692 n1_m1_259200_230400 0 1.867020e-07
I4693 n1_m1_259200_235200 0 2.020602e-07
I4694 n1_m1_259200_240000 0 3.246822e-07
I4695 n1_m1_259200_244800 0 1.934363e-07
I4696 n1_m1_259200_249600 0 3.654532e-07
I4697 n1_m1_259200_254400 0 3.321631e-07
I4698 n1_m1_259200_259200 0 2.181053e-07
I4699 n1_m1_259200_264000 0 2.560841e-07
I4700 n1_m1_259200_268800 0 1.762879e-07
I4701 n1_m1_259200_273600 0 2.604265e-07
I4702 n1_m1_259200_278400 0 1.780362e-07
I4703 n1_m1_259200_283200 0 3.409905e-07
I4704 n1_m1_259200_288000 0 1.274636e-06
I4705 n1_m1_259200_292800 0 3.534676e-07
I4706 n1_m1_259200_297600 0 2.947017e-07
I4707 n1_m1_259200_302400 0 1.977039e-07
I4708 n1_m1_259200_307200 0 2.320600e-07
I4709 n1_m1_259200_312000 0 3.148888e-07
I4710 n1_m1_259200_316800 0 1.818233e-07
I4711 n1_m1_259200_321600 0 2.793796e-07
I4712 n1_m1_259200_326400 0 2.256481e-07
I4713 n1_m1_259200_331200 0 2.384619e-07
I4714 n1_m1_259200_336000 0 2.788549e-07
I4715 n1_m1_259200_340800 0 1.748848e-07
I4716 n1_m1_259200_345600 0 2.907503e-07
I4717 n1_m1_259200_350400 0 3.920450e-07
I4718 n1_m1_259200_355200 0 6.529387e-07
I4719 n1_m1_259200_360000 0 5.405798e-07
I4720 n1_m1_259200_364800 0 3.655219e-07
I4721 n1_m1_259200_369600 0 4.861732e-07
I4722 n1_m1_259200_374400 0 1.852734e-07
I4723 n1_m1_259200_379200 0 1.729972e-07
I4724 n1_m1_259200_384000 0 2.717516e-07
I4725 n1_m1_259200_388800 0 1.922509e-07
I4726 n1_m1_259200_393600 0 3.152654e-07
I4727 n1_m1_259200_398400 0 1.757023e-07
I4728 n1_m1_259200_403200 0 1.784203e-07
I4729 n1_m1_259200_408000 0 1.623462e-07
I4730 n1_m1_264000_0 0 2.324056e-07
I4731 n1_m1_264000_4800 0 2.319151e-07
I4732 n1_m1_264000_9600 0 3.737957e-07
I4733 n1_m1_264000_14400 0 2.656220e-07
I4734 n1_m1_264000_19200 0 2.774097e-07
I4735 n1_m1_264000_24000 0 6.435200e-07
I4736 n1_m1_264000_28800 0 4.567585e-07
I4737 n1_m1_264000_33600 0 4.725095e-07
I4738 n1_m1_264000_38400 0 2.978434e-07
I4739 n1_m1_264000_43200 0 4.091320e-07
I4740 n1_m1_264000_48000 0 1.314021e-06
I4741 n1_m1_264000_52800 0 5.542008e-07
I4742 n1_m1_264000_57600 0 6.660738e-07
I4743 n1_m1_264000_62400 0 3.012582e-07
I4744 n1_m1_264000_67200 0 2.725617e-07
I4745 n1_m1_264000_72000 0 3.981186e-07
I4746 n1_m1_264000_76800 0 2.660976e-07
I4747 n1_m1_264000_81600 0 4.317691e-07
I4748 n1_m1_264000_86400 0 4.394729e-07
I4749 n1_m1_264000_91200 0 3.865854e-07
I4750 n1_m1_264000_96000 0 4.473780e-07
I4751 n1_m1_264000_100800 0 2.593718e-07
I4752 n1_m1_264000_105600 0 3.891997e-07
I4753 n1_m1_264000_110400 0 2.557757e-07
I4754 n1_m1_264000_115200 0 2.581806e-07
I4755 n1_m1_264000_120000 0 5.026917e-07
I4756 n1_m1_264000_124800 0 3.705422e-07
I4757 n1_m1_264000_129600 0 4.049964e-07
I4758 n1_m1_264000_134400 0 2.606392e-07
I4759 n1_m1_264000_139200 0 2.582977e-07
I4760 n1_m1_264000_144000 0 3.897325e-07
I4761 n1_m1_264000_148800 0 2.598217e-07
I4762 n1_m1_264000_153600 0 3.864804e-07
I4763 n1_m1_264000_158400 0 2.781819e-07
I4764 n1_m1_264000_163200 0 2.747664e-07
I4765 n1_m1_264000_168000 0 4.411511e-07
I4766 n1_m1_264000_172800 0 3.426232e-07
I4767 n1_m1_264000_177600 0 5.074738e-07
I4768 n1_m1_264000_182400 0 2.664125e-07
I4769 n1_m1_264000_187200 0 2.514817e-07
I4770 n1_m1_264000_192000 0 3.821908e-07
I4771 n1_m1_264000_196800 0 2.654274e-07
I4772 n1_m1_264000_201600 0 3.991245e-07
I4773 n1_m1_264000_206400 0 2.730576e-07
I4774 n1_m1_264000_211200 0 4.512403e-07
I4775 n1_m1_264000_216000 0 1.072384e-06
I4776 n1_m1_264000_220800 0 4.516468e-07
I4777 n1_m1_264000_225600 0 4.579498e-07
I4778 n1_m1_264000_230400 0 3.251420e-07
I4779 n1_m1_264000_235200 0 2.712715e-07
I4780 n1_m1_264000_240000 0 4.103005e-07
I4781 n1_m1_264000_244800 0 2.657926e-07
I4782 n1_m1_264000_249600 0 4.458734e-07
I4783 n1_m1_264000_254400 0 3.898015e-07
I4784 n1_m1_264000_259200 0 2.928770e-07
I4785 n1_m1_264000_264000 0 3.782123e-07
I4786 n1_m1_264000_268800 0 2.555176e-07
I4787 n1_m1_264000_273600 0 3.799798e-07
I4788 n1_m1_264000_278400 0 2.613738e-07
I4789 n1_m1_264000_283200 0 2.978511e-07
I4790 n1_m1_264000_288000 0 5.637396e-07
I4791 n1_m1_264000_292800 0 2.830879e-07
I4792 n1_m1_264000_297600 0 3.916946e-07
I4793 n1_m1_264000_302400 0 2.696378e-07
I4794 n1_m1_264000_307200 0 2.691714e-07
I4795 n1_m1_264000_312000 0 3.938788e-07
I4796 n1_m1_264000_316800 0 2.675043e-07
I4797 n1_m1_264000_321600 0 3.994640e-07
I4798 n1_m1_264000_326400 0 2.617457e-07
I4799 n1_m1_264000_331200 0 2.632353e-07
I4800 n1_m1_264000_336000 0 4.039844e-07
I4801 n1_m1_264000_340800 0 2.691968e-07
I4802 n1_m1_264000_345600 0 4.066808e-07
I4803 n1_m1_264000_350400 0 4.613808e-07
I4804 n1_m1_264000_355200 0 8.112366e-07
I4805 n1_m1_264000_360000 0 7.136864e-07
I4806 n1_m1_264000_364800 0 3.262608e-07
I4807 n1_m1_264000_369600 0 4.542906e-07
I4808 n1_m1_264000_374400 0 2.721635e-07
I4809 n1_m1_264000_379200 0 2.679900e-07
I4810 n1_m1_264000_384000 0 4.232951e-07
I4811 n1_m1_264000_388800 0 2.610977e-07
I4812 n1_m1_264000_393600 0 4.685517e-07
I4813 n1_m1_264000_398400 0 2.592780e-07
I4814 n1_m1_264000_403200 0 2.706417e-07
I4815 n1_m1_264000_408000 0 2.498425e-07
I4816 n1_m1_268800_0 0 1.477454e-07
I4817 n1_m1_268800_4800 0 1.593053e-07
I4818 n1_m1_268800_9600 0 2.794874e-07
I4819 n1_m1_268800_14400 0 1.975385e-07
I4820 n1_m1_268800_19200 0 1.832245e-07
I4821 n1_m1_268800_24000 0 2.593878e-07
I4822 n1_m1_268800_28800 0 1.738503e-07
I4823 n1_m1_268800_33600 0 2.585203e-07
I4824 n1_m1_268800_38400 0 1.991751e-07
I4825 n1_m1_268800_43200 0 2.608712e-07
I4826 n1_m1_268800_48000 0 6.024613e-07
I4827 n1_m1_268800_52800 0 2.690424e-07
I4828 n1_m1_268800_57600 0 2.753506e-07
I4829 n1_m1_268800_62400 0 1.799414e-07
I4830 n1_m1_268800_67200 0 1.694263e-07
I4831 n1_m1_268800_72000 0 2.859008e-07
I4832 n1_m1_268800_76800 0 1.933096e-07
I4833 n1_m1_268800_81600 0 5.490607e-07
I4834 n1_m1_268800_86400 0 4.841182e-07
I4835 n1_m1_268800_91200 0 2.706051e-07
I4836 n1_m1_268800_96000 0 3.017258e-07
I4837 n1_m1_268800_100800 0 1.781098e-07
I4838 n1_m1_268800_105600 0 2.541610e-07
I4839 n1_m1_268800_110400 0 1.701109e-07
I4840 n1_m1_268800_115200 0 1.669249e-07
I4841 n1_m1_268800_120000 0 2.629641e-07
I4842 n1_m1_268800_124800 0 1.727854e-07
I4843 n1_m1_268800_129600 0 2.596254e-07
I4844 n1_m1_268800_134400 0 1.729802e-07
I4845 n1_m1_268800_139200 0 1.720242e-07
I4846 n1_m1_268800_144000 0 2.598217e-07
I4847 n1_m1_268800_148800 0 1.732144e-07
I4848 n1_m1_268800_153600 0 2.575097e-07
I4849 n1_m1_268800_158400 0 2.025413e-07
I4850 n1_m1_268800_163200 0 2.029350e-07
I4851 n1_m1_268800_168000 0 2.820902e-07
I4852 n1_m1_268800_172800 0 1.838373e-07
I4853 n1_m1_268800_177600 0 2.709874e-07
I4854 n1_m1_268800_182400 0 1.782151e-07
I4855 n1_m1_268800_187200 0 1.718612e-07
I4856 n1_m1_268800_192000 0 2.571599e-07
I4857 n1_m1_268800_196800 0 1.716791e-07
I4858 n1_m1_268800_201600 0 2.589562e-07
I4859 n1_m1_268800_206400 0 1.755426e-07
I4860 n1_m1_268800_211200 0 1.785694e-07
I4861 n1_m1_268800_216000 0 2.758602e-07
I4862 n1_m1_268800_220800 0 1.756768e-07
I4863 n1_m1_268800_225600 0 2.726012e-07
I4864 n1_m1_268800_230400 0 2.009956e-07
I4865 n1_m1_268800_235200 0 1.965487e-07
I4866 n1_m1_268800_240000 0 4.268088e-07
I4867 n1_m1_268800_244800 0 2.441288e-07
I4868 n1_m1_268800_249600 0 2.670930e-07
I4869 n1_m1_268800_254400 0 1.750648e-07
I4870 n1_m1_268800_259200 0 1.720537e-07
I4871 n1_m1_268800_264000 0 2.510622e-07
I4872 n1_m1_268800_268800 0 1.699443e-07
I4873 n1_m1_268800_273600 0 2.578541e-07
I4874 n1_m1_268800_278400 0 1.734539e-07
I4875 n1_m1_268800_283200 0 1.766020e-07
I4876 n1_m1_268800_288000 0 2.670832e-07
I4877 n1_m1_268800_292800 0 1.816430e-07
I4878 n1_m1_268800_297600 0 2.665546e-07
I4879 n1_m1_268800_302400 0 1.806570e-07
I4880 n1_m1_268800_307200 0 1.728485e-07
I4881 n1_m1_268800_312000 0 2.610767e-07
I4882 n1_m1_268800_316800 0 1.749450e-07
I4883 n1_m1_268800_321600 0 2.624174e-07
I4884 n1_m1_268800_326400 0 1.735711e-07
I4885 n1_m1_268800_331200 0 1.753267e-07
I4886 n1_m1_268800_336000 0 2.705323e-07
I4887 n1_m1_268800_340800 0 1.762302e-07
I4888 n1_m1_268800_345600 0 2.623730e-07
I4889 n1_m1_268800_350400 0 1.816172e-07
I4890 n1_m1_268800_355200 0 1.839280e-07
I4891 n1_m1_268800_360000 0 2.650160e-07
I4892 n1_m1_268800_364800 0 1.741402e-07
I4893 n1_m1_268800_369600 0 2.602281e-07
I4894 n1_m1_268800_374400 0 1.750628e-07
I4895 n1_m1_268800_379200 0 1.811745e-07
I4896 n1_m1_268800_384000 0 3.184420e-07
I4897 n1_m1_268800_388800 0 3.457403e-07
I4898 n1_m1_268800_393600 0 5.321531e-07
I4899 n1_m1_268800_398400 0 1.691879e-07
I4900 n1_m1_268800_403200 0 1.718501e-07
I4901 n1_m1_268800_408000 0 1.613870e-07
I4902 n1_m1_273600_0 0 2.459512e-07
I4903 n1_m1_273600_4800 0 2.678000e-07
I4904 n1_m1_273600_9600 0 1.326248e-06
I4905 n1_m1_273600_14400 0 1.210997e-06
I4906 n1_m1_273600_19200 0 5.728431e-07
I4907 n1_m1_273600_24000 0 4.357128e-07
I4908 n1_m1_273600_28800 0 3.822258e-07
I4909 n1_m1_273600_33600 0 7.753022e-07
I4910 n1_m1_273600_38400 0 6.817213e-07
I4911 n1_m1_273600_43200 0 1.248050e-06
I4912 n1_m1_273600_48000 0 2.184255e-06
I4913 n1_m1_273600_52800 0 8.293475e-07
I4914 n1_m1_273600_57600 0 4.996506e-07
I4915 n1_m1_273600_62400 0 2.651270e-07
I4916 n1_m1_273600_67200 0 2.744538e-07
I4917 n1_m1_273600_72000 0 4.043900e-07
I4918 n1_m1_273600_76800 0 2.858807e-07
I4919 n1_m1_273600_81600 0 1.332160e-06
I4920 n1_m1_273600_86400 0 1.514813e-06
I4921 n1_m1_273600_91200 0 1.275394e-06
I4922 n1_m1_273600_96000 0 1.090777e-06
I4923 n1_m1_273600_100800 0 2.741500e-07
I4924 n1_m1_273600_105600 0 3.952724e-07
I4925 n1_m1_273600_110400 0 2.596023e-07
I4926 n1_m1_273600_115200 0 2.545645e-07
I4927 n1_m1_273600_120000 0 3.935608e-07
I4928 n1_m1_273600_124800 0 2.570372e-07
I4929 n1_m1_273600_129600 0 3.892294e-07
I4930 n1_m1_273600_134400 0 2.598217e-07
I4931 n1_m1_273600_139200 0 2.598217e-07
I4932 n1_m1_273600_144000 0 3.897325e-07
I4933 n1_m1_273600_148800 0 2.598217e-07
I4934 n1_m1_273600_153600 0 4.023825e-07
I4935 n1_m1_273600_158400 0 3.131456e-07
I4936 n1_m1_273600_163200 0 3.524564e-07
I4937 n1_m1_273600_168000 0 6.151342e-07
I4938 n1_m1_273600_172800 0 3.398928e-07
I4939 n1_m1_273600_177600 0 4.048033e-07
I4940 n1_m1_273600_182400 0 2.580122e-07
I4941 n1_m1_273600_187200 0 2.554396e-07
I4942 n1_m1_273600_192000 0 3.821986e-07
I4943 n1_m1_273600_196800 0 2.521261e-07
I4944 n1_m1_273600_201600 0 4.100445e-07
I4945 n1_m1_273600_206400 0 3.435808e-07
I4946 n1_m1_273600_211200 0 2.939334e-07
I4947 n1_m1_273600_216000 0 4.006303e-07
I4948 n1_m1_273600_220800 0 2.710588e-07
I4949 n1_m1_273600_225600 0 3.974500e-07
I4950 n1_m1_273600_230400 0 2.706576e-07
I4951 n1_m1_273600_235200 0 3.461216e-07
I4952 n1_m1_273600_240000 0 7.898858e-07
I4953 n1_m1_273600_244800 0 5.928030e-07
I4954 n1_m1_273600_249600 0 5.798102e-07
I4955 n1_m1_273600_254400 0 2.585980e-07
I4956 n1_m1_273600_259200 0 2.583610e-07
I4957 n1_m1_273600_264000 0 3.836120e-07
I4958 n1_m1_273600_268800 0 2.504961e-07
I4959 n1_m1_273600_273600 0 3.760955e-07
I4960 n1_m1_273600_278400 0 2.517366e-07
I4961 n1_m1_273600_283200 0 2.653760e-07
I4962 n1_m1_273600_288000 0 4.091092e-07
I4963 n1_m1_273600_292800 0 2.790754e-07
I4964 n1_m1_273600_297600 0 4.407245e-07
I4965 n1_m1_273600_302400 0 2.587960e-07
I4966 n1_m1_273600_307200 0 2.657865e-07
I4967 n1_m1_273600_312000 0 3.985577e-07
I4968 n1_m1_273600_316800 0 2.600218e-07
I4969 n1_m1_273600_321600 0 3.957535e-07
I4970 n1_m1_273600_326400 0 2.642576e-07
I4971 n1_m1_273600_331200 0 2.636509e-07
I4972 n1_m1_273600_336000 0 3.914779e-07
I4973 n1_m1_273600_340800 0 2.611333e-07
I4974 n1_m1_273600_345600 0 4.101074e-07
I4975 n1_m1_273600_350400 0 2.968824e-07
I4976 n1_m1_273600_355200 0 2.882942e-07
I4977 n1_m1_273600_360000 0 4.067880e-07
I4978 n1_m1_273600_364800 0 2.806949e-07
I4979 n1_m1_273600_369600 0 3.964794e-07
I4980 n1_m1_273600_374400 0 2.608088e-07
I4981 n1_m1_273600_379200 0 2.713566e-07
I4982 n1_m1_273600_384000 0 7.659743e-07
I4983 n1_m1_273600_388800 0 1.743432e-06
I4984 n1_m1_273600_393600 0 2.074023e-06
I4985 n1_m1_273600_398400 0 3.581438e-07
I4986 n1_m1_273600_403200 0 2.530424e-07
I4987 n1_m1_273600_408000 0 2.455747e-07
I4988 n1_m1_278400_0 0 1.543915e-07
I4989 n1_m1_278400_4800 0 1.877339e-07
I4990 n1_m1_278400_9600 0 1.182932e-06
I4991 n1_m1_278400_14400 0 9.670757e-07
I4992 n1_m1_278400_19200 0 3.766503e-07
I4993 n1_m1_278400_24000 0 4.434993e-07
I4994 n1_m1_278400_28800 0 9.129227e-07
I4995 n1_m1_278400_33600 0 1.801895e-06
I4996 n1_m1_278400_38400 0 7.861513e-07
I4997 n1_m1_278400_43200 0 5.483922e-07
I4998 n1_m1_278400_48000 0 6.140844e-07
I4999 n1_m1_278400_52800 0 2.575415e-07
I5000 n1_m1_278400_57600 0 2.856861e-07
I5001 n1_m1_278400_62400 0 1.746358e-07
I5002 n1_m1_278400_67200 0 1.787001e-07
I5003 n1_m1_278400_72000 0 2.674436e-07
I5004 n1_m1_278400_76800 0 1.848143e-07
I5005 n1_m1_278400_81600 0 5.197220e-07
I5006 n1_m1_278400_86400 0 4.506466e-07
I5007 n1_m1_278400_91200 0 3.474910e-07
I5008 n1_m1_278400_96000 0 4.407964e-07
I5009 n1_m1_278400_100800 0 1.994595e-07
I5010 n1_m1_278400_105600 0 3.222569e-07
I5011 n1_m1_278400_110400 0 1.906406e-07
I5012 n1_m1_278400_115200 0 1.746042e-07
I5013 n1_m1_278400_120000 0 2.703848e-07
I5014 n1_m1_278400_124800 0 1.736174e-07
I5015 n1_m1_278400_129600 0 2.596715e-07
I5016 n1_m1_278400_134400 0 1.734190e-07
I5017 n1_m1_278400_139200 0 1.752352e-07
I5018 n1_m1_278400_144000 0 2.635986e-07
I5019 n1_m1_278400_148800 0 1.714569e-07
I5020 n1_m1_278400_153600 0 2.605532e-07
I5021 n1_m1_278400_158400 0 2.553309e-07
I5022 n1_m1_278400_163200 0 3.436768e-07
I5023 n1_m1_278400_168000 0 4.450946e-07
I5024 n1_m1_278400_172800 0 2.038914e-07
I5025 n1_m1_278400_177600 0 2.652174e-07
I5026 n1_m1_278400_182400 0 1.696412e-07
I5027 n1_m1_278400_187200 0 1.716615e-07
I5028 n1_m1_278400_192000 0 2.587014e-07
I5029 n1_m1_278400_196800 0 1.797725e-07
I5030 n1_m1_278400_201600 0 3.183164e-07
I5031 n1_m1_278400_206400 0 2.009305e-07
I5032 n1_m1_278400_211200 0 1.861393e-07
I5033 n1_m1_278400_216000 0 2.670378e-07
I5034 n1_m1_278400_220800 0 2.387176e-07
I5035 n1_m1_278400_225600 0 3.136481e-07
I5036 n1_m1_278400_230400 0 2.112185e-07
I5037 n1_m1_278400_235200 0 4.682916e-07
I5038 n1_m1_278400_240000 0 6.874232e-07
I5039 n1_m1_278400_244800 0 2.315927e-07
I5040 n1_m1_278400_249600 0 3.050811e-07
I5041 n1_m1_278400_254400 0 1.748577e-07
I5042 n1_m1_278400_259200 0 1.771142e-07
I5043 n1_m1_278400_264000 0 2.649272e-07
I5044 n1_m1_278400_268800 0 1.723707e-07
I5045 n1_m1_278400_273600 0 2.703413e-07
I5046 n1_m1_278400_278400 0 1.783747e-07
I5047 n1_m1_278400_283200 0 1.832789e-07
I5048 n1_m1_278400_288000 0 3.046792e-07
I5049 n1_m1_278400_292800 0 4.165708e-07
I5050 n1_m1_278400_297600 0 8.258368e-07
I5051 n1_m1_278400_302400 0 2.528915e-07
I5052 n1_m1_278400_307200 0 1.965977e-07
I5053 n1_m1_278400_312000 0 2.581719e-07
I5054 n1_m1_278400_316800 0 1.735491e-07
I5055 n1_m1_278400_321600 0 2.683819e-07
I5056 n1_m1_278400_326400 0 1.767576e-07
I5057 n1_m1_278400_331200 0 1.843260e-07
I5058 n1_m1_278400_336000 0 2.981664e-07
I5059 n1_m1_278400_340800 0 1.857906e-07
I5060 n1_m1_278400_345600 0 2.716303e-07
I5061 n1_m1_278400_350400 0 2.028589e-07
I5062 n1_m1_278400_355200 0 2.703898e-07
I5063 n1_m1_278400_360000 0 3.104260e-07
I5064 n1_m1_278400_364800 0 1.821475e-07
I5065 n1_m1_278400_369600 0 2.661757e-07
I5066 n1_m1_278400_374400 0 2.046353e-07
I5067 n1_m1_278400_379200 0 2.046748e-07
I5068 n1_m1_278400_384000 0 4.871601e-07
I5069 n1_m1_278400_388800 0 1.187516e-06
I5070 n1_m1_278400_393600 0 1.135053e-06
I5071 n1_m1_278400_398400 0 2.227916e-07
I5072 n1_m1_278400_403200 0 1.892540e-07
I5073 n1_m1_278400_408000 0 1.581525e-07
I5074 n1_m1_283200_0 0 7.731315e-08
I5075 n1_m1_283200_4800 0 8.428064e-08
I5076 n1_m1_283200_9600 0 2.244845e-07
I5077 n1_m1_283200_14400 0 1.994113e-07
I5078 n1_m1_283200_19200 0 1.203894e-07
I5079 n1_m1_283200_24000 0 1.634403e-07
I5080 n1_m1_283200_28800 0 4.314668e-07
I5081 n1_m1_283200_33600 0 1.028935e-06
I5082 n1_m1_283200_38400 0 3.521520e-07
I5083 n1_m1_283200_43200 0 1.328145e-07
I5084 n1_m1_283200_48000 0 1.644703e-07
I5085 n1_m1_283200_52800 0 8.962036e-08
I5086 n1_m1_283200_57600 0 1.379124e-07
I5087 n1_m1_283200_62400 0 8.955333e-08
I5088 n1_m1_283200_67200 0 8.707594e-08
I5089 n1_m1_283200_72000 0 1.347968e-07
I5090 n1_m1_283200_76800 0 8.559801e-08
I5091 n1_m1_283200_81600 0 1.498898e-07
I5092 n1_m1_283200_86400 0 1.023571e-07
I5093 n1_m1_283200_91200 0 8.946275e-08
I5094 n1_m1_283200_96000 0 1.402301e-07
I5095 n1_m1_283200_100800 0 1.325093e-07
I5096 n1_m1_283200_105600 0 3.110756e-07
I5097 n1_m1_283200_110400 0 1.404274e-07
I5098 n1_m1_283200_115200 0 9.501649e-08
I5099 n1_m1_283200_120000 0 1.512009e-07
I5100 n1_m1_283200_124800 0 8.874793e-08
I5101 n1_m1_283200_129600 0 1.299108e-07
I5102 n1_m1_283200_134400 0 8.737487e-08
I5103 n1_m1_283200_139200 0 9.419033e-08
I5104 n1_m1_283200_144000 0 1.440846e-07
I5105 n1_m1_283200_148800 0 8.551041e-08
I5106 n1_m1_283200_153600 0 1.298020e-07
I5107 n1_m1_283200_158400 0 1.064211e-07
I5108 n1_m1_283200_163200 0 1.607757e-07
I5109 n1_m1_283200_168000 0 3.594625e-07
I5110 n1_m1_283200_172800 0 1.039974e-07
I5111 n1_m1_283200_177600 0 1.339381e-07
I5112 n1_m1_283200_182400 0 8.873873e-08
I5113 n1_m1_283200_187200 0 8.674704e-08
I5114 n1_m1_283200_192000 0 1.300045e-07
I5115 n1_m1_283200_196800 0 8.741468e-08
I5116 n1_m1_283200_201600 0 1.392455e-07
I5117 n1_m1_283200_206400 0 9.299009e-08
I5118 n1_m1_283200_211200 0 9.098633e-08
I5119 n1_m1_283200_216000 0 1.379787e-07
I5120 n1_m1_283200_220800 0 1.093150e-07
I5121 n1_m1_283200_225600 0 1.454547e-07
I5122 n1_m1_283200_230400 0 9.124385e-08
I5123 n1_m1_283200_235200 0 1.232116e-07
I5124 n1_m1_283200_240000 0 2.167934e-07
I5125 n1_m1_283200_244800 0 1.134754e-07
I5126 n1_m1_283200_249600 0 1.371776e-07
I5127 n1_m1_283200_254400 0 8.809012e-08
I5128 n1_m1_283200_259200 0 9.167691e-08
I5129 n1_m1_283200_264000 0 1.358066e-07
I5130 n1_m1_283200_268800 0 8.665920e-08
I5131 n1_m1_283200_273600 0 1.312634e-07
I5132 n1_m1_283200_278400 0 8.979473e-08
I5133 n1_m1_283200_283200 0 9.077565e-08
I5134 n1_m1_283200_288000 0 2.046825e-07
I5135 n1_m1_283200_292800 0 3.552170e-07
I5136 n1_m1_283200_297600 0 8.331477e-07
I5137 n1_m1_283200_302400 0 3.007381e-07
I5138 n1_m1_283200_307200 0 1.136647e-07
I5139 n1_m1_283200_312000 0 1.317057e-07
I5140 n1_m1_283200_316800 0 8.688547e-08
I5141 n1_m1_283200_321600 0 1.434975e-07
I5142 n1_m1_283200_326400 0 9.493377e-08
I5143 n1_m1_283200_331200 0 1.052354e-07
I5144 n1_m1_283200_336000 0 1.813248e-07
I5145 n1_m1_283200_340800 0 1.034742e-07
I5146 n1_m1_283200_345600 0 1.328454e-07
I5147 n1_m1_283200_350400 0 8.893594e-08
I5148 n1_m1_283200_355200 0 1.155742e-07
I5149 n1_m1_283200_360000 0 1.735940e-07
I5150 n1_m1_283200_364800 0 8.533320e-08
I5151 n1_m1_283200_369600 0 1.391286e-07
I5152 n1_m1_283200_374400 0 1.314855e-07
I5153 n1_m1_283200_379200 0 1.000127e-07
I5154 n1_m1_283200_384000 0 1.575953e-07
I5155 n1_m1_283200_388800 0 1.931127e-07
I5156 n1_m1_283200_393600 0 2.613048e-07
I5157 n1_m1_283200_398400 0 1.044297e-07
I5158 n1_m1_283200_403200 0 8.632994e-08
I5159 n1_m1_283200_408000 0 7.635410e-08
I5160 n1_m1_288000_0 0 1.558634e-07
I5161 n1_m1_288000_4800 0 1.617900e-07
I5162 n1_m1_288000_9600 0 2.573766e-07
I5163 n1_m1_288000_14400 0 1.750506e-07
I5164 n1_m1_288000_19200 0 1.745353e-07
I5165 n1_m1_288000_24000 0 2.635518e-07
I5166 n1_m1_288000_28800 0 2.098254e-07
I5167 n1_m1_288000_33600 0 4.293374e-07
I5168 n1_m1_288000_38400 0 2.066612e-07
I5169 n1_m1_288000_43200 0 1.722551e-07
I5170 n1_m1_288000_48000 0 2.741168e-07
I5171 n1_m1_288000_52800 0 1.904120e-07
I5172 n1_m1_288000_57600 0 2.743973e-07
I5173 n1_m1_288000_62400 0 1.748079e-07
I5174 n1_m1_288000_67200 0 1.781910e-07
I5175 n1_m1_288000_72000 0 2.932798e-07
I5176 n1_m1_288000_76800 0 2.168654e-07
I5177 n1_m1_288000_81600 0 2.885235e-07
I5178 n1_m1_288000_86400 0 1.777829e-07
I5179 n1_m1_288000_91200 0 1.844621e-07
I5180 n1_m1_288000_96000 0 2.787468e-07
I5181 n1_m1_288000_100800 0 2.399366e-07
I5182 n1_m1_288000_105600 0 7.249034e-07
I5183 n1_m1_288000_110400 0 4.955370e-07
I5184 n1_m1_288000_115200 0 2.742525e-07
I5185 n1_m1_288000_120000 0 3.021514e-07
I5186 n1_m1_288000_124800 0 1.768386e-07
I5187 n1_m1_288000_129600 0 2.765486e-07
I5188 n1_m1_288000_134400 0 1.872659e-07
I5189 n1_m1_288000_139200 0 1.941784e-07
I5190 n1_m1_288000_144000 0 2.986972e-07
I5191 n1_m1_288000_148800 0 1.842513e-07
I5192 n1_m1_288000_153600 0 2.589169e-07
I5193 n1_m1_288000_158400 0 1.739416e-07
I5194 n1_m1_288000_163200 0 2.244790e-07
I5195 n1_m1_288000_168000 0 6.941769e-07
I5196 n1_m1_288000_172800 0 2.358458e-07
I5197 n1_m1_288000_177600 0 2.611091e-07
I5198 n1_m1_288000_182400 0 1.713576e-07
I5199 n1_m1_288000_187200 0 1.731450e-07
I5200 n1_m1_288000_192000 0 2.598217e-07
I5201 n1_m1_288000_196800 0 1.735800e-07
I5202 n1_m1_288000_201600 0 2.757858e-07
I5203 n1_m1_288000_206400 0 2.141922e-07
I5204 n1_m1_288000_211200 0 2.152588e-07
I5205 n1_m1_288000_216000 0 2.788203e-07
I5206 n1_m1_288000_220800 0 1.732219e-07
I5207 n1_m1_288000_225600 0 2.525447e-07
I5208 n1_m1_288000_230400 0 1.720253e-07
I5209 n1_m1_288000_235200 0 1.701080e-07
I5210 n1_m1_288000_240000 0 3.742305e-07
I5211 n1_m1_288000_244800 0 4.534006e-07
I5212 n1_m1_288000_249600 0 4.854778e-07
I5213 n1_m1_288000_254400 0 1.830099e-07
I5214 n1_m1_288000_259200 0 1.784507e-07
I5215 n1_m1_288000_264000 0 2.558181e-07
I5216 n1_m1_288000_268800 0 1.734547e-07
I5217 n1_m1_288000_273600 0 2.630236e-07
I5218 n1_m1_288000_278400 0 1.770728e-07
I5219 n1_m1_288000_283200 0 2.306160e-07
I5220 n1_m1_288000_288000 0 8.514332e-07
I5221 n1_m1_288000_292800 0 8.206396e-07
I5222 n1_m1_288000_297600 0 1.296363e-06
I5223 n1_m1_288000_302400 0 6.130322e-07
I5224 n1_m1_288000_307200 0 5.018865e-07
I5225 n1_m1_288000_312000 0 4.437632e-07
I5226 n1_m1_288000_316800 0 2.312509e-07
I5227 n1_m1_288000_321600 0 2.805923e-07
I5228 n1_m1_288000_326400 0 1.853726e-07
I5229 n1_m1_288000_331200 0 1.796124e-07
I5230 n1_m1_288000_336000 0 3.126577e-07
I5231 n1_m1_288000_340800 0 1.940868e-07
I5232 n1_m1_288000_345600 0 3.234166e-07
I5233 n1_m1_288000_350400 0 4.938414e-07
I5234 n1_m1_288000_355200 0 7.731343e-07
I5235 n1_m1_288000_360000 0 1.190391e-06
I5236 n1_m1_288000_364800 0 5.530758e-07
I5237 n1_m1_288000_369600 0 5.612173e-07
I5238 n1_m1_288000_374400 0 2.271576e-07
I5239 n1_m1_288000_379200 0 2.135440e-07
I5240 n1_m1_288000_384000 0 2.778679e-07
I5241 n1_m1_288000_388800 0 1.737688e-07
I5242 n1_m1_288000_393600 0 2.623732e-07
I5243 n1_m1_288000_398400 0 1.729991e-07
I5244 n1_m1_288000_403200 0 1.669586e-07
I5245 n1_m1_288000_408000 0 1.598903e-07
I5246 n1_m1_292800_0 0 1.558680e-07
I5247 n1_m1_292800_4800 0 1.590418e-07
I5248 n1_m1_292800_9600 0 2.538934e-07
I5249 n1_m1_292800_14400 0 1.742000e-07
I5250 n1_m1_292800_19200 0 1.769317e-07
I5251 n1_m1_292800_24000 0 2.622081e-07
I5252 n1_m1_292800_28800 0 1.932264e-07
I5253 n1_m1_292800_33600 0 2.806143e-07
I5254 n1_m1_292800_38400 0 2.299655e-07
I5255 n1_m1_292800_43200 0 1.726100e-07
I5256 n1_m1_292800_48000 0 2.805087e-07
I5257 n1_m1_292800_52800 0 1.814506e-07
I5258 n1_m1_292800_57600 0 2.669309e-07
I5259 n1_m1_292800_62400 0 2.026399e-07
I5260 n1_m1_292800_67200 0 2.409092e-07
I5261 n1_m1_292800_72000 0 5.497523e-07
I5262 n1_m1_292800_76800 0 5.840622e-07
I5263 n1_m1_292800_81600 0 5.981482e-07
I5264 n1_m1_292800_86400 0 2.132433e-07
I5265 n1_m1_292800_91200 0 1.852941e-07
I5266 n1_m1_292800_96000 0 2.838158e-07
I5267 n1_m1_292800_100800 0 1.862385e-07
I5268 n1_m1_292800_105600 0 2.781885e-07
I5269 n1_m1_292800_110400 0 1.790103e-07
I5270 n1_m1_292800_115200 0 2.142030e-07
I5271 n1_m1_292800_120000 0 3.697532e-07
I5272 n1_m1_292800_124800 0 1.722767e-07
I5273 n1_m1_292800_129600 0 2.595498e-07
I5274 n1_m1_292800_134400 0 1.733932e-07
I5275 n1_m1_292800_139200 0 1.734164e-07
I5276 n1_m1_292800_144000 0 2.602063e-07
I5277 n1_m1_292800_148800 0 1.740192e-07
I5278 n1_m1_292800_153600 0 2.791661e-07
I5279 n1_m1_292800_158400 0 1.770156e-07
I5280 n1_m1_292800_163200 0 1.719083e-07
I5281 n1_m1_292800_168000 0 2.668557e-07
I5282 n1_m1_292800_172800 0 1.672717e-07
I5283 n1_m1_292800_177600 0 2.569086e-07
I5284 n1_m1_292800_182400 0 1.674669e-07
I5285 n1_m1_292800_187200 0 1.728217e-07
I5286 n1_m1_292800_192000 0 2.601979e-07
I5287 n1_m1_292800_196800 0 1.766467e-07
I5288 n1_m1_292800_201600 0 2.722010e-07
I5289 n1_m1_292800_206400 0 1.984483e-07
I5290 n1_m1_292800_211200 0 2.098966e-07
I5291 n1_m1_292800_216000 0 2.741716e-07
I5292 n1_m1_292800_220800 0 1.679121e-07
I5293 n1_m1_292800_225600 0 2.525708e-07
I5294 n1_m1_292800_230400 0 1.830886e-07
I5295 n1_m1_292800_235200 0 1.750619e-07
I5296 n1_m1_292800_240000 0 2.637083e-07
I5297 n1_m1_292800_244800 0 2.056094e-07
I5298 n1_m1_292800_249600 0 3.480641e-07
I5299 n1_m1_292800_254400 0 2.059227e-07
I5300 n1_m1_292800_259200 0 1.754375e-07
I5301 n1_m1_292800_264000 0 2.562724e-07
I5302 n1_m1_292800_268800 0 1.732191e-07
I5303 n1_m1_292800_273600 0 2.598841e-07
I5304 n1_m1_292800_278400 0 1.736761e-07
I5305 n1_m1_292800_283200 0 1.952804e-07
I5306 n1_m1_292800_288000 0 4.586973e-07
I5307 n1_m1_292800_292800 0 2.700635e-07
I5308 n1_m1_292800_297600 0 4.385570e-07
I5309 n1_m1_292800_302400 0 4.765297e-07
I5310 n1_m1_292800_307200 0 8.775758e-07
I5311 n1_m1_292800_312000 0 1.036346e-06
I5312 n1_m1_292800_316800 0 2.487840e-07
I5313 n1_m1_292800_321600 0 2.972140e-07
I5314 n1_m1_292800_326400 0 2.631473e-07
I5315 n1_m1_292800_331200 0 2.027658e-07
I5316 n1_m1_292800_336000 0 2.619041e-07
I5317 n1_m1_292800_340800 0 1.774300e-07
I5318 n1_m1_292800_345600 0 4.912399e-07
I5319 n1_m1_292800_350400 0 8.793109e-07
I5320 n1_m1_292800_355200 0 1.144057e-06
I5321 n1_m1_292800_360000 0 1.618227e-06
I5322 n1_m1_292800_364800 0 1.203207e-06
I5323 n1_m1_292800_369600 0 1.401148e-06
I5324 n1_m1_292800_374400 0 3.708783e-07
I5325 n1_m1_292800_379200 0 2.539237e-07
I5326 n1_m1_292800_384000 0 3.592888e-07
I5327 n1_m1_292800_388800 0 1.768142e-07
I5328 n1_m1_292800_393600 0 2.603678e-07
I5329 n1_m1_292800_398400 0 1.687391e-07
I5330 n1_m1_292800_403200 0 1.604752e-07
I5331 n1_m1_292800_408000 0 1.547760e-07
I5332 n1_m1_297600_0 0 2.398191e-07
I5333 n1_m1_297600_4800 0 2.478628e-07
I5334 n1_m1_297600_9600 0 3.779715e-07
I5335 n1_m1_297600_14400 0 2.655612e-07
I5336 n1_m1_297600_19200 0 2.628544e-07
I5337 n1_m1_297600_24000 0 4.009215e-07
I5338 n1_m1_297600_28800 0 2.719583e-07
I5339 n1_m1_297600_33600 0 4.008060e-07
I5340 n1_m1_297600_38400 0 3.604011e-07
I5341 n1_m1_297600_43200 0 2.697319e-07
I5342 n1_m1_297600_48000 0 4.194497e-07
I5343 n1_m1_297600_52800 0 2.786663e-07
I5344 n1_m1_297600_57600 0 4.771512e-07
I5345 n1_m1_297600_62400 0 7.475333e-07
I5346 n1_m1_297600_67200 0 1.203064e-06
I5347 n1_m1_297600_72000 0 2.311739e-06
I5348 n1_m1_297600_76800 0 1.474435e-06
I5349 n1_m1_297600_81600 0 1.385793e-06
I5350 n1_m1_297600_86400 0 4.034048e-07
I5351 n1_m1_297600_91200 0 2.791230e-07
I5352 n1_m1_297600_96000 0 4.052156e-07
I5353 n1_m1_297600_100800 0 2.629800e-07
I5354 n1_m1_297600_105600 0 4.000519e-07
I5355 n1_m1_297600_110400 0 2.773334e-07
I5356 n1_m1_297600_115200 0 2.576801e-07
I5357 n1_m1_297600_120000 0 3.848782e-07
I5358 n1_m1_297600_124800 0 2.671420e-07
I5359 n1_m1_297600_129600 0 3.909396e-07
I5360 n1_m1_297600_134400 0 2.598217e-07
I5361 n1_m1_297600_139200 0 2.598217e-07
I5362 n1_m1_297600_144000 0 3.841902e-07
I5363 n1_m1_297600_148800 0 2.597918e-07
I5364 n1_m1_297600_153600 0 4.181936e-07
I5365 n1_m1_297600_158400 0 2.914617e-07
I5366 n1_m1_297600_163200 0 3.113585e-07
I5367 n1_m1_297600_168000 0 4.110538e-07
I5368 n1_m1_297600_172800 0 2.597877e-07
I5369 n1_m1_297600_177600 0 3.895095e-07
I5370 n1_m1_297600_182400 0 2.560476e-07
I5371 n1_m1_297600_187200 0 2.628497e-07
I5372 n1_m1_297600_192000 0 4.030056e-07
I5373 n1_m1_297600_196800 0 2.708895e-07
I5374 n1_m1_297600_201600 0 4.029998e-07
I5375 n1_m1_297600_206400 0 2.642802e-07
I5376 n1_m1_297600_211200 0 2.649541e-07
I5377 n1_m1_297600_216000 0 3.882389e-07
I5378 n1_m1_297600_220800 0 2.519000e-07
I5379 n1_m1_297600_225600 0 3.886537e-07
I5380 n1_m1_297600_230400 0 2.895684e-07
I5381 n1_m1_297600_235200 0 3.320108e-07
I5382 n1_m1_297600_240000 0 5.539990e-07
I5383 n1_m1_297600_244800 0 3.128688e-07
I5384 n1_m1_297600_249600 0 6.572478e-07
I5385 n1_m1_297600_254400 0 5.625704e-07
I5386 n1_m1_297600_259200 0 3.997971e-07
I5387 n1_m1_297600_264000 0 4.121579e-07
I5388 n1_m1_297600_268800 0 2.609002e-07
I5389 n1_m1_297600_273600 0 3.909888e-07
I5390 n1_m1_297600_278400 0 2.666545e-07
I5391 n1_m1_297600_283200 0 2.755879e-07
I5392 n1_m1_297600_288000 0 4.383925e-07
I5393 n1_m1_297600_292800 0 2.772807e-07
I5394 n1_m1_297600_297600 0 7.228191e-07
I5395 n1_m1_297600_302400 0 1.133804e-06
I5396 n1_m1_297600_307200 0 1.457839e-06
I5397 n1_m1_297600_312000 0 2.154338e-06
I5398 n1_m1_297600_316800 0 5.648503e-07
I5399 n1_m1_297600_321600 0 4.639681e-07
I5400 n1_m1_297600_326400 0 6.442782e-07
I5401 n1_m1_297600_331200 0 9.845368e-07
I5402 n1_m1_297600_336000 0 8.693284e-07
I5403 n1_m1_297600_340800 0 2.998756e-07
I5404 n1_m1_297600_345600 0 4.748941e-07
I5405 n1_m1_297600_350400 0 4.625171e-07
I5406 n1_m1_297600_355200 0 6.052605e-07
I5407 n1_m1_297600_360000 0 8.448980e-07
I5408 n1_m1_297600_364800 0 7.625329e-07
I5409 n1_m1_297600_369600 0 1.947746e-06
I5410 n1_m1_297600_374400 0 1.395390e-06
I5411 n1_m1_297600_379200 0 8.533873e-07
I5412 n1_m1_297600_384000 0 5.206061e-07
I5413 n1_m1_297600_388800 0 2.751993e-07
I5414 n1_m1_297600_393600 0 3.920443e-07
I5415 n1_m1_297600_398400 0 2.470259e-07
I5416 n1_m1_297600_403200 0 2.378900e-07
I5417 n1_m1_297600_408000 0 2.330716e-07
I5418 n1_m1_302400_0 0 1.477988e-07
I5419 n1_m1_302400_4800 0 1.554868e-07
I5420 n1_m1_302400_9600 0 2.517659e-07
I5421 n1_m1_302400_14400 0 1.771630e-07
I5422 n1_m1_302400_19200 0 1.744472e-07
I5423 n1_m1_302400_24000 0 2.731852e-07
I5424 n1_m1_302400_28800 0 1.838742e-07
I5425 n1_m1_302400_33600 0 2.856510e-07
I5426 n1_m1_302400_38400 0 1.847535e-07
I5427 n1_m1_302400_43200 0 1.819207e-07
I5428 n1_m1_302400_48000 0 2.820863e-07
I5429 n1_m1_302400_52800 0 1.783166e-07
I5430 n1_m1_302400_57600 0 3.902995e-07
I5431 n1_m1_302400_62400 0 9.009409e-07
I5432 n1_m1_302400_67200 0 1.219615e-06
I5433 n1_m1_302400_72000 0 1.282866e-06
I5434 n1_m1_302400_76800 0 4.473057e-07
I5435 n1_m1_302400_81600 0 3.723879e-07
I5436 n1_m1_302400_86400 0 1.814627e-07
I5437 n1_m1_302400_91200 0 1.759838e-07
I5438 n1_m1_302400_96000 0 2.642867e-07
I5439 n1_m1_302400_100800 0 1.709233e-07
I5440 n1_m1_302400_105600 0 2.535117e-07
I5441 n1_m1_302400_110400 0 1.738189e-07
I5442 n1_m1_302400_115200 0 1.740252e-07
I5443 n1_m1_302400_120000 0 2.598217e-07
I5444 n1_m1_302400_124800 0 1.750809e-07
I5445 n1_m1_302400_129600 0 2.601592e-07
I5446 n1_m1_302400_134400 0 1.754482e-07
I5447 n1_m1_302400_139200 0 1.752232e-07
I5448 n1_m1_302400_144000 0 2.560465e-07
I5449 n1_m1_302400_148800 0 1.705661e-07
I5450 n1_m1_302400_153600 0 2.625641e-07
I5451 n1_m1_302400_158400 0 1.954439e-07
I5452 n1_m1_302400_163200 0 2.145722e-07
I5453 n1_m1_302400_168000 0 2.690748e-07
I5454 n1_m1_302400_172800 0 1.761426e-07
I5455 n1_m1_302400_177600 0 2.527022e-07
I5456 n1_m1_302400_182400 0 1.736879e-07
I5457 n1_m1_302400_187200 0 1.837116e-07
I5458 n1_m1_302400_192000 0 2.833654e-07
I5459 n1_m1_302400_196800 0 1.844425e-07
I5460 n1_m1_302400_201600 0 2.659420e-07
I5461 n1_m1_302400_206400 0 1.732144e-07
I5462 n1_m1_302400_211200 0 1.686485e-07
I5463 n1_m1_302400_216000 0 2.565206e-07
I5464 n1_m1_302400_220800 0 1.732144e-07
I5465 n1_m1_302400_225600 0 2.579751e-07
I5466 n1_m1_302400_230400 0 1.723626e-07
I5467 n1_m1_302400_235200 0 2.184682e-07
I5468 n1_m1_302400_240000 0 3.729566e-07
I5469 n1_m1_302400_244800 0 1.754249e-07
I5470 n1_m1_302400_249600 0 5.164303e-07
I5471 n1_m1_302400_254400 0 7.466612e-07
I5472 n1_m1_302400_259200 0 6.352681e-07
I5473 n1_m1_302400_264000 0 3.353701e-07
I5474 n1_m1_302400_268800 0 1.799477e-07
I5475 n1_m1_302400_273600 0 2.711260e-07
I5476 n1_m1_302400_278400 0 1.845503e-07
I5477 n1_m1_302400_283200 0 1.844030e-07
I5478 n1_m1_302400_288000 0 2.815760e-07
I5479 n1_m1_302400_292800 0 1.809669e-07
I5480 n1_m1_302400_297600 0 3.139190e-07
I5481 n1_m1_302400_302400 0 3.600441e-07
I5482 n1_m1_302400_307200 0 2.378439e-07
I5483 n1_m1_302400_312000 0 4.936074e-07
I5484 n1_m1_302400_316800 0 2.464793e-07
I5485 n1_m1_302400_321600 0 4.129280e-07
I5486 n1_m1_302400_326400 0 5.762843e-07
I5487 n1_m1_302400_331200 0 1.240190e-06
I5488 n1_m1_302400_336000 0 1.717656e-06
I5489 n1_m1_302400_340800 0 3.371520e-07
I5490 n1_m1_302400_345600 0 2.905325e-07
I5491 n1_m1_302400_350400 0 1.705984e-07
I5492 n1_m1_302400_355200 0 1.743072e-07
I5493 n1_m1_302400_360000 0 2.785320e-07
I5494 n1_m1_302400_364800 0 1.831557e-07
I5495 n1_m1_302400_369600 0 4.698508e-07
I5496 n1_m1_302400_374400 0 3.784762e-07
I5497 n1_m1_302400_379200 0 3.274098e-07
I5498 n1_m1_302400_384000 0 3.182412e-07
I5499 n1_m1_302400_388800 0 1.715695e-07
I5500 n1_m1_302400_393600 0 2.598217e-07
I5501 n1_m1_302400_398400 0 1.681773e-07
I5502 n1_m1_302400_403200 0 1.598903e-07
I5503 n1_m1_302400_408000 0 1.598903e-07
I5504 n1_m1_307200_0 0 1.435597e-07
I5505 n1_m1_307200_4800 0 1.499071e-07
I5506 n1_m1_307200_9600 0 2.438346e-07
I5507 n1_m1_307200_14400 0 1.753786e-07
I5508 n1_m1_307200_19200 0 1.743338e-07
I5509 n1_m1_307200_24000 0 2.552469e-07
I5510 n1_m1_307200_28800 0 1.733150e-07
I5511 n1_m1_307200_33600 0 2.725656e-07
I5512 n1_m1_307200_38400 0 1.875600e-07
I5513 n1_m1_307200_43200 0 2.113889e-07
I5514 n1_m1_307200_48000 0 3.180388e-07
I5515 n1_m1_307200_52800 0 1.763270e-07
I5516 n1_m1_307200_57600 0 3.648693e-07
I5517 n1_m1_307200_62400 0 6.993891e-07
I5518 n1_m1_307200_67200 0 8.145581e-07
I5519 n1_m1_307200_72000 0 4.432751e-07
I5520 n1_m1_307200_76800 0 1.730272e-07
I5521 n1_m1_307200_81600 0 2.657591e-07
I5522 n1_m1_307200_86400 0 1.746707e-07
I5523 n1_m1_307200_91200 0 1.742348e-07
I5524 n1_m1_307200_96000 0 2.587209e-07
I5525 n1_m1_307200_100800 0 1.724265e-07
I5526 n1_m1_307200_105600 0 2.642709e-07
I5527 n1_m1_307200_110400 0 1.778403e-07
I5528 n1_m1_307200_115200 0 1.708340e-07
I5529 n1_m1_307200_120000 0 2.584038e-07
I5530 n1_m1_307200_124800 0 1.815173e-07
I5531 n1_m1_307200_129600 0 2.800479e-07
I5532 n1_m1_307200_134400 0 2.394072e-07
I5533 n1_m1_307200_139200 0 1.882846e-07
I5534 n1_m1_307200_144000 0 2.606799e-07
I5535 n1_m1_307200_148800 0 1.761462e-07
I5536 n1_m1_307200_153600 0 2.720481e-07
I5537 n1_m1_307200_158400 0 1.709233e-07
I5538 n1_m1_307200_163200 0 1.739970e-07
I5539 n1_m1_307200_168000 0 2.707741e-07
I5540 n1_m1_307200_172800 0 1.755290e-07
I5541 n1_m1_307200_177600 0 3.155845e-07
I5542 n1_m1_307200_182400 0 2.230014e-07
I5543 n1_m1_307200_187200 0 1.771257e-07
I5544 n1_m1_307200_192000 0 2.754875e-07
I5545 n1_m1_307200_196800 0 1.871930e-07
I5546 n1_m1_307200_201600 0 2.774743e-07
I5547 n1_m1_307200_206400 0 2.016578e-07
I5548 n1_m1_307200_211200 0 1.713990e-07
I5549 n1_m1_307200_216000 0 2.543971e-07
I5550 n1_m1_307200_220800 0 1.752454e-07
I5551 n1_m1_307200_225600 0 2.915567e-07
I5552 n1_m1_307200_230400 0 1.689325e-07
I5553 n1_m1_307200_235200 0 1.729213e-07
I5554 n1_m1_307200_240000 0 2.573203e-07
I5555 n1_m1_307200_244800 0 1.751032e-07
I5556 n1_m1_307200_249600 0 4.699300e-07
I5557 n1_m1_307200_254400 0 7.876523e-07
I5558 n1_m1_307200_259200 0 8.312534e-07
I5559 n1_m1_307200_264000 0 3.673010e-07
I5560 n1_m1_307200_268800 0 1.899699e-07
I5561 n1_m1_307200_273600 0 3.607085e-07
I5562 n1_m1_307200_278400 0 2.167584e-07
I5563 n1_m1_307200_283200 0 2.403661e-07
I5564 n1_m1_307200_288000 0 2.762578e-07
I5565 n1_m1_307200_292800 0 1.754748e-07
I5566 n1_m1_307200_297600 0 2.638127e-07
I5567 n1_m1_307200_302400 0 1.843380e-07
I5568 n1_m1_307200_307200 0 1.696314e-07
I5569 n1_m1_307200_312000 0 2.777688e-07
I5570 n1_m1_307200_316800 0 1.889835e-07
I5571 n1_m1_307200_321600 0 2.902524e-07
I5572 n1_m1_307200_326400 0 3.843487e-07
I5573 n1_m1_307200_331200 0 9.132053e-07
I5574 n1_m1_307200_336000 0 1.275232e-06
I5575 n1_m1_307200_340800 0 2.437218e-07
I5576 n1_m1_307200_345600 0 2.861696e-07
I5577 n1_m1_307200_350400 0 1.740312e-07
I5578 n1_m1_307200_355200 0 1.825071e-07
I5579 n1_m1_307200_360000 0 2.719679e-07
I5580 n1_m1_307200_364800 0 1.803455e-07
I5581 n1_m1_307200_369600 0 2.773090e-07
I5582 n1_m1_307200_374400 0 1.850545e-07
I5583 n1_m1_307200_379200 0 1.795649e-07
I5584 n1_m1_307200_384000 0 2.720493e-07
I5585 n1_m1_307200_388800 0 1.703966e-07
I5586 n1_m1_307200_393600 0 2.523004e-07
I5587 n1_m1_307200_398400 0 1.610877e-07
I5588 n1_m1_307200_403200 0 1.555193e-07
I5589 n1_m1_307200_408000 0 1.555193e-07
I5590 n1_m1_312000_0 0 2.216121e-07
I5591 n1_m1_312000_4800 0 2.303076e-07
I5592 n1_m1_312000_9600 0 3.580660e-07
I5593 n1_m1_312000_14400 0 2.474968e-07
I5594 n1_m1_312000_19200 0 2.553888e-07
I5595 n1_m1_312000_24000 0 3.885621e-07
I5596 n1_m1_312000_28800 0 2.693875e-07
I5597 n1_m1_312000_33600 0 5.642296e-07
I5598 n1_m1_312000_38400 0 7.186532e-07
I5599 n1_m1_312000_43200 0 8.574292e-07
I5600 n1_m1_312000_48000 0 6.688168e-07
I5601 n1_m1_312000_52800 0 2.658761e-07
I5602 n1_m1_312000_57600 0 4.118470e-07
I5603 n1_m1_312000_62400 0 3.850020e-07
I5604 n1_m1_312000_67200 0 3.826330e-07
I5605 n1_m1_312000_72000 0 4.082858e-07
I5606 n1_m1_312000_76800 0 2.621264e-07
I5607 n1_m1_312000_81600 0 3.945042e-07
I5608 n1_m1_312000_86400 0 2.644328e-07
I5609 n1_m1_312000_91200 0 2.587482e-07
I5610 n1_m1_312000_96000 0 3.931497e-07
I5611 n1_m1_312000_100800 0 2.725905e-07
I5612 n1_m1_312000_105600 0 3.997485e-07
I5613 n1_m1_312000_110400 0 2.753459e-07
I5614 n1_m1_312000_115200 0 2.703367e-07
I5615 n1_m1_312000_120000 0 4.688035e-07
I5616 n1_m1_312000_124800 0 3.096678e-07
I5617 n1_m1_312000_129600 0 5.511834e-07
I5618 n1_m1_312000_134400 0 3.500436e-07
I5619 n1_m1_312000_139200 0 2.809244e-07
I5620 n1_m1_312000_144000 0 4.053298e-07
I5621 n1_m1_312000_148800 0 2.675870e-07
I5622 n1_m1_312000_153600 0 4.028473e-07
I5623 n1_m1_312000_158400 0 3.164532e-07
I5624 n1_m1_312000_163200 0 2.798694e-07
I5625 n1_m1_312000_168000 0 3.888097e-07
I5626 n1_m1_312000_172800 0 2.964407e-07
I5627 n1_m1_312000_177600 0 4.911215e-07
I5628 n1_m1_312000_182400 0 3.236480e-07
I5629 n1_m1_312000_187200 0 2.730206e-07
I5630 n1_m1_312000_192000 0 4.185103e-07
I5631 n1_m1_312000_196800 0 3.668505e-07
I5632 n1_m1_312000_201600 0 4.849629e-07
I5633 n1_m1_312000_206400 0 3.188599e-07
I5634 n1_m1_312000_211200 0 2.856576e-07
I5635 n1_m1_312000_216000 0 4.128152e-07
I5636 n1_m1_312000_220800 0 2.634623e-07
I5637 n1_m1_312000_225600 0 4.831992e-07
I5638 n1_m1_312000_230400 0 2.622366e-07
I5639 n1_m1_312000_235200 0 2.602522e-07
I5640 n1_m1_312000_240000 0 3.899377e-07
I5641 n1_m1_312000_244800 0 2.503048e-07
I5642 n1_m1_312000_249600 0 4.250806e-07
I5643 n1_m1_312000_254400 0 4.921212e-07
I5644 n1_m1_312000_259200 0 4.797076e-07
I5645 n1_m1_312000_264000 0 4.356309e-07
I5646 n1_m1_312000_268800 0 2.722394e-07
I5647 n1_m1_312000_273600 0 4.757496e-07
I5648 n1_m1_312000_278400 0 3.598928e-07
I5649 n1_m1_312000_283200 0 3.356390e-07
I5650 n1_m1_312000_288000 0 4.151431e-07
I5651 n1_m1_312000_292800 0 2.644666e-07
I5652 n1_m1_312000_297600 0 3.830786e-07
I5653 n1_m1_312000_302400 0 2.573513e-07
I5654 n1_m1_312000_307200 0 2.538994e-07
I5655 n1_m1_312000_312000 0 3.796018e-07
I5656 n1_m1_312000_316800 0 2.649980e-07
I5657 n1_m1_312000_321600 0 3.867150e-07
I5658 n1_m1_312000_326400 0 3.131089e-07
I5659 n1_m1_312000_331200 0 5.215360e-07
I5660 n1_m1_312000_336000 0 6.027863e-07
I5661 n1_m1_312000_340800 0 2.664170e-07
I5662 n1_m1_312000_345600 0 4.220435e-07
I5663 n1_m1_312000_350400 0 4.164279e-07
I5664 n1_m1_312000_355200 0 3.604264e-07
I5665 n1_m1_312000_360000 0 4.088614e-07
I5666 n1_m1_312000_364800 0 2.528173e-07
I5667 n1_m1_312000_369600 0 3.987724e-07
I5668 n1_m1_312000_374400 0 2.653177e-07
I5669 n1_m1_312000_379200 0 2.571002e-07
I5670 n1_m1_312000_384000 0 3.897533e-07
I5671 n1_m1_312000_388800 0 2.534673e-07
I5672 n1_m1_312000_393600 0 3.725370e-07
I5673 n1_m1_312000_398400 0 2.393225e-07
I5674 n1_m1_312000_403200 0 2.352753e-07
I5675 n1_m1_312000_408000 0 2.333683e-07
I5676 n1_m1_316800_0 0 1.487589e-07
I5677 n1_m1_316800_4800 0 1.555258e-07
I5678 n1_m1_316800_9600 0 2.514665e-07
I5679 n1_m1_316800_14400 0 1.685716e-07
I5680 n1_m1_316800_19200 0 1.701547e-07
I5681 n1_m1_316800_24000 0 2.631774e-07
I5682 n1_m1_316800_28800 0 4.333004e-07
I5683 n1_m1_316800_33600 0 1.116011e-06
I5684 n1_m1_316800_38400 0 5.864922e-07
I5685 n1_m1_316800_43200 0 4.284260e-07
I5686 n1_m1_316800_48000 0 3.380386e-07
I5687 n1_m1_316800_52800 0 1.812210e-07
I5688 n1_m1_316800_57600 0 2.763719e-07
I5689 n1_m1_316800_62400 0 1.799866e-07
I5690 n1_m1_316800_67200 0 1.748180e-07
I5691 n1_m1_316800_72000 0 2.585405e-07
I5692 n1_m1_316800_76800 0 1.756977e-07
I5693 n1_m1_316800_81600 0 2.567431e-07
I5694 n1_m1_316800_86400 0 1.693718e-07
I5695 n1_m1_316800_91200 0 1.731066e-07
I5696 n1_m1_316800_96000 0 2.595403e-07
I5697 n1_m1_316800_100800 0 1.768137e-07
I5698 n1_m1_316800_105600 0 2.672577e-07
I5699 n1_m1_316800_110400 0 1.789766e-07
I5700 n1_m1_316800_115200 0 1.768827e-07
I5701 n1_m1_316800_120000 0 3.207304e-07
I5702 n1_m1_316800_124800 0 2.025566e-07
I5703 n1_m1_316800_129600 0 2.633285e-07
I5704 n1_m1_316800_134400 0 1.811964e-07
I5705 n1_m1_316800_139200 0 2.043013e-07
I5706 n1_m1_316800_144000 0 2.812661e-07
I5707 n1_m1_316800_148800 0 1.802593e-07
I5708 n1_m1_316800_153600 0 2.835040e-07
I5709 n1_m1_316800_158400 0 2.732865e-07
I5710 n1_m1_316800_163200 0 2.899424e-07
I5711 n1_m1_316800_168000 0 2.908153e-07
I5712 n1_m1_316800_172800 0 2.563607e-07
I5713 n1_m1_316800_177600 0 1.036802e-06
I5714 n1_m1_316800_182400 0 5.727312e-07
I5715 n1_m1_316800_187200 0 2.112178e-07
I5716 n1_m1_316800_192000 0 4.614858e-07
I5717 n1_m1_316800_196800 0 7.242074e-07
I5718 n1_m1_316800_201600 0 6.539861e-07
I5719 n1_m1_316800_206400 0 2.080141e-07
I5720 n1_m1_316800_211200 0 1.874249e-07
I5721 n1_m1_316800_216000 0 2.773847e-07
I5722 n1_m1_316800_220800 0 1.951688e-07
I5723 n1_m1_316800_225600 0 3.689374e-07
I5724 n1_m1_316800_230400 0 1.789704e-07
I5725 n1_m1_316800_235200 0 1.750744e-07
I5726 n1_m1_316800_240000 0 2.633169e-07
I5727 n1_m1_316800_244800 0 1.714460e-07
I5728 n1_m1_316800_249600 0 2.663049e-07
I5729 n1_m1_316800_254400 0 2.506495e-07
I5730 n1_m1_316800_259200 0 2.666675e-07
I5731 n1_m1_316800_264000 0 2.832744e-07
I5732 n1_m1_316800_268800 0 1.754979e-07
I5733 n1_m1_316800_273600 0 3.086161e-07
I5734 n1_m1_316800_278400 0 1.852638e-07
I5735 n1_m1_316800_283200 0 1.997238e-07
I5736 n1_m1_316800_288000 0 2.740726e-07
I5737 n1_m1_316800_292800 0 1.857602e-07
I5738 n1_m1_316800_297600 0 2.990748e-07
I5739 n1_m1_316800_302400 0 1.812118e-07
I5740 n1_m1_316800_307200 0 1.730675e-07
I5741 n1_m1_316800_312000 0 2.565207e-07
I5742 n1_m1_316800_316800 0 1.683638e-07
I5743 n1_m1_316800_321600 0 2.618980e-07
I5744 n1_m1_316800_326400 0 1.738296e-07
I5745 n1_m1_316800_331200 0 1.729561e-07
I5746 n1_m1_316800_336000 0 2.706381e-07
I5747 n1_m1_316800_340800 0 1.820728e-07
I5748 n1_m1_316800_345600 0 3.005793e-07
I5749 n1_m1_316800_350400 0 3.776694e-07
I5750 n1_m1_316800_355200 0 2.806540e-07
I5751 n1_m1_316800_360000 0 2.661107e-07
I5752 n1_m1_316800_364800 0 1.799195e-07
I5753 n1_m1_316800_369600 0 2.601986e-07
I5754 n1_m1_316800_374400 0 1.810367e-07
I5755 n1_m1_316800_379200 0 1.787277e-07
I5756 n1_m1_316800_384000 0 2.569941e-07
I5757 n1_m1_316800_388800 0 1.714069e-07
I5758 n1_m1_316800_393600 0 2.495846e-07
I5759 n1_m1_316800_398400 0 1.629271e-07
I5760 n1_m1_316800_403200 0 1.598903e-07
I5761 n1_m1_316800_408000 0 1.598903e-07
I5762 n1_m1_321600_0 0 2.307039e-07
I5763 n1_m1_321600_4800 0 2.306227e-07
I5764 n1_m1_321600_9600 0 3.975998e-07
I5765 n1_m1_321600_14400 0 2.662914e-07
I5766 n1_m1_321600_19200 0 2.565861e-07
I5767 n1_m1_321600_24000 0 4.175863e-07
I5768 n1_m1_321600_28800 0 7.459853e-07
I5769 n1_m1_321600_33600 0 1.742542e-06
I5770 n1_m1_321600_38400 0 6.329515e-07
I5771 n1_m1_321600_43200 0 3.406950e-07
I5772 n1_m1_321600_48000 0 4.271153e-07
I5773 n1_m1_321600_52800 0 3.108067e-07
I5774 n1_m1_321600_57600 0 4.177853e-07
I5775 n1_m1_321600_62400 0 2.587915e-07
I5776 n1_m1_321600_67200 0 2.678491e-07
I5777 n1_m1_321600_72000 0 3.876853e-07
I5778 n1_m1_321600_76800 0 2.568053e-07
I5779 n1_m1_321600_81600 0 3.946096e-07
I5780 n1_m1_321600_86400 0 2.641850e-07
I5781 n1_m1_321600_91200 0 2.659742e-07
I5782 n1_m1_321600_96000 0 4.228993e-07
I5783 n1_m1_321600_100800 0 2.747015e-07
I5784 n1_m1_321600_105600 0 4.036191e-07
I5785 n1_m1_321600_110400 0 2.824556e-07
I5786 n1_m1_321600_115200 0 2.743457e-07
I5787 n1_m1_321600_120000 0 4.161439e-07
I5788 n1_m1_321600_124800 0 3.073468e-07
I5789 n1_m1_321600_129600 0 5.385636e-07
I5790 n1_m1_321600_134400 0 3.485017e-07
I5791 n1_m1_321600_139200 0 5.924989e-07
I5792 n1_m1_321600_144000 0 1.376399e-06
I5793 n1_m1_321600_148800 0 6.655040e-07
I5794 n1_m1_321600_153600 0 4.919216e-07
I5795 n1_m1_321600_158400 0 2.791285e-07
I5796 n1_m1_321600_163200 0 3.601911e-07
I5797 n1_m1_321600_168000 0 1.284455e-06
I5798 n1_m1_321600_172800 0 1.267851e-06
I5799 n1_m1_321600_177600 0 2.286380e-06
I5800 n1_m1_321600_182400 0 1.149486e-06
I5801 n1_m1_321600_187200 0 5.039802e-07
I5802 n1_m1_321600_192000 0 4.923706e-07
I5803 n1_m1_321600_196800 0 6.911580e-07
I5804 n1_m1_321600_201600 0 1.046114e-06
I5805 n1_m1_321600_206400 0 8.604663e-07
I5806 n1_m1_321600_211200 0 3.870287e-07
I5807 n1_m1_321600_216000 0 4.574986e-07
I5808 n1_m1_321600_220800 0 6.561300e-07
I5809 n1_m1_321600_225600 0 1.456779e-06
I5810 n1_m1_321600_230400 0 3.858900e-07
I5811 n1_m1_321600_235200 0 2.715998e-07
I5812 n1_m1_321600_240000 0 3.921853e-07
I5813 n1_m1_321600_244800 0 2.568376e-07
I5814 n1_m1_321600_249600 0 3.921017e-07
I5815 n1_m1_321600_254400 0 3.690861e-07
I5816 n1_m1_321600_259200 0 4.084796e-07
I5817 n1_m1_321600_264000 0 4.495017e-07
I5818 n1_m1_321600_268800 0 2.606806e-07
I5819 n1_m1_321600_273600 0 4.974602e-07
I5820 n1_m1_321600_278400 0 2.784061e-07
I5821 n1_m1_321600_283200 0 2.884761e-07
I5822 n1_m1_321600_288000 0 4.915603e-07
I5823 n1_m1_321600_292800 0 3.818948e-07
I5824 n1_m1_321600_297600 0 7.520710e-07
I5825 n1_m1_321600_302400 0 3.927807e-07
I5826 n1_m1_321600_307200 0 3.066306e-07
I5827 n1_m1_321600_312000 0 3.885809e-07
I5828 n1_m1_321600_316800 0 2.591679e-07
I5829 n1_m1_321600_321600 0 3.902159e-07
I5830 n1_m1_321600_326400 0 2.594176e-07
I5831 n1_m1_321600_331200 0 3.577100e-07
I5832 n1_m1_321600_336000 0 6.953312e-07
I5833 n1_m1_321600_340800 0 2.647725e-07
I5834 n1_m1_321600_345600 0 4.046002e-07
I5835 n1_m1_321600_350400 0 3.011819e-07
I5836 n1_m1_321600_355200 0 2.802961e-07
I5837 n1_m1_321600_360000 0 3.921019e-07
I5838 n1_m1_321600_364800 0 2.728334e-07
I5839 n1_m1_321600_369600 0 4.424257e-07
I5840 n1_m1_321600_374400 0 7.232798e-07
I5841 n1_m1_321600_379200 0 6.784942e-07
I5842 n1_m1_321600_384000 0 4.346577e-07
I5843 n1_m1_321600_388800 0 2.595516e-07
I5844 n1_m1_321600_393600 0 3.826220e-07
I5845 n1_m1_321600_398400 0 2.460506e-07
I5846 n1_m1_321600_403200 0 2.398354e-07
I5847 n1_m1_321600_408000 0 2.398354e-07
I5848 n1_m1_326400_0 0 1.534657e-07
I5849 n1_m1_326400_4800 0 1.552712e-07
I5850 n1_m1_326400_9600 0 2.553345e-07
I5851 n1_m1_326400_14400 0 1.735439e-07
I5852 n1_m1_326400_19200 0 2.523545e-07
I5853 n1_m1_326400_24000 0 9.124770e-07
I5854 n1_m1_326400_28800 0 6.492675e-07
I5855 n1_m1_326400_33600 0 5.914732e-07
I5856 n1_m1_326400_38400 0 2.503844e-07
I5857 n1_m1_326400_43200 0 1.975144e-07
I5858 n1_m1_326400_48000 0 3.170354e-07
I5859 n1_m1_326400_52800 0 2.922381e-07
I5860 n1_m1_326400_57600 0 3.266794e-07
I5861 n1_m1_326400_62400 0 1.679189e-07
I5862 n1_m1_326400_67200 0 1.759750e-07
I5863 n1_m1_326400_72000 0 2.635771e-07
I5864 n1_m1_326400_76800 0 1.741588e-07
I5865 n1_m1_326400_81600 0 2.716985e-07
I5866 n1_m1_326400_86400 0 1.790857e-07
I5867 n1_m1_326400_91200 0 1.730057e-07
I5868 n1_m1_326400_96000 0 4.055087e-07
I5869 n1_m1_326400_100800 0 4.254085e-07
I5870 n1_m1_326400_105600 0 8.152989e-07
I5871 n1_m1_326400_110400 0 4.805709e-07
I5872 n1_m1_326400_115200 0 4.554557e-07
I5873 n1_m1_326400_120000 0 4.728706e-07
I5874 n1_m1_326400_124800 0 3.350934e-07
I5875 n1_m1_326400_129600 0 6.746680e-07
I5876 n1_m1_326400_134400 0 4.160940e-07
I5877 n1_m1_326400_139200 0 3.726908e-07
I5878 n1_m1_326400_144000 0 7.775416e-07
I5879 n1_m1_326400_148800 0 3.942239e-07
I5880 n1_m1_326400_153600 0 2.989468e-07
I5881 n1_m1_326400_158400 0 1.803580e-07
I5882 n1_m1_326400_163200 0 2.444118e-07
I5883 n1_m1_326400_168000 0 1.319839e-06
I5884 n1_m1_326400_172800 0 1.260442e-06
I5885 n1_m1_326400_177600 0 1.564873e-06
I5886 n1_m1_326400_182400 0 6.303305e-07
I5887 n1_m1_326400_187200 0 3.082925e-07
I5888 n1_m1_326400_192000 0 3.503873e-07
I5889 n1_m1_326400_196800 0 2.230818e-07
I5890 n1_m1_326400_201600 0 4.447107e-07
I5891 n1_m1_326400_206400 0 5.509197e-07
I5892 n1_m1_326400_211200 0 2.840122e-07
I5893 n1_m1_326400_216000 0 3.049063e-07
I5894 n1_m1_326400_220800 0 2.597138e-07
I5895 n1_m1_326400_225600 0 5.548913e-07
I5896 n1_m1_326400_230400 0 2.081782e-07
I5897 n1_m1_326400_235200 0 1.791933e-07
I5898 n1_m1_326400_240000 0 2.607410e-07
I5899 n1_m1_326400_244800 0 1.820539e-07
I5900 n1_m1_326400_249600 0 3.151839e-07
I5901 n1_m1_326400_254400 0 2.239096e-07
I5902 n1_m1_326400_259200 0 1.963038e-07
I5903 n1_m1_326400_264000 0 3.328329e-07
I5904 n1_m1_326400_268800 0 1.802321e-07
I5905 n1_m1_326400_273600 0 2.613800e-07
I5906 n1_m1_326400_278400 0 1.874355e-07
I5907 n1_m1_326400_283200 0 3.260255e-07
I5908 n1_m1_326400_288000 0 6.935078e-07
I5909 n1_m1_326400_292800 0 5.876096e-07
I5910 n1_m1_326400_297600 0 1.206663e-06
I5911 n1_m1_326400_302400 0 7.257543e-07
I5912 n1_m1_326400_307200 0 4.269672e-07
I5913 n1_m1_326400_312000 0 2.675855e-07
I5914 n1_m1_326400_316800 0 1.749854e-07
I5915 n1_m1_326400_321600 0 2.575302e-07
I5916 n1_m1_326400_326400 0 1.684865e-07
I5917 n1_m1_326400_331200 0 2.116237e-07
I5918 n1_m1_326400_336000 0 3.668626e-07
I5919 n1_m1_326400_340800 0 1.719364e-07
I5920 n1_m1_326400_345600 0 2.579891e-07
I5921 n1_m1_326400_350400 0 1.728989e-07
I5922 n1_m1_326400_355200 0 1.726473e-07
I5923 n1_m1_326400_360000 0 2.560660e-07
I5924 n1_m1_326400_364800 0 1.678455e-07
I5925 n1_m1_326400_369600 0 3.289618e-07
I5926 n1_m1_326400_374400 0 5.173584e-07
I5927 n1_m1_326400_379200 0 5.271843e-07
I5928 n1_m1_326400_384000 0 3.949454e-07
I5929 n1_m1_326400_388800 0 1.772213e-07
I5930 n1_m1_326400_393600 0 2.587011e-07
I5931 n1_m1_326400_398400 0 1.643010e-07
I5932 n1_m1_326400_403200 0 1.597110e-07
I5933 n1_m1_326400_408000 0 1.560318e-07
I5934 n1_m1_331200_0 0 1.471104e-07
I5935 n1_m1_331200_4800 0 1.513065e-07
I5936 n1_m1_331200_9600 0 2.451953e-07
I5937 n1_m1_331200_14400 0 1.723768e-07
I5938 n1_m1_331200_19200 0 3.779585e-07
I5939 n1_m1_331200_24000 0 1.436734e-06
I5940 n1_m1_331200_28800 0 1.053330e-06
I5941 n1_m1_331200_33600 0 9.148568e-07
I5942 n1_m1_331200_38400 0 3.980433e-07
I5943 n1_m1_331200_43200 0 4.364597e-07
I5944 n1_m1_331200_48000 0 6.365003e-07
I5945 n1_m1_331200_52800 0 2.157916e-07
I5946 n1_m1_331200_57600 0 3.082133e-07
I5947 n1_m1_331200_62400 0 1.726701e-07
I5948 n1_m1_331200_67200 0 1.723740e-07
I5949 n1_m1_331200_72000 0 2.599840e-07
I5950 n1_m1_331200_76800 0 1.695530e-07
I5951 n1_m1_331200_81600 0 2.687939e-07
I5952 n1_m1_331200_86400 0 1.770886e-07
I5953 n1_m1_331200_91200 0 2.212701e-07
I5954 n1_m1_331200_96000 0 9.472654e-07
I5955 n1_m1_331200_100800 0 9.665726e-07
I5956 n1_m1_331200_105600 0 1.764595e-06
I5957 n1_m1_331200_110400 0 1.248429e-06
I5958 n1_m1_331200_115200 0 1.232637e-06
I5959 n1_m1_331200_120000 0 1.314025e-06
I5960 n1_m1_331200_124800 0 6.287338e-07
I5961 n1_m1_331200_129600 0 1.358628e-06
I5962 n1_m1_331200_134400 0 9.743838e-07
I5963 n1_m1_331200_139200 0 4.780224e-07
I5964 n1_m1_331200_144000 0 3.023500e-07
I5965 n1_m1_331200_148800 0 1.943338e-07
I5966 n1_m1_331200_153600 0 2.604768e-07
I5967 n1_m1_331200_158400 0 1.694753e-07
I5968 n1_m1_331200_163200 0 1.891980e-07
I5969 n1_m1_331200_168000 0 6.765741e-07
I5970 n1_m1_331200_172800 0 7.126988e-07
I5971 n1_m1_331200_177600 0 9.182890e-07
I5972 n1_m1_331200_182400 0 3.330205e-07
I5973 n1_m1_331200_187200 0 1.970951e-07
I5974 n1_m1_331200_192000 0 3.428146e-07
I5975 n1_m1_331200_196800 0 1.879148e-07
I5976 n1_m1_331200_201600 0 3.443079e-07
I5977 n1_m1_331200_206400 0 2.558668e-07
I5978 n1_m1_331200_211200 0 2.556820e-07
I5979 n1_m1_331200_216000 0 3.367436e-07
I5980 n1_m1_331200_220800 0 1.827983e-07
I5981 n1_m1_331200_225600 0 3.594316e-07
I5982 n1_m1_331200_230400 0 1.905754e-07
I5983 n1_m1_331200_235200 0 1.755403e-07
I5984 n1_m1_331200_240000 0 2.679571e-07
I5985 n1_m1_331200_244800 0 2.321816e-07
I5986 n1_m1_331200_249600 0 5.762052e-07
I5987 n1_m1_331200_254400 0 3.687178e-07
I5988 n1_m1_331200_259200 0 1.950087e-07
I5989 n1_m1_331200_264000 0 2.677652e-07
I5990 n1_m1_331200_268800 0 1.729378e-07
I5991 n1_m1_331200_273600 0 2.607991e-07
I5992 n1_m1_331200_278400 0 2.217023e-07
I5993 n1_m1_331200_283200 0 6.575489e-07
I5994 n1_m1_331200_288000 0 1.625417e-06
I5995 n1_m1_331200_292800 0 9.005039e-07
I5996 n1_m1_331200_297600 0 7.080681e-07
I5997 n1_m1_331200_302400 0 5.022045e-07
I5998 n1_m1_331200_307200 0 4.579820e-07
I5999 n1_m1_331200_312000 0 2.840142e-07
I6000 n1_m1_331200_316800 0 1.734826e-07
I6001 n1_m1_331200_321600 0 2.600154e-07
I6002 n1_m1_331200_326400 0 1.674127e-07
I6003 n1_m1_331200_331200 0 1.737468e-07
I6004 n1_m1_331200_336000 0 2.623263e-07
I6005 n1_m1_331200_340800 0 1.785565e-07
I6006 n1_m1_331200_345600 0 2.600434e-07
I6007 n1_m1_331200_350400 0 1.764826e-07
I6008 n1_m1_331200_355200 0 1.761511e-07
I6009 n1_m1_331200_360000 0 2.570685e-07
I6010 n1_m1_331200_364800 0 1.715860e-07
I6011 n1_m1_331200_369600 0 2.692046e-07
I6012 n1_m1_331200_374400 0 1.994454e-07
I6013 n1_m1_331200_379200 0 2.494145e-07
I6014 n1_m1_331200_384000 0 3.891690e-07
I6015 n1_m1_331200_388800 0 1.794141e-07
I6016 n1_m1_331200_393600 0 2.606199e-07
I6017 n1_m1_331200_398400 0 1.663466e-07
I6018 n1_m1_331200_403200 0 1.593010e-07
I6019 n1_m1_331200_408000 0 1.549336e-07
I6020 n1_m1_336000_0 0 2.318084e-07
I6021 n1_m1_336000_4800 0 2.337215e-07
I6022 n1_m1_336000_9600 0 3.743160e-07
I6023 n1_m1_336000_14400 0 2.637960e-07
I6024 n1_m1_336000_19200 0 3.133577e-07
I6025 n1_m1_336000_24000 0 9.030932e-07
I6026 n1_m1_336000_28800 0 6.400941e-07
I6027 n1_m1_336000_33600 0 9.495645e-07
I6028 n1_m1_336000_38400 0 6.708462e-07
I6029 n1_m1_336000_43200 0 1.360101e-06
I6030 n1_m1_336000_48000 0 2.041111e-06
I6031 n1_m1_336000_52800 0 2.598217e-07
I6032 n1_m1_336000_57600 0 3.897325e-07
I6033 n1_m1_336000_62400 0 2.598217e-07
I6034 n1_m1_336000_67200 0 2.529253e-07
I6035 n1_m1_336000_72000 0 3.872498e-07
I6036 n1_m1_336000_76800 0 2.603714e-07
I6037 n1_m1_336000_81600 0 4.125889e-07
I6038 n1_m1_336000_86400 0 2.607481e-07
I6039 n1_m1_336000_91200 0 3.505874e-07
I6040 n1_m1_336000_96000 0 1.739230e-06
I6041 n1_m1_336000_100800 0 1.901450e-06
I6042 n1_m1_336000_105600 0 3.064766e-06
I6043 n1_m1_336000_110400 0 1.980171e-06
I6044 n1_m1_336000_115200 0 1.614912e-06
I6045 n1_m1_336000_120000 0 1.972717e-06
I6046 n1_m1_336000_124800 0 9.972817e-07
I6047 n1_m1_336000_129600 0 8.614696e-07
I6048 n1_m1_336000_134400 0 7.401757e-07
I6049 n1_m1_336000_139200 0 3.988311e-07
I6050 n1_m1_336000_144000 0 3.853332e-07
I6051 n1_m1_336000_148800 0 2.616606e-07
I6052 n1_m1_336000_153600 0 3.841261e-07
I6053 n1_m1_336000_158400 0 2.549551e-07
I6054 n1_m1_336000_163200 0 2.549796e-07
I6055 n1_m1_336000_168000 0 3.951138e-07
I6056 n1_m1_336000_172800 0 3.114745e-07
I6057 n1_m1_336000_177600 0 4.779582e-07
I6058 n1_m1_336000_182400 0 2.898374e-07
I6059 n1_m1_336000_187200 0 2.789963e-07
I6060 n1_m1_336000_192000 0 6.638079e-07
I6061 n1_m1_336000_196800 0 8.523468e-07
I6062 n1_m1_336000_201600 0 1.087930e-06
I6063 n1_m1_336000_206400 0 2.803397e-07
I6064 n1_m1_336000_211200 0 3.383242e-07
I6065 n1_m1_336000_216000 0 5.024462e-07
I6066 n1_m1_336000_220800 0 2.774870e-07
I6067 n1_m1_336000_225600 0 4.748634e-07
I6068 n1_m1_336000_230400 0 3.000817e-07
I6069 n1_m1_336000_235200 0 2.748927e-07
I6070 n1_m1_336000_240000 0 3.967237e-07
I6071 n1_m1_336000_244800 0 2.993030e-07
I6072 n1_m1_336000_249600 0 8.660268e-07
I6073 n1_m1_336000_254400 0 7.609184e-07
I6074 n1_m1_336000_259200 0 4.241432e-07
I6075 n1_m1_336000_264000 0 4.189690e-07
I6076 n1_m1_336000_268800 0 2.685918e-07
I6077 n1_m1_336000_273600 0 3.827495e-07
I6078 n1_m1_336000_278400 0 2.871459e-07
I6079 n1_m1_336000_283200 0 4.409092e-07
I6080 n1_m1_336000_288000 0 1.308221e-06
I6081 n1_m1_336000_292800 0 9.205545e-07
I6082 n1_m1_336000_297600 0 6.447363e-07
I6083 n1_m1_336000_302400 0 3.693580e-07
I6084 n1_m1_336000_307200 0 3.668501e-07
I6085 n1_m1_336000_312000 0 4.294703e-07
I6086 n1_m1_336000_316800 0 2.642569e-07
I6087 n1_m1_336000_321600 0 3.836997e-07
I6088 n1_m1_336000_326400 0 2.520049e-07
I6089 n1_m1_336000_331200 0 2.533978e-07
I6090 n1_m1_336000_336000 0 3.824326e-07
I6091 n1_m1_336000_340800 0 2.549551e-07
I6092 n1_m1_336000_345600 0 3.873942e-07
I6093 n1_m1_336000_350400 0 2.598217e-07
I6094 n1_m1_336000_355200 0 2.598217e-07
I6095 n1_m1_336000_360000 0 3.897325e-07
I6096 n1_m1_336000_364800 0 2.598217e-07
I6097 n1_m1_336000_369600 0 3.897325e-07
I6098 n1_m1_336000_374400 0 2.606988e-07
I6099 n1_m1_336000_379200 0 2.679112e-07
I6100 n1_m1_336000_384000 0 3.977730e-07
I6101 n1_m1_336000_388800 0 2.605151e-07
I6102 n1_m1_336000_393600 0 3.791083e-07
I6103 n1_m1_336000_398400 0 2.438489e-07
I6104 n1_m1_336000_403200 0 2.413331e-07
I6105 n1_m1_336000_408000 0 2.406010e-07
I6106 n1_m1_340800_0 0 7.606162e-08
I6107 n1_m1_340800_4800 0 7.730466e-08
I6108 n1_m1_340800_9600 0 1.271834e-07
I6109 n1_m1_340800_14400 0 8.660722e-08
I6110 n1_m1_340800_19200 0 8.673962e-08
I6111 n1_m1_340800_24000 0 1.381273e-07
I6112 n1_m1_340800_28800 0 9.139946e-08
I6113 n1_m1_340800_33600 0 1.564894e-07
I6114 n1_m1_340800_38400 0 9.028874e-08
I6115 n1_m1_340800_43200 0 1.244547e-07
I6116 n1_m1_340800_48000 0 1.934776e-07
I6117 n1_m1_340800_52800 0 8.660722e-08
I6118 n1_m1_340800_57600 0 1.299108e-07
I6119 n1_m1_340800_62400 0 8.660722e-08
I6120 n1_m1_340800_67200 0 8.558260e-08
I6121 n1_m1_340800_72000 0 1.260756e-07
I6122 n1_m1_340800_76800 0 1.254662e-07
I6123 n1_m1_340800_81600 0 1.354245e-07
I6124 n1_m1_340800_86400 0 1.046071e-07
I6125 n1_m1_340800_91200 0 1.024384e-07
I6126 n1_m1_340800_96000 0 1.637199e-07
I6127 n1_m1_340800_100800 0 2.583426e-07
I6128 n1_m1_340800_105600 0 6.470667e-07
I6129 n1_m1_340800_110400 0 3.486731e-07
I6130 n1_m1_340800_115200 0 1.510595e-07
I6131 n1_m1_340800_120000 0 1.717981e-07
I6132 n1_m1_340800_124800 0 1.011567e-07
I6133 n1_m1_340800_129600 0 1.321291e-07
I6134 n1_m1_340800_134400 0 8.713292e-08
I6135 n1_m1_340800_139200 0 1.024661e-07
I6136 n1_m1_340800_144000 0 1.917601e-07
I6137 n1_m1_340800_148800 0 9.051442e-08
I6138 n1_m1_340800_153600 0 1.299108e-07
I6139 n1_m1_340800_158400 0 8.748338e-08
I6140 n1_m1_340800_163200 0 8.853714e-08
I6141 n1_m1_340800_168000 0 1.302637e-07
I6142 n1_m1_340800_172800 0 8.683065e-08
I6143 n1_m1_340800_177600 0 1.436829e-07
I6144 n1_m1_340800_182400 0 9.295275e-08
I6145 n1_m1_340800_187200 0 9.043667e-08
I6146 n1_m1_340800_192000 0 1.641147e-07
I6147 n1_m1_340800_196800 0 1.422712e-07
I6148 n1_m1_340800_201600 0 2.004177e-07
I6149 n1_m1_340800_206400 0 9.206410e-08
I6150 n1_m1_340800_211200 0 8.975141e-08
I6151 n1_m1_340800_216000 0 1.882747e-07
I6152 n1_m1_340800_220800 0 1.476016e-07
I6153 n1_m1_340800_225600 0 1.390332e-07
I6154 n1_m1_340800_230400 0 8.924800e-08
I6155 n1_m1_340800_235200 0 9.192065e-08
I6156 n1_m1_340800_240000 0 1.352080e-07
I6157 n1_m1_340800_244800 0 8.468578e-08
I6158 n1_m1_340800_249600 0 1.499499e-07
I6159 n1_m1_340800_254400 0 2.306304e-07
I6160 n1_m1_340800_259200 0 2.132827e-07
I6161 n1_m1_340800_264000 0 1.433859e-07
I6162 n1_m1_340800_268800 0 8.689525e-08
I6163 n1_m1_340800_273600 0 1.289400e-07
I6164 n1_m1_340800_278400 0 8.651012e-08
I6165 n1_m1_340800_283200 0 8.874342e-08
I6166 n1_m1_340800_288000 0 1.379736e-07
I6167 n1_m1_340800_292800 0 1.101853e-07
I6168 n1_m1_340800_297600 0 1.530852e-07
I6169 n1_m1_340800_302400 0 8.971324e-08
I6170 n1_m1_340800_307200 0 1.354677e-07
I6171 n1_m1_340800_312000 0 1.967693e-07
I6172 n1_m1_340800_316800 0 9.947581e-08
I6173 n1_m1_340800_321600 0 1.417319e-07
I6174 n1_m1_340800_326400 0 1.047307e-07
I6175 n1_m1_340800_331200 0 1.106070e-07
I6176 n1_m1_340800_336000 0 1.521866e-07
I6177 n1_m1_340800_340800 0 9.012607e-08
I6178 n1_m1_340800_345600 0 1.304010e-07
I6179 n1_m1_340800_350400 0 8.466547e-08
I6180 n1_m1_340800_355200 0 8.466547e-08
I6181 n1_m1_340800_360000 0 1.295012e-07
I6182 n1_m1_340800_364800 0 8.660722e-08
I6183 n1_m1_340800_369600 0 1.299108e-07
I6184 n1_m1_340800_374400 0 8.660722e-08
I6185 n1_m1_340800_379200 0 8.660722e-08
I6186 n1_m1_340800_384000 0 1.272800e-07
I6187 n1_m1_340800_388800 0 8.555823e-08
I6188 n1_m1_340800_393600 0 1.277795e-07
I6189 n1_m1_340800_398400 0 8.115281e-08
I6190 n1_m1_340800_403200 0 7.994513e-08
I6191 n1_m1_340800_408000 0 8.090069e-08
I6192 n1_m1_345600_0 0 2.219390e-07
I6193 n1_m1_345600_4800 0 2.235783e-07
I6194 n1_m1_345600_9600 0 3.669517e-07
I6195 n1_m1_345600_14400 0 2.572110e-07
I6196 n1_m1_345600_19200 0 2.585611e-07
I6197 n1_m1_345600_24000 0 3.925066e-07
I6198 n1_m1_345600_28800 0 2.776192e-07
I6199 n1_m1_345600_33600 0 4.487936e-07
I6200 n1_m1_345600_38400 0 2.626464e-07
I6201 n1_m1_345600_43200 0 2.875687e-07
I6202 n1_m1_345600_48000 0 4.463156e-07
I6203 n1_m1_345600_52800 0 2.598217e-07
I6204 n1_m1_345600_57600 0 3.893193e-07
I6205 n1_m1_345600_62400 0 2.590324e-07
I6206 n1_m1_345600_67200 0 2.597553e-07
I6207 n1_m1_345600_72000 0 3.813739e-07
I6208 n1_m1_345600_76800 0 3.317904e-07
I6209 n1_m1_345600_81600 0 5.746050e-07
I6210 n1_m1_345600_86400 0 5.141284e-07
I6211 n1_m1_345600_91200 0 3.473381e-07
I6212 n1_m1_345600_96000 0 4.093531e-07
I6213 n1_m1_345600_100800 0 3.251286e-07
I6214 n1_m1_345600_105600 0 6.888858e-07
I6215 n1_m1_345600_110400 0 4.175889e-07
I6216 n1_m1_345600_115200 0 2.909867e-07
I6217 n1_m1_345600_120000 0 4.175815e-07
I6218 n1_m1_345600_124800 0 2.728508e-07
I6219 n1_m1_345600_129600 0 4.053271e-07
I6220 n1_m1_345600_134400 0 2.699186e-07
I6221 n1_m1_345600_139200 0 3.025025e-07
I6222 n1_m1_345600_144000 0 5.707878e-07
I6223 n1_m1_345600_148800 0 2.930573e-07
I6224 n1_m1_345600_153600 0 3.958078e-07
I6225 n1_m1_345600_158400 0 2.704373e-07
I6226 n1_m1_345600_163200 0 2.750681e-07
I6227 n1_m1_345600_168000 0 4.053893e-07
I6228 n1_m1_345600_172800 0 2.679753e-07
I6229 n1_m1_345600_177600 0 4.211566e-07
I6230 n1_m1_345600_182400 0 3.759324e-07
I6231 n1_m1_345600_187200 0 2.970050e-07
I6232 n1_m1_345600_192000 0 4.415778e-07
I6233 n1_m1_345600_196800 0 3.106878e-07
I6234 n1_m1_345600_201600 0 4.921791e-07
I6235 n1_m1_345600_206400 0 2.658178e-07
I6236 n1_m1_345600_211200 0 2.711120e-07
I6237 n1_m1_345600_216000 0 1.358582e-06
I6238 n1_m1_345600_220800 0 8.608406e-07
I6239 n1_m1_345600_225600 0 4.619019e-07
I6240 n1_m1_345600_230400 0 2.636381e-07
I6241 n1_m1_345600_235200 0 2.635927e-07
I6242 n1_m1_345600_240000 0 3.928204e-07
I6243 n1_m1_345600_244800 0 2.566401e-07
I6244 n1_m1_345600_249600 0 3.979547e-07
I6245 n1_m1_345600_254400 0 5.113466e-07
I6246 n1_m1_345600_259200 0 4.981292e-07
I6247 n1_m1_345600_264000 0 4.067180e-07
I6248 n1_m1_345600_268800 0 2.602163e-07
I6249 n1_m1_345600_273600 0 3.907441e-07
I6250 n1_m1_345600_278400 0 2.539764e-07
I6251 n1_m1_345600_283200 0 2.629890e-07
I6252 n1_m1_345600_288000 0 3.960411e-07
I6253 n1_m1_345600_292800 0 2.973332e-07
I6254 n1_m1_345600_297600 0 4.413436e-07
I6255 n1_m1_345600_302400 0 2.669917e-07
I6256 n1_m1_345600_307200 0 3.049984e-07
I6257 n1_m1_345600_312000 0 5.403578e-07
I6258 n1_m1_345600_316800 0 4.419487e-07
I6259 n1_m1_345600_321600 0 7.146297e-07
I6260 n1_m1_345600_326400 0 4.512176e-07
I6261 n1_m1_345600_331200 0 4.052218e-07
I6262 n1_m1_345600_336000 0 4.878595e-07
I6263 n1_m1_345600_340800 0 2.751780e-07
I6264 n1_m1_345600_345600 0 3.930741e-07
I6265 n1_m1_345600_350400 0 2.545501e-07
I6266 n1_m1_345600_355200 0 2.513478e-07
I6267 n1_m1_345600_360000 0 3.899031e-07
I6268 n1_m1_345600_364800 0 2.602385e-07
I6269 n1_m1_345600_369600 0 3.897325e-07
I6270 n1_m1_345600_374400 0 2.586266e-07
I6271 n1_m1_345600_379200 0 2.583024e-07
I6272 n1_m1_345600_384000 0 3.878079e-07
I6273 n1_m1_345600_388800 0 2.864747e-07
I6274 n1_m1_345600_393600 0 4.855238e-07
I6275 n1_m1_345600_398400 0 2.574376e-07
I6276 n1_m1_345600_403200 0 2.375456e-07
I6277 n1_m1_345600_408000 0 2.366700e-07
I6278 n1_m1_350400_0 0 1.565472e-07
I6279 n1_m1_350400_4800 0 1.506920e-07
I6280 n1_m1_350400_9600 0 2.461775e-07
I6281 n1_m1_350400_14400 0 1.745353e-07
I6282 n1_m1_350400_19200 0 1.732144e-07
I6283 n1_m1_350400_24000 0 2.632007e-07
I6284 n1_m1_350400_28800 0 2.040661e-07
I6285 n1_m1_350400_33600 0 2.758967e-07
I6286 n1_m1_350400_38400 0 1.721990e-07
I6287 n1_m1_350400_43200 0 1.760699e-07
I6288 n1_m1_350400_48000 0 2.701961e-07
I6289 n1_m1_350400_52800 0 1.732144e-07
I6290 n1_m1_350400_57600 0 2.580099e-07
I6291 n1_m1_350400_62400 0 1.697534e-07
I6292 n1_m1_350400_67200 0 1.732144e-07
I6293 n1_m1_350400_72000 0 2.558082e-07
I6294 n1_m1_350400_76800 0 1.870230e-07
I6295 n1_m1_350400_81600 0 9.931148e-07
I6296 n1_m1_350400_86400 0 1.018741e-06
I6297 n1_m1_350400_91200 0 5.610341e-07
I6298 n1_m1_350400_96000 0 3.095626e-07
I6299 n1_m1_350400_100800 0 1.737062e-07
I6300 n1_m1_350400_105600 0 2.639769e-07
I6301 n1_m1_350400_110400 0 1.976041e-07
I6302 n1_m1_350400_115200 0 1.847601e-07
I6303 n1_m1_350400_120000 0 5.004121e-07
I6304 n1_m1_350400_124800 0 5.001953e-07
I6305 n1_m1_350400_129600 0 5.542832e-07
I6306 n1_m1_350400_134400 0 2.055136e-07
I6307 n1_m1_350400_139200 0 1.766960e-07
I6308 n1_m1_350400_144000 0 2.675584e-07
I6309 n1_m1_350400_148800 0 1.795034e-07
I6310 n1_m1_350400_153600 0 2.619666e-07
I6311 n1_m1_350400_158400 0 1.796213e-07
I6312 n1_m1_350400_163200 0 1.824926e-07
I6313 n1_m1_350400_168000 0 2.722395e-07
I6314 n1_m1_350400_172800 0 1.809560e-07
I6315 n1_m1_350400_177600 0 3.247801e-07
I6316 n1_m1_350400_182400 0 1.854665e-07
I6317 n1_m1_350400_187200 0 1.937883e-07
I6318 n1_m1_350400_192000 0 3.177224e-07
I6319 n1_m1_350400_196800 0 3.382992e-07
I6320 n1_m1_350400_201600 0 5.516614e-07
I6321 n1_m1_350400_206400 0 1.879539e-07
I6322 n1_m1_350400_211200 0 1.759874e-07
I6323 n1_m1_350400_216000 0 7.974601e-07
I6324 n1_m1_350400_220800 0 4.463128e-07
I6325 n1_m1_350400_225600 0 2.931334e-07
I6326 n1_m1_350400_230400 0 1.752647e-07
I6327 n1_m1_350400_235200 0 1.738557e-07
I6328 n1_m1_350400_240000 0 2.632704e-07
I6329 n1_m1_350400_244800 0 1.732304e-07
I6330 n1_m1_350400_249600 0 2.620733e-07
I6331 n1_m1_350400_254400 0 2.087042e-07
I6332 n1_m1_350400_259200 0 1.994374e-07
I6333 n1_m1_350400_264000 0 2.656625e-07
I6334 n1_m1_350400_268800 0 1.756245e-07
I6335 n1_m1_350400_273600 0 2.642576e-07
I6336 n1_m1_350400_278400 0 1.785992e-07
I6337 n1_m1_350400_283200 0 2.080520e-07
I6338 n1_m1_350400_288000 0 2.821414e-07
I6339 n1_m1_350400_292800 0 1.883188e-07
I6340 n1_m1_350400_297600 0 2.660288e-07
I6341 n1_m1_350400_302400 0 1.732144e-07
I6342 n1_m1_350400_307200 0 1.732144e-07
I6343 n1_m1_350400_312000 0 2.947829e-07
I6344 n1_m1_350400_316800 0 2.919974e-07
I6345 n1_m1_350400_321600 0 5.005922e-07
I6346 n1_m1_350400_326400 0 2.748592e-07
I6347 n1_m1_350400_331200 0 2.242894e-07
I6348 n1_m1_350400_336000 0 2.622591e-07
I6349 n1_m1_350400_340800 0 1.732144e-07
I6350 n1_m1_350400_345600 0 2.598217e-07
I6351 n1_m1_350400_350400 0 1.732144e-07
I6352 n1_m1_350400_355200 0 1.732144e-07
I6353 n1_m1_350400_360000 0 2.684093e-07
I6354 n1_m1_350400_364800 0 1.750425e-07
I6355 n1_m1_350400_369600 0 2.581563e-07
I6356 n1_m1_350400_374400 0 1.674158e-07
I6357 n1_m1_350400_379200 0 1.665524e-07
I6358 n1_m1_350400_384000 0 2.555295e-07
I6359 n1_m1_350400_388800 0 2.018048e-07
I6360 n1_m1_350400_393600 0 3.466631e-07
I6361 n1_m1_350400_398400 0 1.705940e-07
I6362 n1_m1_350400_403200 0 1.547380e-07
I6363 n1_m1_350400_408000 0 1.550275e-07
I6364 n1_m1_355200_0 0 1.505976e-07
I6365 n1_m1_355200_4800 0 1.505494e-07
I6366 n1_m1_355200_9600 0 2.625014e-07
I6367 n1_m1_355200_14400 0 1.873243e-07
I6368 n1_m1_355200_19200 0 1.773681e-07
I6369 n1_m1_355200_24000 0 2.616675e-07
I6370 n1_m1_355200_28800 0 1.791333e-07
I6371 n1_m1_355200_33600 0 2.532056e-07
I6372 n1_m1_355200_38400 0 1.741351e-07
I6373 n1_m1_355200_43200 0 1.737750e-07
I6374 n1_m1_355200_48000 0 2.594721e-07
I6375 n1_m1_355200_52800 0 1.732144e-07
I6376 n1_m1_355200_57600 0 2.580099e-07
I6377 n1_m1_355200_62400 0 1.697534e-07
I6378 n1_m1_355200_67200 0 1.732144e-07
I6379 n1_m1_355200_72000 0 2.558082e-07
I6380 n1_m1_355200_76800 0 1.831930e-07
I6381 n1_m1_355200_81600 0 9.246237e-07
I6382 n1_m1_355200_86400 0 1.161593e-06
I6383 n1_m1_355200_91200 0 7.002171e-07
I6384 n1_m1_355200_96000 0 2.991669e-07
I6385 n1_m1_355200_100800 0 1.709233e-07
I6386 n1_m1_355200_105600 0 3.702455e-07
I6387 n1_m1_355200_110400 0 2.776373e-07
I6388 n1_m1_355200_115200 0 1.890052e-07
I6389 n1_m1_355200_120000 0 1.086911e-06
I6390 n1_m1_355200_124800 0 1.208690e-06
I6391 n1_m1_355200_129600 0 1.214052e-06
I6392 n1_m1_355200_134400 0 2.356241e-07
I6393 n1_m1_355200_139200 0 1.756851e-07
I6394 n1_m1_355200_144000 0 2.644704e-07
I6395 n1_m1_355200_148800 0 1.768152e-07
I6396 n1_m1_355200_153600 0 2.644360e-07
I6397 n1_m1_355200_158400 0 1.850114e-07
I6398 n1_m1_355200_163200 0 2.200647e-07
I6399 n1_m1_355200_168000 0 3.116783e-07
I6400 n1_m1_355200_172800 0 1.791210e-07
I6401 n1_m1_355200_177600 0 2.710543e-07
I6402 n1_m1_355200_182400 0 5.914543e-07
I6403 n1_m1_355200_187200 0 5.374950e-07
I6404 n1_m1_355200_192000 0 3.513062e-07
I6405 n1_m1_355200_196800 0 5.693813e-07
I6406 n1_m1_355200_201600 0 1.163353e-06
I6407 n1_m1_355200_206400 0 2.005767e-07
I6408 n1_m1_355200_211200 0 1.833457e-07
I6409 n1_m1_355200_216000 0 3.330883e-07
I6410 n1_m1_355200_220800 0 2.073867e-07
I6411 n1_m1_355200_225600 0 2.676199e-07
I6412 n1_m1_355200_230400 0 1.738855e-07
I6413 n1_m1_355200_235200 0 1.901539e-07
I6414 n1_m1_355200_240000 0 2.970178e-07
I6415 n1_m1_355200_244800 0 1.733072e-07
I6416 n1_m1_355200_249600 0 2.640923e-07
I6417 n1_m1_355200_254400 0 1.843946e-07
I6418 n1_m1_355200_259200 0 1.711346e-07
I6419 n1_m1_355200_264000 0 2.796964e-07
I6420 n1_m1_355200_268800 0 1.768423e-07
I6421 n1_m1_355200_273600 0 2.635385e-07
I6422 n1_m1_355200_278400 0 1.972399e-07
I6423 n1_m1_355200_283200 0 2.494343e-07
I6424 n1_m1_355200_288000 0 2.819557e-07
I6425 n1_m1_355200_292800 0 1.838828e-07
I6426 n1_m1_355200_297600 0 2.640380e-07
I6427 n1_m1_355200_302400 0 1.749551e-07
I6428 n1_m1_355200_307200 0 1.774879e-07
I6429 n1_m1_355200_312000 0 2.718568e-07
I6430 n1_m1_355200_316800 0 1.939919e-07
I6431 n1_m1_355200_321600 0 2.990239e-07
I6432 n1_m1_355200_326400 0 1.835728e-07
I6433 n1_m1_355200_331200 0 1.780707e-07
I6434 n1_m1_355200_336000 0 2.623962e-07
I6435 n1_m1_355200_340800 0 1.732144e-07
I6436 n1_m1_355200_345600 0 2.598217e-07
I6437 n1_m1_355200_350400 0 1.732144e-07
I6438 n1_m1_355200_355200 0 1.732144e-07
I6439 n1_m1_355200_360000 0 2.717186e-07
I6440 n1_m1_355200_364800 0 1.750425e-07
I6441 n1_m1_355200_369600 0 2.555807e-07
I6442 n1_m1_355200_374400 0 1.699138e-07
I6443 n1_m1_355200_379200 0 1.708258e-07
I6444 n1_m1_355200_384000 0 2.539115e-07
I6445 n1_m1_355200_388800 0 1.806358e-07
I6446 n1_m1_355200_393600 0 2.715483e-07
I6447 n1_m1_355200_398400 0 1.588573e-07
I6448 n1_m1_355200_403200 0 1.532282e-07
I6449 n1_m1_355200_408000 0 1.607497e-07
I6450 n1_m1_360000_0 0 2.352107e-07
I6451 n1_m1_360000_4800 0 2.351174e-07
I6452 n1_m1_360000_9600 0 3.894067e-07
I6453 n1_m1_360000_14400 0 2.639819e-07
I6454 n1_m1_360000_19200 0 2.613183e-07
I6455 n1_m1_360000_24000 0 3.915281e-07
I6456 n1_m1_360000_28800 0 2.624030e-07
I6457 n1_m1_360000_33600 0 3.915373e-07
I6458 n1_m1_360000_38400 0 2.587832e-07
I6459 n1_m1_360000_43200 0 2.692344e-07
I6460 n1_m1_360000_48000 0 3.903241e-07
I6461 n1_m1_360000_52800 0 2.598217e-07
I6462 n1_m1_360000_57600 0 3.893503e-07
I6463 n1_m1_360000_62400 0 2.590915e-07
I6464 n1_m1_360000_67200 0 2.597506e-07
I6465 n1_m1_360000_72000 0 3.812077e-07
I6466 n1_m1_360000_76800 0 2.645648e-07
I6467 n1_m1_360000_81600 0 5.057045e-07
I6468 n1_m1_360000_86400 0 5.260141e-07
I6469 n1_m1_360000_91200 0 3.675944e-07
I6470 n1_m1_360000_96000 0 3.890715e-07
I6471 n1_m1_360000_100800 0 2.581592e-07
I6472 n1_m1_360000_105600 0 1.088349e-06
I6473 n1_m1_360000_110400 0 7.740257e-07
I6474 n1_m1_360000_115200 0 3.235963e-07
I6475 n1_m1_360000_120000 0 7.744308e-07
I6476 n1_m1_360000_124800 0 8.508363e-07
I6477 n1_m1_360000_129600 0 9.671694e-07
I6478 n1_m1_360000_134400 0 3.003229e-07
I6479 n1_m1_360000_139200 0 2.773120e-07
I6480 n1_m1_360000_144000 0 6.895653e-07
I6481 n1_m1_360000_148800 0 4.098805e-07
I6482 n1_m1_360000_153600 0 4.199207e-07
I6483 n1_m1_360000_158400 0 2.629927e-07
I6484 n1_m1_360000_163200 0 2.760384e-07
I6485 n1_m1_360000_168000 0 4.080591e-07
I6486 n1_m1_360000_172800 0 2.774810e-07
I6487 n1_m1_360000_177600 0 6.768962e-07
I6488 n1_m1_360000_182400 0 1.676210e-06
I6489 n1_m1_360000_187200 0 1.678996e-06
I6490 n1_m1_360000_192000 0 7.769097e-07
I6491 n1_m1_360000_196800 0 4.199829e-07
I6492 n1_m1_360000_201600 0 7.109900e-07
I6493 n1_m1_360000_206400 0 3.210735e-07
I6494 n1_m1_360000_211200 0 5.074891e-07
I6495 n1_m1_360000_216000 0 1.046267e-06
I6496 n1_m1_360000_220800 0 8.190189e-07
I6497 n1_m1_360000_225600 0 5.346617e-07
I6498 n1_m1_360000_230400 0 2.795200e-07
I6499 n1_m1_360000_235200 0 2.655465e-07
I6500 n1_m1_360000_240000 0 4.009305e-07
I6501 n1_m1_360000_244800 0 2.598474e-07
I6502 n1_m1_360000_249600 0 3.907558e-07
I6503 n1_m1_360000_254400 0 2.615289e-07
I6504 n1_m1_360000_259200 0 3.284806e-07
I6505 n1_m1_360000_264000 0 6.341813e-07
I6506 n1_m1_360000_268800 0 2.719361e-07
I6507 n1_m1_360000_273600 0 3.884113e-07
I6508 n1_m1_360000_278400 0 2.658051e-07
I6509 n1_m1_360000_283200 0 2.736106e-07
I6510 n1_m1_360000_288000 0 3.940820e-07
I6511 n1_m1_360000_292800 0 2.902481e-07
I6512 n1_m1_360000_297600 0 5.848449e-07
I6513 n1_m1_360000_302400 0 2.685416e-07
I6514 n1_m1_360000_307200 0 2.612272e-07
I6515 n1_m1_360000_312000 0 4.097618e-07
I6516 n1_m1_360000_316800 0 3.038899e-07
I6517 n1_m1_360000_321600 0 4.590773e-07
I6518 n1_m1_360000_326400 0 2.592589e-07
I6519 n1_m1_360000_331200 0 2.549866e-07
I6520 n1_m1_360000_336000 0 3.866093e-07
I6521 n1_m1_360000_340800 0 2.547696e-07
I6522 n1_m1_360000_345600 0 3.819939e-07
I6523 n1_m1_360000_350400 0 2.566885e-07
I6524 n1_m1_360000_355200 0 2.565123e-07
I6525 n1_m1_360000_360000 0 4.552650e-07
I6526 n1_m1_360000_364800 0 2.579146e-07
I6527 n1_m1_360000_369600 0 3.950248e-07
I6528 n1_m1_360000_374400 0 2.706319e-07
I6529 n1_m1_360000_379200 0 2.856591e-07
I6530 n1_m1_360000_384000 0 4.438019e-07
I6531 n1_m1_360000_388800 0 3.613150e-07
I6532 n1_m1_360000_393600 0 4.170196e-07
I6533 n1_m1_360000_398400 0 2.420906e-07
I6534 n1_m1_360000_403200 0 2.336927e-07
I6535 n1_m1_360000_408000 0 2.329436e-07
I6536 n1_m1_364800_0 0 1.555972e-07
I6537 n1_m1_364800_4800 0 1.588689e-07
I6538 n1_m1_364800_9600 0 2.421028e-07
I6539 n1_m1_364800_14400 0 1.841992e-07
I6540 n1_m1_364800_19200 0 2.004643e-07
I6541 n1_m1_364800_24000 0 7.451973e-07
I6542 n1_m1_364800_28800 0 4.855791e-07
I6543 n1_m1_364800_33600 0 3.374501e-07
I6544 n1_m1_364800_38400 0 1.973037e-07
I6545 n1_m1_364800_43200 0 1.757476e-07
I6546 n1_m1_364800_48000 0 2.772623e-07
I6547 n1_m1_364800_52800 0 1.736279e-07
I6548 n1_m1_364800_57600 0 2.547781e-07
I6549 n1_m1_364800_62400 0 1.683804e-07
I6550 n1_m1_364800_67200 0 1.683425e-07
I6551 n1_m1_364800_72000 0 2.530462e-07
I6552 n1_m1_364800_76800 0 2.020223e-07
I6553 n1_m1_364800_81600 0 2.692426e-07
I6554 n1_m1_364800_86400 0 1.856941e-07
I6555 n1_m1_364800_91200 0 1.692581e-07
I6556 n1_m1_364800_96000 0 2.605455e-07
I6557 n1_m1_364800_100800 0 1.740830e-07
I6558 n1_m1_364800_105600 0 4.111904e-07
I6559 n1_m1_364800_110400 0 2.936791e-07
I6560 n1_m1_364800_115200 0 2.197740e-07
I6561 n1_m1_364800_120000 0 2.905995e-07
I6562 n1_m1_364800_124800 0 1.827615e-07
I6563 n1_m1_364800_129600 0 2.667198e-07
I6564 n1_m1_364800_134400 0 2.604720e-07
I6565 n1_m1_364800_139200 0 4.132555e-07
I6566 n1_m1_364800_144000 0 1.207207e-06
I6567 n1_m1_364800_148800 0 5.293261e-07
I6568 n1_m1_364800_153600 0 2.795449e-07
I6569 n1_m1_364800_158400 0 1.732144e-07
I6570 n1_m1_364800_163200 0 1.776625e-07
I6571 n1_m1_364800_168000 0 2.657629e-07
I6572 n1_m1_364800_172800 0 1.796108e-07
I6573 n1_m1_364800_177600 0 3.598387e-07
I6574 n1_m1_364800_182400 0 6.687980e-07
I6575 n1_m1_364800_187200 0 6.155790e-07
I6576 n1_m1_364800_192000 0 3.692196e-07
I6577 n1_m1_364800_196800 0 2.157559e-07
I6578 n1_m1_364800_201600 0 2.694265e-07
I6579 n1_m1_364800_206400 0 1.977241e-07
I6580 n1_m1_364800_211200 0 7.102863e-07
I6581 n1_m1_364800_216000 0 1.460318e-06
I6582 n1_m1_364800_220800 0 1.025916e-06
I6583 n1_m1_364800_225600 0 4.237440e-07
I6584 n1_m1_364800_230400 0 1.831342e-07
I6585 n1_m1_364800_235200 0 1.743994e-07
I6586 n1_m1_364800_240000 0 2.662402e-07
I6587 n1_m1_364800_244800 0 1.734942e-07
I6588 n1_m1_364800_249600 0 2.599353e-07
I6589 n1_m1_364800_254400 0 1.758130e-07
I6590 n1_m1_364800_259200 0 2.656853e-07
I6591 n1_m1_364800_264000 0 4.660927e-07
I6592 n1_m1_364800_268800 0 1.824754e-07
I6593 n1_m1_364800_273600 0 2.600408e-07
I6594 n1_m1_364800_278400 0 1.700527e-07
I6595 n1_m1_364800_283200 0 1.847283e-07
I6596 n1_m1_364800_288000 0 3.196539e-07
I6597 n1_m1_364800_292800 0 2.108732e-07
I6598 n1_m1_364800_297600 0 3.839715e-07
I6599 n1_m1_364800_302400 0 1.948629e-07
I6600 n1_m1_364800_307200 0 2.752908e-07
I6601 n1_m1_364800_312000 0 3.622562e-07
I6602 n1_m1_364800_316800 0 3.737208e-07
I6603 n1_m1_364800_321600 0 5.418553e-07
I6604 n1_m1_364800_326400 0 1.869499e-07
I6605 n1_m1_364800_331200 0 1.721583e-07
I6606 n1_m1_364800_336000 0 2.534878e-07
I6607 n1_m1_364800_340800 0 1.729410e-07
I6608 n1_m1_364800_345600 0 2.598217e-07
I6609 n1_m1_364800_350400 0 1.714151e-07
I6610 n1_m1_364800_355200 0 1.686322e-07
I6611 n1_m1_364800_360000 0 2.831792e-07
I6612 n1_m1_364800_364800 0 1.716701e-07
I6613 n1_m1_364800_369600 0 2.960484e-07
I6614 n1_m1_364800_374400 0 2.161519e-07
I6615 n1_m1_364800_379200 0 2.784369e-07
I6616 n1_m1_364800_384000 0 6.373374e-07
I6617 n1_m1_364800_388800 0 5.984853e-07
I6618 n1_m1_364800_393600 0 4.930076e-07
I6619 n1_m1_364800_398400 0 1.645555e-07
I6620 n1_m1_364800_403200 0 1.532583e-07
I6621 n1_m1_364800_408000 0 1.586426e-07
I6622 n1_m1_369600_0 0 1.572422e-07
I6623 n1_m1_369600_4800 0 1.536700e-07
I6624 n1_m1_369600_9600 0 2.709557e-07
I6625 n1_m1_369600_14400 0 2.380059e-07
I6626 n1_m1_369600_19200 0 5.817381e-07
I6627 n1_m1_369600_24000 0 1.841113e-06
I6628 n1_m1_369600_28800 0 1.300016e-06
I6629 n1_m1_369600_33600 0 1.136372e-06
I6630 n1_m1_369600_38400 0 8.436185e-07
I6631 n1_m1_369600_43200 0 8.178018e-07
I6632 n1_m1_369600_48000 0 6.410073e-07
I6633 n1_m1_369600_52800 0 2.007933e-07
I6634 n1_m1_369600_57600 0 2.686528e-07
I6635 n1_m1_369600_62400 0 1.687556e-07
I6636 n1_m1_369600_67200 0 1.665524e-07
I6637 n1_m1_369600_72000 0 2.538420e-07
I6638 n1_m1_369600_76800 0 3.504958e-07
I6639 n1_m1_369600_81600 0 3.707413e-07
I6640 n1_m1_369600_86400 0 2.250666e-07
I6641 n1_m1_369600_91200 0 1.995909e-07
I6642 n1_m1_369600_96000 0 2.967201e-07
I6643 n1_m1_369600_100800 0 1.696761e-07
I6644 n1_m1_369600_105600 0 2.551465e-07
I6645 n1_m1_369600_110400 0 2.550863e-07
I6646 n1_m1_369600_115200 0 6.337965e-07
I6647 n1_m1_369600_120000 0 7.143725e-07
I6648 n1_m1_369600_124800 0 2.109567e-07
I6649 n1_m1_369600_129600 0 4.013603e-07
I6650 n1_m1_369600_134400 0 9.639947e-07
I6651 n1_m1_369600_139200 0 1.362550e-06
I6652 n1_m1_369600_144000 0 1.711209e-06
I6653 n1_m1_369600_148800 0 4.858363e-07
I6654 n1_m1_369600_153600 0 3.457960e-07
I6655 n1_m1_369600_158400 0 1.732144e-07
I6656 n1_m1_369600_163200 0 1.732144e-07
I6657 n1_m1_369600_168000 0 2.598217e-07
I6658 n1_m1_369600_172800 0 1.824607e-07
I6659 n1_m1_369600_177600 0 3.186446e-07
I6660 n1_m1_369600_182400 0 2.753902e-07
I6661 n1_m1_369600_187200 0 2.652260e-07
I6662 n1_m1_369600_192000 0 3.108543e-07
I6663 n1_m1_369600_196800 0 1.686485e-07
I6664 n1_m1_369600_201600 0 2.718703e-07
I6665 n1_m1_369600_206400 0 2.312055e-07
I6666 n1_m1_369600_211200 0 5.662243e-07
I6667 n1_m1_369600_216000 0 7.512916e-07
I6668 n1_m1_369600_220800 0 4.573972e-07
I6669 n1_m1_369600_225600 0 6.137758e-07
I6670 n1_m1_369600_230400 0 2.119506e-07
I6671 n1_m1_369600_235200 0 1.738079e-07
I6672 n1_m1_369600_240000 0 2.634533e-07
I6673 n1_m1_369600_244800 0 1.756355e-07
I6674 n1_m1_369600_249600 0 2.598849e-07
I6675 n1_m1_369600_254400 0 1.679519e-07
I6676 n1_m1_369600_259200 0 1.726447e-07
I6677 n1_m1_369600_264000 0 2.639759e-07
I6678 n1_m1_369600_268800 0 1.714222e-07
I6679 n1_m1_369600_273600 0 2.561900e-07
I6680 n1_m1_369600_278400 0 1.716171e-07
I6681 n1_m1_369600_283200 0 1.911952e-07
I6682 n1_m1_369600_288000 0 3.152415e-07
I6683 n1_m1_369600_292800 0 1.742790e-07
I6684 n1_m1_369600_297600 0 2.755692e-07
I6685 n1_m1_369600_302400 0 3.329488e-07
I6686 n1_m1_369600_307200 0 6.423228e-07
I6687 n1_m1_369600_312000 0 1.121154e-06
I6688 n1_m1_369600_316800 0 5.900760e-07
I6689 n1_m1_369600_321600 0 4.749188e-07
I6690 n1_m1_369600_326400 0 1.884085e-07
I6691 n1_m1_369600_331200 0 1.758625e-07
I6692 n1_m1_369600_336000 0 2.620499e-07
I6693 n1_m1_369600_340800 0 1.685820e-07
I6694 n1_m1_369600_345600 0 2.598217e-07
I6695 n1_m1_369600_350400 0 1.732144e-07
I6696 n1_m1_369600_355200 0 1.786553e-07
I6697 n1_m1_369600_360000 0 2.925781e-07
I6698 n1_m1_369600_364800 0 1.719627e-07
I6699 n1_m1_369600_369600 0 2.715062e-07
I6700 n1_m1_369600_374400 0 3.261105e-07
I6701 n1_m1_369600_379200 0 7.211924e-07
I6702 n1_m1_369600_384000 0 1.422553e-06
I6703 n1_m1_369600_388800 0 7.757473e-07
I6704 n1_m1_369600_393600 0 4.243212e-07
I6705 n1_m1_369600_398400 0 1.639147e-07
I6706 n1_m1_369600_403200 0 1.566827e-07
I6707 n1_m1_369600_408000 0 1.508071e-07
I6708 n1_m1_374400_0 0 1.629391e-07
I6709 n1_m1_374400_4800 0 1.534938e-07
I6710 n1_m1_374400_9600 0 2.726429e-07
I6711 n1_m1_374400_14400 0 1.976938e-07
I6712 n1_m1_374400_19200 0 5.638527e-07
I6713 n1_m1_374400_24000 0 1.927359e-06
I6714 n1_m1_374400_28800 0 1.297616e-06
I6715 n1_m1_374400_33600 0 1.337131e-06
I6716 n1_m1_374400_38400 0 1.083651e-06
I6717 n1_m1_374400_43200 0 1.106502e-06
I6718 n1_m1_374400_48000 0 8.249418e-07
I6719 n1_m1_374400_52800 0 1.995325e-07
I6720 n1_m1_374400_57600 0 2.701109e-07
I6721 n1_m1_374400_62400 0 1.700134e-07
I6722 n1_m1_374400_67200 0 1.665524e-07
I6723 n1_m1_374400_72000 0 2.506851e-07
I6724 n1_m1_374400_76800 0 2.391361e-07
I6725 n1_m1_374400_81600 0 7.504078e-07
I6726 n1_m1_374400_86400 0 6.291842e-07
I6727 n1_m1_374400_91200 0 3.915328e-07
I6728 n1_m1_374400_96000 0 4.109488e-07
I6729 n1_m1_374400_100800 0 1.888352e-07
I6730 n1_m1_374400_105600 0 2.637320e-07
I6731 n1_m1_374400_110400 0 2.843204e-07
I6732 n1_m1_374400_115200 0 6.822403e-07
I6733 n1_m1_374400_120000 0 7.192866e-07
I6734 n1_m1_374400_124800 0 2.068929e-07
I6735 n1_m1_374400_129600 0 3.884576e-07
I6736 n1_m1_374400_134400 0 1.019964e-06
I6737 n1_m1_374400_139200 0 1.226692e-06
I6738 n1_m1_374400_144000 0 1.254610e-06
I6739 n1_m1_374400_148800 0 2.939537e-07
I6740 n1_m1_374400_153600 0 3.019160e-07
I6741 n1_m1_374400_158400 0 1.965007e-07
I6742 n1_m1_374400_163200 0 1.871860e-07
I6743 n1_m1_374400_168000 0 2.610175e-07
I6744 n1_m1_374400_172800 0 1.835313e-07
I6745 n1_m1_374400_177600 0 4.256490e-07
I6746 n1_m1_374400_182400 0 2.805537e-07
I6747 n1_m1_374400_187200 0 2.510451e-07
I6748 n1_m1_374400_192000 0 3.926220e-07
I6749 n1_m1_374400_196800 0 1.937725e-07
I6750 n1_m1_374400_201600 0 2.648566e-07
I6751 n1_m1_374400_206400 0 1.870166e-07
I6752 n1_m1_374400_211200 0 2.669766e-07
I6753 n1_m1_374400_216000 0 8.223146e-07
I6754 n1_m1_374400_220800 0 4.416299e-07
I6755 n1_m1_374400_225600 0 6.059166e-07
I6756 n1_m1_374400_230400 0 1.954501e-07
I6757 n1_m1_374400_235200 0 1.843837e-07
I6758 n1_m1_374400_240000 0 2.737005e-07
I6759 n1_m1_374400_244800 0 1.737151e-07
I6760 n1_m1_374400_249600 0 2.594766e-07
I6761 n1_m1_374400_254400 0 1.717927e-07
I6762 n1_m1_374400_259200 0 1.727463e-07
I6763 n1_m1_374400_264000 0 2.589638e-07
I6764 n1_m1_374400_268800 0 1.725564e-07
I6765 n1_m1_374400_273600 0 2.588345e-07
I6766 n1_m1_374400_278400 0 1.688850e-07
I6767 n1_m1_374400_283200 0 1.707544e-07
I6768 n1_m1_374400_288000 0 2.660251e-07
I6769 n1_m1_374400_292800 0 1.818790e-07
I6770 n1_m1_374400_297600 0 2.758235e-07
I6771 n1_m1_374400_302400 0 2.463929e-07
I6772 n1_m1_374400_307200 0 5.923560e-07
I6773 n1_m1_374400_312000 0 1.246462e-06
I6774 n1_m1_374400_316800 0 4.801273e-07
I6775 n1_m1_374400_321600 0 3.113123e-07
I6776 n1_m1_374400_326400 0 1.812701e-07
I6777 n1_m1_374400_331200 0 1.851917e-07
I6778 n1_m1_374400_336000 0 2.597507e-07
I6779 n1_m1_374400_340800 0 1.690990e-07
I6780 n1_m1_374400_345600 0 2.611378e-07
I6781 n1_m1_374400_350400 0 1.697735e-07
I6782 n1_m1_374400_355200 0 1.777419e-07
I6783 n1_m1_374400_360000 0 2.664919e-07
I6784 n1_m1_374400_364800 0 1.843617e-07
I6785 n1_m1_374400_369600 0 5.160029e-07
I6786 n1_m1_374400_374400 0 3.934038e-07
I6787 n1_m1_374400_379200 0 3.794541e-07
I6788 n1_m1_374400_384000 0 6.424115e-07
I6789 n1_m1_374400_388800 0 5.588505e-07
I6790 n1_m1_374400_393600 0 4.117981e-07
I6791 n1_m1_374400_398400 0 1.617059e-07
I6792 n1_m1_374400_403200 0 1.538768e-07
I6793 n1_m1_374400_408000 0 1.597787e-07
I6794 n1_m1_379200_0 0 1.638723e-07
I6795 n1_m1_379200_4800 0 1.545792e-07
I6796 n1_m1_379200_9600 0 2.520476e-07
I6797 n1_m1_379200_14400 0 1.779026e-07
I6798 n1_m1_379200_19200 0 3.291610e-07
I6799 n1_m1_379200_24000 0 1.113549e-06
I6800 n1_m1_379200_28800 0 5.990769e-07
I6801 n1_m1_379200_33600 0 6.096106e-07
I6802 n1_m1_379200_38400 0 5.313300e-07
I6803 n1_m1_379200_43200 0 5.325538e-07
I6804 n1_m1_379200_48000 0 4.061405e-07
I6805 n1_m1_379200_52800 0 1.779482e-07
I6806 n1_m1_379200_57600 0 2.585527e-07
I6807 n1_m1_379200_62400 0 1.692410e-07
I6808 n1_m1_379200_67200 0 1.665524e-07
I6809 n1_m1_379200_72000 0 2.498285e-07
I6810 n1_m1_379200_76800 0 1.835230e-07
I6811 n1_m1_379200_81600 0 6.432546e-07
I6812 n1_m1_379200_86400 0 5.711515e-07
I6813 n1_m1_379200_91200 0 3.629863e-07
I6814 n1_m1_379200_96000 0 4.102568e-07
I6815 n1_m1_379200_100800 0 1.842683e-07
I6816 n1_m1_379200_105600 0 2.636896e-07
I6817 n1_m1_379200_110400 0 1.873404e-07
I6818 n1_m1_379200_115200 0 3.091842e-07
I6819 n1_m1_379200_120000 0 3.388578e-07
I6820 n1_m1_379200_124800 0 1.841696e-07
I6821 n1_m1_379200_129600 0 2.809671e-07
I6822 n1_m1_379200_134400 0 3.934417e-07
I6823 n1_m1_379200_139200 0 4.115283e-07
I6824 n1_m1_379200_144000 0 4.534893e-07
I6825 n1_m1_379200_148800 0 1.778189e-07
I6826 n1_m1_379200_153600 0 2.805438e-07
I6827 n1_m1_379200_158400 0 3.042925e-07
I6828 n1_m1_379200_163200 0 2.888112e-07
I6829 n1_m1_379200_168000 0 2.743199e-07
I6830 n1_m1_379200_172800 0 1.731495e-07
I6831 n1_m1_379200_177600 0 3.473825e-07
I6832 n1_m1_379200_182400 0 3.706658e-07
I6833 n1_m1_379200_187200 0 4.663673e-07
I6834 n1_m1_379200_192000 0 4.158550e-07
I6835 n1_m1_379200_196800 0 1.744061e-07
I6836 n1_m1_379200_201600 0 2.879948e-07
I6837 n1_m1_379200_206400 0 2.201860e-07
I6838 n1_m1_379200_211200 0 1.825268e-07
I6839 n1_m1_379200_216000 0 6.748301e-07
I6840 n1_m1_379200_220800 0 9.381887e-07
I6841 n1_m1_379200_225600 0 1.317199e-06
I6842 n1_m1_379200_230400 0 2.929415e-07
I6843 n1_m1_379200_235200 0 2.002973e-07
I6844 n1_m1_379200_240000 0 3.011525e-07
I6845 n1_m1_379200_244800 0 1.765276e-07
I6846 n1_m1_379200_249600 0 2.598217e-07
I6847 n1_m1_379200_254400 0 1.732144e-07
I6848 n1_m1_379200_259200 0 1.732144e-07
I6849 n1_m1_379200_264000 0 2.527184e-07
I6850 n1_m1_379200_268800 0 1.686322e-07
I6851 n1_m1_379200_273600 0 2.529483e-07
I6852 n1_m1_379200_278400 0 1.683257e-07
I6853 n1_m1_379200_283200 0 1.692028e-07
I6854 n1_m1_379200_288000 0 2.524946e-07
I6855 n1_m1_379200_292800 0 1.835219e-07
I6856 n1_m1_379200_297600 0 2.798234e-07
I6857 n1_m1_379200_302400 0 1.788973e-07
I6858 n1_m1_379200_307200 0 3.668767e-07
I6859 n1_m1_379200_312000 0 7.409157e-07
I6860 n1_m1_379200_316800 0 2.904313e-07
I6861 n1_m1_379200_321600 0 2.845961e-07
I6862 n1_m1_379200_326400 0 2.860421e-07
I6863 n1_m1_379200_331200 0 3.553784e-07
I6864 n1_m1_379200_336000 0 2.663429e-07
I6865 n1_m1_379200_340800 0 1.989782e-07
I6866 n1_m1_379200_345600 0 3.457062e-07
I6867 n1_m1_379200_350400 0 1.778854e-07
I6868 n1_m1_379200_355200 0 1.772537e-07
I6869 n1_m1_379200_360000 0 2.680450e-07
I6870 n1_m1_379200_364800 0 1.955182e-07
I6871 n1_m1_379200_369600 0 8.262465e-07
I6872 n1_m1_379200_374400 0 6.491346e-07
I6873 n1_m1_379200_379200 0 4.041748e-07
I6874 n1_m1_379200_384000 0 3.451220e-07
I6875 n1_m1_379200_388800 0 3.561025e-07
I6876 n1_m1_379200_393600 0 3.524783e-07
I6877 n1_m1_379200_398400 0 1.617146e-07
I6878 n1_m1_379200_403200 0 1.514655e-07
I6879 n1_m1_379200_408000 0 1.557651e-07
I6880 n1_m1_384000_0 0 2.322568e-07
I6881 n1_m1_384000_4800 0 2.301820e-07
I6882 n1_m1_384000_9600 0 3.632956e-07
I6883 n1_m1_384000_14400 0 2.893232e-07
I6884 n1_m1_384000_19200 0 2.875847e-07
I6885 n1_m1_384000_24000 0 4.194664e-07
I6886 n1_m1_384000_28800 0 2.695360e-07
I6887 n1_m1_384000_33600 0 5.001244e-07
I6888 n1_m1_384000_38400 0 3.643380e-07
I6889 n1_m1_384000_43200 0 2.963556e-07
I6890 n1_m1_384000_48000 0 4.357018e-07
I6891 n1_m1_384000_52800 0 2.700320e-07
I6892 n1_m1_384000_57600 0 3.771751e-07
I6893 n1_m1_384000_62400 0 2.526964e-07
I6894 n1_m1_384000_67200 0 2.512327e-07
I6895 n1_m1_384000_72000 0 3.747428e-07
I6896 n1_m1_384000_76800 0 2.550845e-07
I6897 n1_m1_384000_81600 0 4.026442e-07
I6898 n1_m1_384000_86400 0 2.753275e-07
I6899 n1_m1_384000_91200 0 2.686766e-07
I6900 n1_m1_384000_96000 0 4.078550e-07
I6901 n1_m1_384000_100800 0 2.544198e-07
I6902 n1_m1_384000_105600 0 3.893046e-07
I6903 n1_m1_384000_110400 0 2.612340e-07
I6904 n1_m1_384000_115200 0 2.772669e-07
I6905 n1_m1_384000_120000 0 3.907470e-07
I6906 n1_m1_384000_124800 0 2.578319e-07
I6907 n1_m1_384000_129600 0 3.838603e-07
I6908 n1_m1_384000_134400 0 2.833102e-07
I6909 n1_m1_384000_139200 0 2.747669e-07
I6910 n1_m1_384000_144000 0 3.958211e-07
I6911 n1_m1_384000_148800 0 2.587684e-07
I6912 n1_m1_384000_153600 0 5.007198e-07
I6913 n1_m1_384000_158400 0 9.591633e-07
I6914 n1_m1_384000_163200 0 8.624820e-07
I6915 n1_m1_384000_168000 0 4.991246e-07
I6916 n1_m1_384000_172800 0 2.682615e-07
I6917 n1_m1_384000_177600 0 3.918397e-07
I6918 n1_m1_384000_182400 0 2.608745e-07
I6919 n1_m1_384000_187200 0 2.685901e-07
I6920 n1_m1_384000_192000 0 4.031370e-07
I6921 n1_m1_384000_196800 0 2.693633e-07
I6922 n1_m1_384000_201600 0 3.977141e-07
I6923 n1_m1_384000_206400 0 2.661294e-07
I6924 n1_m1_384000_211200 0 2.757909e-07
I6925 n1_m1_384000_216000 0 1.421804e-06
I6926 n1_m1_384000_220800 0 2.067163e-06
I6927 n1_m1_384000_225600 0 2.948705e-06
I6928 n1_m1_384000_230400 0 1.177601e-06
I6929 n1_m1_384000_235200 0 6.245248e-07
I6930 n1_m1_384000_240000 0 4.627044e-07
I6931 n1_m1_384000_244800 0 2.676773e-07
I6932 n1_m1_384000_249600 0 4.004406e-07
I6933 n1_m1_384000_254400 0 2.800858e-07
I6934 n1_m1_384000_259200 0 2.646395e-07
I6935 n1_m1_384000_264000 0 3.835472e-07
I6936 n1_m1_384000_268800 0 2.542480e-07
I6937 n1_m1_384000_273600 0 3.857283e-07
I6938 n1_m1_384000_278400 0 2.547380e-07
I6939 n1_m1_384000_283200 0 2.574991e-07
I6940 n1_m1_384000_288000 0 3.791559e-07
I6941 n1_m1_384000_292800 0 2.666073e-07
I6942 n1_m1_384000_297600 0 4.233467e-07
I6943 n1_m1_384000_302400 0 2.583588e-07
I6944 n1_m1_384000_307200 0 2.642747e-07
I6945 n1_m1_384000_312000 0 3.970828e-07
I6946 n1_m1_384000_316800 0 2.650864e-07
I6947 n1_m1_384000_321600 0 4.636868e-07
I6948 n1_m1_384000_326400 0 6.880014e-07
I6949 n1_m1_384000_331200 0 8.476660e-07
I6950 n1_m1_384000_336000 0 4.120145e-07
I6951 n1_m1_384000_340800 0 3.632103e-07
I6952 n1_m1_384000_345600 0 8.904404e-07
I6953 n1_m1_384000_350400 0 5.342177e-07
I6954 n1_m1_384000_355200 0 4.023749e-07
I6955 n1_m1_384000_360000 0 4.366364e-07
I6956 n1_m1_384000_364800 0 3.016536e-07
I6957 n1_m1_384000_369600 0 1.972662e-06
I6958 n1_m1_384000_374400 0 1.652014e-06
I6959 n1_m1_384000_379200 0 8.457793e-07
I6960 n1_m1_384000_384000 0 6.885948e-07
I6961 n1_m1_384000_388800 0 3.322047e-07
I6962 n1_m1_384000_393600 0 3.688868e-07
I6963 n1_m1_384000_398400 0 2.407276e-07
I6964 n1_m1_384000_403200 0 2.351055e-07
I6965 n1_m1_384000_408000 0 2.265285e-07
I6966 n1_m1_388800_0 0 1.710364e-07
I6967 n1_m1_388800_4800 0 1.624154e-07
I6968 n1_m1_388800_9600 0 2.480394e-07
I6969 n1_m1_388800_14400 0 1.923873e-07
I6970 n1_m1_388800_19200 0 1.874669e-07
I6971 n1_m1_388800_24000 0 2.692313e-07
I6972 n1_m1_388800_28800 0 1.932626e-07
I6973 n1_m1_388800_33600 0 6.085818e-07
I6974 n1_m1_388800_38400 0 5.030221e-07
I6975 n1_m1_388800_43200 0 3.288988e-07
I6976 n1_m1_388800_48000 0 4.024734e-07
I6977 n1_m1_388800_52800 0 2.564550e-07
I6978 n1_m1_388800_57600 0 2.678288e-07
I6979 n1_m1_388800_62400 0 1.690227e-07
I6980 n1_m1_388800_67200 0 1.666068e-07
I6981 n1_m1_388800_72000 0 2.509690e-07
I6982 n1_m1_388800_76800 0 1.708285e-07
I6983 n1_m1_388800_81600 0 2.631168e-07
I6984 n1_m1_388800_86400 0 1.773031e-07
I6985 n1_m1_388800_91200 0 1.717003e-07
I6986 n1_m1_388800_96000 0 2.495900e-07
I6987 n1_m1_388800_100800 0 1.741350e-07
I6988 n1_m1_388800_105600 0 2.644638e-07
I6989 n1_m1_388800_110400 0 1.676211e-07
I6990 n1_m1_388800_115200 0 1.686830e-07
I6991 n1_m1_388800_120000 0 2.851404e-07
I6992 n1_m1_388800_124800 0 2.418903e-07
I6993 n1_m1_388800_129600 0 2.926166e-07
I6994 n1_m1_388800_134400 0 1.718562e-07
I6995 n1_m1_388800_139200 0 1.837457e-07
I6996 n1_m1_388800_144000 0 2.756361e-07
I6997 n1_m1_388800_148800 0 1.753465e-07
I6998 n1_m1_388800_153600 0 3.114864e-07
I6999 n1_m1_388800_158400 0 5.292409e-07
I7000 n1_m1_388800_163200 0 4.289078e-07
I7001 n1_m1_388800_168000 0 2.999243e-07
I7002 n1_m1_388800_172800 0 1.793769e-07
I7003 n1_m1_388800_177600 0 2.578369e-07
I7004 n1_m1_388800_182400 0 1.715638e-07
I7005 n1_m1_388800_187200 0 1.731013e-07
I7006 n1_m1_388800_192000 0 2.673178e-07
I7007 n1_m1_388800_196800 0 1.892710e-07
I7008 n1_m1_388800_201600 0 2.967323e-07
I7009 n1_m1_388800_206400 0 1.802997e-07
I7010 n1_m1_388800_211200 0 1.819914e-07
I7011 n1_m1_388800_216000 0 7.605707e-07
I7012 n1_m1_388800_220800 0 1.263287e-06
I7013 n1_m1_388800_225600 0 2.095179e-06
I7014 n1_m1_388800_230400 0 1.196112e-06
I7015 n1_m1_388800_235200 0 9.583164e-07
I7016 n1_m1_388800_240000 0 6.840267e-07
I7017 n1_m1_388800_244800 0 1.788798e-07
I7018 n1_m1_388800_249600 0 2.860186e-07
I7019 n1_m1_388800_254400 0 1.934689e-07
I7020 n1_m1_388800_259200 0 1.734013e-07
I7021 n1_m1_388800_264000 0 2.527535e-07
I7022 n1_m1_388800_268800 0 1.671002e-07
I7023 n1_m1_388800_273600 0 2.677434e-07
I7024 n1_m1_388800_278400 0 1.741467e-07
I7025 n1_m1_388800_283200 0 1.701265e-07
I7026 n1_m1_388800_288000 0 2.551702e-07
I7027 n1_m1_388800_292800 0 1.872204e-07
I7028 n1_m1_388800_297600 0 3.209776e-07
I7029 n1_m1_388800_302400 0 1.796919e-07
I7030 n1_m1_388800_307200 0 1.676598e-07
I7031 n1_m1_388800_312000 0 2.590906e-07
I7032 n1_m1_388800_316800 0 1.785998e-07
I7033 n1_m1_388800_321600 0 2.519408e-07
I7034 n1_m1_388800_326400 0 1.769424e-07
I7035 n1_m1_388800_331200 0 1.841953e-07
I7036 n1_m1_388800_336000 0 2.561894e-07
I7037 n1_m1_388800_340800 0 1.744252e-07
I7038 n1_m1_388800_345600 0 2.991807e-07
I7039 n1_m1_388800_350400 0 2.056970e-07
I7040 n1_m1_388800_355200 0 1.760897e-07
I7041 n1_m1_388800_360000 0 2.538491e-07
I7042 n1_m1_388800_364800 0 1.722623e-07
I7043 n1_m1_388800_369600 0 3.985419e-07
I7044 n1_m1_388800_374400 0 3.117412e-07
I7045 n1_m1_388800_379200 0 2.248050e-07
I7046 n1_m1_388800_384000 0 3.367259e-07
I7047 n1_m1_388800_388800 0 1.791584e-07
I7048 n1_m1_388800_393600 0 2.408599e-07
I7049 n1_m1_388800_398400 0 1.551473e-07
I7050 n1_m1_388800_403200 0 1.538213e-07
I7051 n1_m1_388800_408000 0 1.512066e-07
I7052 n1_m1_393600_0 0 1.721644e-07
I7053 n1_m1_393600_4800 0 1.623926e-07
I7054 n1_m1_393600_9600 0 2.340793e-07
I7055 n1_m1_393600_14400 0 1.764480e-07
I7056 n1_m1_393600_19200 0 1.724943e-07
I7057 n1_m1_393600_24000 0 2.581805e-07
I7058 n1_m1_393600_28800 0 1.840860e-07
I7059 n1_m1_393600_33600 0 3.674069e-07
I7060 n1_m1_393600_38400 0 2.689581e-07
I7061 n1_m1_393600_43200 0 2.410221e-07
I7062 n1_m1_393600_48000 0 5.498654e-07
I7063 n1_m1_393600_52800 0 2.678352e-07
I7064 n1_m1_393600_57600 0 2.618634e-07
I7065 n1_m1_393600_62400 0 1.648049e-07
I7066 n1_m1_393600_67200 0 1.666221e-07
I7067 n1_m1_393600_72000 0 2.603517e-07
I7068 n1_m1_393600_76800 0 1.675944e-07
I7069 n1_m1_393600_81600 0 2.564445e-07
I7070 n1_m1_393600_86400 0 1.727345e-07
I7071 n1_m1_393600_91200 0 1.682234e-07
I7072 n1_m1_393600_96000 0 2.429380e-07
I7073 n1_m1_393600_100800 0 1.699778e-07
I7074 n1_m1_393600_105600 0 2.594022e-07
I7075 n1_m1_393600_110400 0 1.696559e-07
I7076 n1_m1_393600_115200 0 1.763835e-07
I7077 n1_m1_393600_120000 0 4.469213e-07
I7078 n1_m1_393600_124800 0 4.860164e-07
I7079 n1_m1_393600_129600 0 4.564540e-07
I7080 n1_m1_393600_134400 0 1.754015e-07
I7081 n1_m1_393600_139200 0 1.712355e-07
I7082 n1_m1_393600_144000 0 2.590603e-07
I7083 n1_m1_393600_148800 0 1.754081e-07
I7084 n1_m1_393600_153600 0 2.805728e-07
I7085 n1_m1_393600_158400 0 2.463532e-07
I7086 n1_m1_393600_163200 0 2.189184e-07
I7087 n1_m1_393600_168000 0 2.687659e-07
I7088 n1_m1_393600_172800 0 1.745495e-07
I7089 n1_m1_393600_177600 0 2.590377e-07
I7090 n1_m1_393600_182400 0 1.675941e-07
I7091 n1_m1_393600_187200 0 1.705029e-07
I7092 n1_m1_393600_192000 0 2.641864e-07
I7093 n1_m1_393600_196800 0 1.925974e-07
I7094 n1_m1_393600_201600 0 3.422733e-07
I7095 n1_m1_393600_206400 0 1.790032e-07
I7096 n1_m1_393600_211200 0 1.865182e-07
I7097 n1_m1_393600_216000 0 3.427156e-07
I7098 n1_m1_393600_220800 0 7.620024e-07
I7099 n1_m1_393600_225600 0 1.769874e-06
I7100 n1_m1_393600_230400 0 1.236845e-06
I7101 n1_m1_393600_235200 0 1.234083e-06
I7102 n1_m1_393600_240000 0 1.022636e-06
I7103 n1_m1_393600_244800 0 1.749419e-07
I7104 n1_m1_393600_249600 0 2.748380e-07
I7105 n1_m1_393600_254400 0 1.799040e-07
I7106 n1_m1_393600_259200 0 1.799415e-07
I7107 n1_m1_393600_264000 0 2.600744e-07
I7108 n1_m1_393600_268800 0 1.674240e-07
I7109 n1_m1_393600_273600 0 2.835808e-07
I7110 n1_m1_393600_278400 0 1.888396e-07
I7111 n1_m1_393600_283200 0 1.651760e-07
I7112 n1_m1_393600_288000 0 2.465316e-07
I7113 n1_m1_393600_292800 0 1.760560e-07
I7114 n1_m1_393600_297600 0 2.766211e-07
I7115 n1_m1_393600_302400 0 1.771630e-07
I7116 n1_m1_393600_307200 0 1.666793e-07
I7117 n1_m1_393600_312000 0 2.552629e-07
I7118 n1_m1_393600_316800 0 1.728691e-07
I7119 n1_m1_393600_321600 0 2.486217e-07
I7120 n1_m1_393600_326400 0 1.662810e-07
I7121 n1_m1_393600_331200 0 1.704514e-07
I7122 n1_m1_393600_336000 0 2.587086e-07
I7123 n1_m1_393600_340800 0 1.676519e-07
I7124 n1_m1_393600_345600 0 2.555434e-07
I7125 n1_m1_393600_350400 0 1.745353e-07
I7126 n1_m1_393600_355200 0 1.745038e-07
I7127 n1_m1_393600_360000 0 2.519681e-07
I7128 n1_m1_393600_364800 0 1.730541e-07
I7129 n1_m1_393600_369600 0 2.638506e-07
I7130 n1_m1_393600_374400 0 3.752773e-07
I7131 n1_m1_393600_379200 0 4.104339e-07
I7132 n1_m1_393600_384000 0 2.924233e-07
I7133 n1_m1_393600_388800 0 1.690711e-07
I7134 n1_m1_393600_393600 0 2.443331e-07
I7135 n1_m1_393600_398400 0 1.519566e-07
I7136 n1_m1_393600_403200 0 1.477970e-07
I7137 n1_m1_393600_408000 0 1.465661e-07
I7138 n1_m1_398400_0 0 1.606603e-07
I7139 n1_m1_398400_4800 0 1.507421e-07
I7140 n1_m1_398400_9600 0 2.175146e-07
I7141 n1_m1_398400_14400 0 1.527611e-07
I7142 n1_m1_398400_19200 0 1.566560e-07
I7143 n1_m1_398400_24000 0 2.319465e-07
I7144 n1_m1_398400_28800 0 1.536280e-07
I7145 n1_m1_398400_33600 0 2.419627e-07
I7146 n1_m1_398400_38400 0 1.577802e-07
I7147 n1_m1_398400_43200 0 1.573717e-07
I7148 n1_m1_398400_48000 0 2.517033e-07
I7149 n1_m1_398400_52800 0 1.659186e-07
I7150 n1_m1_398400_57600 0 2.311771e-07
I7151 n1_m1_398400_62400 0 1.618812e-07
I7152 n1_m1_398400_67200 0 1.593993e-07
I7153 n1_m1_398400_72000 0 2.440767e-07
I7154 n1_m1_398400_76800 0 1.598261e-07
I7155 n1_m1_398400_81600 0 2.499721e-07
I7156 n1_m1_398400_86400 0 1.659448e-07
I7157 n1_m1_398400_91200 0 1.566793e-07
I7158 n1_m1_398400_96000 0 2.338645e-07
I7159 n1_m1_398400_100800 0 1.619539e-07
I7160 n1_m1_398400_105600 0 2.560438e-07
I7161 n1_m1_398400_110400 0 1.706958e-07
I7162 n1_m1_398400_115200 0 1.706621e-07
I7163 n1_m1_398400_120000 0 2.727150e-07
I7164 n1_m1_398400_124800 0 2.568866e-07
I7165 n1_m1_398400_129600 0 4.606134e-07
I7166 n1_m1_398400_134400 0 1.840423e-07
I7167 n1_m1_398400_139200 0 1.706958e-07
I7168 n1_m1_398400_144000 0 2.573518e-07
I7169 n1_m1_398400_148800 0 1.795516e-07
I7170 n1_m1_398400_153600 0 2.633524e-07
I7171 n1_m1_398400_158400 0 1.670398e-07
I7172 n1_m1_398400_163200 0 1.724435e-07
I7173 n1_m1_398400_168000 0 2.569345e-07
I7174 n1_m1_398400_172800 0 1.624774e-07
I7175 n1_m1_398400_177600 0 2.484095e-07
I7176 n1_m1_398400_182400 0 1.664111e-07
I7177 n1_m1_398400_187200 0 1.682847e-07
I7178 n1_m1_398400_192000 0 2.474574e-07
I7179 n1_m1_398400_196800 0 1.661299e-07
I7180 n1_m1_398400_201600 0 2.758622e-07
I7181 n1_m1_398400_206400 0 1.955515e-07
I7182 n1_m1_398400_211200 0 1.689697e-07
I7183 n1_m1_398400_216000 0 2.679876e-07
I7184 n1_m1_398400_220800 0 1.828880e-07
I7185 n1_m1_398400_225600 0 5.232402e-07
I7186 n1_m1_398400_230400 0 4.990549e-07
I7187 n1_m1_398400_235200 0 4.810684e-07
I7188 n1_m1_398400_240000 0 4.295855e-07
I7189 n1_m1_398400_244800 0 1.724154e-07
I7190 n1_m1_398400_249600 0 2.668961e-07
I7191 n1_m1_398400_254400 0 1.990763e-07
I7192 n1_m1_398400_259200 0 2.429059e-07
I7193 n1_m1_398400_264000 0 2.832825e-07
I7194 n1_m1_398400_268800 0 1.631316e-07
I7195 n1_m1_398400_273600 0 2.511441e-07
I7196 n1_m1_398400_278400 0 1.684629e-07
I7197 n1_m1_398400_283200 0 1.699096e-07
I7198 n1_m1_398400_288000 0 2.545633e-07
I7199 n1_m1_398400_292800 0 1.719338e-07
I7200 n1_m1_398400_297600 0 2.697414e-07
I7201 n1_m1_398400_302400 0 1.840200e-07
I7202 n1_m1_398400_307200 0 1.959603e-07
I7203 n1_m1_398400_312000 0 2.688205e-07
I7204 n1_m1_398400_316800 0 1.624755e-07
I7205 n1_m1_398400_321600 0 2.307928e-07
I7206 n1_m1_398400_326400 0 1.545182e-07
I7207 n1_m1_398400_331200 0 1.544785e-07
I7208 n1_m1_398400_336000 0 2.294215e-07
I7209 n1_m1_398400_340800 0 1.507618e-07
I7210 n1_m1_398400_345600 0 2.285286e-07
I7211 n1_m1_398400_350400 0 1.651203e-07
I7212 n1_m1_398400_355200 0 1.802851e-07
I7213 n1_m1_398400_360000 0 2.457791e-07
I7214 n1_m1_398400_364800 0 1.702144e-07
I7215 n1_m1_398400_369600 0 2.434807e-07
I7216 n1_m1_398400_374400 0 4.488838e-07
I7217 n1_m1_398400_379200 0 7.239761e-07
I7218 n1_m1_398400_384000 0 4.742543e-07
I7219 n1_m1_398400_388800 0 1.747938e-07
I7220 n1_m1_398400_393600 0 2.450142e-07
I7221 n1_m1_398400_398400 0 1.424810e-07
I7222 n1_m1_398400_403200 0 1.440800e-07
I7223 n1_m1_398400_408000 0 1.511483e-07
I7224 n1_m1_403200_0 0 1.507621e-07
I7225 n1_m1_403200_4800 0 1.481244e-07
I7226 n1_m1_403200_9600 0 2.198491e-07
I7227 n1_m1_403200_14400 0 1.465661e-07
I7228 n1_m1_403200_19200 0 1.513352e-07
I7229 n1_m1_403200_24000 0 2.334619e-07
I7230 n1_m1_403200_28800 0 1.576309e-07
I7231 n1_m1_403200_33600 0 2.336747e-07
I7232 n1_m1_403200_38400 0 1.542578e-07
I7233 n1_m1_403200_43200 0 1.572463e-07
I7234 n1_m1_403200_48000 0 2.380363e-07
I7235 n1_m1_403200_52800 0 1.632724e-07
I7236 n1_m1_403200_57600 0 2.277286e-07
I7237 n1_m1_403200_62400 0 1.598903e-07
I7238 n1_m1_403200_67200 0 1.551699e-07
I7239 n1_m1_403200_72000 0 2.273265e-07
I7240 n1_m1_403200_76800 0 1.499377e-07
I7241 n1_m1_403200_81600 0 2.404409e-07
I7242 n1_m1_403200_86400 0 1.610711e-07
I7243 n1_m1_403200_91200 0 1.525257e-07
I7244 n1_m1_403200_96000 0 2.276320e-07
I7245 n1_m1_403200_100800 0 1.549381e-07
I7246 n1_m1_403200_105600 0 2.395108e-07
I7247 n1_m1_403200_110400 0 1.665524e-07
I7248 n1_m1_403200_115200 0 1.665190e-07
I7249 n1_m1_403200_120000 0 2.519103e-07
I7250 n1_m1_403200_124800 0 1.797053e-07
I7251 n1_m1_403200_129600 0 2.740708e-07
I7252 n1_m1_403200_134400 0 1.632556e-07
I7253 n1_m1_403200_139200 0 1.634611e-07
I7254 n1_m1_403200_144000 0 2.463240e-07
I7255 n1_m1_403200_148800 0 1.670561e-07
I7256 n1_m1_403200_153600 0 2.523614e-07
I7257 n1_m1_403200_158400 0 1.674797e-07
I7258 n1_m1_403200_163200 0 1.682775e-07
I7259 n1_m1_403200_168000 0 2.483142e-07
I7260 n1_m1_403200_172800 0 1.596102e-07
I7261 n1_m1_403200_177600 0 2.341152e-07
I7262 n1_m1_403200_182400 0 1.654096e-07
I7263 n1_m1_403200_187200 0 1.711346e-07
I7264 n1_m1_403200_192000 0 2.427670e-07
I7265 n1_m1_403200_196800 0 1.578104e-07
I7266 n1_m1_403200_201600 0 2.558447e-07
I7267 n1_m1_403200_206400 0 1.796622e-07
I7268 n1_m1_403200_211200 0 1.619864e-07
I7269 n1_m1_403200_216000 0 2.569583e-07
I7270 n1_m1_403200_220800 0 1.735841e-07
I7271 n1_m1_403200_225600 0 3.040200e-07
I7272 n1_m1_403200_230400 0 2.407672e-07
I7273 n1_m1_403200_235200 0 2.086984e-07
I7274 n1_m1_403200_240000 0 2.688462e-07
I7275 n1_m1_403200_244800 0 1.765590e-07
I7276 n1_m1_403200_249600 0 2.529543e-07
I7277 n1_m1_403200_254400 0 1.767065e-07
I7278 n1_m1_403200_259200 0 1.984206e-07
I7279 n1_m1_403200_264000 0 2.665784e-07
I7280 n1_m1_403200_268800 0 1.574448e-07
I7281 n1_m1_403200_273600 0 2.363520e-07
I7282 n1_m1_403200_278400 0 1.596986e-07
I7283 n1_m1_403200_283200 0 1.577349e-07
I7284 n1_m1_403200_288000 0 2.365675e-07
I7285 n1_m1_403200_292800 0 1.623203e-07
I7286 n1_m1_403200_297600 0 2.520221e-07
I7287 n1_m1_403200_302400 0 1.757005e-07
I7288 n1_m1_403200_307200 0 1.658498e-07
I7289 n1_m1_403200_312000 0 2.378069e-07
I7290 n1_m1_403200_316800 0 1.593268e-07
I7291 n1_m1_403200_321600 0 2.364610e-07
I7292 n1_m1_403200_326400 0 1.521151e-07
I7293 n1_m1_403200_331200 0 1.522776e-07
I7294 n1_m1_403200_336000 0 2.319427e-07
I7295 n1_m1_403200_340800 0 1.507936e-07
I7296 n1_m1_403200_345600 0 2.276324e-07
I7297 n1_m1_403200_350400 0 1.593567e-07
I7298 n1_m1_403200_355200 0 1.666498e-07
I7299 n1_m1_403200_360000 0 2.443276e-07
I7300 n1_m1_403200_364800 0 1.443960e-07
I7301 n1_m1_403200_369600 0 2.266185e-07
I7302 n1_m1_403200_374400 0 2.497907e-07
I7303 n1_m1_403200_379200 0 3.046007e-07
I7304 n1_m1_403200_384000 0 2.744020e-07
I7305 n1_m1_403200_388800 0 1.625632e-07
I7306 n1_m1_403200_393600 0 2.281561e-07
I7307 n1_m1_403200_398400 0 1.399040e-07
I7308 n1_m1_403200_403200 0 1.440800e-07
I7309 n1_m1_403200_408000 0 1.482760e-07
I7310 n1_m1_408000_0 0 1.571611e-07
I7311 n1_m1_408000_4800 0 1.603127e-07
I7312 n1_m1_408000_9600 0 2.391894e-07
I7313 n1_m1_408000_14400 0 1.579993e-07
I7314 n1_m1_408000_19200 0 1.619301e-07
I7315 n1_m1_408000_24000 0 2.494695e-07
I7316 n1_m1_408000_28800 0 1.647515e-07
I7317 n1_m1_408000_33600 0 2.439117e-07
I7318 n1_m1_408000_38400 0 1.672309e-07
I7319 n1_m1_408000_43200 0 1.708704e-07
I7320 n1_m1_408000_48000 0 2.435991e-07
I7321 n1_m1_408000_52800 0 1.641637e-07
I7322 n1_m1_408000_57600 0 2.287048e-07
I7323 n1_m1_408000_62400 0 1.620920e-07
I7324 n1_m1_408000_67200 0 1.565055e-07
I7325 n1_m1_408000_72000 0 2.313498e-07
I7326 n1_m1_408000_76800 0 1.493926e-07
I7327 n1_m1_408000_81600 0 2.352700e-07
I7328 n1_m1_408000_86400 0 1.589397e-07
I7329 n1_m1_408000_91200 0 1.517495e-07
I7330 n1_m1_408000_96000 0 2.218681e-07
I7331 n1_m1_408000_100800 0 1.502218e-07
I7332 n1_m1_408000_105600 0 2.359500e-07
I7333 n1_m1_408000_110400 0 1.641048e-07
I7334 n1_m1_408000_115200 0 1.633392e-07
I7335 n1_m1_408000_120000 0 2.468712e-07
I7336 n1_m1_408000_124800 0 1.699080e-07
I7337 n1_m1_408000_129600 0 2.488972e-07
I7338 n1_m1_408000_134400 0 1.688647e-07
I7339 n1_m1_408000_139200 0 1.727466e-07
I7340 n1_m1_408000_144000 0 2.459512e-07
I7341 n1_m1_408000_148800 0 1.620839e-07
I7342 n1_m1_408000_153600 0 2.576617e-07
I7343 n1_m1_408000_158400 0 1.752376e-07
I7344 n1_m1_408000_163200 0 1.665803e-07
I7345 n1_m1_408000_168000 0 2.520507e-07
I7346 n1_m1_408000_172800 0 1.665626e-07
I7347 n1_m1_408000_177600 0 2.254816e-07
I7348 n1_m1_408000_182400 0 1.609564e-07
I7349 n1_m1_408000_187200 0 1.720175e-07
I7350 n1_m1_408000_192000 0 2.448564e-07
I7351 n1_m1_408000_196800 0 1.553243e-07
I7352 n1_m1_408000_201600 0 2.551238e-07
I7353 n1_m1_408000_206400 0 1.986469e-07
I7354 n1_m1_408000_211200 0 2.280933e-07
I7355 n1_m1_408000_216000 0 2.547496e-07
I7356 n1_m1_408000_220800 0 1.654332e-07
I7357 n1_m1_408000_225600 0 2.573406e-07
I7358 n1_m1_408000_230400 0 1.791494e-07
I7359 n1_m1_408000_235200 0 1.813269e-07
I7360 n1_m1_408000_240000 0 2.583350e-07
I7361 n1_m1_408000_244800 0 1.753957e-07
I7362 n1_m1_408000_249600 0 2.624632e-07
I7363 n1_m1_408000_254400 0 1.681452e-07
I7364 n1_m1_408000_259200 0 1.685185e-07
I7365 n1_m1_408000_264000 0 2.501821e-07
I7366 n1_m1_408000_268800 0 1.549587e-07
I7367 n1_m1_408000_273600 0 2.342782e-07
I7368 n1_m1_408000_278400 0 1.596544e-07
I7369 n1_m1_408000_283200 0 1.579651e-07
I7370 n1_m1_408000_288000 0 2.370783e-07
I7371 n1_m1_408000_292800 0 1.598624e-07
I7372 n1_m1_408000_297600 0 2.482930e-07
I7373 n1_m1_408000_302400 0 1.750809e-07
I7374 n1_m1_408000_307200 0 1.767093e-07
I7375 n1_m1_408000_312000 0 2.499034e-07
I7376 n1_m1_408000_316800 0 1.605586e-07
I7377 n1_m1_408000_321600 0 2.398354e-07
I7378 n1_m1_408000_326400 0 1.582390e-07
I7379 n1_m1_408000_331200 0 1.572336e-07
I7380 n1_m1_408000_336000 0 2.277480e-07
I7381 n1_m1_408000_340800 0 1.531332e-07
I7382 n1_m1_408000_345600 0 2.360332e-07
I7383 n1_m1_408000_350400 0 1.626731e-07
I7384 n1_m1_408000_355200 0 1.582851e-07
I7385 n1_m1_408000_360000 0 2.318004e-07
I7386 n1_m1_408000_364800 0 1.576126e-07
I7387 n1_m1_408000_369600 0 2.332978e-07
I7388 n1_m1_408000_374400 0 1.522040e-07
I7389 n1_m1_408000_379200 0 1.750072e-07
I7390 n1_m1_408000_384000 0 2.851666e-07
I7391 n1_m1_408000_388800 0 1.678110e-07
I7392 n1_m1_408000_393600 0 2.364536e-07
I7393 n1_m1_408000_398400 0 1.473361e-07
I7394 n1_m1_408000_403200 0 1.429177e-07
I7395 n1_m1_408000_408000 0 1.388322e-07
I7396 n1_m1_4000_0 0 8.203313e-08
I7397 n1_m1_4000_4800 0 7.849897e-08
I7398 n1_m1_4000_9600 0 1.146732e-07
I7399 n1_m1_4000_14400 0 7.816279e-08
I7400 n1_m1_4000_19200 0 7.749718e-08
I7401 n1_m1_4000_24000 0 1.147742e-07
I7402 n1_m1_4000_28800 0 7.661408e-08
I7403 n1_m1_4000_33600 0 1.147814e-07
I7404 n1_m1_4000_38400 0 7.658114e-08
I7405 n1_m1_4000_43200 0 7.661408e-08
I7406 n1_m1_4000_48000 0 1.173862e-07
I7407 n1_m1_4000_52800 0 7.793867e-08
I7408 n1_m1_4000_57600 0 1.228108e-07
I7409 n1_m1_4000_62400 0 7.875083e-08
I7410 n1_m1_4000_67200 0 7.666342e-08
I7411 n1_m1_4000_72000 0 1.106034e-07
I7412 n1_m1_4000_76800 0 7.816765e-08
I7413 n1_m1_4000_81600 0 1.150561e-07
I7414 n1_m1_4000_86400 0 7.979235e-08
I7415 n1_m1_4000_91200 0 8.126115e-08
I7416 n1_m1_4000_96000 0 1.197748e-07
I7417 n1_m1_4000_100800 0 8.546167e-08
I7418 n1_m1_4000_105600 0 1.240865e-07
I7419 n1_m1_4000_110400 0 8.014824e-08
I7420 n1_m1_4000_115200 0 8.014824e-08
I7421 n1_m1_4000_120000 0 1.202224e-07
I7422 n1_m1_4000_124800 0 8.013313e-08
I7423 n1_m1_4000_129600 0 1.199385e-07
I7424 n1_m1_4000_134400 0 7.977793e-08
I7425 n1_m1_4000_139200 0 7.979478e-08
I7426 n1_m1_4000_144000 0 1.229482e-07
I7427 n1_m1_4000_148800 0 8.320930e-08
I7428 n1_m1_4000_153600 0 1.258001e-07
I7429 n1_m1_4000_158400 0 8.348969e-08
I7430 n1_m1_4000_163200 0 8.012545e-08
I7431 n1_m1_4000_168000 0 1.287372e-07
I7432 n1_m1_4000_172800 0 8.150806e-08
I7433 n1_m1_4000_177600 0 1.203857e-07
I7434 n1_m1_4000_182400 0 8.606863e-08
I7435 n1_m1_4000_187200 0 8.576634e-08
I7436 n1_m1_4000_192000 0 1.221223e-07
I7437 n1_m1_4000_196800 0 8.021215e-08
I7438 n1_m1_4000_201600 0 1.220402e-07
I7439 n1_m1_4000_206400 0 8.376157e-08
I7440 n1_m1_4000_211200 0 8.249513e-08
I7441 n1_m1_4000_216000 0 1.293196e-07
I7442 n1_m1_4000_220800 0 8.408199e-08
I7443 n1_m1_4000_225600 0 1.229179e-07
I7444 n1_m1_4000_230400 0 8.166663e-08
I7445 n1_m1_4000_235200 0 8.542090e-08
I7446 n1_m1_4000_240000 0 1.234566e-07
I7447 n1_m1_4000_244800 0 8.554945e-08
I7448 n1_m1_4000_249600 0 1.224421e-07
I7449 n1_m1_4000_254400 0 8.339359e-08
I7450 n1_m1_4000_259200 0 8.341241e-08
I7451 n1_m1_4000_264000 0 1.227320e-07
I7452 n1_m1_4000_268800 0 8.328683e-08
I7453 n1_m1_4000_273600 0 1.229734e-07
I7454 n1_m1_4000_278400 0 8.468929e-08
I7455 n1_m1_4000_283200 0 9.640062e-08
I7456 n1_m1_4000_288000 0 1.200294e-07
I7457 n1_m1_4000_292800 0 8.418478e-08
I7458 n1_m1_4000_297600 0 1.255198e-07
I7459 n1_m1_4000_302400 0 8.130192e-08
I7460 n1_m1_4000_307200 0 8.327618e-08
I7461 n1_m1_4000_312000 0 1.248068e-07
I7462 n1_m1_4000_316800 0 8.307306e-08
I7463 n1_m1_4000_321600 0 1.225726e-07
I7464 n1_m1_4000_326400 0 7.961326e-08
I7465 n1_m1_4000_331200 0 7.851467e-08
I7466 n1_m1_4000_336000 0 1.246096e-07
I7467 n1_m1_4000_340800 0 8.307306e-08
I7468 n1_m1_4000_345600 0 1.213743e-07
I7469 n1_m1_4000_350400 0 7.974202e-08
I7470 n1_m1_4000_355200 0 7.974202e-08
I7471 n1_m1_4000_360000 0 1.221926e-07
I7472 n1_m1_4000_364800 0 7.734643e-08
I7473 n1_m1_4000_369600 0 1.104242e-07
I7474 n1_m1_4000_374400 0 7.361208e-08
I7475 n1_m1_4000_379200 0 7.701560e-08
I7476 n1_m1_4000_384000 0 1.187280e-07
I7477 n1_m1_4000_388800 0 7.346990e-08
I7478 n1_m1_4000_393600 0 1.093934e-07
I7479 n1_m1_4000_398400 0 7.000153e-08
I7480 n1_m1_4000_403200 0 7.563092e-08
I7481 n1_m1_4000_408000 0 8.773831e-08
I7482 n1_m1_32000_0 0 7.408157e-08
I7483 n1_m1_32000_4800 0 6.995199e-08
I7484 n1_m1_32000_9600 0 1.095955e-07
I7485 n1_m1_32000_14400 0 7.926097e-08
I7486 n1_m1_32000_19200 0 8.556703e-08
I7487 n1_m1_32000_24000 0 1.375437e-07
I7488 n1_m1_32000_28800 0 8.651613e-08
I7489 n1_m1_32000_33600 0 1.261654e-07
I7490 n1_m1_32000_38400 0 8.433521e-08
I7491 n1_m1_32000_43200 0 8.577274e-08
I7492 n1_m1_32000_48000 0 1.257626e-07
I7493 n1_m1_32000_52800 0 8.351212e-08
I7494 n1_m1_32000_57600 0 1.270009e-07
I7495 n1_m1_32000_62400 0 8.393426e-08
I7496 n1_m1_32000_67200 0 8.393426e-08
I7497 n1_m1_32000_72000 0 1.259014e-07
I7498 n1_m1_32000_76800 0 9.584050e-08
I7499 n1_m1_32000_81600 0 5.736599e-07
I7500 n1_m1_32000_86400 0 5.884447e-07
I7501 n1_m1_32000_91200 0 3.757087e-07
I7502 n1_m1_32000_96000 0 1.704698e-07
I7503 n1_m1_32000_100800 0 8.770286e-08
I7504 n1_m1_32000_105600 0 1.282164e-07
I7505 n1_m1_32000_110400 0 8.172440e-08
I7506 n1_m1_32000_115200 0 8.235264e-08
I7507 n1_m1_32000_120000 0 1.799099e-07
I7508 n1_m1_32000_124800 0 2.254214e-07
I7509 n1_m1_32000_129600 0 2.461611e-07
I7510 n1_m1_32000_134400 0 8.631757e-08
I7511 n1_m1_32000_139200 0 8.459407e-08
I7512 n1_m1_32000_144000 0 1.273552e-07
I7513 n1_m1_32000_148800 0 8.546444e-08
I7514 n1_m1_32000_153600 0 1.334778e-07
I7515 n1_m1_32000_158400 0 8.660722e-08
I7516 n1_m1_32000_163200 0 8.660722e-08
I7517 n1_m1_32000_168000 0 1.283788e-07
I7518 n1_m1_32000_172800 0 8.599616e-08
I7519 n1_m1_32000_177600 0 1.395691e-07
I7520 n1_m1_32000_182400 0 5.321423e-07
I7521 n1_m1_32000_187200 0 6.944581e-07
I7522 n1_m1_32000_192000 0 8.126133e-07
I7523 n1_m1_32000_196800 0 1.872518e-07
I7524 n1_m1_32000_201600 0 1.764447e-07
I7525 n1_m1_32000_206400 0 1.229695e-07
I7526 n1_m1_32000_211200 0 8.771634e-08
I7527 n1_m1_32000_216000 0 1.442127e-07
I7528 n1_m1_32000_220800 0 1.414871e-07
I7529 n1_m1_32000_225600 0 2.034329e-07
I7530 n1_m1_32000_230400 0 9.274115e-08
I7531 n1_m1_32000_235200 0 8.950649e-08
I7532 n1_m1_32000_240000 0 1.334949e-07
I7533 n1_m1_32000_244800 0 9.119666e-08
I7534 n1_m1_32000_249600 0 1.337041e-07
I7535 n1_m1_32000_254400 0 8.431467e-08
I7536 n1_m1_32000_259200 0 8.616850e-08
I7537 n1_m1_32000_264000 0 1.282283e-07
I7538 n1_m1_32000_268800 0 8.372881e-08
I7539 n1_m1_32000_273600 0 1.570398e-07
I7540 n1_m1_32000_278400 0 3.262978e-07
I7541 n1_m1_32000_283200 0 4.369256e-07
I7542 n1_m1_32000_288000 0 1.988152e-07
I7543 n1_m1_32000_292800 0 8.751054e-08
I7544 n1_m1_32000_297600 0 1.369426e-07
I7545 n1_m1_32000_302400 0 8.829688e-08
I7546 n1_m1_32000_307200 0 8.611975e-08
I7547 n1_m1_32000_312000 0 2.736385e-07
I7548 n1_m1_32000_316800 0 2.576249e-07
I7549 n1_m1_32000_321600 0 2.161061e-07
I7550 n1_m1_32000_326400 0 8.523748e-08
I7551 n1_m1_32000_331200 0 8.394603e-08
I7552 n1_m1_32000_336000 0 1.290337e-07
I7553 n1_m1_32000_340800 0 8.659358e-08
I7554 n1_m1_32000_345600 0 1.609428e-07
I7555 n1_m1_32000_350400 0 2.785742e-07
I7556 n1_m1_32000_355200 0 4.175444e-07
I7557 n1_m1_32000_360000 0 3.963005e-07
I7558 n1_m1_32000_364800 0 1.555007e-07
I7559 n1_m1_32000_369600 0 1.406434e-07
I7560 n1_m1_32000_374400 0 8.930281e-08
I7561 n1_m1_32000_379200 0 9.400630e-08
I7562 n1_m1_32000_384000 0 1.696630e-07
I7563 n1_m1_32000_388800 0 1.677074e-07
I7564 n1_m1_32000_393600 0 2.127002e-07
I7565 n1_m1_32000_398400 0 8.176195e-08
I7566 n1_m1_32000_403200 0 7.469301e-08
I7567 n1_m1_32000_408000 0 7.990918e-08
I7568 n1_m1_60000_0 0 7.661408e-08
I7569 n1_m1_60000_4800 0 7.661408e-08
I7570 n1_m1_60000_9600 0 1.158514e-07
I7571 n1_m1_60000_14400 0 8.069736e-08
I7572 n1_m1_60000_19200 0 8.384895e-08
I7573 n1_m1_60000_24000 0 1.262557e-07
I7574 n1_m1_60000_28800 0 8.341143e-08
I7575 n1_m1_60000_33600 0 1.259128e-07
I7576 n1_m1_60000_38400 0 8.203004e-08
I7577 n1_m1_60000_43200 0 8.320768e-08
I7578 n1_m1_60000_48000 0 1.263173e-07
I7579 n1_m1_60000_52800 0 8.392576e-08
I7580 n1_m1_60000_57600 0 1.276319e-07
I7581 n1_m1_60000_62400 0 8.421741e-08
I7582 n1_m1_60000_67200 0 8.330767e-08
I7583 n1_m1_60000_72000 0 1.280308e-07
I7584 n1_m1_60000_76800 0 1.441304e-07
I7585 n1_m1_60000_81600 0 3.896344e-07
I7586 n1_m1_60000_86400 0 1.772760e-07
I7587 n1_m1_60000_91200 0 1.023957e-07
I7588 n1_m1_60000_96000 0 1.633941e-07
I7589 n1_m1_60000_100800 0 1.122796e-07
I7590 n1_m1_60000_105600 0 1.328492e-07
I7591 n1_m1_60000_110400 0 8.676345e-08
I7592 n1_m1_60000_115200 0 8.944251e-08
I7593 n1_m1_60000_120000 0 2.215457e-07
I7594 n1_m1_60000_124800 0 1.177400e-07
I7595 n1_m1_60000_129600 0 1.337703e-07
I7596 n1_m1_60000_134400 0 8.926236e-08
I7597 n1_m1_60000_139200 0 9.816700e-08
I7598 n1_m1_60000_144000 0 1.362198e-07
I7599 n1_m1_60000_148800 0 8.841899e-08
I7600 n1_m1_60000_153600 0 1.346561e-07
I7601 n1_m1_60000_158400 0 8.578972e-08
I7602 n1_m1_60000_163200 0 8.816111e-08
I7603 n1_m1_60000_168000 0 1.308178e-07
I7604 n1_m1_60000_172800 0 8.337808e-08
I7605 n1_m1_60000_177600 0 1.370651e-07
I7606 n1_m1_60000_182400 0 1.073388e-07
I7607 n1_m1_60000_187200 0 1.122692e-07
I7608 n1_m1_60000_192000 0 1.500613e-07
I7609 n1_m1_60000_196800 0 8.841899e-08
I7610 n1_m1_60000_201600 0 1.334113e-07
I7611 n1_m1_60000_206400 0 8.581623e-08
I7612 n1_m1_60000_211200 0 8.479546e-08
I7613 n1_m1_60000_216000 0 1.275766e-07
I7614 n1_m1_60000_220800 0 8.486929e-08
I7615 n1_m1_60000_225600 0 1.294599e-07
I7616 n1_m1_60000_230400 0 8.689811e-08
I7617 n1_m1_60000_235200 0 8.623481e-08
I7618 n1_m1_60000_240000 0 1.276319e-07
I7619 n1_m1_60000_244800 0 8.555299e-08
I7620 n1_m1_60000_249600 0 1.302795e-07
I7621 n1_m1_60000_254400 0 8.748544e-08
I7622 n1_m1_60000_259200 0 8.762625e-08
I7623 n1_m1_60000_264000 0 1.311946e-07
I7624 n1_m1_60000_268800 0 8.841899e-08
I7625 n1_m1_60000_273600 0 1.326285e-07
I7626 n1_m1_60000_278400 0 8.966944e-08
I7627 n1_m1_60000_283200 0 8.977815e-08
I7628 n1_m1_60000_288000 0 1.386936e-07
I7629 n1_m1_60000_292800 0 1.002816e-07
I7630 n1_m1_60000_297600 0 1.345185e-07
I7631 n1_m1_60000_302400 0 8.768102e-08
I7632 n1_m1_60000_307200 0 1.251039e-07
I7633 n1_m1_60000_312000 0 2.251207e-07
I7634 n1_m1_60000_316800 0 1.670693e-07
I7635 n1_m1_60000_321600 0 1.645442e-07
I7636 n1_m1_60000_326400 0 8.430539e-08
I7637 n1_m1_60000_331200 0 9.113369e-08
I7638 n1_m1_60000_336000 0 1.310023e-07
I7639 n1_m1_60000_340800 0 8.766335e-08
I7640 n1_m1_60000_345600 0 1.371932e-07
I7641 n1_m1_60000_350400 0 9.761926e-08
I7642 n1_m1_60000_355200 0 1.186529e-07
I7643 n1_m1_60000_360000 0 1.381350e-07
I7644 n1_m1_60000_364800 0 8.419018e-08
I7645 n1_m1_60000_369600 0 1.270348e-07
I7646 n1_m1_60000_374400 0 8.678619e-08
I7647 n1_m1_60000_379200 0 8.893582e-08
I7648 n1_m1_60000_384000 0 2.291324e-07
I7649 n1_m1_60000_388800 0 9.424941e-08
I7650 n1_m1_60000_393600 0 1.296147e-07
I7651 n1_m1_60000_398400 0 8.075758e-08
I7652 n1_m1_60000_403200 0 7.965441e-08
I7653 n1_m1_60000_408000 0 8.166558e-08
I7654 n1_m1_88000_0 0 7.328303e-08
I7655 n1_m1_88000_4800 0 7.452608e-08
I7656 n1_m1_88000_9600 0 1.149211e-07
I7657 n1_m1_88000_14400 0 7.826336e-08
I7658 n1_m1_88000_19200 0 8.006522e-08
I7659 n1_m1_88000_24000 0 1.244830e-07
I7660 n1_m1_88000_28800 0 1.024708e-07
I7661 n1_m1_88000_33600 0 3.564641e-07
I7662 n1_m1_88000_38400 0 4.781145e-07
I7663 n1_m1_88000_43200 0 2.633656e-07
I7664 n1_m1_88000_48000 0 1.310444e-07
I7665 n1_m1_88000_52800 0 9.170900e-08
I7666 n1_m1_88000_57600 0 1.452379e-07
I7667 n1_m1_88000_62400 0 8.957443e-08
I7668 n1_m1_88000_67200 0 8.424705e-08
I7669 n1_m1_88000_72000 0 1.254869e-07
I7670 n1_m1_88000_76800 0 9.432275e-08
I7671 n1_m1_88000_81600 0 1.351841e-07
I7672 n1_m1_88000_86400 0 1.125240e-07
I7673 n1_m1_88000_91200 0 1.626598e-07
I7674 n1_m1_88000_96000 0 2.425221e-07
I7675 n1_m1_88000_100800 0 1.123849e-07
I7676 n1_m1_88000_105600 0 1.281124e-07
I7677 n1_m1_88000_110400 0 1.008003e-07
I7678 n1_m1_88000_115200 0 1.003179e-07
I7679 n1_m1_88000_120000 0 1.380676e-07
I7680 n1_m1_88000_124800 0 9.765814e-08
I7681 n1_m1_88000_129600 0 1.427003e-07
I7682 n1_m1_88000_134400 0 1.141031e-07
I7683 n1_m1_88000_139200 0 1.318007e-07
I7684 n1_m1_88000_144000 0 1.591661e-07
I7685 n1_m1_88000_148800 0 1.048579e-07
I7686 n1_m1_88000_153600 0 1.504673e-07
I7687 n1_m1_88000_158400 0 9.670063e-08
I7688 n1_m1_88000_163200 0 9.571901e-08
I7689 n1_m1_88000_168000 0 2.151176e-07
I7690 n1_m1_88000_172800 0 3.492059e-07
I7691 n1_m1_88000_177600 0 5.569750e-07
I7692 n1_m1_88000_182400 0 1.690322e-07
I7693 n1_m1_88000_187200 0 1.227006e-07
I7694 n1_m1_88000_192000 0 1.381810e-07
I7695 n1_m1_88000_196800 0 8.868862e-08
I7696 n1_m1_88000_201600 0 1.366101e-07
I7697 n1_m1_88000_206400 0 9.725752e-08
I7698 n1_m1_88000_211200 0 1.256267e-07
I7699 n1_m1_88000_216000 0 4.241338e-07
I7700 n1_m1_88000_220800 0 1.847840e-07
I7701 n1_m1_88000_225600 0 2.051199e-07
I7702 n1_m1_88000_230400 0 1.039966e-07
I7703 n1_m1_88000_235200 0 8.912677e-08
I7704 n1_m1_88000_240000 0 1.299108e-07
I7705 n1_m1_88000_244800 0 8.631626e-08
I7706 n1_m1_88000_249600 0 1.277937e-07
I7707 n1_m1_88000_254400 0 8.916216e-08
I7708 n1_m1_88000_259200 0 8.753461e-08
I7709 n1_m1_88000_264000 0 1.313308e-07
I7710 n1_m1_88000_268800 0 9.557064e-08
I7711 n1_m1_88000_273600 0 1.308231e-07
I7712 n1_m1_88000_278400 0 8.707207e-08
I7713 n1_m1_88000_283200 0 8.747008e-08
I7714 n1_m1_88000_288000 0 1.614129e-07
I7715 n1_m1_88000_292800 0 1.337381e-07
I7716 n1_m1_88000_297600 0 1.499744e-07
I7717 n1_m1_88000_302400 0 9.518949e-08
I7718 n1_m1_88000_307200 0 9.503854e-08
I7719 n1_m1_88000_312000 0 1.314612e-07
I7720 n1_m1_88000_316800 0 8.660722e-08
I7721 n1_m1_88000_321600 0 1.277416e-07
I7722 n1_m1_88000_326400 0 8.362959e-08
I7723 n1_m1_88000_331200 0 8.633505e-08
I7724 n1_m1_88000_336000 0 1.295131e-07
I7725 n1_m1_88000_340800 0 8.496992e-08
I7726 n1_m1_88000_345600 0 1.309966e-07
I7727 n1_m1_88000_350400 0 9.043341e-08
I7728 n1_m1_88000_355200 0 8.807047e-08
I7729 n1_m1_88000_360000 0 1.297355e-07
I7730 n1_m1_88000_364800 0 2.607742e-07
I7731 n1_m1_88000_369600 0 4.158372e-07
I7732 n1_m1_88000_374400 0 9.994046e-08
I7733 n1_m1_88000_379200 0 9.490095e-08
I7734 n1_m1_88000_384000 0 1.307932e-07
I7735 n1_m1_88000_388800 0 8.660722e-08
I7736 n1_m1_88000_393600 0 1.299108e-07
I7737 n1_m1_88000_398400 0 8.498856e-08
I7738 n1_m1_88000_403200 0 8.083345e-08
I7739 n1_m1_88000_408000 0 7.765402e-08
I7740 n1_m1_116000_0 0 1.486459e-07
I7741 n1_m1_116000_4800 0 1.557143e-07
I7742 n1_m1_116000_9600 0 2.491704e-07
I7743 n1_m1_116000_14400 0 1.710342e-07
I7744 n1_m1_116000_19200 0 1.640419e-07
I7745 n1_m1_116000_24000 0 2.500516e-07
I7746 n1_m1_116000_28800 0 1.960424e-07
I7747 n1_m1_116000_33600 0 3.824118e-07
I7748 n1_m1_116000_38400 0 2.073711e-07
I7749 n1_m1_116000_43200 0 2.762566e-07
I7750 n1_m1_116000_48000 0 3.576072e-07
I7751 n1_m1_116000_52800 0 1.854278e-07
I7752 n1_m1_116000_57600 0 2.461947e-07
I7753 n1_m1_116000_62400 0 1.761009e-07
I7754 n1_m1_116000_67200 0 2.634643e-07
I7755 n1_m1_116000_72000 0 4.453270e-07
I7756 n1_m1_116000_76800 0 2.089669e-07
I7757 n1_m1_116000_81600 0 2.632072e-07
I7758 n1_m1_116000_86400 0 2.169147e-07
I7759 n1_m1_116000_91200 0 1.798969e-07
I7760 n1_m1_116000_96000 0 2.637366e-07
I7761 n1_m1_116000_100800 0 1.929403e-07
I7762 n1_m1_116000_105600 0 2.879966e-07
I7763 n1_m1_116000_110400 0 1.755665e-07
I7764 n1_m1_116000_115200 0 1.686322e-07
I7765 n1_m1_116000_120000 0 2.651643e-07
I7766 n1_m1_116000_124800 0 1.742924e-07
I7767 n1_m1_116000_129600 0 2.611438e-07
I7768 n1_m1_116000_134400 0 1.754731e-07
I7769 n1_m1_116000_139200 0 1.748864e-07
I7770 n1_m1_116000_144000 0 2.585136e-07
I7771 n1_m1_116000_148800 0 1.672960e-07
I7772 n1_m1_116000_153600 0 2.602759e-07
I7773 n1_m1_116000_158400 0 1.743915e-07
I7774 n1_m1_116000_163200 0 1.748223e-07
I7775 n1_m1_116000_168000 0 2.732867e-07
I7776 n1_m1_116000_172800 0 1.826888e-07
I7777 n1_m1_116000_177600 0 2.686661e-07
I7778 n1_m1_116000_182400 0 1.767598e-07
I7779 n1_m1_116000_187200 0 1.921348e-07
I7780 n1_m1_116000_192000 0 3.427793e-07
I7781 n1_m1_116000_196800 0 6.041210e-07
I7782 n1_m1_116000_201600 0 1.364235e-06
I7783 n1_m1_116000_206400 0 6.738154e-07
I7784 n1_m1_116000_211200 0 4.315992e-07
I7785 n1_m1_116000_216000 0 5.045985e-07
I7786 n1_m1_116000_220800 0 7.311819e-07
I7787 n1_m1_116000_225600 0 1.756544e-06
I7788 n1_m1_116000_230400 0 6.562619e-07
I7789 n1_m1_116000_235200 0 7.284965e-07
I7790 n1_m1_116000_240000 0 1.332673e-06
I7791 n1_m1_116000_244800 0 5.538566e-07
I7792 n1_m1_116000_249600 0 3.243866e-07
I7793 n1_m1_116000_254400 0 2.050440e-07
I7794 n1_m1_116000_259200 0 1.807728e-07
I7795 n1_m1_116000_264000 0 2.811929e-07
I7796 n1_m1_116000_268800 0 1.809906e-07
I7797 n1_m1_116000_273600 0 2.623724e-07
I7798 n1_m1_116000_278400 0 1.751754e-07
I7799 n1_m1_116000_283200 0 1.779731e-07
I7800 n1_m1_116000_288000 0 2.598217e-07
I7801 n1_m1_116000_292800 0 1.732144e-07
I7802 n1_m1_116000_297600 0 2.663567e-07
I7803 n1_m1_116000_302400 0 1.979143e-07
I7804 n1_m1_116000_307200 0 2.017930e-07
I7805 n1_m1_116000_312000 0 2.641461e-07
I7806 n1_m1_116000_316800 0 1.792565e-07
I7807 n1_m1_116000_321600 0 2.676717e-07
I7808 n1_m1_116000_326400 0 1.753480e-07
I7809 n1_m1_116000_331200 0 1.935557e-07
I7810 n1_m1_116000_336000 0 6.317726e-07
I7811 n1_m1_116000_340800 0 8.463715e-07
I7812 n1_m1_116000_345600 0 5.750742e-07
I7813 n1_m1_116000_350400 0 2.891211e-07
I7814 n1_m1_116000_355200 0 1.912963e-07
I7815 n1_m1_116000_360000 0 2.903324e-07
I7816 n1_m1_116000_364800 0 1.778354e-07
I7817 n1_m1_116000_369600 0 2.601605e-07
I7818 n1_m1_116000_374400 0 1.769013e-07
I7819 n1_m1_116000_379200 0 1.801795e-07
I7820 n1_m1_116000_384000 0 2.663907e-07
I7821 n1_m1_116000_388800 0 1.809409e-07
I7822 n1_m1_116000_393600 0 2.695525e-07
I7823 n1_m1_116000_398400 0 1.662924e-07
I7824 n1_m1_116000_403200 0 1.607331e-07
I7825 n1_m1_116000_408000 0 1.568615e-07
I7826 n1_m1_172000_0 0 8.106833e-08
I7827 n1_m1_172000_4800 0 7.994513e-08
I7828 n1_m1_172000_9600 0 1.250859e-07
I7829 n1_m1_172000_14400 0 8.492545e-08
I7830 n1_m1_172000_19200 0 1.067742e-07
I7831 n1_m1_172000_24000 0 5.454487e-07
I7832 n1_m1_172000_28800 0 4.322616e-07
I7833 n1_m1_172000_33600 0 2.144500e-07
I7834 n1_m1_172000_38400 0 8.529023e-08
I7835 n1_m1_172000_43200 0 8.221717e-08
I7836 n1_m1_172000_48000 0 1.272399e-07
I7837 n1_m1_172000_52800 0 8.711094e-08
I7838 n1_m1_172000_57600 0 1.279054e-07
I7839 n1_m1_172000_62400 0 8.500670e-08
I7840 n1_m1_172000_67200 0 8.331138e-08
I7841 n1_m1_172000_72000 0 1.322141e-07
I7842 n1_m1_172000_76800 0 1.049061e-07
I7843 n1_m1_172000_81600 0 1.567289e-07
I7844 n1_m1_172000_86400 0 9.522759e-08
I7845 n1_m1_172000_91200 0 1.002806e-07
I7846 n1_m1_172000_96000 0 2.568448e-07
I7847 n1_m1_172000_100800 0 1.982787e-07
I7848 n1_m1_172000_105600 0 1.560047e-07
I7849 n1_m1_172000_110400 0 9.557299e-08
I7850 n1_m1_172000_115200 0 8.548313e-08
I7851 n1_m1_172000_120000 0 1.416234e-07
I7852 n1_m1_172000_124800 0 9.493874e-08
I7853 n1_m1_172000_129600 0 1.331603e-07
I7854 n1_m1_172000_134400 0 1.080653e-07
I7855 n1_m1_172000_139200 0 1.107195e-07
I7856 n1_m1_172000_144000 0 1.378062e-07
I7857 n1_m1_172000_148800 0 8.660722e-08
I7858 n1_m1_172000_153600 0 1.271769e-07
I7859 n1_m1_172000_158400 0 8.584104e-08
I7860 n1_m1_172000_163200 0 8.961698e-08
I7861 n1_m1_172000_168000 0 1.722737e-07
I7862 n1_m1_172000_172800 0 2.351464e-07
I7863 n1_m1_172000_177600 0 2.011806e-07
I7864 n1_m1_172000_182400 0 8.730391e-08
I7865 n1_m1_172000_187200 0 8.501067e-08
I7866 n1_m1_172000_192000 0 1.292222e-07
I7867 n1_m1_172000_196800 0 8.877450e-08
I7868 n1_m1_172000_201600 0 1.322852e-07
I7869 n1_m1_172000_206400 0 8.785439e-08
I7870 n1_m1_172000_211200 0 9.152675e-08
I7871 n1_m1_172000_216000 0 1.299248e-07
I7872 n1_m1_172000_220800 0 8.507566e-08
I7873 n1_m1_172000_225600 0 1.309464e-07
I7874 n1_m1_172000_230400 0 8.465367e-08
I7875 n1_m1_172000_235200 0 8.598351e-08
I7876 n1_m1_172000_240000 0 1.261843e-07
I7877 n1_m1_172000_244800 0 8.591887e-08
I7878 n1_m1_172000_249600 0 1.332804e-07
I7879 n1_m1_172000_254400 0 8.941830e-08
I7880 n1_m1_172000_259200 0 8.989616e-08
I7881 n1_m1_172000_264000 0 1.359839e-07
I7882 n1_m1_172000_268800 0 9.693692e-08
I7883 n1_m1_172000_273600 0 1.326888e-07
I7884 n1_m1_172000_278400 0 8.739734e-08
I7885 n1_m1_172000_283200 0 8.481531e-08
I7886 n1_m1_172000_288000 0 1.305477e-07
I7887 n1_m1_172000_292800 0 8.597194e-08
I7888 n1_m1_172000_297600 0 1.302872e-07
I7889 n1_m1_172000_302400 0 9.229095e-08
I7890 n1_m1_172000_307200 0 1.244512e-07
I7891 n1_m1_172000_312000 0 1.390504e-07
I7892 n1_m1_172000_316800 0 9.199490e-08
I7893 n1_m1_172000_321600 0 1.311933e-07
I7894 n1_m1_172000_326400 0 8.743857e-08
I7895 n1_m1_172000_331200 0 8.712236e-08
I7896 n1_m1_172000_336000 0 1.333279e-07
I7897 n1_m1_172000_340800 0 8.667628e-08
I7898 n1_m1_172000_345600 0 1.310725e-07
I7899 n1_m1_172000_350400 0 1.090122e-07
I7900 n1_m1_172000_355200 0 1.597477e-07
I7901 n1_m1_172000_360000 0 1.998411e-07
I7902 n1_m1_172000_364800 0 9.815752e-08
I7903 n1_m1_172000_369600 0 1.351305e-07
I7904 n1_m1_172000_374400 0 9.249985e-08
I7905 n1_m1_172000_379200 0 9.288458e-08
I7906 n1_m1_172000_384000 0 1.958504e-07
I7907 n1_m1_172000_388800 0 1.901117e-07
I7908 n1_m1_172000_393600 0 2.108339e-07
I7909 n1_m1_172000_398400 0 8.911770e-08
I7910 n1_m1_172000_403200 0 8.186257e-08
I7911 n1_m1_172000_408000 0 7.655111e-08
I7912 n1_m1_200000_0 0 7.822959e-08
I7913 n1_m1_200000_4800 0 7.994513e-08
I7914 n1_m1_200000_9600 0 1.208479e-07
I7915 n1_m1_200000_14400 0 8.369051e-08
I7916 n1_m1_200000_19200 0 8.589850e-08
I7917 n1_m1_200000_24000 0 1.319663e-07
I7918 n1_m1_200000_28800 0 8.727612e-08
I7919 n1_m1_200000_33600 0 1.269588e-07
I7920 n1_m1_200000_38400 0 8.340170e-08
I7921 n1_m1_200000_43200 0 8.431098e-08
I7922 n1_m1_200000_48000 0 1.285319e-07
I7923 n1_m1_200000_52800 0 9.058068e-08
I7924 n1_m1_200000_57600 0 1.342209e-07
I7925 n1_m1_200000_62400 0 8.697665e-08
I7926 n1_m1_200000_67200 0 9.570008e-08
I7927 n1_m1_200000_72000 0 1.344090e-07
I7928 n1_m1_200000_76800 0 9.412688e-08
I7929 n1_m1_200000_81600 0 1.303485e-07
I7930 n1_m1_200000_86400 0 8.771622e-08
I7931 n1_m1_200000_91200 0 8.783388e-08
I7932 n1_m1_200000_96000 0 1.327617e-07
I7933 n1_m1_200000_100800 0 9.286563e-08
I7934 n1_m1_200000_105600 0 1.520657e-07
I7935 n1_m1_200000_110400 0 9.020624e-08
I7936 n1_m1_200000_115200 0 1.003565e-07
I7937 n1_m1_200000_120000 0 1.329496e-07
I7938 n1_m1_200000_124800 0 9.883209e-08
I7939 n1_m1_200000_129600 0 1.772220e-07
I7940 n1_m1_200000_134400 0 1.034829e-07
I7941 n1_m1_200000_139200 0 1.174625e-07
I7942 n1_m1_200000_144000 0 1.948786e-07
I7943 n1_m1_200000_148800 0 3.619952e-07
I7944 n1_m1_200000_153600 0 6.894201e-07
I7945 n1_m1_200000_158400 0 1.323179e-07
I7946 n1_m1_200000_163200 0 8.978215e-08
I7947 n1_m1_200000_168000 0 1.298673e-07
I7948 n1_m1_200000_172800 0 8.610097e-08
I7949 n1_m1_200000_177600 0 1.304853e-07
I7950 n1_m1_200000_182400 0 8.649095e-08
I7951 n1_m1_200000_187200 0 8.887273e-08
I7952 n1_m1_200000_192000 0 1.433533e-07
I7953 n1_m1_200000_196800 0 8.744405e-08
I7954 n1_m1_200000_201600 0 2.243186e-07
I7955 n1_m1_200000_206400 0 3.543861e-07
I7956 n1_m1_200000_211200 0 1.720707e-07
I7957 n1_m1_200000_216000 0 1.503417e-07
I7958 n1_m1_200000_220800 0 8.667349e-08
I7959 n1_m1_200000_225600 0 1.291977e-07
I7960 n1_m1_200000_230400 0 8.832577e-08
I7961 n1_m1_200000_235200 0 8.729396e-08
I7962 n1_m1_200000_240000 0 1.286423e-07
I7963 n1_m1_200000_244800 0 1.389261e-07
I7964 n1_m1_200000_249600 0 4.070803e-07
I7965 n1_m1_200000_254400 0 1.489993e-07
I7966 n1_m1_200000_259200 0 9.048400e-08
I7967 n1_m1_200000_264000 0 1.338377e-07
I7968 n1_m1_200000_268800 0 8.841048e-08
I7969 n1_m1_200000_273600 0 1.301374e-07
I7970 n1_m1_200000_278400 0 1.005132e-07
I7971 n1_m1_200000_283200 0 1.895278e-07
I7972 n1_m1_200000_288000 0 2.182620e-07
I7973 n1_m1_200000_292800 0 9.621857e-08
I7974 n1_m1_200000_297600 0 1.255011e-07
I7975 n1_m1_200000_302400 0 8.512894e-08
I7976 n1_m1_200000_307200 0 8.660722e-08
I7977 n1_m1_200000_312000 0 1.299108e-07
I7978 n1_m1_200000_316800 0 8.660722e-08
I7979 n1_m1_200000_321600 0 1.315351e-07
I7980 n1_m1_200000_326400 0 8.950117e-08
I7981 n1_m1_200000_331200 0 8.860474e-08
I7982 n1_m1_200000_336000 0 1.376145e-07
I7983 n1_m1_200000_340800 0 8.845538e-08
I7984 n1_m1_200000_345600 0 1.362148e-07
I7985 n1_m1_200000_350400 0 8.795226e-08
I7986 n1_m1_200000_355200 0 8.850721e-08
I7987 n1_m1_200000_360000 0 1.317331e-07
I7988 n1_m1_200000_364800 0 9.850261e-08
I7989 n1_m1_200000_369600 0 1.438848e-07
I7990 n1_m1_200000_374400 0 1.044712e-07
I7991 n1_m1_200000_379200 0 9.175706e-08
I7992 n1_m1_200000_384000 0 1.809470e-07
I7993 n1_m1_200000_388800 0 9.178775e-08
I7994 n1_m1_200000_393600 0 1.344787e-07
I7995 n1_m1_200000_398400 0 8.566429e-08
I7996 n1_m1_200000_403200 0 8.306391e-08
I7997 n1_m1_200000_408000 0 8.242818e-08
I7998 n1_m1_228000_0 0 7.868635e-08
I7999 n1_m1_228000_4800 0 8.573790e-08
I8000 n1_m1_228000_9600 0 1.441649e-07
I8001 n1_m1_228000_14400 0 9.825334e-08
I8002 n1_m1_228000_19200 0 9.076765e-08
I8003 n1_m1_228000_24000 0 2.794227e-07
I8004 n1_m1_228000_28800 0 3.752144e-07
I8005 n1_m1_228000_33600 0 2.892994e-07
I8006 n1_m1_228000_38400 0 9.001117e-08
I8007 n1_m1_228000_43200 0 8.857885e-08
I8008 n1_m1_228000_48000 0 2.750337e-07
I8009 n1_m1_228000_52800 0 1.304963e-07
I8010 n1_m1_228000_57600 0 1.328800e-07
I8011 n1_m1_228000_62400 0 8.487670e-08
I8012 n1_m1_228000_67200 0 9.149868e-08
I8013 n1_m1_228000_72000 0 1.630285e-07
I8014 n1_m1_228000_76800 0 2.311079e-07
I8015 n1_m1_228000_81600 0 4.161092e-07
I8016 n1_m1_228000_86400 0 1.045528e-07
I8017 n1_m1_228000_91200 0 9.537997e-08
I8018 n1_m1_228000_96000 0 1.538942e-07
I8019 n1_m1_228000_100800 0 9.097898e-08
I8020 n1_m1_228000_105600 0 1.299509e-07
I8021 n1_m1_228000_110400 0 8.813629e-08
I8022 n1_m1_228000_115200 0 9.940322e-08
I8023 n1_m1_228000_120000 0 1.707966e-07
I8024 n1_m1_228000_124800 0 1.039604e-07
I8025 n1_m1_228000_129600 0 1.409314e-07
I8026 n1_m1_228000_134400 0 8.782210e-08
I8027 n1_m1_228000_139200 0 8.662654e-08
I8028 n1_m1_228000_144000 0 1.292383e-07
I8029 n1_m1_228000_148800 0 8.328420e-08
I8030 n1_m1_228000_153600 0 1.598162e-07
I8031 n1_m1_228000_158400 0 2.711174e-07
I8032 n1_m1_228000_163200 0 2.376229e-07
I8033 n1_m1_228000_168000 0 1.502925e-07
I8034 n1_m1_228000_172800 0 8.927324e-08
I8035 n1_m1_228000_177600 0 1.303558e-07
I8036 n1_m1_228000_182400 0 8.388958e-08
I8037 n1_m1_228000_187200 0 8.495180e-08
I8038 n1_m1_228000_192000 0 2.289497e-07
I8039 n1_m1_228000_196800 0 2.804102e-07
I8040 n1_m1_228000_201600 0 5.015204e-07
I8041 n1_m1_228000_206400 0 1.887642e-07
I8042 n1_m1_228000_211200 0 9.929269e-08
I8043 n1_m1_228000_216000 0 1.274274e-07
I8044 n1_m1_228000_220800 0 8.639141e-08
I8045 n1_m1_228000_225600 0 1.275878e-07
I8046 n1_m1_228000_230400 0 8.999817e-08
I8047 n1_m1_228000_235200 0 1.587386e-07
I8048 n1_m1_228000_240000 0 2.901075e-07
I8049 n1_m1_228000_244800 0 9.306748e-08
I8050 n1_m1_228000_249600 0 1.367610e-07
I8051 n1_m1_228000_254400 0 9.354884e-08
I8052 n1_m1_228000_259200 0 1.762986e-07
I8053 n1_m1_228000_264000 0 3.361589e-07
I8054 n1_m1_228000_268800 0 1.141144e-07
I8055 n1_m1_228000_273600 0 2.793185e-07
I8056 n1_m1_228000_278400 0 1.116269e-07
I8057 n1_m1_228000_283200 0 8.827077e-08
I8058 n1_m1_228000_288000 0 1.388360e-07
I8059 n1_m1_228000_292800 0 8.671368e-08
I8060 n1_m1_228000_297600 0 1.485653e-07
I8061 n1_m1_228000_302400 0 1.016628e-07
I8062 n1_m1_228000_307200 0 8.773601e-08
I8063 n1_m1_228000_312000 0 1.257333e-07
I8064 n1_m1_228000_316800 0 8.812929e-08
I8065 n1_m1_228000_321600 0 1.895138e-07
I8066 n1_m1_228000_326400 0 1.006366e-07
I8067 n1_m1_228000_331200 0 8.487041e-08
I8068 n1_m1_228000_336000 0 1.299108e-07
I8069 n1_m1_228000_340800 0 8.660722e-08
I8070 n1_m1_228000_345600 0 1.299108e-07
I8071 n1_m1_228000_350400 0 8.790570e-08
I8072 n1_m1_228000_355200 0 9.203501e-08
I8073 n1_m1_228000_360000 0 1.338667e-07
I8074 n1_m1_228000_364800 0 8.660722e-08
I8075 n1_m1_228000_369600 0 1.299108e-07
I8076 n1_m1_228000_374400 0 8.660722e-08
I8077 n1_m1_228000_379200 0 8.734518e-08
I8078 n1_m1_228000_384000 0 1.378119e-07
I8079 n1_m1_228000_388800 0 9.229844e-08
I8080 n1_m1_228000_393600 0 1.315480e-07
I8081 n1_m1_228000_398400 0 8.534792e-08
I8082 n1_m1_228000_403200 0 7.910018e-08
I8083 n1_m1_228000_408000 0 7.432297e-08
I8084 n1_m1_256000_0 0 7.487520e-08
I8085 n1_m1_256000_4800 0 8.513954e-08
I8086 n1_m1_256000_9600 0 1.259320e-07
I8087 n1_m1_256000_14400 0 8.494931e-08
I8088 n1_m1_256000_19200 0 2.130013e-07
I8089 n1_m1_256000_24000 0 8.980901e-07
I8090 n1_m1_256000_28800 0 5.981926e-07
I8091 n1_m1_256000_33600 0 3.028654e-07
I8092 n1_m1_256000_38400 0 9.019338e-08
I8093 n1_m1_256000_43200 0 1.189074e-07
I8094 n1_m1_256000_48000 0 3.049117e-07
I8095 n1_m1_256000_52800 0 4.162019e-07
I8096 n1_m1_256000_57600 0 6.819935e-07
I8097 n1_m1_256000_62400 0 2.114609e-07
I8098 n1_m1_256000_67200 0 9.399300e-08
I8099 n1_m1_256000_72000 0 1.299108e-07
I8100 n1_m1_256000_76800 0 8.997124e-08
I8101 n1_m1_256000_81600 0 1.332006e-07
I8102 n1_m1_256000_86400 0 1.062871e-07
I8103 n1_m1_256000_91200 0 9.665327e-08
I8104 n1_m1_256000_96000 0 1.868900e-07
I8105 n1_m1_256000_100800 0 1.249226e-07
I8106 n1_m1_256000_105600 0 1.319358e-07
I8107 n1_m1_256000_110400 0 8.546799e-08
I8108 n1_m1_256000_115200 0 8.604059e-08
I8109 n1_m1_256000_120000 0 1.662440e-07
I8110 n1_m1_256000_124800 0 1.332925e-07
I8111 n1_m1_256000_129600 0 1.520824e-07
I8112 n1_m1_256000_134400 0 1.025026e-07
I8113 n1_m1_256000_139200 0 9.022122e-08
I8114 n1_m1_256000_144000 0 1.317798e-07
I8115 n1_m1_256000_148800 0 8.750359e-08
I8116 n1_m1_256000_153600 0 1.265754e-07
I8117 n1_m1_256000_158400 0 8.612124e-08
I8118 n1_m1_256000_163200 0 8.492521e-08
I8119 n1_m1_256000_168000 0 1.538025e-07
I8120 n1_m1_256000_172800 0 2.075266e-07
I8121 n1_m1_256000_177600 0 3.125598e-07
I8122 n1_m1_256000_182400 0 9.654146e-08
I8123 n1_m1_256000_187200 0 8.454723e-08
I8124 n1_m1_256000_192000 0 1.271671e-07
I8125 n1_m1_256000_196800 0 9.010076e-08
I8126 n1_m1_256000_201600 0 1.349209e-07
I8127 n1_m1_256000_206400 0 8.572165e-08
I8128 n1_m1_256000_211200 0 1.064411e-07
I8129 n1_m1_256000_216000 0 2.544405e-07
I8130 n1_m1_256000_220800 0 1.019027e-07
I8131 n1_m1_256000_225600 0 1.403579e-07
I8132 n1_m1_256000_230400 0 1.046016e-07
I8133 n1_m1_256000_235200 0 1.021548e-07
I8134 n1_m1_256000_240000 0 1.444422e-07
I8135 n1_m1_256000_244800 0 1.055281e-07
I8136 n1_m1_256000_249600 0 1.491380e-07
I8137 n1_m1_256000_254400 0 9.381419e-08
I8138 n1_m1_256000_259200 0 9.089508e-08
I8139 n1_m1_256000_264000 0 1.285360e-07
I8140 n1_m1_256000_268800 0 8.833193e-08
I8141 n1_m1_256000_273600 0 1.307694e-07
I8142 n1_m1_256000_278400 0 9.929780e-08
I8143 n1_m1_256000_283200 0 2.622032e-07
I8144 n1_m1_256000_288000 0 9.188021e-07
I8145 n1_m1_256000_292800 0 3.322084e-07
I8146 n1_m1_256000_297600 0 1.974308e-07
I8147 n1_m1_256000_302400 0 9.503527e-08
I8148 n1_m1_256000_307200 0 1.651812e-07
I8149 n1_m1_256000_312000 0 2.085892e-07
I8150 n1_m1_256000_316800 0 1.081469e-07
I8151 n1_m1_256000_321600 0 1.672237e-07
I8152 n1_m1_256000_326400 0 1.646047e-07
I8153 n1_m1_256000_331200 0 1.493423e-07
I8154 n1_m1_256000_336000 0 1.288462e-07
I8155 n1_m1_256000_340800 0 8.971477e-08
I8156 n1_m1_256000_345600 0 1.372473e-07
I8157 n1_m1_256000_350400 0 9.149818e-08
I8158 n1_m1_256000_355200 0 9.206624e-08
I8159 n1_m1_256000_360000 0 1.504751e-07
I8160 n1_m1_256000_364800 0 1.548627e-07
I8161 n1_m1_256000_369600 0 2.111277e-07
I8162 n1_m1_256000_374400 0 8.929540e-08
I8163 n1_m1_256000_379200 0 8.670798e-08
I8164 n1_m1_256000_384000 0 1.604986e-07
I8165 n1_m1_256000_388800 0 9.287962e-08
I8166 n1_m1_256000_393600 0 1.288831e-07
I8167 n1_m1_256000_398400 0 8.959674e-08
I8168 n1_m1_256000_403200 0 9.041498e-08
I8169 n1_m1_256000_408000 0 8.211342e-08
I8170 n1_m1_284000_0 0 1.598903e-07
I8171 n1_m1_284000_4800 0 1.659005e-07
I8172 n1_m1_284000_9600 0 2.702876e-07
I8173 n1_m1_284000_14400 0 2.120740e-07
I8174 n1_m1_284000_19200 0 1.879095e-07
I8175 n1_m1_284000_24000 0 2.696728e-07
I8176 n1_m1_284000_28800 0 4.735538e-07
I8177 n1_m1_284000_33600 0 1.369933e-06
I8178 n1_m1_284000_38400 0 4.209638e-07
I8179 n1_m1_284000_43200 0 1.952600e-07
I8180 n1_m1_284000_48000 0 2.935886e-07
I8181 n1_m1_284000_52800 0 1.954664e-07
I8182 n1_m1_284000_57600 0 2.794941e-07
I8183 n1_m1_284000_62400 0 1.774099e-07
I8184 n1_m1_284000_67200 0 1.737198e-07
I8185 n1_m1_284000_72000 0 2.700118e-07
I8186 n1_m1_284000_76800 0 1.725410e-07
I8187 n1_m1_284000_81600 0 2.716938e-07
I8188 n1_m1_284000_86400 0 1.836138e-07
I8189 n1_m1_284000_91200 0 1.774946e-07
I8190 n1_m1_284000_96000 0 2.641613e-07
I8191 n1_m1_284000_100800 0 2.735175e-07
I8192 n1_m1_284000_105600 0 9.655853e-07
I8193 n1_m1_284000_110400 0 6.214720e-07
I8194 n1_m1_284000_115200 0 2.676513e-07
I8195 n1_m1_284000_120000 0 2.710449e-07
I8196 n1_m1_284000_124800 0 1.850670e-07
I8197 n1_m1_284000_129600 0 2.814660e-07
I8198 n1_m1_284000_134400 0 1.987455e-07
I8199 n1_m1_284000_139200 0 2.315913e-07
I8200 n1_m1_284000_144000 0 3.655933e-07
I8201 n1_m1_284000_148800 0 1.900718e-07
I8202 n1_m1_284000_153600 0 2.628781e-07
I8203 n1_m1_284000_158400 0 1.808190e-07
I8204 n1_m1_284000_163200 0 3.017619e-07
I8205 n1_m1_284000_168000 0 1.075895e-06
I8206 n1_m1_284000_172800 0 3.214456e-07
I8207 n1_m1_284000_177600 0 2.738556e-07
I8208 n1_m1_284000_182400 0 1.746762e-07
I8209 n1_m1_284000_187200 0 1.733188e-07
I8210 n1_m1_284000_192000 0 2.598217e-07
I8211 n1_m1_284000_196800 0 1.732144e-07
I8212 n1_m1_284000_201600 0 2.724248e-07
I8213 n1_m1_284000_206400 0 1.959492e-07
I8214 n1_m1_284000_211200 0 1.870070e-07
I8215 n1_m1_284000_216000 0 2.790818e-07
I8216 n1_m1_284000_220800 0 1.889795e-07
I8217 n1_m1_284000_225600 0 2.694977e-07
I8218 n1_m1_284000_230400 0 1.799591e-07
I8219 n1_m1_284000_235200 0 1.777987e-07
I8220 n1_m1_284000_240000 0 4.394495e-07
I8221 n1_m1_284000_244800 0 5.565754e-07
I8222 n1_m1_284000_249600 0 5.741264e-07
I8223 n1_m1_284000_254400 0 1.782921e-07
I8224 n1_m1_284000_259200 0 1.855166e-07
I8225 n1_m1_284000_264000 0 2.647081e-07
I8226 n1_m1_284000_268800 0 1.732319e-07
I8227 n1_m1_284000_273600 0 2.600544e-07
I8228 n1_m1_284000_278400 0 1.915135e-07
I8229 n1_m1_284000_283200 0 3.011541e-07
I8230 n1_m1_284000_288000 0 9.256348e-07
I8231 n1_m1_284000_292800 0 1.089397e-06
I8232 n1_m1_284000_297600 0 1.940815e-06
I8233 n1_m1_284000_302400 0 9.364981e-07
I8234 n1_m1_284000_307200 0 4.245037e-07
I8235 n1_m1_284000_312000 0 3.334925e-07
I8236 n1_m1_284000_316800 0 1.892838e-07
I8237 n1_m1_284000_321600 0 2.672003e-07
I8238 n1_m1_284000_326400 0 1.798304e-07
I8239 n1_m1_284000_331200 0 2.003271e-07
I8240 n1_m1_284000_336000 0 3.041269e-07
I8241 n1_m1_284000_340800 0 2.042607e-07
I8242 n1_m1_284000_345600 0 2.697797e-07
I8243 n1_m1_284000_350400 0 2.002901e-07
I8244 n1_m1_284000_355200 0 2.744822e-07
I8245 n1_m1_284000_360000 0 4.190251e-07
I8246 n1_m1_284000_364800 0 2.098177e-07
I8247 n1_m1_284000_369600 0 2.869159e-07
I8248 n1_m1_284000_374400 0 2.085502e-07
I8249 n1_m1_284000_379200 0 1.883460e-07
I8250 n1_m1_284000_384000 0 2.646359e-07
I8251 n1_m1_284000_388800 0 1.888234e-07
I8252 n1_m1_284000_393600 0 3.106492e-07
I8253 n1_m1_284000_398400 0 1.825973e-07
I8254 n1_m1_284000_403200 0 1.640131e-07
I8255 n1_m1_284000_408000 0 1.544397e-07
I8256 n1_m1_340000_0 0 7.994513e-08
I8257 n1_m1_340000_4800 0 8.113664e-08
I8258 n1_m1_340000_9600 0 1.285993e-07
I8259 n1_m1_340000_14400 0 8.660722e-08
I8260 n1_m1_340000_19200 0 8.703057e-08
I8261 n1_m1_340000_24000 0 1.519792e-07
I8262 n1_m1_340000_28800 0 9.585342e-08
I8263 n1_m1_340000_33600 0 1.406343e-07
I8264 n1_m1_340000_38400 0 9.671235e-08
I8265 n1_m1_340000_43200 0 1.898509e-07
I8266 n1_m1_340000_48000 0 3.110076e-07
I8267 n1_m1_340000_52800 0 8.660722e-08
I8268 n1_m1_340000_57600 0 1.299108e-07
I8269 n1_m1_340000_62400 0 8.660722e-08
I8270 n1_m1_340000_67200 0 8.424992e-08
I8271 n1_m1_340000_72000 0 1.270219e-07
I8272 n1_m1_340000_76800 0 9.102202e-08
I8273 n1_m1_340000_81600 0 1.287941e-07
I8274 n1_m1_340000_86400 0 9.093720e-08
I8275 n1_m1_340000_91200 0 8.979234e-08
I8276 n1_m1_340000_96000 0 2.176491e-07
I8277 n1_m1_340000_100800 0 4.222560e-07
I8278 n1_m1_340000_105600 0 9.475516e-07
I8279 n1_m1_340000_110400 0 4.967362e-07
I8280 n1_m1_340000_115200 0 2.110186e-07
I8281 n1_m1_340000_120000 0 2.379246e-07
I8282 n1_m1_340000_124800 0 1.317902e-07
I8283 n1_m1_340000_129600 0 1.354619e-07
I8284 n1_m1_340000_134400 0 8.933974e-08
I8285 n1_m1_340000_139200 0 8.942332e-08
I8286 n1_m1_340000_144000 0 1.397653e-07
I8287 n1_m1_340000_148800 0 8.646911e-08
I8288 n1_m1_340000_153600 0 1.297037e-07
I8289 n1_m1_340000_158400 0 8.646911e-08
I8290 n1_m1_340000_163200 0 8.646911e-08
I8291 n1_m1_340000_168000 0 1.297828e-07
I8292 n1_m1_340000_172800 0 8.694417e-08
I8293 n1_m1_340000_177600 0 1.587615e-07
I8294 n1_m1_340000_182400 0 9.442090e-08
I8295 n1_m1_340000_187200 0 9.198721e-08
I8296 n1_m1_340000_192000 0 1.484323e-07
I8297 n1_m1_340000_196800 0 2.322235e-07
I8298 n1_m1_340000_201600 0 2.963279e-07
I8299 n1_m1_340000_206400 0 9.090978e-08
I8300 n1_m1_340000_211200 0 9.065455e-08
I8301 n1_m1_340000_216000 0 1.327611e-07
I8302 n1_m1_340000_220800 0 9.518018e-08
I8303 n1_m1_340000_225600 0 1.313622e-07
I8304 n1_m1_340000_230400 0 8.982410e-08
I8305 n1_m1_340000_235200 0 9.380396e-08
I8306 n1_m1_340000_240000 0 1.378594e-07
I8307 n1_m1_340000_244800 0 8.675352e-08
I8308 n1_m1_340000_249600 0 1.722492e-07
I8309 n1_m1_340000_254400 0 2.561345e-07
I8310 n1_m1_340000_259200 0 2.120385e-07
I8311 n1_m1_340000_264000 0 1.463455e-07
I8312 n1_m1_340000_268800 0 8.736956e-08
I8313 n1_m1_340000_273600 0 1.275832e-07
I8314 n1_m1_340000_278400 0 8.861554e-08
I8315 n1_m1_340000_283200 0 8.490263e-08
I8316 n1_m1_340000_288000 0 1.468887e-07
I8317 n1_m1_340000_292800 0 1.245626e-07
I8318 n1_m1_340000_297600 0 1.531534e-07
I8319 n1_m1_340000_302400 0 9.257887e-08
I8320 n1_m1_340000_307200 0 1.448069e-07
I8321 n1_m1_340000_312000 0 1.850744e-07
I8322 n1_m1_340000_316800 0 8.834337e-08
I8323 n1_m1_340000_321600 0 1.297234e-07
I8324 n1_m1_340000_326400 0 8.714663e-08
I8325 n1_m1_340000_331200 0 9.086133e-08
I8326 n1_m1_340000_336000 0 1.297037e-07
I8327 n1_m1_340000_340800 0 8.646911e-08
I8328 n1_m1_340000_345600 0 1.298445e-07
I8329 n1_m1_340000_350400 0 8.660722e-08
I8330 n1_m1_340000_355200 0 8.660722e-08
I8331 n1_m1_340000_360000 0 1.299108e-07
I8332 n1_m1_340000_364800 0 8.660722e-08
I8333 n1_m1_340000_369600 0 1.299108e-07
I8334 n1_m1_340000_374400 0 8.662087e-08
I8335 n1_m1_340000_379200 0 8.673304e-08
I8336 n1_m1_340000_384000 0 1.271769e-07
I8337 n1_m1_340000_388800 0 8.428231e-08
I8338 n1_m1_340000_393600 0 1.257599e-07
I8339 n1_m1_340000_398400 0 7.994513e-08
I8340 n1_m1_340000_403200 0 7.994513e-08
I8341 n1_m1_340000_408000 0 8.214124e-08
I8342 n1_m1_368000_0 0 7.925780e-08
I8343 n1_m1_368000_4800 0 7.907499e-08
I8344 n1_m1_368000_9600 0 1.235896e-07
I8345 n1_m1_368000_14400 0 1.060272e-07
I8346 n1_m1_368000_19200 0 1.911607e-07
I8347 n1_m1_368000_24000 0 7.838128e-07
I8348 n1_m1_368000_28800 0 5.133651e-07
I8349 n1_m1_368000_33600 0 2.970949e-07
I8350 n1_m1_368000_38400 0 1.783065e-07
I8351 n1_m1_368000_43200 0 1.427260e-07
I8352 n1_m1_368000_48000 0 1.523064e-07
I8353 n1_m1_368000_52800 0 9.043468e-08
I8354 n1_m1_368000_57600 0 1.290858e-07
I8355 n1_m1_368000_62400 0 8.327618e-08
I8356 n1_m1_368000_67200 0 8.327618e-08
I8357 n1_m1_368000_72000 0 1.269210e-07
I8358 n1_m1_368000_76800 0 1.591582e-07
I8359 n1_m1_368000_81600 0 1.433102e-07
I8360 n1_m1_368000_86400 0 8.532233e-08
I8361 n1_m1_368000_91200 0 8.683837e-08
I8362 n1_m1_368000_96000 0 1.357190e-07
I8363 n1_m1_368000_100800 0 8.622293e-08
I8364 n1_m1_368000_105600 0 1.388315e-07
I8365 n1_m1_368000_110400 0 9.361461e-08
I8366 n1_m1_368000_115200 0 1.527338e-07
I8367 n1_m1_368000_120000 0 1.977411e-07
I8368 n1_m1_368000_124800 0 9.771058e-08
I8369 n1_m1_368000_129600 0 1.690620e-07
I8370 n1_m1_368000_134400 0 2.650648e-07
I8371 n1_m1_368000_139200 0 4.842432e-07
I8372 n1_m1_368000_144000 0 8.206928e-07
I8373 n1_m1_368000_148800 0 2.799867e-07
I8374 n1_m1_368000_153600 0 1.554145e-07
I8375 n1_m1_368000_158400 0 8.660722e-08
I8376 n1_m1_368000_163200 0 8.730065e-08
I8377 n1_m1_368000_168000 0 1.308370e-07
I8378 n1_m1_368000_172800 0 8.941221e-08
I8379 n1_m1_368000_177600 0 1.377506e-07
I8380 n1_m1_368000_182400 0 1.594446e-07
I8381 n1_m1_368000_187200 0 1.430973e-07
I8382 n1_m1_368000_192000 0 1.379854e-07
I8383 n1_m1_368000_196800 0 9.459767e-08
I8384 n1_m1_368000_201600 0 1.338073e-07
I8385 n1_m1_368000_206400 0 1.080137e-07
I8386 n1_m1_368000_211200 0 3.742764e-07
I8387 n1_m1_368000_216000 0 5.650809e-07
I8388 n1_m1_368000_220800 0 3.939975e-07
I8389 n1_m1_368000_225600 0 2.334057e-07
I8390 n1_m1_368000_230400 0 9.419673e-08
I8391 n1_m1_368000_235200 0 8.742374e-08
I8392 n1_m1_368000_240000 0 1.347258e-07
I8393 n1_m1_368000_244800 0 8.894505e-08
I8394 n1_m1_368000_249600 0 1.309630e-07
I8395 n1_m1_368000_254400 0 8.604501e-08
I8396 n1_m1_368000_259200 0 1.004676e-07
I8397 n1_m1_368000_264000 0 1.616159e-07
I8398 n1_m1_368000_268800 0 8.549173e-08
I8399 n1_m1_368000_273600 0 1.262780e-07
I8400 n1_m1_368000_278400 0 8.438151e-08
I8401 n1_m1_368000_283200 0 1.013699e-07
I8402 n1_m1_368000_288000 0 1.766373e-07
I8403 n1_m1_368000_292800 0 9.317142e-08
I8404 n1_m1_368000_297600 0 1.549144e-07
I8405 n1_m1_368000_302400 0 1.435364e-07
I8406 n1_m1_368000_307200 0 2.537900e-07
I8407 n1_m1_368000_312000 0 3.644486e-07
I8408 n1_m1_368000_316800 0 2.706208e-07
I8409 n1_m1_368000_321600 0 2.953534e-07
I8410 n1_m1_368000_326400 0 9.388434e-08
I8411 n1_m1_368000_331200 0 8.637689e-08
I8412 n1_m1_368000_336000 0 1.264859e-07
I8413 n1_m1_368000_340800 0 8.493439e-08
I8414 n1_m1_368000_345600 0 1.299108e-07
I8415 n1_m1_368000_350400 0 8.621481e-08
I8416 n1_m1_368000_355200 0 8.560791e-08
I8417 n1_m1_368000_360000 0 1.258323e-07
I8418 n1_m1_368000_364800 0 8.812569e-08
I8419 n1_m1_368000_369600 0 1.367939e-07
I8420 n1_m1_368000_374400 0 1.186287e-07
I8421 n1_m1_368000_379200 0 2.956243e-07
I8422 n1_m1_368000_384000 0 6.732290e-07
I8423 n1_m1_368000_388800 0 4.186306e-07
I8424 n1_m1_368000_393600 0 2.538652e-07
I8425 n1_m1_368000_398400 0 8.314212e-08
I8426 n1_m1_368000_403200 0 7.689275e-08
I8427 n1_m1_368000_408000 0 7.496968e-08
I8428 n1_m1_396000_0 0 8.363766e-08
I8429 n1_m1_396000_4800 0 7.770348e-08
I8430 n1_m1_396000_9600 0 1.106548e-07
I8431 n1_m1_396000_14400 0 8.198438e-08
I8432 n1_m1_396000_19200 0 8.228211e-08
I8433 n1_m1_396000_24000 0 1.227517e-07
I8434 n1_m1_396000_28800 0 8.287266e-08
I8435 n1_m1_396000_33600 0 1.249904e-07
I8436 n1_m1_396000_38400 0 8.024689e-08
I8437 n1_m1_396000_43200 0 8.453969e-08
I8438 n1_m1_396000_48000 0 2.069217e-07
I8439 n1_m1_396000_52800 0 1.005412e-07
I8440 n1_m1_396000_57600 0 1.208810e-07
I8441 n1_m1_396000_62400 0 8.154566e-08
I8442 n1_m1_396000_67200 0 8.230331e-08
I8443 n1_m1_396000_72000 0 1.302761e-07
I8444 n1_m1_396000_76800 0 8.261048e-08
I8445 n1_m1_396000_81600 0 1.268860e-07
I8446 n1_m1_396000_86400 0 8.491068e-08
I8447 n1_m1_396000_91200 0 8.106631e-08
I8448 n1_m1_396000_96000 0 1.195183e-07
I8449 n1_m1_396000_100800 0 8.345692e-08
I8450 n1_m1_396000_105600 0 1.294185e-07
I8451 n1_m1_396000_110400 0 8.561344e-08
I8452 n1_m1_396000_115200 0 8.831118e-08
I8453 n1_m1_396000_120000 0 2.110218e-07
I8454 n1_m1_396000_124800 0 2.254020e-07
I8455 n1_m1_396000_129600 0 2.735372e-07
I8456 n1_m1_396000_134400 0 9.410218e-08
I8457 n1_m1_396000_139200 0 8.522999e-08
I8458 n1_m1_396000_144000 0 1.287860e-07
I8459 n1_m1_396000_148800 0 8.917457e-08
I8460 n1_m1_396000_153600 0 1.373463e-07
I8461 n1_m1_396000_158400 0 8.831872e-08
I8462 n1_m1_396000_163200 0 8.830437e-08
I8463 n1_m1_396000_168000 0 1.306573e-07
I8464 n1_m1_396000_172800 0 8.434157e-08
I8465 n1_m1_396000_177600 0 1.295872e-07
I8466 n1_m1_396000_182400 0 8.361878e-08
I8467 n1_m1_396000_187200 0 8.374584e-08
I8468 n1_m1_396000_192000 0 1.280567e-07
I8469 n1_m1_396000_196800 0 8.980140e-08
I8470 n1_m1_396000_201600 0 1.570984e-07
I8471 n1_m1_396000_206400 0 9.321914e-08
I8472 n1_m1_396000_211200 0 8.974287e-08
I8473 n1_m1_396000_216000 0 1.306059e-07
I8474 n1_m1_396000_220800 0 1.762126e-07
I8475 n1_m1_396000_225600 0 5.533186e-07
I8476 n1_m1_396000_230400 0 4.704840e-07
I8477 n1_m1_396000_235200 0 4.788994e-07
I8478 n1_m1_396000_240000 0 4.031850e-07
I8479 n1_m1_396000_244800 0 8.621389e-08
I8480 n1_m1_396000_249600 0 1.360895e-07
I8481 n1_m1_396000_254400 0 9.630776e-08
I8482 n1_m1_396000_259200 0 1.070063e-07
I8483 n1_m1_396000_264000 0 1.367422e-07
I8484 n1_m1_396000_268800 0 8.291896e-08
I8485 n1_m1_396000_273600 0 1.342774e-07
I8486 n1_m1_396000_278400 0 9.113371e-08
I8487 n1_m1_396000_283200 0 8.357822e-08
I8488 n1_m1_396000_288000 0 1.249782e-07
I8489 n1_m1_396000_292800 0 8.755256e-08
I8490 n1_m1_396000_297600 0 1.364282e-07
I8491 n1_m1_396000_302400 0 9.065099e-08
I8492 n1_m1_396000_307200 0 9.315169e-08
I8493 n1_m1_396000_312000 0 1.338844e-07
I8494 n1_m1_396000_316800 0 8.302166e-08
I8495 n1_m1_396000_321600 0 1.207125e-07
I8496 n1_m1_396000_326400 0 8.317703e-08
I8497 n1_m1_396000_331200 0 8.460688e-08
I8498 n1_m1_396000_336000 0 1.229826e-07
I8499 n1_m1_396000_340800 0 8.037368e-08
I8500 n1_m1_396000_345600 0 1.215977e-07
I8501 n1_m1_396000_350400 0 8.644473e-08
I8502 n1_m1_396000_355200 0 9.249107e-08
I8503 n1_m1_396000_360000 0 1.197027e-07
I8504 n1_m1_396000_364800 0 8.634300e-08
I8505 n1_m1_396000_369600 0 1.297994e-07
I8506 n1_m1_396000_374400 0 2.543303e-07
I8507 n1_m1_396000_379200 0 3.495207e-07
I8508 n1_m1_396000_384000 0 2.106462e-07
I8509 n1_m1_396000_388800 0 8.803651e-08
I8510 n1_m1_396000_393600 0 1.254965e-07
I8511 n1_m1_396000_398400 0 7.388425e-08
I8512 n1_m1_396000_403200 0 7.273427e-08
I8513 n1_m1_396000_408000 0 7.429448e-08
.op
.end
