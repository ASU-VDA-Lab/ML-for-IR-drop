R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R114 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R115 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R116 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R117 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R118 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R119 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R120 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R121 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R122 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R123 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R124 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R125 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R126 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R127 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R128 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R129 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R130 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R131 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R132 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R133 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R134 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R135 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R136 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R137 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R138 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R139 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R140 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R141 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R142 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R143 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R144 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R145 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R146 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R147 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R148 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R149 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R150 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R151 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R152 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R153 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R154 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R155 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R156 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R157 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R158 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R159 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R160 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R161 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R162 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R163 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R164 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R165 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R166 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R167 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R168 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R169 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R170 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R171 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R172 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R173 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R174 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R175 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R176 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R177 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R178 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R179 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R180 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R181 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R182 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R183 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R184 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R185 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R186 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R187 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R188 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R189 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R190 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R191 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R192 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R193 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R194 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R195 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R196 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R197 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R198 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R199 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R200 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R201 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R202 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R203 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R204 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R205 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R206 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R207 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R208 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R209 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R210 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R211 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R212 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R213 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R214 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R215 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R216 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R217 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R218 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R219 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R220 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R221 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R222 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R223 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R224 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R225 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R226 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R227 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R228 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R229 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R230 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R231 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R232 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R233 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R234 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R235 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R236 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R237 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R238 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R239 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R240 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R241 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R242 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R243 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R244 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R245 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R246 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R247 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R248 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R249 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R250 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R251 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R252 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R253 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R254 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R255 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R256 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R257 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R258 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R259 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R260 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R261 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R262 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R263 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R264 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R265 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R266 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R267 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R268 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R269 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R270 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R271 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R272 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R273 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R274 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R275 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R276 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R277 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R278 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R279 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R280 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R281 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R282 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R283 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R284 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R285 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R286 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R287 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R288 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R289 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R290 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R291 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R292 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R293 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R294 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R295 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R296 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R297 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R298 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R299 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R300 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R301 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R302 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R303 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R304 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R305 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R306 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R307 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R308 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R309 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R310 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R311 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R312 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R313 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R314 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R315 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R316 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R317 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R318 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R319 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R320 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R321 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R322 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R323 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R324 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R325 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R326 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R327 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R328 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R329 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R330 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R331 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R332 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R333 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R334 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R335 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R336 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R337 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R338 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R339 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R340 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R341 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R342 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R343 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R344 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R345 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R346 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R347 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R348 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R349 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R350 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R351 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R352 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R353 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R354 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R355 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R356 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R357 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R358 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R359 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R360 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R361 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R362 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R363 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R364 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R365 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R366 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R367 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R368 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R369 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R370 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R371 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R372 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R373 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R374 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R375 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R376 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R377 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R378 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R379 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R380 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R381 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R382 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R383 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R384 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R385 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R386 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R387 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R388 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R389 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R390 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R391 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R392 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R393 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R394 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R395 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R396 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R397 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R398 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R399 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R400 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R401 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R402 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R403 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R404 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R405 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R406 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R407 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R408 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R409 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R410 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R411 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R412 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R413 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R414 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R415 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R416 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R417 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R418 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R419 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R420 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R421 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R422 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R423 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R424 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R425 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R426 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R427 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R428 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R429 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R430 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R431 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R432 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R433 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R434 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R435 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R436 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R437 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R438 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R439 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R440 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R441 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R442 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R443 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R444 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R445 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R446 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R447 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R448 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R449 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R450 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R451 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R452 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R453 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R454 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R455 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R456 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R457 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R458 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R459 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R460 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R461 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R462 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R463 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R464 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R465 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R466 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R467 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R468 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R469 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R470 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R471 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R472 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R473 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R474 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R475 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R476 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R477 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R478 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R479 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R480 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R481 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R482 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R483 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R484 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R485 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R486 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R487 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R488 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R489 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R490 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R491 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R492 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R493 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R494 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R495 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R496 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R497 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R498 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R499 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R500 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R501 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R502 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R503 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R504 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R505 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R506 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R507 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R508 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R509 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R510 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R511 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R512 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R513 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R514 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R515 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R516 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R517 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R518 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R519 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R520 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R521 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R522 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R523 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R524 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R525 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R526 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R527 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R528 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R529 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R530 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R531 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R532 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R533 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R534 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R535 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R536 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R537 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R538 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R539 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R540 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R541 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R542 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R543 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R544 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R545 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R546 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R547 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R548 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R549 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R550 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R551 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R552 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R553 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R554 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R555 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R556 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R557 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R558 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R559 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R560 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R561 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R562 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R563 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R564 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R565 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R566 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R567 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R568 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R569 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R570 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R571 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R572 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R573 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R574 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R575 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R576 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R577 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R578 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R579 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R580 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R581 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R582 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R583 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R584 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R585 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R586 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R587 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R588 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R589 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R590 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R591 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R592 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R593 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R594 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R595 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R596 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R597 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R598 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R599 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R600 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R601 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R602 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R603 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R604 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R605 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R606 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R607 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R608 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R609 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R610 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R611 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R612 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R613 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R614 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R615 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R616 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R617 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R618 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R619 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R620 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R621 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R622 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R623 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R624 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R625 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R626 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R627 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R628 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R629 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R630 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R631 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R632 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R633 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R634 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R635 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R636 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R637 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R638 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R639 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R640 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R641 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R642 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R643 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R644 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R645 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R646 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R647 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R648 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R649 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R650 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R651 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R652 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R653 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R654 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R655 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R656 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R657 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R658 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R659 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R660 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R661 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R662 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R663 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R664 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R665 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R666 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R667 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R668 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R669 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R670 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R671 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R672 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R673 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R674 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R675 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R676 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R677 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R678 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R679 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R680 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R681 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R682 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R683 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R684 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R685 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R686 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R687 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R688 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R689 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R690 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R691 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R692 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R693 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R694 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R695 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R696 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R697 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R698 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R699 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R700 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R701 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R702 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R703 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R704 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R705 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R706 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R707 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R708 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R709 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R710 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R711 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R712 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R713 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R714 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R715 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R716 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R717 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R718 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R719 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R720 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R721 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R722 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R723 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R724 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R725 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R726 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R727 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R728 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R729 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R730 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R731 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R732 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R733 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R734 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R735 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R736 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R737 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R738 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R739 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R740 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R741 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R742 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R743 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R744 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R745 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R746 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R747 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R748 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R749 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R750 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R751 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R752 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R753 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R754 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R755 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R756 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R757 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R758 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R759 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R760 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R761 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R762 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R763 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R764 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R765 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R766 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R767 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R768 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R769 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R770 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R771 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R772 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R773 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R774 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R775 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R776 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R777 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R778 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R779 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R780 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R781 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R782 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R783 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R784 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R785 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R786 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R787 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R788 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R789 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R790 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R791 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R792 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R793 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R794 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R795 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R796 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R797 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R798 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R799 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R800 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R801 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R802 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R803 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R804 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R805 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R806 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R807 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R808 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R809 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R810 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R811 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R812 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R813 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R814 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R815 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R816 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R817 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R818 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R819 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R820 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R821 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R822 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R823 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R824 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R825 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R826 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R827 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R828 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R829 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R830 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R831 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R832 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R833 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R834 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R835 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R836 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R837 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R838 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R839 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R840 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R841 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R842 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R843 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R844 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R845 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R846 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R847 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R848 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R849 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R850 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R851 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R852 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R853 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R854 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R855 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R856 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R857 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R858 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R859 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R860 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R861 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R862 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R863 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R864 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R865 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R866 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R867 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R868 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R869 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R870 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R871 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R872 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R873 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R874 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R875 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R876 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R877 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R878 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R879 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R880 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R881 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R882 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R883 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R884 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R885 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R886 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R887 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R888 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R889 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R890 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R891 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R892 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R893 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R894 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R895 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R896 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R897 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R898 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R899 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R900 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R901 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R902 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R903 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R904 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R905 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R906 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R907 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R908 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R909 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R910 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R911 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R912 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R913 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R914 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R915 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R916 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R917 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R918 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R919 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R920 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R921 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R922 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R923 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R924 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R925 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R926 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R927 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R928 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R929 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R930 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R931 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R932 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R933 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R934 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R935 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R936 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R937 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R938 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R939 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R940 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R941 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R942 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R943 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R944 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R945 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R946 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R947 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R948 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R949 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R950 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R951 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R952 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R953 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R954 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R955 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R956 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R957 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R958 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R959 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R960 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R961 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R962 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R963 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R964 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R965 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R966 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R967 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R968 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R969 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R970 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R971 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R972 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R973 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R974 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R975 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R976 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R977 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R978 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R979 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R980 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R981 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R982 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R983 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R984 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R985 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R986 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R987 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R988 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R989 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R990 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R991 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R992 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R993 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R994 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R995 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R996 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R997 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R998 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R999 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1000 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1001 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1002 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1003 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1004 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1005 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1006 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1007 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1008 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1009 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1010 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1011 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1012 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1013 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1014 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1015 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1016 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1017 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1018 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1019 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1020 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1021 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1022 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1023 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1024 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1025 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1026 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1027 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1028 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1029 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1030 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1031 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1032 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1033 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1034 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1035 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1036 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1037 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1038 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1039 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1040 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1041 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1042 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1043 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1044 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1045 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1046 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1047 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1048 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1049 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1050 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1051 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1052 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1053 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1054 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1055 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1056 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1057 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1058 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1059 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1060 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1061 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1062 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1063 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1064 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1065 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1066 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1067 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1068 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1069 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1070 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1071 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1072 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1073 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1074 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1075 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1076 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1077 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1078 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1079 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1080 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1081 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1082 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1083 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1084 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1085 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1086 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1087 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1088 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1089 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1090 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1091 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1092 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1093 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1094 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1095 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1096 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1097 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1098 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1099 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1100 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1101 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1102 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1103 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1104 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1105 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1106 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1107 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1108 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1109 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1110 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1111 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1112 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1113 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1114 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1115 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1116 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1117 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1118 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1119 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1120 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1121 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1122 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1123 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1124 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1125 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1126 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1127 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1128 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1129 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1130 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1131 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1132 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1133 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1134 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1135 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1136 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1137 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1138 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1139 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1140 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1141 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1142 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1143 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1144 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1145 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1146 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1147 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1148 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1149 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1150 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1151 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1152 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1153 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1154 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1155 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1156 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1157 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1158 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1159 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1160 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1161 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1162 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1163 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1164 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1165 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1166 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1167 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1168 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1169 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1170 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1171 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1172 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1173 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1174 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1175 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1176 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1177 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1178 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1179 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1180 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1181 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1182 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1183 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1184 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1185 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1186 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1187 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1188 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1189 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1190 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1191 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1192 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1193 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1194 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1195 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1196 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1197 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1198 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1199 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1200 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1201 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1202 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1203 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1204 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1205 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1206 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1207 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1208 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1209 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1210 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1211 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1212 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1213 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1214 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1215 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1216 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1217 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1218 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1219 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1220 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1221 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1222 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1223 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1224 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1225 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1226 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1227 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1228 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1229 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1230 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1231 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1232 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1233 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1234 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1235 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1236 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1237 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1238 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1239 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1240 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1241 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1242 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1243 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1244 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1245 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1246 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1247 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1248 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1249 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1250 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1251 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1252 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1253 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1254 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1255 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1256 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1257 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1258 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1259 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1260 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1261 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1262 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1263 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1264 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1265 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1266 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1267 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1268 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1269 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1270 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1271 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1272 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1273 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1274 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1275 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1276 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1277 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1278 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1279 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1280 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1281 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1282 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1283 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1284 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1285 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1286 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1287 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1288 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1289 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1290 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1291 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1292 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1293 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1294 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1295 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1296 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1297 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1298 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1299 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1300 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1301 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1302 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1303 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1304 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1305 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1306 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1307 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1308 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1309 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1310 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1311 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1312 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1313 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1314 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1315 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1316 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1317 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1318 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1319 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1320 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1321 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1322 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1323 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1324 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1325 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1326 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1327 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1328 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1329 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1330 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1331 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1332 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1333 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1334 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1335 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1336 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1337 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1338 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1339 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1340 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1341 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1342 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1343 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1344 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1345 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1346 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1347 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1348 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1349 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1350 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1351 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1352 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1353 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1354 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1355 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1356 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1357 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1358 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1359 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1360 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1361 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1362 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1363 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1364 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1365 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1366 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1367 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1368 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1369 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1370 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1371 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1372 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1373 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1374 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1375 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1376 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1377 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1378 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1379 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1380 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1381 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1382 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1383 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1384 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1385 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1386 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1387 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1388 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1389 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1390 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1391 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1392 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1393 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1394 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1395 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1396 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1397 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1398 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1399 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1400 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1401 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1402 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1403 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1404 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1405 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1406 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1407 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1408 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1409 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1410 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1411 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1412 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1413 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1414 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1415 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1416 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1417 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1418 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1419 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1420 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1421 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1422 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1423 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1424 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1425 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1426 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1427 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1428 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1429 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1430 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1431 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1432 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1433 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1434 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1435 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1436 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1437 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1438 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1439 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1440 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1441 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1442 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1443 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1444 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1445 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1446 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1447 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1448 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1449 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1450 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1451 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1452 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1453 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1454 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1455 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1456 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1457 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1458 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1459 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1460 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1461 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1462 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1463 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1464 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1465 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1466 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1467 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1468 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1469 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1470 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1471 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1472 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1473 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1474 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1475 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1476 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1477 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1478 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1479 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1480 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1481 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1482 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1483 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1484 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1485 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1486 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1487 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1488 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1489 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1490 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1491 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1492 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1493 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1494 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1495 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1496 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1497 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1498 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1499 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1500 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1501 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1502 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1503 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1504 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1505 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1506 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1507 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1508 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1509 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1510 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1511 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1512 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1513 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1514 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1515 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1516 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1517 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1518 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1519 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1520 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1521 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1522 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1523 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1524 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1525 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1526 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1527 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1528 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1529 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1530 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1531 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1532 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1533 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1534 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1535 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1536 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1537 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1538 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1539 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1540 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1541 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1542 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1543 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1544 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1545 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1546 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1547 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1548 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1549 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1550 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1551 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1552 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1553 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1554 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1555 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1556 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1557 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1558 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1559 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1560 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1561 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1562 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1563 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1564 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1565 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1566 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1567 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1568 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1569 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1570 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1571 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1572 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1573 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1574 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1575 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1576 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1577 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1578 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1579 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1580 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1581 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1582 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1583 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1584 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1585 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1586 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1587 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1588 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1589 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1590 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1591 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1592 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1593 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1594 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1595 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1596 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1597 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1598 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1599 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1600 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1601 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1602 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1603 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1604 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1605 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1606 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1607 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1608 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1609 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1610 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1611 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1612 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1613 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1614 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1615 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1616 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1617 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1618 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1619 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1620 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1621 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1622 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1623 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1624 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1625 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1626 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1627 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1628 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1629 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1630 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1631 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1632 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1633 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1634 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1635 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1636 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1637 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1638 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1639 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1640 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1641 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1642 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1643 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1644 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1645 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1646 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1647 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1648 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1649 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1650 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1651 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1652 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1653 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1654 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1655 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1656 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1657 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1658 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1659 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1660 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1661 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1662 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1663 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1664 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1665 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1666 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1667 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1668 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1669 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1670 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1671 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1672 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1673 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1674 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1675 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1676 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1677 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1678 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1679 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1680 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R1681 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R1682 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R1683 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R1684 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R1685 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R1686 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R1687 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R1688 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R1689 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R1690 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R1691 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R1692 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R1693 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R1694 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R1695 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1696 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1697 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1698 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1699 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R1700 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R1701 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R1702 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R1703 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R1704 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R1705 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R1706 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R1707 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R1708 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R1709 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R1710 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R1711 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R1712 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R1713 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R1714 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R1715 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R1716 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R1717 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R1718 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R1719 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R1720 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R1721 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R1722 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R1723 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R1724 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R1725 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R1726 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R1727 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R1728 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R1729 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R1730 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R1731 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R1732 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R1733 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R1734 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R1735 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R1736 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R1737 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R1738 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R1739 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R1740 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R1741 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R1742 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R1743 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R1744 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R1745 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R1746 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R1747 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R1748 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R1749 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R1750 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R1751 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R1752 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R1753 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R1754 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R1755 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R1756 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R1757 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R1758 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R1759 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R1760 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R1761 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R1762 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R1763 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R1764 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R1765 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R1766 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R1767 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R1768 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R1769 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R1770 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R1771 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R1772 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R1773 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R1774 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R1775 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R1776 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R1777 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R1778 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R1779 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R1780 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R1781 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R1782 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R1783 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R1784 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R1785 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R1786 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R1787 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R1788 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R1789 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R1790 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R1791 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R1792 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R1793 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R1794 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R1795 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R1796 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R1797 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R1798 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R1799 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R1800 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R1801 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R1802 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R1803 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R1804 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R1805 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R1806 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R1807 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R1808 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R1809 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R1810 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R1811 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R1812 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R1813 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R1814 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R1815 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R1816 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R1817 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R1818 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R1819 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R1820 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R1821 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R1822 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R1823 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R1824 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R1825 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R1826 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R1827 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R1828 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R1829 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R1830 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R1831 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R1832 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R1833 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R1834 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R1835 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R1836 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R1837 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R1838 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R1839 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R1840 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R1841 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R1842 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R1843 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R1844 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R1845 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R1846 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R1847 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R1848 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R1849 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R1850 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R1851 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R1852 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R1853 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R1854 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R1855 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R1856 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R1857 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R1858 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R1859 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R1860 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R1861 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R1862 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R1863 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R1864 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R1865 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R1866 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R1867 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R1868 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R1869 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R1870 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R1871 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R1872 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R1873 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R1874 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R1875 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R1876 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R1877 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R1878 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R1879 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R1880 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R1881 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R1882 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R1883 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R1884 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R1885 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R1886 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R1887 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R1888 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R1889 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R1890 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R1891 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R1892 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R1893 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R1894 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R1895 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R1896 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R1897 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R1898 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R1899 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R1900 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R1901 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R1902 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R1903 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R1904 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R1905 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R1906 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R1907 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R1908 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R1909 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R1910 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R1911 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R1912 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R1913 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R1914 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R1915 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R1916 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R1917 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R1918 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R1919 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R1920 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R1921 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R1922 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R1923 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R1924 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R1925 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R1926 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R1927 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R1928 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R1929 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R1930 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R1931 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R1932 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R1933 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R1934 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R1935 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R1936 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R1937 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R1938 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R1939 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R1940 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R1941 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R1942 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R1943 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R1944 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R1945 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R1946 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R1947 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R1948 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R1949 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R1950 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R1951 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R1952 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R1953 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R1954 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R1955 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R1956 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R1957 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R1958 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R1959 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R1960 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R1961 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R1962 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R1963 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R1964 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R1965 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R1966 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R1967 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R1968 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R1969 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R1970 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R1971 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R1972 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R1973 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R1974 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R1975 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R1976 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R1977 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R1978 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R1979 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R1980 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R1981 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R1982 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R1983 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R1984 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R1985 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R1986 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R1987 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R1988 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R1989 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R1990 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R1991 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R1992 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R1993 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R1994 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R1995 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R1996 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R1997 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R1998 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R1999 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2000 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2001 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2002 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2003 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2004 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2005 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2006 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2007 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2008 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2009 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2010 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2011 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2012 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2013 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2014 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2015 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2016 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2017 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2018 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2019 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2020 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2021 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2022 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2023 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2024 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2025 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2026 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2027 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2028 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2029 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2030 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2031 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2032 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2033 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2034 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2035 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2036 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2037 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2038 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2039 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2040 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2041 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2042 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2043 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2044 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2045 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2046 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2047 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2048 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2049 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2050 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2051 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2052 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2053 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2054 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2055 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2056 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2057 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2058 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2059 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2060 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2061 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2062 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2063 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2064 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2065 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2066 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2067 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2068 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2069 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2070 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2071 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2072 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2073 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2074 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2075 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2076 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2077 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2078 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2079 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2080 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2081 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2082 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2083 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2084 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2085 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2086 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2087 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2088 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2089 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2090 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2091 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2092 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2093 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2094 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2095 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2096 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2097 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2098 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2099 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2100 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2101 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2102 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2103 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2104 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2105 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2106 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2107 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2108 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2109 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2110 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2111 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2112 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2113 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2114 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2115 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2116 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2117 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2118 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2119 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2120 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2121 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2122 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2123 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2124 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2125 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2126 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2127 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2128 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2129 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2130 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2131 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2132 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2133 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2134 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2135 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2136 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2137 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2138 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2139 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2140 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2141 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2142 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2143 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2144 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2145 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2146 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2147 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2148 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2149 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2150 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2151 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2152 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2153 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2154 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2155 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2156 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2157 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2158 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2159 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2160 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2161 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2162 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2163 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2164 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2165 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2166 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2167 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2168 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2169 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2170 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2171 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2172 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2173 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2174 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2175 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2176 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2177 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2178 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2179 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2180 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2181 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2182 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2183 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2184 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2185 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2186 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2187 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2188 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2189 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2190 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2191 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2192 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2193 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2194 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2195 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2196 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2197 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2198 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2199 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2200 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2201 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2202 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2203 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2204 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2205 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2206 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2207 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2208 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2209 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2210 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2211 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2212 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2213 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2214 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2215 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2216 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2217 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2218 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2219 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2220 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2221 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2222 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2223 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2224 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2225 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2226 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2227 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2228 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2229 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2230 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2231 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2232 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2233 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2234 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2235 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2236 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2237 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2238 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2239 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2240 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2241 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2242 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2243 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2244 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2245 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2246 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2247 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2248 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2249 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2250 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2251 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2252 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2253 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2254 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2255 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2256 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2257 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2258 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2259 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2260 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2261 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2262 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2263 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2264 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2265 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2266 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2267 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2268 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2269 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2270 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2271 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2272 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2273 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2274 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2275 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2276 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2277 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2278 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2279 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2280 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2281 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2282 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2283 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2284 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2285 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2286 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2287 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2288 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2289 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2290 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2291 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2292 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2293 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2294 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2295 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2296 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2297 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2298 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2299 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2300 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2301 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2302 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2303 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2304 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2305 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2306 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2307 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2308 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2309 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2310 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2311 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2312 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2313 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2314 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2315 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2316 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2317 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2318 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2319 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2320 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2321 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2322 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2323 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2324 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2325 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2326 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2327 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2328 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2329 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2330 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2331 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2332 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2333 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2334 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2335 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2336 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2337 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2338 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2339 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2340 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2341 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2342 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2343 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2344 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2345 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2346 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2347 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2348 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2349 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2350 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2351 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2352 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2353 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2354 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2355 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2356 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2357 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2358 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2359 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2360 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2361 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2362 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2363 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2364 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2365 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2366 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2367 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2368 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2369 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2370 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2371 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2372 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2373 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2374 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2375 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2376 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2377 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2378 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2379 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2380 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2381 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2382 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2383 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2384 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2385 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2386 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2387 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2388 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2389 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2390 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2391 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2392 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2393 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2394 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2395 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2396 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2397 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2398 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2399 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2400 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2401 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2402 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2403 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2404 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2405 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2406 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2407 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2408 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2409 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2410 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2411 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2412 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2413 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2414 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2415 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2416 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2417 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2418 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2419 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2420 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2421 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2422 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2423 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2424 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2425 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2426 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2427 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2428 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2429 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2430 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2431 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2432 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2433 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2434 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2435 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2436 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2437 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2438 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2439 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2440 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2441 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2442 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2443 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2444 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2445 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2446 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2447 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2448 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2449 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2450 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2451 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2452 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2453 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2454 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2455 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2456 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2457 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2458 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2459 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2460 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2461 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2462 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2463 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2464 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2465 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2466 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2467 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2468 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2469 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2470 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2471 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R2472 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R2473 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R2474 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R2475 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R2476 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R2477 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R2478 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R2479 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R2480 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R2481 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R2482 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R2483 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R2484 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R2485 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R2486 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2487 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2488 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2489 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2490 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2491 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2492 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2493 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2494 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2495 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2496 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2497 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2498 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2499 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2500 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2501 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2502 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2503 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2504 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2505 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2506 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2507 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2508 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2509 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2510 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2511 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2512 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2513 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2514 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2515 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2516 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2517 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2518 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2519 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2520 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2521 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2522 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2523 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2524 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2525 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2526 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2527 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2528 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2529 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2530 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2531 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2532 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2533 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2534 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2535 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2536 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2537 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2538 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2539 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2540 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2541 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2542 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2543 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2544 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2545 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2546 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2547 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2548 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2549 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2550 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2551 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2552 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2553 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2554 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2555 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2556 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2557 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2558 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2559 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R2560 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R2561 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R2562 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R2563 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R2564 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R2565 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R2566 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R2567 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R2568 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R2569 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R2570 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R2571 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R2572 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R2573 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R2574 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R2575 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R2576 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R2577 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R2578 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R2579 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R2580 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R2581 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R2582 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R2583 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R2584 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R2585 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R2586 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R2587 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R2588 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R2589 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R2590 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R2591 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R2592 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R2593 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R2594 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R2595 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R2596 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R2597 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R2598 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R2599 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R2600 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R2601 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R2602 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R2603 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R2604 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R2605 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R2606 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R2607 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R2608 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R2609 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R2610 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R2611 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R2612 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R2613 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R2614 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R2615 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R2616 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R2617 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R2618 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R2619 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R2620 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R2621 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R2622 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R2623 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R2624 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R2625 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R2626 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R2627 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R2628 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R2629 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R2630 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R2631 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R2632 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R2633 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R2634 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R2635 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R2636 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R2637 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R2638 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R2639 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R2640 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R2641 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R2642 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R2643 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R2644 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R2645 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R2646 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R2647 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R2648 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R2649 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R2650 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R2651 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R2652 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R2653 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R2654 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R2655 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R2656 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R2657 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R2658 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R2659 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R2660 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R2661 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R2662 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R2663 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R2664 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R2665 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R2666 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R2667 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R2668 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R2669 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R2670 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R2671 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R2672 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R2673 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R2674 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R2675 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R2676 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R2677 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R2678 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R2679 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R2680 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R2681 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R2682 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R2683 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R2684 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R2685 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R2686 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R2687 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R2688 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R2689 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R2690 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R2691 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R2692 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R2693 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R2694 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R2695 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R2696 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R2697 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R2698 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R2699 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R2700 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R2701 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R2702 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R2703 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R2704 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R2705 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R2706 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R2707 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R2708 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R2709 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R2710 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R2711 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R2712 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R2713 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R2714 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R2715 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R2716 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R2717 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R2718 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R2719 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R2720 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R2721 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R2722 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R2723 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R2724 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R2725 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R2726 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R2727 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R2728 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R2729 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R2730 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R2731 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R2732 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R2733 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R2734 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R2735 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R2736 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R2737 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R2738 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R2739 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R2740 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R2741 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R2742 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R2743 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R2744 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R2745 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R2746 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R2747 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R2748 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R2749 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R2750 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R2751 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R2752 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R2753 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R2754 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R2755 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R2756 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R2757 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R2758 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R2759 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R2760 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R2761 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R2762 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R2763 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R2764 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R2765 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R2766 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R2767 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R2768 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R2769 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R2770 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R2771 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R2772 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R2773 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R2774 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R2775 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R2776 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R2777 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R2778 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R2779 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R2780 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R2781 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R2782 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R2783 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R2784 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R2785 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R2786 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R2787 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R2788 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R2789 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R2790 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R2791 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R2792 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R2793 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R2794 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R2795 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R2796 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R2797 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R2798 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R2799 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R2800 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R2801 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R2802 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R2803 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R2804 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R2805 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R2806 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R2807 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R2808 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R2809 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R2810 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R2811 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R2812 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R2813 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R2814 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R2815 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R2816 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R2817 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R2818 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R2819 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R2820 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R2821 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R2822 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R2823 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R2824 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R2825 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R2826 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R2827 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R2828 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R2829 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R2830 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R2831 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R2832 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R2833 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R2834 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R2835 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R2836 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R2837 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R2838 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R2839 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R2840 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R2841 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R2842 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R2843 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R2844 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R2845 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R2846 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R2847 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R2848 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R2849 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R2850 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R2851 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R2852 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R2853 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R2854 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R2855 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R2856 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R2857 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R2858 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R2859 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R2860 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R2861 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R2862 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R2863 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R2864 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R2865 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R2866 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R2867 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R2868 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R2869 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R2870 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R2871 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R2872 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R2873 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R2874 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R2875 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R2876 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R2877 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R2878 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R2879 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R2880 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R2881 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R2882 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R2883 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R2884 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R2885 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R2886 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R2887 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R2888 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R2889 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R2890 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R2891 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R2892 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R2893 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R2894 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R2895 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R2896 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R2897 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R2898 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R2899 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R2900 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R2901 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R2902 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R2903 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R2904 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R2905 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R2906 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R2907 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R2908 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R2909 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R2910 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R2911 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R2912 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R2913 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R2914 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R2915 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R2916 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R2917 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R2918 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R2919 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R2920 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R2921 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R2922 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R2923 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R2924 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R2925 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R2926 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R2927 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R2928 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R2929 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R2930 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R2931 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R2932 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R2933 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R2934 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R2935 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R2936 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R2937 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R2938 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R2939 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R2940 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R2941 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R2942 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R2943 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R2944 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R2945 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R2946 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R2947 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R2948 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R2949 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R2950 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R2951 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R2952 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R2953 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R2954 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R2955 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R2956 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R2957 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R2958 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R2959 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R2960 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R2961 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R2962 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R2963 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R2964 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R2965 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R2966 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R2967 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R2968 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R2969 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R2970 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R2971 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R2972 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R2973 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R2974 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R2975 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R2976 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R2977 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R2978 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R2979 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R2980 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R2981 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R2982 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R2983 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R2984 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R2985 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R2986 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R2987 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R2988 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R2989 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R2990 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R2991 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R2992 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R2993 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R2994 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R2995 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R2996 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R2997 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R2998 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R2999 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3000 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3001 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3002 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3003 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3004 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3005 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3006 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3007 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3008 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3009 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3010 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3011 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3012 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3013 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3014 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3015 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3016 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3017 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3018 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3019 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3020 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3021 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3022 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3023 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3024 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3025 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3026 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3027 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3028 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3029 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3030 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3031 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3032 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3033 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3034 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3035 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3036 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3037 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3038 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3039 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3040 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3041 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3042 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3043 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3044 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3045 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3046 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3047 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3048 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3049 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3050 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3051 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3052 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3053 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3054 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3055 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3056 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3057 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3058 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3059 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3060 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3061 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3062 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3063 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3064 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3065 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3066 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3067 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3068 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3069 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3070 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3071 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3072 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3073 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3074 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3075 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3076 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3077 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3078 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3079 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3080 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3081 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3082 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3083 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3084 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3085 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3086 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3087 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3088 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3089 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3090 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3091 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3092 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3093 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3094 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3095 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3096 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3097 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3098 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3099 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3100 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3101 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3102 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3103 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3104 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3105 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3106 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3107 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3108 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3109 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3110 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3111 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3112 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3113 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3114 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3115 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3116 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3117 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3118 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3119 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3120 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3121 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3122 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3123 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3124 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3125 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3126 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3127 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3128 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3129 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3130 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3131 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3132 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3133 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3134 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3135 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3136 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3137 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3138 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3139 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3140 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3141 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3142 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3143 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3144 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3145 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3146 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3147 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3148 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3149 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3150 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3151 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3152 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3153 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3154 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3155 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3156 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3157 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3158 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3159 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3160 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3161 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3162 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3163 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3164 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R3165 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R3166 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R3167 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R3168 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R3169 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R3170 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R3171 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R3172 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R3173 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R3174 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R3175 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R3176 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R3177 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R3178 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R3179 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R3180 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R3181 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R3182 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R3183 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R3184 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R3185 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R3186 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R3187 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R3188 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R3189 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R3190 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R3191 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R3192 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R3193 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R3194 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R3195 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R3196 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R3197 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R3198 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R3199 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R3200 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R3201 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R3202 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R3203 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R3204 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R3205 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R3206 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R3207 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R3208 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R3209 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R3210 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R3211 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R3212 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R3213 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R3214 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R3215 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R3216 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R3217 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R3218 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R3219 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R3220 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R3221 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R3222 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R3223 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R3224 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R3225 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R3226 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R3227 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R3228 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R3229 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R3230 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R3231 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R3232 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R3233 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R3234 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R3235 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R3236 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R3237 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R3238 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R3239 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R3240 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R3241 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R3242 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R3243 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R3244 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R3245 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R3246 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R3247 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R3248 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R3249 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R3250 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R3251 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R3252 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R3253 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R3254 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R3255 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R3256 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R3257 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R3258 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R3259 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R3260 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R3261 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R3262 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R3263 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R3264 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R3265 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R3266 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R3267 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R3268 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R3269 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R3270 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R3271 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R3272 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R3273 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R3274 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R3275 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R3276 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R3277 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R3278 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R3279 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R3280 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R3281 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R3282 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R3283 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R3284 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R3285 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R3286 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R3287 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R3288 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R3289 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R3290 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R3291 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R3292 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R3293 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R3294 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R3295 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R3296 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R3297 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R3298 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R3299 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R3300 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R3301 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R3302 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R3303 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R3304 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R3305 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R3306 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R3307 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R3308 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R3309 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R3310 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R3311 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R3312 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R3313 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R3314 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R3315 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R3316 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R3317 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R3318 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R3319 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R3320 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R3321 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R3322 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R3323 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R3324 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R3325 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R3326 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R3327 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R3328 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R3329 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R3330 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R3331 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R3332 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R3333 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R3334 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R3335 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R3336 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R3337 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R3338 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R3339 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R3340 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R3341 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R3342 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R3343 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R3344 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R3345 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R3346 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R3347 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R3348 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R3349 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R3350 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R3351 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R3352 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R3353 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R3354 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R3355 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R3356 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R3357 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R3358 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R3359 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R3360 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R3361 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R3362 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R3363 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R3364 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R3365 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R3366 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R3367 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R3368 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R3369 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R3370 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R3371 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R3372 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R3373 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R3374 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R3375 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R3376 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R3377 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R3378 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R3379 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R3380 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R3381 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R3382 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R3383 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R3384 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R3385 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R3386 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R3387 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R3388 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R3389 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R3390 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R3391 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R3392 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R3393 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R3394 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R3395 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R3396 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R3397 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R3398 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R3399 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R3400 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R3401 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R3402 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R3403 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R3404 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R3405 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R3406 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R3407 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R3408 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R3409 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R3410 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R3411 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R3412 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R3413 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R3414 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R3415 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R3416 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R3417 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R3418 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R3419 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R3420 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R3421 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R3422 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R3423 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R3424 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R3425 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R3426 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R3427 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R3428 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R3429 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R3430 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R3431 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R3432 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R3433 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R3434 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R3435 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R3436 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R3437 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R3438 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R3439 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R3440 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R3441 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R3442 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R3443 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R3444 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R3445 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R3446 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R3447 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R3448 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R3449 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R3450 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R3451 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R3452 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R3453 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R3454 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R3455 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R3456 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R3457 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R3458 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R3459 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R3460 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R3461 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R3462 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R3463 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R3464 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R3465 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R3466 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R3467 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R3468 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R3469 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R3470 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R3471 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R3472 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R3473 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R3474 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R3475 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R3476 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R3477 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R3478 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R3479 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R3480 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R3481 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R3482 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R3483 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R3484 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R3485 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R3486 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R3487 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R3488 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R3489 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R3490 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R3491 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R3492 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R3493 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R3494 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R3495 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R3496 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R3497 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R3498 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R3499 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R3500 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R3501 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R3502 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R3503 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R3504 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R3505 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R3506 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R3507 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R3508 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R3509 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R3510 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R3511 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R3512 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R3513 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R3514 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R3515 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R3516 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R3517 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R3518 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R3519 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R3520 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R3521 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R3522 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R3523 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R3524 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R3525 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R3526 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R3527 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R3528 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R3529 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R3530 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R3531 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R3532 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R3533 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R3534 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R3535 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R3536 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R3537 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R3538 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R3539 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R3540 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R3541 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R3542 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R3543 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R3544 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R3545 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R3546 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R3547 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R3548 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R3549 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R3550 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R3551 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R3552 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R3553 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R3554 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R3555 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R3556 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R3557 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R3558 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R3559 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R3560 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R3561 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R3562 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R3563 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R3564 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R3565 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R3566 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R3567 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R3568 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R3569 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R3570 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R3571 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R3572 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R3573 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R3574 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R3575 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R3576 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R3577 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R3578 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R3579 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R3580 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R3581 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R3582 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R3583 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R3584 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R3585 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R3586 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R3587 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R3588 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R3589 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R3590 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R3591 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R3592 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R3593 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R3594 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R3595 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R3596 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R3597 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R3598 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R3599 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R3600 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R3601 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R3602 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R3603 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R3604 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R3605 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R3606 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R3607 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R3608 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R3609 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R3610 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R3611 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R3612 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R3613 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R3614 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R3615 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R3616 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R3617 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R3618 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R3619 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R3620 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R3621 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R3622 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R3623 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R3624 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R3625 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R3626 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R3627 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R3628 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R3629 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R3630 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R3631 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R3632 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R3633 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R3634 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R3635 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R3636 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R3637 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R3638 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R3639 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R3640 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R3641 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R3642 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R3643 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R3644 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R3645 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R3646 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R3647 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R3648 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R3649 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R3650 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R3651 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R3652 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R3653 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R3654 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R3655 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R3656 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R3657 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R3658 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R3659 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R3660 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R3661 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R3662 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R3663 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R3664 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R3665 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R3666 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R3667 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R3668 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R3669 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R3670 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R3671 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R3672 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R3673 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R3674 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R3675 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R3676 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R3677 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R3678 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R3679 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R3680 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R3681 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R3682 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R3683 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R3684 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R3685 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R3686 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R3687 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R3688 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R3689 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R3690 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R3691 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R3692 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R3693 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R3694 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R3695 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R3696 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R3697 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R3698 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R3699 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R3700 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R3701 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R3702 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R3703 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R3704 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R3705 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R3706 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R3707 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R3708 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R3709 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R3710 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R3711 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R3712 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R3713 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R3714 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R3715 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R3716 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R3717 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R3718 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R3719 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R3720 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R3721 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R3722 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R3723 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R3724 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R3725 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R3726 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R3727 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R3728 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R3729 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R3730 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R3731 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R3732 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R3733 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R3734 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R3735 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R3736 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R3737 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R3738 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R3739 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R3740 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R3741 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R3742 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R3743 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R3744 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R3745 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R3746 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R3747 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R3748 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R3749 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R3750 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R3751 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R3752 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R3753 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R3754 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R3755 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R3756 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R3757 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R3758 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R3759 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R3760 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R3761 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R3762 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R3763 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R3764 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R3765 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R3766 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R3767 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R3768 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R3769 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R3770 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R3771 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R3772 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R3773 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R3774 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R3775 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R3776 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R3777 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R3778 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R3779 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R3780 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R3781 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R3782 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R3783 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R3784 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R3785 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R3786 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R3787 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R3788 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R3789 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R3790 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R3791 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R3792 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R3793 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R3794 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R3795 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R3796 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R3797 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R3798 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R3799 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R3800 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R3801 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R3802 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R3803 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R3804 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R3805 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R3806 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R3807 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R3808 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R3809 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R3810 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R3811 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R3812 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R3813 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R3814 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R3815 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R3816 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R3817 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R3818 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R3819 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R3820 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R3821 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R3822 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R3823 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R3824 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R3825 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R3826 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R3827 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R3828 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R3829 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R3830 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R3831 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R3832 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R3833 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R3834 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R3835 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R3836 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R3837 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R3838 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R3839 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R3840 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R3841 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R3842 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R3843 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R3844 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R3845 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R3846 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R3847 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R3848 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R3849 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R3850 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R3851 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R3852 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R3853 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R3854 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R3855 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R3856 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R3857 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R3858 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R3859 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R3860 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R3861 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R3862 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R3863 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R3864 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R3865 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R3866 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R3867 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R3868 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R3869 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R3870 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R3871 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R3872 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R3873 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R3874 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R3875 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R3876 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R3877 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R3878 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R3879 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R3880 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R3881 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R3882 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R3883 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R3884 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R3885 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R3886 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R3887 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R3888 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R3889 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R3890 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R3891 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R3892 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R3893 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R3894 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R3895 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R3896 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R3897 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R3898 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R3899 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R3900 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R3901 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R3902 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R3903 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R3904 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R3905 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R3906 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R3907 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R3908 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R3909 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R3910 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R3911 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R3912 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R3913 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R3914 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R3915 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R3916 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R3917 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R3918 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R3919 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R3920 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R3921 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R3922 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R3923 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R3924 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R3925 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R3926 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R3927 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R3928 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R3929 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R3930 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R3931 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R3932 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R3933 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R3934 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R3935 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R3936 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R3937 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R3938 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R3939 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R3940 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R3941 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R3942 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R3943 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R3944 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R3945 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R3946 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R3947 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R3948 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R3949 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R3950 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R3951 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R3952 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R3953 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R3954 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R3955 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R3956 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R3957 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R3958 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R3959 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R3960 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R3961 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R3962 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R3963 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R3964 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R3965 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R3966 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R3967 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R3968 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R3969 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R3970 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R3971 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R3972 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R3973 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R3974 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R3975 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R3976 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R3977 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R3978 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R3979 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R3980 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R3981 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R3982 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R3983 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R3984 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R3985 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R3986 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R3987 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R3988 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R3989 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R3990 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R3991 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R3992 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R3993 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R3994 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R3995 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R3996 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R3997 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R3998 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R3999 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R4000 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R4001 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R4002 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R4003 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R4004 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R4005 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R4006 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R4007 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R4008 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R4009 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R4010 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R4011 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R4012 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R4013 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R4014 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R4015 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R4016 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R4017 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R4018 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R4019 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R4020 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R4021 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R4022 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R4023 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R4024 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R4025 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R4026 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R4027 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R4028 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R4029 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R4030 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R4031 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R4032 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R4033 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R4034 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R4035 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R4036 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R4037 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R4038 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R4039 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R4040 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R4041 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R4042 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R4043 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R4044 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R4045 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R4046 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R4047 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R4048 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R4049 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R4050 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R4051 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R4052 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R4053 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R4054 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R4055 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R4056 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R4057 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R4058 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R4059 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R4060 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R4061 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R4062 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R4063 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R4064 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R4065 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R4066 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R4067 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R4068 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R4069 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R4070 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R4071 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R4072 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R4073 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R4074 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R4075 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R4076 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R4077 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R4078 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R4079 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R4080 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R4081 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R4082 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R4083 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R4084 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R4085 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R4086 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R4087 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R4088 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R4089 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R4090 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R4091 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R4092 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R4093 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R4094 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R4095 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R4096 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R4097 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R4098 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R4099 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R4100 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R4101 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R4102 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R4103 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R4104 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R4105 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R4106 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R4107 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R4108 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R4109 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R4110 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R4111 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R4112 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R4113 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R4114 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R4115 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R4116 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R4117 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R4118 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R4119 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R4120 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R4121 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R4122 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R4123 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R4124 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R4125 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R4126 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R4127 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R4128 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R4129 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R4130 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R4131 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R4132 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R4133 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R4134 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R4135 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R4136 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R4137 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R4138 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R4139 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R4140 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R4141 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R4142 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R4143 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R4144 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R4145 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R4146 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R4147 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R4148 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R4149 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R4150 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R4151 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R4152 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R4153 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R4154 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R4155 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R4156 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R4157 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R4158 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R4159 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R4160 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R4161 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R4162 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R4163 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R4164 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R4165 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R4166 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R4167 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R4168 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R4169 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R4170 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R4171 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R4172 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R4173 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R4174 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R4175 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R4176 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R4177 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R4178 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R4179 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R4180 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R4181 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R4182 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R4183 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R4184 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R4185 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R4186 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R4187 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R4188 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R4189 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R4190 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R4191 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R4192 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R4193 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R4194 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R4195 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R4196 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R4197 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R4198 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R4199 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R4200 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R4201 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R4202 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R4203 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R4204 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R4205 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R4206 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R4207 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R4208 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R4209 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R4210 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R4211 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R4212 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R4213 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R4214 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R4215 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R4216 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R4217 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R4218 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R4219 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R4220 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R4221 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R4222 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R4223 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R4224 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R4225 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R4226 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R4227 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R4228 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R4229 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R4230 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R4231 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R4232 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R4233 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R4234 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R4235 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R4236 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R4237 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R4238 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R4239 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R4240 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R4241 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R4242 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R4243 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R4244 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R4245 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R4246 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R4247 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R4248 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R4249 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R4250 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R4251 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R4252 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R4253 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R4254 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R4255 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R4256 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R4257 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R4258 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R4259 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R4260 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R4261 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R4262 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R4263 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R4264 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R4265 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R4266 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R4267 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R4268 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R4269 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R4270 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R4271 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R4272 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R4273 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R4274 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R4275 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R4276 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R4277 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R4278 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R4279 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R4280 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R4281 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R4282 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R4283 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R4284 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R4285 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R4286 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R4287 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R4288 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R4289 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R4290 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R4291 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R4292 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R4293 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R4294 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R4295 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R4296 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R4297 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R4298 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R4299 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R4300 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R4301 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R4302 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R4303 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R4304 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R4305 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R4306 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R4307 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R4308 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R4309 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R4310 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R4311 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R4312 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R4313 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R4314 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R4315 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R4316 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R4317 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R4318 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R4319 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R4320 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R4321 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R4322 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R4323 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R4324 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R4325 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R4326 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R4327 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R4328 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R4329 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R4330 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R4331 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R4332 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R4333 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R4334 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R4335 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R4336 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R4337 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R4338 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R4339 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R4340 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R4341 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R4342 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R4343 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R4344 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R4345 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R4346 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R4347 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R4348 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R4349 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R4350 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R4351 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R4352 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R4353 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R4354 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R4355 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R4356 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R4357 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R4358 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R4359 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R4360 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R4361 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R4362 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R4363 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R4364 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R4365 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R4366 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R4367 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R4368 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R4369 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R4370 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R4371 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R4372 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R4373 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R4374 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R4375 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R4376 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R4377 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R4378 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R4379 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R4380 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R4381 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R4382 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R4383 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R4384 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R4385 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R4386 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R4387 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R4388 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R4389 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R4390 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R4391 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R4392 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R4393 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R4394 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R4395 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R4396 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R4397 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R4398 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R4399 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R4400 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R4401 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R4402 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R4403 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R4404 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R4405 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R4406 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R4407 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R4408 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R4409 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R4410 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R4411 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R4412 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R4413 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R4414 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R4415 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R4416 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R4417 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R4418 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R4419 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R4420 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R4421 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R4422 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R4423 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R4424 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R4425 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R4426 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R4427 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R4428 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R4429 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R4430 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R4431 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R4432 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R4433 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R4434 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R4435 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R4436 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R4437 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R4438 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R4439 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R4440 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R4441 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R4442 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R4443 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R4444 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R4445 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R4446 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R4447 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R4448 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R4449 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R4450 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R4451 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R4452 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R4453 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R4454 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R4455 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R4456 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R4457 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R4458 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R4459 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R4460 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R4461 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R4462 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R4463 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R4464 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R4465 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R4466 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R4467 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R4468 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R4469 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R4470 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R4471 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R4472 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R4473 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R4474 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R4475 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R4476 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R4477 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R4478 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R4479 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R4480 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R4481 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R4482 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R4483 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R4484 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R4485 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R4486 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R4487 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R4488 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R4489 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R4490 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R4491 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R4492 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R4493 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R4494 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R4495 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R4496 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R4497 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R4498 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R4499 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R4500 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R4501 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R4502 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R4503 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R4504 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R4505 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R4506 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R4507 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R4508 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R4509 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R4510 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R4511 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R4512 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R4513 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R4514 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R4515 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R4516 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R4517 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R4518 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R4519 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R4520 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R4521 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R4522 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R4523 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R4524 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R4525 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R4526 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R4527 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R4528 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R4529 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R4530 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R4531 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R4532 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R4533 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R4534 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R4535 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R4536 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R4537 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R4538 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R4539 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R4540 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R4541 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R4542 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R4543 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R4544 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R4545 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R4546 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R4547 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R4548 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R4549 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R4550 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R4551 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R4552 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R4553 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R4554 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R4555 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R4556 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R4557 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R4558 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R4559 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R4560 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R4561 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R4562 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R4563 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R4564 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R4565 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R4566 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R4567 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R4568 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R4569 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R4570 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R4571 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R4572 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R4573 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R4574 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R4575 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R4576 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R4577 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R4578 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R4579 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R4580 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R4581 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R4582 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R4583 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R4584 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R4585 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R4586 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R4587 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R4588 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R4589 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R4590 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R4591 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R4592 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R4593 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R4594 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R4595 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R4596 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R4597 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R4598 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R4599 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R4600 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R4601 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R4602 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R4603 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R4604 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R4605 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R4606 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R4607 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R4608 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R4609 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R4610 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R4611 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R4612 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R4613 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R4614 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R4615 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R4616 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R4617 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R4618 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R4619 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R4620 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R4621 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R4622 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R4623 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R4624 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R4625 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R4626 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R4627 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R4628 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R4629 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R4630 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R4631 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R4632 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R4633 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R4634 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R4635 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R4636 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R4637 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R4638 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R4639 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R4640 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R4641 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R4642 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R4643 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R4644 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R4645 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R4646 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R4647 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R4648 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R4649 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R4650 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R4651 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R4652 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R4653 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R4654 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R4655 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R4656 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R4657 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R4658 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R4659 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R4660 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R4661 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R4662 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R4663 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R4664 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R4665 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R4666 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R4667 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R4668 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R4669 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R4670 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R4671 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R4672 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R4673 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R4674 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R4675 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R4676 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R4677 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R4678 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R4679 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R4680 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R4681 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R4682 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R4683 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R4684 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R4685 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R4686 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R4687 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R4688 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R4689 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R4690 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R4691 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R4692 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R4693 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R4694 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R4695 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R4696 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R4697 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R4698 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R4699 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R4700 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R4701 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R4702 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R4703 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R4704 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R4705 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R4706 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R4707 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R4708 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R4709 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R4710 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R4711 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R4712 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R4713 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R4714 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R4715 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R4716 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R4717 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R4718 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R4719 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R4720 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R4721 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R4722 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R4723 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R4724 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R4725 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R4726 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R4727 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R4728 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R4729 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R4730 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R4731 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R4732 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R4733 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R4734 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R4735 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R4736 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R4737 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R4738 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R4739 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R4740 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R4741 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R4742 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R4743 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R4744 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R4745 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R4746 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R4747 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R4748 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R4749 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R4750 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R4751 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R4752 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R4753 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R4754 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R4755 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R4756 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R4757 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R4758 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R4759 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R4760 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R4761 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R4762 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R4763 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R4764 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R4765 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R4766 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R4767 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R4768 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R4769 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R4770 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R4771 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R4772 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R4773 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R4774 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R4775 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R4776 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R4777 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R4778 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R4779 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R4780 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R4781 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R4782 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R4783 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R4784 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R4785 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R4786 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R4787 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R4788 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R4789 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R4790 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R4791 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R4792 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R4793 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R4794 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R4795 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R4796 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R4797 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R4798 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R4799 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R4800 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R4801 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R4802 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R4803 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R4804 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R4805 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R4806 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R4807 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R4808 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R4809 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R4810 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R4811 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R4812 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R4813 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R4814 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R4815 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R4816 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R4817 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R4818 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R4819 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R4820 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R4821 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R4822 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R4823 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R4824 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R4825 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R4826 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R4827 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R4828 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R4829 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R4830 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R4831 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R4832 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R4833 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R4834 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R4835 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R4836 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R4837 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R4838 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R4839 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R4840 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R4841 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R4842 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R4843 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R4844 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R4845 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R4846 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R4847 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R4848 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R4849 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R4850 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R4851 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R4852 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R4853 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R4854 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R4855 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R4856 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R4857 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R4858 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R4859 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R4860 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R4861 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R4862 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R4863 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R4864 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R4865 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R4866 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R4867 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R4868 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R4869 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R4870 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R4871 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R4872 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R4873 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R4874 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R4875 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R4876 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R4877 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R4878 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R4879 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R4880 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R4881 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R4882 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R4883 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R4884 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R4885 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R4886 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R4887 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R4888 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R4889 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R4890 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R4891 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R4892 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R4893 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R4894 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R4895 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R4896 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R4897 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R4898 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R4899 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R4900 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R4901 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R4902 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R4903 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R4904 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R4905 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R4906 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R4907 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R4908 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R4909 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R4910 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R4911 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R4912 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R4913 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R4914 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R4915 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R4916 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R4917 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R4918 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R4919 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R4920 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R4921 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R4922 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R4923 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R4924 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R4925 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R4926 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R4927 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R4928 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R4929 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R4930 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R4931 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R4932 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R4933 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R4934 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R4935 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R4936 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R4937 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R4938 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R4939 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R4940 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R4941 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R4942 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R4943 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R4944 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R4945 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R4946 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R4947 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R4948 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R4949 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R4950 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R4951 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R4952 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R4953 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R4954 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R4955 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R4956 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R4957 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R4958 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R4959 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R4960 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R4961 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R4962 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R4963 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R4964 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R4965 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R4966 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R4967 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R4968 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R4969 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R4970 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R4971 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R4972 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R4973 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R4974 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R4975 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R4976 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R4977 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R4978 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R4979 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R4980 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R4981 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R4982 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R4983 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R4984 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R4985 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R4986 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R4987 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R4988 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R4989 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R4990 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R4991 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R4992 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R4993 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R4994 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R4995 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R4996 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R4997 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R4998 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R4999 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R5000 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R5001 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R5002 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R5003 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R5004 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R5005 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R5006 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R5007 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R5008 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R5009 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R5010 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R5011 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R5012 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R5013 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R5014 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R5015 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R5016 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R5017 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R5018 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R5019 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R5020 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R5021 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R5022 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R5023 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R5024 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R5025 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R5026 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R5027 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R5028 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R5029 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R5030 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R5031 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R5032 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R5033 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R5034 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R5035 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R5036 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R5037 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R5038 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R5039 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R5040 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R5041 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R5042 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R5043 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R5044 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R5045 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R5046 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R5047 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R5048 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R5049 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R5050 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R5051 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R5052 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R5053 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R5054 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R5055 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R5056 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R5057 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R5058 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R5059 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R5060 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R5061 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R5062 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R5063 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R5064 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R5065 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R5066 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R5067 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R5068 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R5069 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R5070 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R5071 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R5072 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R5073 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R5074 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R5075 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R5076 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R5077 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R5078 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R5079 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R5080 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R5081 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R5082 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R5083 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R5084 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R5085 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R5086 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R5087 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R5088 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R5089 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R5090 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R5091 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R5092 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R5093 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R5094 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R5095 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R5096 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R5097 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R5098 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R5099 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R5100 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R5101 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R5102 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R5103 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R5104 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R5105 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R5106 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R5107 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R5108 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R5109 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R5110 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R5111 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R5112 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R5113 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R5114 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R5115 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R5116 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R5117 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R5118 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R5119 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R5120 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R5121 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R5122 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R5123 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R5124 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R5125 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R5126 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R5127 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R5128 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R5129 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R5130 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R5131 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R5132 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R5133 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R5134 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R5135 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R5136 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R5137 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R5138 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R5139 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R5140 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R5141 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R5142 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R5143 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R5144 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R5145 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R5146 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R5147 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R5148 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R5149 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R5150 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R5151 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R5152 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R5153 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R5154 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R5155 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R5156 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R5157 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R5158 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R5159 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R5160 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R5161 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R5162 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R5163 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R5164 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R5165 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R5166 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R5167 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R5168 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R5169 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R5170 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R5171 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R5172 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R5173 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R5174 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R5175 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R5176 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R5177 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R5178 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R5179 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R5180 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R5181 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R5182 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R5183 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R5184 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R5185 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R5186 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R5187 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R5188 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R5189 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R5190 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R5191 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R5192 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R5193 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R5194 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R5195 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R5196 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R5197 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R5198 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R5199 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R5200 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R5201 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R5202 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R5203 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R5204 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R5205 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R5206 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R5207 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R5208 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R5209 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R5210 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R5211 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R5212 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R5213 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R5214 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R5215 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R5216 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R5217 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R5218 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R5219 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R5220 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R5221 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R5222 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R5223 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R5224 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R5225 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R5226 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R5227 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R5228 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R5229 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R5230 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R5231 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R5232 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R5233 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R5234 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R5235 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R5236 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R5237 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R5238 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R5239 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R5240 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R5241 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R5242 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R5243 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R5244 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R5245 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R5246 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R5247 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R5248 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R5249 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R5250 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R5251 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R5252 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R5253 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R5254 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R5255 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R5256 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R5257 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R5258 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R5259 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R5260 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R5261 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R5262 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R5263 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R5264 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R5265 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R5266 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R5267 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R5268 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R5269 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R5270 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R5271 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R5272 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R5273 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R5274 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R5275 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R5276 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R5277 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R5278 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R5279 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R5280 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R5281 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R5282 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R5283 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R5284 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R5285 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R5286 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R5287 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R5288 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R5289 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R5290 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R5291 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R5292 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R5293 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R5294 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R5295 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R5296 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R5297 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R5298 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R5299 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R5300 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R5301 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R5302 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R5303 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R5304 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R5305 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R5306 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R5307 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R5308 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R5309 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R5310 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R5311 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R5312 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R5313 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R5314 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R5315 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R5316 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R5317 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R5318 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R5319 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R5320 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R5321 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R5322 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R5323 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R5324 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R5325 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R5326 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R5327 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R5328 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R5329 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R5330 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R5331 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R5332 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R5333 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R5334 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R5335 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R5336 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R5337 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R5338 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R5339 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R5340 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R5341 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R5342 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R5343 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R5344 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R5345 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R5346 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R5347 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R5348 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R5349 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R5350 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R5351 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R5352 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R5353 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R5354 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R5355 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R5356 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R5357 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R5358 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R5359 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R5360 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R5361 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R5362 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R5363 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R5364 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R5365 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R5366 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R5367 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R5368 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R5369 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R5370 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R5371 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R5372 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R5373 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R5374 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R5375 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R5376 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R5377 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R5378 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R5379 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R5380 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R5381 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R5382 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R5383 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R5384 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R5385 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R5386 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R5387 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R5388 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R5389 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R5390 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R5391 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R5392 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R5393 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R5394 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R5395 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R5396 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R5397 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R5398 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R5399 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R5400 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R5401 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R5402 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R5403 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R5404 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R5405 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R5406 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R5407 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R5408 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R5409 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R5410 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R5411 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R5412 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R5413 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R5414 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R5415 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R5416 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R5417 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R5418 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R5419 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R5420 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R5421 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R5422 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R5423 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R5424 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R5425 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R5426 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R5427 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R5428 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R5429 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R5430 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R5431 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R5432 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R5433 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R5434 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R5435 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R5436 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R5437 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R5438 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R5439 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R5440 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R5441 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R5442 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R5443 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R5444 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R5445 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R5446 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R5447 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R5448 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R5449 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R5450 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R5451 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R5452 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R5453 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R5454 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R5455 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R5456 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R5457 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R5458 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R5459 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R5460 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R5461 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R5462 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R5463 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R5464 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R5465 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R5466 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R5467 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R5468 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R5469 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R5470 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R5471 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R5472 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R5473 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R5474 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R5475 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R5476 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R5477 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R5478 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R5479 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R5480 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R5481 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R5482 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R5483 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R5484 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R5485 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R5486 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R5487 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R5488 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R5489 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R5490 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R5491 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R5492 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R5493 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R5494 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R5495 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R5496 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R5497 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R5498 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R5499 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R5500 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R5501 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R5502 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R5503 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R5504 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R5505 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R5506 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R5507 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R5508 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R5509 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R5510 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R5511 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R5512 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R5513 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R5514 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R5515 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R5516 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R5517 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R5518 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R5519 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R5520 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R5521 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R5522 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R5523 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R5524 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R5525 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R5526 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R5527 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R5528 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R5529 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R5530 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R5531 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R5532 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R5533 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R5534 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R5535 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R5536 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R5537 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R5538 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R5539 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R5540 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R5541 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R5542 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R5543 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R5544 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R5545 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R5546 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R5547 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R5548 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R5549 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R5550 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R5551 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R5552 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R5553 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R5554 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R5555 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R5556 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R5557 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R5558 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R5559 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R5560 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R5561 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R5562 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R5563 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R5564 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R5565 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R5566 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R5567 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R5568 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R5569 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R5570 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R5571 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R5572 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R5573 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R5574 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R5575 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R5576 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R5577 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R5578 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R5579 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R5580 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R5581 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R5582 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R5583 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R5584 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R5585 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R5586 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R5587 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R5588 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R5589 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R5590 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R5591 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R5592 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R5593 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R5594 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R5595 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R5596 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R5597 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R5598 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R5599 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R5600 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R5601 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R5602 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R5603 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R5604 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R5605 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R5606 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R5607 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R5608 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R5609 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R5610 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R5611 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R5612 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R5613 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R5614 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R5615 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R5616 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R5617 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R5618 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R5619 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R5620 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R5621 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R5622 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R5623 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R5624 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R5625 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R5626 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R5627 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R5628 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R5629 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R5630 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R5631 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R5632 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R5633 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R5634 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R5635 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R5636 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R5637 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R5638 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R5639 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R5640 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R5641 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R5642 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R5643 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R5644 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R5645 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R5646 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R5647 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R5648 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R5649 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R5650 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R5651 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R5652 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R5653 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R5654 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R5655 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R5656 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R5657 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R5658 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R5659 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R5660 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R5661 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R5662 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R5663 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R5664 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R5665 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R5666 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R5667 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R5668 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R5669 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R5670 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R5671 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R5672 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R5673 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R5674 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R5675 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R5676 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R5677 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R5678 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R5679 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R5680 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R5681 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R5682 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R5683 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R5684 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R5685 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R5686 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R5687 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R5688 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R5689 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R5690 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R5691 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R5692 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R5693 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R5694 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R5695 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R5696 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R5697 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R5698 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R5699 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R5700 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R5701 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R5702 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R5703 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R5704 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R5705 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R5706 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R5707 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R5708 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R5709 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R5710 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R5711 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R5712 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R5713 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R5714 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R5715 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R5716 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R5717 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R5718 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R5719 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R5720 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R5721 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R5722 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R5723 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R5724 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R5725 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R5726 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R5727 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R5728 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R5729 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R5730 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R5731 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R5732 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R5733 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R5734 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R5735 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R5736 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R5737 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R5738 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R5739 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R5740 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R5741 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R5742 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R5743 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R5744 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R5745 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R5746 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R5747 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R5748 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R5749 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R5750 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R5751 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R5752 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R5753 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R5754 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R5755 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R5756 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R5757 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R5758 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R5759 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R5760 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R5761 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R5762 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R5763 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R5764 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R5765 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R5766 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R5767 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R5768 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R5769 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R5770 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R5771 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R5772 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R5773 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R5774 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R5775 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R5776 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R5777 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R5778 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R5779 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R5780 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R5781 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R5782 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R5783 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R5784 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R5785 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R5786 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R5787 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R5788 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R5789 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R5790 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R5791 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R5792 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R5793 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R5794 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R5795 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R5796 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R5797 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R5798 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R5799 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R5800 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R5801 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R5802 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R5803 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R5804 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R5805 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R5806 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R5807 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R5808 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R5809 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R5810 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R5811 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R5812 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R5813 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R5814 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R5815 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R5816 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R5817 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R5818 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R5819 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R5820 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R5821 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R5822 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R5823 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R5824 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R5825 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R5826 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R5827 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R5828 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R5829 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R5830 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R5831 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R5832 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R5833 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R5834 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R5835 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R5836 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R5837 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R5838 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R5839 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R5840 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R5841 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R5842 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R5843 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R5844 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R5845 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R5846 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R5847 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R5848 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R5849 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R5850 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R5851 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R5852 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R5853 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R5854 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R5855 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R5856 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R5857 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R5858 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R5859 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R5860 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R5861 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R5862 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R5863 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R5864 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R5865 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R5866 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R5867 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R5868 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R5869 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R5870 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R5871 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R5872 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R5873 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R5874 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R5875 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R5876 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R5877 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R5878 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R5879 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R5880 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R5881 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R5882 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R5883 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R5884 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R5885 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R5886 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R5887 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R5888 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R5889 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R5890 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R5891 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R5892 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R5893 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R5894 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R5895 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R5896 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R5897 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R5898 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R5899 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R5900 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R5901 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R5902 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R5903 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R5904 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R5905 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R5906 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R5907 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R5908 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R5909 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R5910 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R5911 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R5912 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R5913 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R5914 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R5915 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R5916 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R5917 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R5918 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R5919 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R5920 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R5921 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R5922 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R5923 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R5924 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R5925 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R5926 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R5927 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R5928 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R5929 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R5930 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R5931 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R5932 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R5933 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R5934 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R5935 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R5936 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R5937 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R5938 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R5939 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R5940 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R5941 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R5942 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R5943 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R5944 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R5945 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R5946 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R5947 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R5948 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R5949 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R5950 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R5951 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R5952 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R5953 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R5954 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R5955 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R5956 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R5957 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R5958 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R5959 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R5960 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R5961 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R5962 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R5963 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R5964 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R5965 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R5966 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R5967 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R5968 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R5969 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R5970 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R5971 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R5972 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R5973 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R5974 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R5975 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R5976 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R5977 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R5978 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R5979 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R5980 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R5981 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R5982 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R5983 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R5984 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R5985 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R5986 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R5987 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R5988 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R5989 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R5990 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R5991 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R5992 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R5993 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R5994 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R5995 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R5996 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R5997 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R5998 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R5999 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R6000 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R6001 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R6002 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R6003 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R6004 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R6005 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R6006 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R6007 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R6008 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R6009 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R6010 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R6011 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R6012 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R6013 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R6014 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R6015 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R6016 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R6017 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R6018 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R6019 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R6020 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R6021 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R6022 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R6023 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R6024 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R6025 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R6026 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R6027 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R6028 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R6029 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R6030 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R6031 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R6032 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R6033 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R6034 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R6035 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R6036 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R6037 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R6038 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R6039 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R6040 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R6041 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R6042 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R6043 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R6044 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R6045 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R6046 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R6047 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R6048 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R6049 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R6050 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R6051 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R6052 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R6053 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R6054 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R6055 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R6056 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R6057 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R6058 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R6059 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R6060 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R6061 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R6062 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R6063 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R6064 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R6065 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R6066 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R6067 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R6068 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R6069 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R6070 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R6071 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R6072 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R6073 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R6074 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R6075 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R6076 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R6077 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R6078 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R6079 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R6080 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R6081 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R6082 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R6083 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R6084 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R6085 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R6086 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R6087 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R6088 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R6089 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R6090 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R6091 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R6092 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R6093 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R6094 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R6095 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R6096 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R6097 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R6098 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R6099 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R6100 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R6101 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R6102 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R6103 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R6104 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R6105 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R6106 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R6107 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R6108 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R6109 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R6110 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R6111 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R6112 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R6113 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R6114 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R6115 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R6116 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R6117 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R6118 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R6119 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R6120 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R6121 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R6122 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R6123 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R6124 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R6125 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R6126 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R6127 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R6128 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R6129 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R6130 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R6131 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R6132 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R6133 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R6134 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R6135 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R6136 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R6137 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R6138 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R6139 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R6140 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R6141 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R6142 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R6143 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R6144 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R6145 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R6146 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R6147 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R6148 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R6149 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R6150 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R6151 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R6152 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R6153 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R6154 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R6155 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R6156 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R6157 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R6158 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R6159 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R6160 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R6161 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R6162 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R6163 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R6164 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R6165 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R6166 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R6167 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R6168 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R6169 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R6170 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R6171 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R6172 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R6173 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R6174 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R6175 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R6176 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R6177 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R6178 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R6179 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R6180 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R6181 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R6182 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R6183 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R6184 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R6185 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R6186 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R6187 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R6188 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R6189 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R6190 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R6191 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R6192 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R6193 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R6194 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R6195 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R6196 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R6197 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R6198 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R6199 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R6200 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R6201 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R6202 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R6203 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R6204 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R6205 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R6206 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R6207 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R6208 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R6209 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R6210 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R6211 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R6212 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R6213 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R6214 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R6215 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R6216 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R6217 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R6218 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R6219 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R6220 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R6221 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R6222 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R6223 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R6224 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R6225 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R6226 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R6227 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R6228 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R6229 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R6230 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R6231 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R6232 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R6233 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R6234 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R6235 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R6236 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R6237 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R6238 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R6239 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R6240 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R6241 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R6242 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R6243 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R6244 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R6245 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R6246 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R6247 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R6248 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R6249 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R6250 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R6251 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R6252 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R6253 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R6254 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R6255 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R6256 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R6257 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R6258 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R6259 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R6260 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R6261 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R6262 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R6263 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R6264 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R6265 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R6266 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R6267 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R6268 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R6269 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R6270 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R6271 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R6272 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R6273 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R6274 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R6275 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R6276 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R6277 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R6278 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R6279 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R6280 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R6281 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R6282 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R6283 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R6284 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R6285 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R6286 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R6287 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R6288 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R6289 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R6290 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R6291 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R6292 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R6293 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R6294 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R6295 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R6296 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R6297 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R6298 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R6299 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R6300 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R6301 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R6302 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R6303 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R6304 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R6305 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R6306 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R6307 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R6308 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R6309 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R6310 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R6311 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R6312 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R6313 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R6314 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R6315 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R6316 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R6317 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R6318 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R6319 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R6320 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R6321 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R6322 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R6323 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R6324 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R6325 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R6326 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R6327 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R6328 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R6329 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R6330 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R6331 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R6332 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R6333 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R6334 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R6335 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R6336 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R6337 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R6338 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R6339 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R6340 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R6341 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R6342 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R6343 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R6344 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R6345 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R6346 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R6347 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R6348 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R6349 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R6350 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R6351 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R6352 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R6353 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R6354 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R6355 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R6356 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R6357 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R6358 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R6359 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R6360 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R6361 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R6362 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R6363 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R6364 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R6365 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R6366 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R6367 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R6368 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R6369 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R6370 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R6371 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R6372 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R6373 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R6374 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R6375 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R6376 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R6377 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R6378 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R6379 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R6380 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R6381 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R6382 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R6383 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R6384 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R6385 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R6386 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R6387 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R6388 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R6389 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R6390 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R6391 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R6392 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R6393 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R6394 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R6395 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R6396 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R6397 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R6398 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R6399 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R6400 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R6401 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R6402 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R6403 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R6404 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R6405 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R6406 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R6407 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R6408 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R6409 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R6410 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R6411 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R6412 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R6413 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R6414 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R6415 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R6416 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R6417 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R6418 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R6419 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R6420 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R6421 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R6422 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R6423 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R6424 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R6425 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R6426 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R6427 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R6428 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R6429 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R6430 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R6431 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R6432 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R6433 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R6434 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R6435 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R6436 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R6437 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R6438 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R6439 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R6440 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R6441 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R6442 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R6443 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R6444 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R6445 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R6446 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R6447 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R6448 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R6449 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R6450 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R6451 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R6452 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R6453 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R6454 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R6455 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R6456 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R6457 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R6458 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R6459 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R6460 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R6461 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R6462 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R6463 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R6464 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R6465 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R6466 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R6467 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R6468 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R6469 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R6470 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R6471 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R6472 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R6473 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R6474 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R6475 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R6476 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R6477 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R6478 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R6479 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R6480 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R6481 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R6482 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R6483 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R6484 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R6485 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R6486 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R6487 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R6488 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R6489 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R6490 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R6491 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R6492 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R6493 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R6494 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R6495 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R6496 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R6497 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R6498 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R6499 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R6500 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R6501 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R6502 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R6503 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R6504 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R6505 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R6506 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R6507 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R6508 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R6509 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R6510 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R6511 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R6512 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R6513 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R6514 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R6515 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R6516 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R6517 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R6518 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R6519 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R6520 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R6521 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R6522 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R6523 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R6524 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R6525 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R6526 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R6527 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R6528 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R6529 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R6530 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R6531 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R6532 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R6533 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R6534 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R6535 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R6536 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R6537 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R6538 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R6539 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R6540 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R6541 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R6542 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R6543 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R6544 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R6545 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R6546 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R6547 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R6548 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R6549 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R6550 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R6551 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R6552 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R6553 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R6554 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R6555 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R6556 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R6557 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R6558 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R6559 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R6560 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R6561 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R6562 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R6563 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R6564 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R6565 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R6566 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R6567 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R6568 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R6569 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R6570 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R6571 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R6572 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R6573 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R6574 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R6575 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R6576 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R6577 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R6578 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R6579 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R6580 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R6581 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R6582 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R6583 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R6584 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R6585 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R6586 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R6587 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R6588 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R6589 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R6590 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R6591 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R6592 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R6593 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R6594 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R6595 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R6596 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R6597 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R6598 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R6599 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R6600 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R6601 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R6602 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R6603 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R6604 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R6605 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R6606 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R6607 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R6608 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R6609 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R6610 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R6611 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R6612 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R6613 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R6614 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R6615 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R6616 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R6617 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R6618 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R6619 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R6620 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R6621 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R6622 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R6623 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R6624 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R6625 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R6626 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R6627 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R6628 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R6629 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R6630 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R6631 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R6632 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R6633 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R6634 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R6635 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R6636 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R6637 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R6638 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R6639 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R6640 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R6641 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R6642 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R6643 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R6644 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R6645 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R6646 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R6647 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R6648 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R6649 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R6650 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R6651 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R6652 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R6653 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R6654 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R6655 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R6656 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R6657 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R6658 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R6659 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R6660 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R6661 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R6662 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R6663 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R6664 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R6665 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R6666 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R6667 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R6668 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R6669 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R6670 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R6671 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R6672 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R6673 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R6674 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R6675 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R6676 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R6677 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R6678 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R6679 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R6680 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R6681 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R6682 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R6683 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R6684 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R6685 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R6686 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R6687 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R6688 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R6689 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R6690 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R6691 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R6692 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R6693 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R6694 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R6695 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R6696 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R6697 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R6698 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R6699 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R6700 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R6701 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R6702 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R6703 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R6704 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R6705 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R6706 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R6707 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R6708 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R6709 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R6710 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R6711 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R6712 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R6713 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R6714 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R6715 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R6716 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R6717 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R6718 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R6719 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R6720 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R6721 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R6722 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R6723 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R6724 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R6725 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R6726 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R6727 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R6728 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R6729 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R6730 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R6731 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R6732 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R6733 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R6734 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R6735 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R6736 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R6737 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R6738 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R6739 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R6740 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R6741 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R6742 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R6743 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R6744 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R6745 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R6746 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R6747 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R6748 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R6749 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R6750 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R6751 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R6752 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R6753 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R6754 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R6755 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R6756 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R6757 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R6758 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R6759 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R6760 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R6761 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R6762 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R6763 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R6764 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R6765 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R6766 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R6767 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R6768 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R6769 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R6770 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R6771 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R6772 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R6773 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R6774 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R6775 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R6776 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R6777 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R6778 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R6779 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R6780 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R6781 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R6782 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R6783 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R6784 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R6785 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R6786 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R6787 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R6788 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R6789 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R6790 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R6791 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R6792 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R6793 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R6794 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R6795 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R6796 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R6797 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R6798 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R6799 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R6800 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R6801 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R6802 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R6803 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R6804 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R6805 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R6806 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R6807 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R6808 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R6809 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R6810 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R6811 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R6812 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R6813 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R6814 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R6815 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R6816 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R6817 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R6818 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R6819 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R6820 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R6821 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R6822 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R6823 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R6824 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R6825 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R6826 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R6827 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R6828 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R6829 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R6830 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R6831 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R6832 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R6833 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R6834 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R6835 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R6836 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R6837 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R6838 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R6839 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R6840 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R6841 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R6842 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R6843 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R6844 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R6845 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R6846 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R6847 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R6848 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R6849 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R6850 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R6851 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R6852 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R6853 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R6854 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R6855 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R6856 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R6857 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R6858 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R6859 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R6860 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R6861 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R6862 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R6863 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R6864 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R6865 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R6866 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R6867 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R6868 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R6869 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R6870 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R6871 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R6872 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R6873 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R6874 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R6875 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R6876 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R6877 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R6878 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R6879 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R6880 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R6881 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R6882 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R6883 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R6884 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R6885 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R6886 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R6887 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R6888 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R6889 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R6890 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R6891 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R6892 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R6893 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R6894 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R6895 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R6896 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R6897 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R6898 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R6899 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R6900 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R6901 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R6902 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R6903 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R6904 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R6905 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R6906 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R6907 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R6908 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R6909 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R6910 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R6911 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R6912 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R6913 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R6914 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R6915 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R6916 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R6917 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R6918 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R6919 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R6920 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R6921 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R6922 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R6923 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R6924 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R6925 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R6926 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R6927 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R6928 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R6929 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R6930 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R6931 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R6932 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R6933 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R6934 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R6935 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R6936 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R6937 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R6938 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R6939 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R6940 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R6941 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R6942 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R6943 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R6944 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R6945 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R6946 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R6947 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R6948 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R6949 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R6950 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R6951 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R6952 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R6953 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R6954 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R6955 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R6956 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R6957 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R6958 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R6959 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R6960 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R6961 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R6962 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R6963 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R6964 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R6965 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R6966 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R6967 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R6968 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R6969 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R6970 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R6971 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R6972 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R6973 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R6974 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R6975 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R6976 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R6977 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R6978 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R6979 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R6980 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R6981 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R6982 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R6983 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R6984 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R6985 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R6986 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R6987 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R6988 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R6989 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R6990 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R6991 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R6992 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R6993 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R6994 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R6995 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R6996 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R6997 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R6998 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R6999 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R7000 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R7001 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R7002 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R7003 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R7004 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R7005 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R7006 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R7007 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R7008 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R7009 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R7010 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R7011 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R7012 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R7013 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R7014 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R7015 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R7016 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R7017 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R7018 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R7019 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R7020 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R7021 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R7022 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R7023 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R7024 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R7025 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R7026 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R7027 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R7028 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R7029 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R7030 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R7031 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R7032 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R7033 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R7034 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R7035 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R7036 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R7037 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R7038 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R7039 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R7040 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R7041 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R7042 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R7043 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R7044 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R7045 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R7046 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R7047 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R7048 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R7049 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R7050 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R7051 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R7052 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R7053 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R7054 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R7055 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R7056 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R7057 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R7058 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R7059 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R7060 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R7061 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R7062 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R7063 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R7064 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R7065 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R7066 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R7067 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R7068 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R7069 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R7070 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R7071 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R7072 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R7073 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R7074 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R7075 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R7076 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R7077 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R7078 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R7079 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R7080 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R7081 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R7082 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R7083 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R7084 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R7085 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R7086 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R7087 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R7088 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R7089 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R7090 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R7091 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R7092 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R7093 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R7094 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R7095 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R7096 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R7097 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R7098 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R7099 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R7100 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R7101 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R7102 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R7103 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R7104 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R7105 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R7106 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R7107 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R7108 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R7109 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R7110 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R7111 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R7112 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R7113 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R7114 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R7115 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R7116 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R7117 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R7118 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R7119 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R7120 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R7121 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R7122 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R7123 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R7124 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R7125 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R7126 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R7127 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R7128 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R7129 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R7130 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R7131 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R7132 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R7133 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R7134 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R7135 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R7136 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R7137 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R7138 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R7139 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R7140 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R7141 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R7142 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R7143 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R7144 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R7145 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R7146 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R7147 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R7148 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R7149 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R7150 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R7151 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R7152 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R7153 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R7154 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R7155 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R7156 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R7157 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R7158 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R7159 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R7160 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R7161 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R7162 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R7163 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R7164 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R7165 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R7166 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R7167 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R7168 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R7169 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R7170 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R7171 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R7172 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R7173 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R7174 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R7175 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R7176 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R7177 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R7178 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R7179 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R7180 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R7181 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R7182 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R7183 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R7184 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R7185 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R7186 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R7187 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R7188 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R7189 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R7190 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R7191 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R7192 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R7193 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R7194 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R7195 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R7196 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R7197 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R7198 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R7199 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R7200 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R7201 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R7202 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R7203 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R7204 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R7205 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R7206 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R7207 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R7208 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R7209 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R7210 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R7211 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R7212 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R7213 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R7214 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R7215 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R7216 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R7217 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R7218 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R7219 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R7220 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R7221 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R7222 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R7223 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R7224 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R7225 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R7226 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R7227 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R7228 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R7229 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R7230 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R7231 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R7232 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R7233 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R7234 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R7235 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R7236 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R7237 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R7238 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R7239 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R7240 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R7241 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R7242 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R7243 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R7244 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R7245 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R7246 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R7247 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R7248 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R7249 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R7250 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R7251 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R7252 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R7253 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R7254 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R7255 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R7256 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R7257 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R7258 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R7259 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R7260 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R7261 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R7262 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R7263 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R7264 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R7265 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R7266 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R7267 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R7268 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R7269 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R7270 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R7271 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R7272 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R7273 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R7274 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R7275 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R7276 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R7277 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R7278 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R7279 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R7280 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R7281 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R7282 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R7283 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R7284 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R7285 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R7286 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R7287 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R7288 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R7289 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R7290 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R7291 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R7292 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R7293 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R7294 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R7295 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R7296 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R7297 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R7298 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R7299 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R7300 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R7301 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R7302 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R7303 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R7304 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R7305 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R7306 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R7307 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R7308 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R7309 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R7310 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R7311 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R7312 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R7313 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R7314 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R7315 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R7316 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R7317 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R7318 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R7319 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R7320 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R7321 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R7322 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R7323 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R7324 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R7325 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R7326 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R7327 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R7328 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R7329 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R7330 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R7331 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R7332 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R7333 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R7334 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R7335 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R7336 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R7337 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R7338 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R7339 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R7340 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R7341 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R7342 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R7343 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R7344 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R7345 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R7346 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R7347 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R7348 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R7349 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R7350 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R7351 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R7352 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R7353 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R7354 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R7355 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R7356 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R7357 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R7358 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R7359 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R7360 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R7361 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R7362 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R7363 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R7364 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R7365 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R7366 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R7367 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R7368 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R7369 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R7370 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R7371 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R7372 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R7373 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R7374 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R7375 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R7376 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R7377 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R7378 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R7379 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R7380 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R7381 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R7382 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R7383 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R7384 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R7385 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R7386 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R7387 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R7388 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R7389 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R7390 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R7391 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R7392 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R7393 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R7394 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R7395 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R7396 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R7397 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R7398 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R7399 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R7400 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R7401 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R7402 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R7403 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R7404 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R7405 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R7406 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R7407 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R7408 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R7409 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R7410 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R7411 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R7412 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R7413 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R7414 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R7415 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R7416 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R7417 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R7418 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R7419 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R7420 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R7421 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R7422 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R7423 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R7424 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R7425 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R7426 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R7427 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R7428 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R7429 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R7430 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R7431 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R7432 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R7433 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R7434 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R7435 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R7436 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R7437 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R7438 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R7439 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R7440 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R7441 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R7442 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R7443 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R7444 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R7445 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R7446 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R7447 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R7448 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R7449 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R7450 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R7451 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R7452 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R7453 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R7454 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R7455 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R7456 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R7457 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R7458 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R7459 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R7460 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R7461 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R7462 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R7463 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R7464 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R7465 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R7466 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R7467 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R7468 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R7469 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R7470 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R7471 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R7472 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R7473 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R7474 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R7475 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R7476 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R7477 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R7478 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R7479 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R7480 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R7481 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R7482 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R7483 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R7484 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R7485 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R7486 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R7487 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R7488 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R7489 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R7490 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R7491 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R7492 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R7493 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R7494 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R7495 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R7496 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R7497 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R7498 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R7499 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R7500 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R7501 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R7502 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R7503 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R7504 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R7505 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R7506 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R7507 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R7508 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R7509 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R7510 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R7511 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R7512 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R7513 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R7514 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R7515 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R7516 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R7517 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R7518 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R7519 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R7520 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R7521 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R7522 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R7523 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R7524 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R7525 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R7526 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R7527 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R7528 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R7529 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R7530 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R7531 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R7532 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R7533 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R7534 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R7535 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R7536 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R7537 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R7538 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R7539 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R7540 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R7541 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R7542 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R7543 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R7544 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R7545 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R7546 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R7547 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R7548 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R7549 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R7550 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R7551 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R7552 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R7553 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R7554 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R7555 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R7556 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R7557 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R7558 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R7559 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R7560 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R7561 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R7562 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R7563 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R7564 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R7565 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R7566 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R7567 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R7568 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R7569 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R7570 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R7571 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R7572 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R7573 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R7574 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R7575 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R7576 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R7577 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R7578 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R7579 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R7580 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R7581 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R7582 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R7583 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R7584 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R7585 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R7586 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R7587 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R7588 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R7589 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R7590 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R7591 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R7592 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R7593 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R7594 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R7595 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R7596 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R7597 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R7598 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R7599 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R7600 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R7601 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R7602 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R7603 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R7604 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R7605 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R7606 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R7607 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R7608 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R7609 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R7610 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R7611 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R7612 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R7613 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R7614 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R7615 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R7616 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R7617 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R7618 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R7619 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R7620 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R7621 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R7622 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R7623 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R7624 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R7625 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R7626 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R7627 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R7628 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R7629 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R7630 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R7631 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R7632 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R7633 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R7634 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R7635 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R7636 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R7637 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R7638 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R7639 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R7640 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R7641 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R7642 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R7643 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R7644 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R7645 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R7646 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R7647 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R7648 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R7649 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R7650 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R7651 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R7652 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R7653 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R7654 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R7655 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R7656 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R7657 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R7658 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R7659 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R7660 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R7661 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R7662 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R7663 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R7664 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R7665 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R7666 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R7667 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R7668 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R7669 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R7670 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R7671 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R7672 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R7673 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R7674 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R7675 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R7676 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R7677 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R7678 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R7679 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R7680 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R7681 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R7682 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R7683 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R7684 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R7685 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R7686 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R7687 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R7688 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R7689 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R7690 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R7691 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R7692 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R7693 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R7694 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R7695 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R7696 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R7697 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R7698 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R7699 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R7700 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R7701 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R7702 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R7703 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R7704 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R7705 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R7706 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R7707 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R7708 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R7709 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R7710 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R7711 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R7712 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R7713 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R7714 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R7715 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R7716 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R7717 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R7718 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R7719 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R7720 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R7721 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R7722 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R7723 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R7724 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R7725 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R7726 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R7727 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R7728 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R7729 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R7730 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R7731 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R7732 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R7733 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R7734 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R7735 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R7736 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R7737 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R7738 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R7739 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R7740 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R7741 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R7742 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R7743 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R7744 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R7745 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R7746 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R7747 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R7748 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R7749 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R7750 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R7751 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R7752 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R7753 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R7754 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R7755 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R7756 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R7757 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R7758 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R7759 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R7760 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R7761 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R7762 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R7763 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R7764 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R7765 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R7766 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R7767 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R7768 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R7769 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R7770 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R7771 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R7772 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R7773 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R7774 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R7775 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R7776 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R7777 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R7778 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R7779 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R7780 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R7781 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R7782 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R7783 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R7784 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R7785 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R7786 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R7787 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R7788 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R7789 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R7790 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R7791 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R7792 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R7793 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R7794 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R7795 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R7796 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R7797 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R7798 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R7799 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R7800 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R7801 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R7802 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R7803 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R7804 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R7805 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R7806 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R7807 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R7808 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R7809 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R7810 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R7811 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R7812 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R7813 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R7814 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R7815 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R7816 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R7817 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R7818 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R7819 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R7820 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R7821 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R7822 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R7823 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R7824 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R7825 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R7826 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R7827 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R7828 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R7829 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R7830 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R7831 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R7832 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R7833 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R7834 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R7835 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R7836 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R7837 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R7838 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R7839 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R7840 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R7841 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R7842 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R7843 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R7844 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R7845 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R7846 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R7847 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R7848 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R7849 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R7850 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R7851 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R7852 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R7853 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R7854 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R7855 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R7856 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R7857 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R7858 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R7859 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R7860 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R7861 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R7862 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R7863 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R7864 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R7865 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R7866 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R7867 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R7868 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R7869 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R7870 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R7871 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R7872 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R7873 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R7874 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R7875 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R7876 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R7877 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R7878 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R7879 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R7880 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R7881 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R7882 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R7883 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R7884 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R7885 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R7886 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R7887 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R7888 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R7889 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R7890 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R7891 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R7892 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R7893 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R7894 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R7895 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R7896 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R7897 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R7898 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R7899 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R7900 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R7901 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R7902 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R7903 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R7904 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R7905 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R7906 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R7907 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R7908 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R7909 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R7910 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R7911 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R7912 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R7913 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R7914 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R7915 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R7916 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R7917 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R7918 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R7919 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R7920 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R7921 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R7922 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R7923 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R7924 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R7925 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R7926 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R7927 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R7928 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R7929 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R7930 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R7931 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R7932 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R7933 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R7934 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R7935 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R7936 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R7937 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R7938 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R7939 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R7940 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R7941 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R7942 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R7943 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R7944 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R7945 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R7946 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R7947 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R7948 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R7949 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R7950 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R7951 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R7952 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R7953 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R7954 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R7955 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R7956 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R7957 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R7958 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R7959 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R7960 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R7961 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R7962 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R7963 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R7964 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R7965 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R7966 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R7967 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R7968 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R7969 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R7970 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R7971 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R7972 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R7973 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R7974 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R7975 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R7976 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R7977 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R7978 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R7979 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R7980 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R7981 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R7982 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R7983 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R7984 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R7985 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R7986 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R7987 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R7988 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R7989 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R7990 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R7991 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R7992 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R7993 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R7994 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R7995 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R7996 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R7997 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R7998 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R7999 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R8000 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R8001 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R8002 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R8003 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R8004 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R8005 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R8006 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R8007 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R8008 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R8009 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R8010 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R8011 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R8012 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R8013 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R8014 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R8015 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R8016 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R8017 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R8018 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R8019 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R8020 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R8021 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R8022 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R8023 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R8024 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R8025 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R8026 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R8027 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R8028 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R8029 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R8030 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R8031 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R8032 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R8033 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R8034 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R8035 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R8036 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R8037 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R8038 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R8039 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R8040 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R8041 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R8042 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R8043 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R8044 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R8045 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R8046 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R8047 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R8048 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R8049 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R8050 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R8051 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R8052 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R8053 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R8054 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R8055 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R8056 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R8057 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R8058 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R8059 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R8060 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R8061 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R8062 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R8063 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R8064 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R8065 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R8066 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R8067 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R8068 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R8069 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R8070 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R8071 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R8072 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R8073 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R8074 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R8075 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R8076 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R8077 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R8078 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R8079 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R8080 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R8081 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R8082 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R8083 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R8084 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R8085 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R8086 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R8087 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R8088 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R8089 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R8090 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R8091 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R8092 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R8093 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R8094 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R8095 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R8096 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R8097 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R8098 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R8099 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R8100 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R8101 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R8102 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R8103 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R8104 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R8105 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R8106 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R8107 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R8108 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R8109 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R8110 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R8111 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R8112 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R8113 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R8114 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R8115 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R8116 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R8117 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R8118 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R8119 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R8120 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R8121 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R8122 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R8123 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R8124 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R8125 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R8126 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R8127 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R8128 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R8129 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R8130 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R8131 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R8132 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R8133 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R8134 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R8135 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R8136 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R8137 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R8138 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R8139 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R8140 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R8141 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R8142 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R8143 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R8144 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R8145 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R8146 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R8147 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R8148 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R8149 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R8150 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R8151 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R8152 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R8153 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R8154 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R8155 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R8156 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R8157 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R8158 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R8159 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R8160 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R8161 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R8162 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R8163 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R8164 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R8165 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R8166 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R8167 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R8168 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R8169 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R8170 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R8171 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R8172 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R8173 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R8174 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R8175 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R8176 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R8177 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R8178 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R8179 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R8180 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R8181 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R8182 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R8183 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R8184 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R8185 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R8186 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R8187 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R8188 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R8189 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R8190 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R8191 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R8192 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R8193 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R8194 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R8195 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R8196 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R8197 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R8198 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R8199 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R8200 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R8201 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R8202 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R8203 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R8204 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R8205 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R8206 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R8207 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R8208 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R8209 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R8210 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R8211 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R8212 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R8213 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R8214 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R8215 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R8216 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R8217 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R8218 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R8219 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R8220 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R8221 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R8222 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R8223 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R8224 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R8225 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R8226 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R8227 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R8228 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R8229 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R8230 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R8231 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R8232 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R8233 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R8234 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R8235 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R8236 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R8237 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R8238 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R8239 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R8240 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R8241 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R8242 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R8243 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R8244 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R8245 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R8246 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R8247 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R8248 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R8249 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R8250 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R8251 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R8252 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R8253 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R8254 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R8255 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R8256 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R8257 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R8258 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R8259 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R8260 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R8261 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R8262 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R8263 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R8264 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R8265 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R8266 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R8267 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R8268 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R8269 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R8270 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R8271 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R8272 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R8273 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R8274 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R8275 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R8276 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R8277 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R8278 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R8279 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R8280 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R8281 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R8282 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R8283 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R8284 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R8285 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R8286 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R8287 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R8288 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R8289 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R8290 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R8291 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R8292 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R8293 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R8294 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R8295 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R8296 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R8297 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R8298 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R8299 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R8300 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R8301 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R8302 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R8303 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R8304 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R8305 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R8306 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R8307 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R8308 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R8309 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R8310 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R8311 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R8312 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R8313 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R8314 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R8315 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R8316 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R8317 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R8318 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R8319 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R8320 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R8321 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R8322 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R8323 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R8324 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R8325 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R8326 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R8327 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R8328 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R8329 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R8330 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R8331 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R8332 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R8333 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R8334 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R8335 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R8336 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R8337 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R8338 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R8339 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R8340 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R8341 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R8342 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R8343 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R8344 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R8345 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R8346 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R8347 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R8348 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R8349 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R8350 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R8351 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R8352 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R8353 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R8354 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R8355 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R8356 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R8357 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R8358 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R8359 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R8360 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R8361 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R8362 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R8363 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R8364 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R8365 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R8366 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R8367 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R8368 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R8369 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R8370 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R8371 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R8372 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R8373 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R8374 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R8375 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R8376 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R8377 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R8378 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R8379 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R8380 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R8381 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R8382 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R8383 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R8384 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R8385 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R8386 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R8387 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R8388 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R8389 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R8390 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R8391 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R8392 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R8393 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R8394 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R8395 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R8396 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R8397 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R8398 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R8399 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R8400 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R8401 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R8402 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R8403 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R8404 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R8405 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R8406 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R8407 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R8408 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R8409 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R8410 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R8411 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R8412 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R8413 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R8414 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R8415 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R8416 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R8417 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R8418 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R8419 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R8420 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R8421 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R8422 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R8423 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R8424 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R8425 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R8426 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R8427 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R8428 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R8429 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R8430 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R8431 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R8432 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R8433 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R8434 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R8435 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R8436 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R8437 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R8438 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R8439 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R8440 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R8441 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R8442 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R8443 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R8444 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R8445 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R8446 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R8447 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R8448 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R8449 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R8450 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R8451 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R8452 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R8453 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R8454 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R8455 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R8456 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R8457 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R8458 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R8459 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R8460 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R8461 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R8462 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R8463 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R8464 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R8465 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R8466 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R8467 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R8468 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R8469 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R8470 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R8471 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R8472 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R8473 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R8474 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R8475 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R8476 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R8477 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R8478 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R8479 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R8480 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R8481 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R8482 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R8483 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R8484 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R8485 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R8486 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R8487 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R8488 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R8489 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R8490 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R8491 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R8492 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R8493 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R8494 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R8495 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R8496 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R8497 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R8498 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R8499 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R8500 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R8501 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R8502 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R8503 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R8504 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R8505 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R8506 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R8507 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R8508 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R8509 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R8510 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R8511 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R8512 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R8513 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R8514 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R8515 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R8516 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R8517 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R8518 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R8519 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R8520 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R8521 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R8522 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R8523 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R8524 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R8525 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R8526 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R8527 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R8528 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R8529 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R8530 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R8531 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R8532 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R8533 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R8534 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R8535 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R8536 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R8537 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R8538 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R8539 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R8540 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R8541 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R8542 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R8543 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R8544 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R8545 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R8546 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R8547 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R8548 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R8549 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R8550 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R8551 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R8552 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R8553 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R8554 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R8555 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R8556 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R8557 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R8558 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R8559 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R8560 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R8561 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R8562 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R8563 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R8564 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R8565 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R8566 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R8567 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R8568 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R8569 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R8570 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R8571 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R8572 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R8573 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R8574 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R8575 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R8576 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R8577 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R8578 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R8579 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R8580 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R8581 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R8582 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R8583 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R8584 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R8585 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R8586 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R8587 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R8588 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R8589 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R8590 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R8591 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R8592 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R8593 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R8594 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R8595 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R8596 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R8597 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R8598 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R8599 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R8600 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R8601 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R8602 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R8603 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R8604 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R8605 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R8606 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R8607 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R8608 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R8609 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R8610 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R8611 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R8612 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R8613 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R8614 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R8615 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R8616 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R8617 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R8618 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R8619 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R8620 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R8621 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R8622 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R8623 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R8624 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R8625 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R8626 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R8627 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R8628 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R8629 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R8630 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R8631 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R8632 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R8633 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R8634 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R8635 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R8636 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R8637 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R8638 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R8639 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R8640 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R8641 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R8642 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R8643 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R8644 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R8645 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R8646 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R8647 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R8648 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R8649 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R8650 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R8651 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R8652 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R8653 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R8654 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R8655 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R8656 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R8657 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R8658 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R8659 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R8660 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R8661 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R8662 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R8663 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R8664 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R8665 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R8666 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R8667 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R8668 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R8669 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R8670 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R8671 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R8672 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R8673 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R8674 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R8675 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R8676 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R8677 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R8678 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R8679 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R8680 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R8681 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R8682 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R8683 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R8684 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R8685 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R8686 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R8687 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R8688 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R8689 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R8690 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R8691 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R8692 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R8693 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R8694 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R8695 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R8696 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R8697 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R8698 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R8699 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R8700 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R8701 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R8702 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R8703 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R8704 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R8705 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R8706 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R8707 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R8708 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R8709 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R8710 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R8711 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R8712 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R8713 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R8714 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R8715 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R8716 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R8717 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R8718 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R8719 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R8720 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R8721 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R8722 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R8723 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R8724 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R8725 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R8726 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R8727 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R8728 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R8729 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R8730 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R8731 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R8732 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R8733 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R8734 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R8735 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R8736 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R8737 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R8738 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R8739 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R8740 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R8741 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R8742 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R8743 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R8744 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R8745 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R8746 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R8747 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R8748 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R8749 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R8750 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R8751 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R8752 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R8753 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R8754 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R8755 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R8756 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R8757 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R8758 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R8759 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R8760 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R8761 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R8762 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R8763 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R8764 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R8765 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R8766 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R8767 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R8768 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R8769 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R8770 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R8771 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R8772 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R8773 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R8774 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R8775 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R8776 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R8777 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R8778 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R8779 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R8780 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R8781 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R8782 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R8783 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R8784 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R8785 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R8786 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R8787 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R8788 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R8789 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R8790 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R8791 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R8792 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R8793 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R8794 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R8795 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R8796 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R8797 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R8798 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R8799 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R8800 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R8801 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R8802 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R8803 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R8804 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R8805 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R8806 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R8807 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R8808 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R8809 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R8810 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R8811 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R8812 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R8813 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R8814 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R8815 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R8816 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R8817 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R8818 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R8819 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R8820 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R8821 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R8822 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R8823 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R8824 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R8825 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R8826 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R8827 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R8828 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R8829 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R8830 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R8831 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R8832 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R8833 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R8834 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R8835 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R8836 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R8837 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R8838 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R8839 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R8840 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R8841 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R8842 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R8843 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R8844 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R8845 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R8846 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R8847 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R8848 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R8849 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R8850 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R8851 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R8852 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R8853 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R8854 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R8855 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R8856 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R8857 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R8858 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R8859 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R8860 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R8861 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R8862 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R8863 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R8864 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R8865 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R8866 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R8867 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R8868 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R8869 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R8870 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R8871 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R8872 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R8873 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R8874 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R8875 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R8876 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R8877 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R8878 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R8879 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R8880 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R8881 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R8882 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R8883 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R8884 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R8885 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R8886 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R8887 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R8888 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R8889 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R8890 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R8891 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R8892 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R8893 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R8894 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R8895 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R8896 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R8897 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R8898 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R8899 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R8900 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R8901 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R8902 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R8903 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R8904 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R8905 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R8906 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R8907 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R8908 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R8909 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R8910 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R8911 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R8912 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R8913 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R8914 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R8915 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R8916 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R8917 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R8918 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R8919 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R8920 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R8921 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R8922 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R8923 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R8924 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R8925 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R8926 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R8927 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R8928 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R8929 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R8930 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R8931 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R8932 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R8933 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R8934 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R8935 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R8936 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R8937 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R8938 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R8939 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R8940 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R8941 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R8942 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R8943 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R8944 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R8945 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R8946 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R8947 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R8948 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R8949 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R8950 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R8951 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R8952 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R8953 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R8954 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R8955 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R8956 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R8957 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R8958 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R8959 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R8960 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R8961 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R8962 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R8963 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R8964 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R8965 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R8966 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R8967 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R8968 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R8969 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R8970 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R8971 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R8972 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R8973 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R8974 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R8975 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R8976 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R8977 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R8978 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R8979 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R8980 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R8981 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R8982 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R8983 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R8984 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R8985 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R8986 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R8987 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R8988 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R8989 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R8990 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R8991 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R8992 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R8993 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R8994 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R8995 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R8996 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R8997 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R8998 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R8999 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R9000 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R9001 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R9002 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R9003 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R9004 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R9005 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R9006 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R9007 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R9008 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R9009 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R9010 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R9011 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R9012 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R9013 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R9014 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R9015 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R9016 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R9017 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R9018 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R9019 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R9020 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R9021 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R9022 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R9023 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R9024 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R9025 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R9026 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R9027 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R9028 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R9029 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R9030 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R9031 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R9032 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R9033 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R9034 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R9035 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R9036 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R9037 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R9038 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R9039 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R9040 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R9041 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R9042 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R9043 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R9044 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R9045 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R9046 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R9047 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R9048 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R9049 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R9050 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R9051 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R9052 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R9053 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R9054 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R9055 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R9056 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R9057 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R9058 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R9059 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R9060 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R9061 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R9062 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R9063 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R9064 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R9065 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R9066 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R9067 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R9068 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R9069 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R9070 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R9071 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R9072 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R9073 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R9074 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R9075 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R9076 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R9077 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R9078 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R9079 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R9080 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R9081 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R9082 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R9083 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R9084 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R9085 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R9086 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R9087 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R9088 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R9089 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R9090 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R9091 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R9092 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R9093 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R9094 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R9095 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R9096 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R9097 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R9098 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R9099 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R9100 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R9101 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R9102 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R9103 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R9104 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R9105 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R9106 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R9107 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R9108 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R9109 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R9110 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R9111 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R9112 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R9113 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R9114 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R9115 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R9116 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R9117 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R9118 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R9119 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R9120 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R9121 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R9122 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R9123 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R9124 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R9125 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R9126 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R9127 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R9128 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R9129 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R9130 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R9131 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R9132 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R9133 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R9134 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R9135 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R9136 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R9137 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R9138 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R9139 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R9140 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R9141 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R9142 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R9143 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R9144 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R9145 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R9146 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R9147 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R9148 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R9149 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R9150 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R9151 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R9152 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R9153 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R9154 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R9155 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R9156 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R9157 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R9158 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R9159 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R9160 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R9161 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R9162 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R9163 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R9164 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R9165 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R9166 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R9167 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R9168 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R9169 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R9170 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R9171 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R9172 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R9173 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R9174 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R9175 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R9176 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R9177 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R9178 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R9179 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R9180 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R9181 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R9182 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R9183 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R9184 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R9185 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R9186 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R9187 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R9188 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R9189 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R9190 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R9191 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R9192 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R9193 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R9194 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R9195 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R9196 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R9197 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R9198 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R9199 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R9200 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R9201 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R9202 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R9203 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R9204 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R9205 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R9206 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R9207 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R9208 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R9209 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R9210 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R9211 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R9212 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R9213 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R9214 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R9215 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R9216 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R9217 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R9218 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R9219 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R9220 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R9221 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R9222 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R9223 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R9224 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R9225 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R9226 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R9227 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R9228 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R9229 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R9230 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R9231 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R9232 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R9233 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R9234 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R9235 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R9236 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R9237 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R9238 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R9239 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R9240 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R9241 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R9242 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R9243 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R9244 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R9245 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R9246 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R9247 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R9248 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R9249 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R9250 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R9251 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R9252 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R9253 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R9254 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R9255 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R9256 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R9257 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R9258 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R9259 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R9260 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R9261 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R9262 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R9263 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R9264 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R9265 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R9266 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R9267 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R9268 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R9269 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R9270 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R9271 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R9272 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R9273 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R9274 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R9275 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R9276 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R9277 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R9278 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R9279 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R9280 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R9281 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R9282 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R9283 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R9284 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R9285 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R9286 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R9287 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R9288 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R9289 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R9290 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R9291 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R9292 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R9293 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R9294 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R9295 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R9296 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R9297 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R9298 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R9299 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R9300 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R9301 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R9302 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R9303 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R9304 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R9305 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R9306 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R9307 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R9308 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R9309 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R9310 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R9311 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R9312 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R9313 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R9314 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R9315 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R9316 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R9317 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R9318 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R9319 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R9320 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R9321 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R9322 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R9323 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R9324 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R9325 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R9326 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R9327 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R9328 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R9329 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R9330 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R9331 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R9332 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R9333 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R9334 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R9335 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R9336 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R9337 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R9338 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R9339 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R9340 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R9341 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R9342 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R9343 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R9344 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R9345 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R9346 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R9347 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R9348 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R9349 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R9350 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R9351 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R9352 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R9353 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R9354 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R9355 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R9356 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R9357 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R9358 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R9359 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R9360 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R9361 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R9362 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R9363 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R9364 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R9365 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R9366 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R9367 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R9368 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R9369 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R9370 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R9371 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R9372 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R9373 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R9374 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R9375 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R9376 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R9377 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R9378 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R9379 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R9380 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R9381 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R9382 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R9383 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R9384 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R9385 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R9386 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R9387 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R9388 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R9389 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R9390 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R9391 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R9392 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R9393 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R9394 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R9395 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R9396 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R9397 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R9398 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R9399 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R9400 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R9401 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R9402 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R9403 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R9404 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R9405 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R9406 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R9407 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R9408 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R9409 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R9410 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R9411 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R9412 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R9413 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R9414 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R9415 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R9416 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R9417 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R9418 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R9419 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R9420 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R9421 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R9422 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R9423 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R9424 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R9425 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R9426 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R9427 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R9428 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R9429 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R9430 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R9431 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R9432 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R9433 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R9434 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R9435 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R9436 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R9437 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R9438 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R9439 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R9440 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R9441 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R9442 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R9443 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R9444 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R9445 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R9446 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R9447 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R9448 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R9449 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R9450 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R9451 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R9452 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R9453 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R9454 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R9455 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R9456 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R9457 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R9458 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R9459 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R9460 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R9461 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R9462 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R9463 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R9464 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R9465 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R9466 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R9467 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R9468 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R9469 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R9470 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R9471 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R9472 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R9473 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R9474 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R9475 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R9476 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R9477 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R9478 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R9479 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R9480 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R9481 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R9482 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R9483 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R9484 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R9485 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R9486 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R9487 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R9488 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R9489 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R9490 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R9491 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R9492 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R9493 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R9494 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R9495 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R9496 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R9497 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R9498 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R9499 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R9500 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R9501 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R9502 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R9503 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R9504 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R9505 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R9506 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R9507 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R9508 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R9509 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R9510 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R9511 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R9512 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R9513 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R9514 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R9515 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R9516 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R9517 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R9518 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R9519 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R9520 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R9521 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R9522 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R9523 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R9524 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R9525 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R9526 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R9527 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R9528 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R9529 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R9530 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R9531 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R9532 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R9533 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R9534 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R9535 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R9536 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R9537 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R9538 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R9539 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R9540 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R9541 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R9542 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R9543 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R9544 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R9545 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R9546 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R9547 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R9548 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R9549 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R9550 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R9551 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R9552 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R9553 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R9554 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R9555 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R9556 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R9557 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R9558 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R9559 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R9560 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R9561 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R9562 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R9563 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R9564 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R9565 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R9566 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R9567 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R9568 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R9569 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R9570 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R9571 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R9572 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R9573 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R9574 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R9575 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R9576 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R9577 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R9578 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R9579 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R9580 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R9581 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R9582 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R9583 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R9584 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R9585 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R9586 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R9587 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R9588 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R9589 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R9590 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R9591 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R9592 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R9593 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R9594 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R9595 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R9596 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R9597 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R9598 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R9599 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R9600 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R9601 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R9602 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R9603 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R9604 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R9605 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R9606 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R9607 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R9608 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R9609 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R9610 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R9611 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R9612 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R9613 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R9614 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R9615 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R9616 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R9617 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R9618 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R9619 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R9620 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R9621 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R9622 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R9623 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R9624 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R9625 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R9626 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R9627 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R9628 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R9629 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R9630 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R9631 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R9632 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R9633 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R9634 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R9635 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R9636 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R9637 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R9638 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R9639 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R9640 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R9641 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R9642 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R9643 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R9644 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R9645 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R9646 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R9647 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R9648 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R9649 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R9650 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R9651 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R9652 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R9653 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R9654 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R9655 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R9656 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R9657 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R9658 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R9659 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R9660 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R9661 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R9662 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R9663 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R9664 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R9665 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R9666 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R9667 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R9668 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R9669 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R9670 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R9671 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R9672 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R9673 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R9674 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R9675 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R9676 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R9677 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R9678 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R9679 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R9680 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R9681 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R9682 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R9683 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R9684 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R9685 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R9686 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R9687 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R9688 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R9689 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R9690 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R9691 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R9692 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R9693 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R9694 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R9695 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R9696 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R9697 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R9698 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R9699 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R9700 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R9701 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R9702 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R9703 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R9704 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R9705 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R9706 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R9707 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R9708 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R9709 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R9710 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R9711 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R9712 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R9713 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R9714 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R9715 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R9716 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R9717 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R9718 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R9719 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R9720 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R9721 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R9722 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R9723 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R9724 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R9725 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R9726 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R9727 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R9728 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R9729 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R9730 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R9731 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R9732 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R9733 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R9734 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R9735 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R9736 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R9737 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R9738 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R9739 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R9740 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R9741 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R9742 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R9743 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R9744 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R9745 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R9746 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R9747 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R9748 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R9749 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R9750 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R9751 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R9752 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R9753 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R9754 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R9755 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R9756 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R9757 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R9758 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R9759 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R9760 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R9761 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R9762 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R9763 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R9764 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R9765 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R9766 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R9767 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R9768 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R9769 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R9770 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R9771 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R9772 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R9773 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R9774 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R9775 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R9776 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R9777 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R9778 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R9779 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R9780 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R9781 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R9782 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R9783 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R9784 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R9785 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R9786 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R9787 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R9788 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R9789 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R9790 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R9791 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R9792 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R9793 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R9794 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R9795 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R9796 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R9797 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R9798 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R9799 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R9800 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R9801 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R9802 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R9803 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R9804 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R9805 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R9806 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R9807 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R9808 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R9809 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R9810 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R9811 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R9812 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R9813 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R9814 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R9815 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R9816 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R9817 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R9818 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R9819 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R9820 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R9821 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R9822 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R9823 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R9824 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R9825 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R9826 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R9827 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R9828 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R9829 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R9830 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R9831 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R9832 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R9833 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R9834 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R9835 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R9836 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R9837 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R9838 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R9839 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R9840 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R9841 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R9842 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R9843 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R9844 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R9845 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R9846 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R9847 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R9848 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R9849 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R9850 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R9851 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R9852 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R9853 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R9854 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R9855 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R9856 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R9857 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R9858 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R9859 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R9860 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R9861 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R9862 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R9863 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R9864 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R9865 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R9866 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R9867 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R9868 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R9869 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R9870 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R9871 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R9872 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R9873 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R9874 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R9875 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R9876 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R9877 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R9878 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R9879 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R9880 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R9881 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R9882 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R9883 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R9884 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R9885 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R9886 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R9887 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R9888 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R9889 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R9890 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R9891 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R9892 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R9893 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R9894 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R9895 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R9896 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R9897 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R9898 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R9899 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R9900 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R9901 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R9902 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R9903 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R9904 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R9905 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R9906 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R9907 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R9908 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R9909 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R9910 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R9911 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R9912 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R9913 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R9914 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R9915 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R9916 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R9917 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R9918 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R9919 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R9920 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R9921 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R9922 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R9923 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R9924 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R9925 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R9926 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R9927 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R9928 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R9929 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R9930 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R9931 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R9932 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R9933 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R9934 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R9935 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R9936 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R9937 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R9938 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R9939 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R9940 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R9941 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R9942 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R9943 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R9944 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R9945 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R9946 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R9947 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R9948 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R9949 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R9950 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R9951 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R9952 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R9953 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R9954 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R9955 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R9956 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R9957 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R9958 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R9959 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R9960 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R9961 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R9962 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R9963 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R9964 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R9965 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R9966 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R9967 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R9968 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R9969 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R9970 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R9971 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R9972 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R9973 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R9974 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R9975 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R9976 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R9977 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R9978 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R9979 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R9980 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R9981 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R9982 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R9983 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R9984 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R9985 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R9986 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R9987 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R9988 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R9989 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R9990 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R9991 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R9992 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R9993 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R9994 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R9995 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R9996 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R9997 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R9998 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R9999 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R10000 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R10001 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R10002 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R10003 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R10004 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R10005 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R10006 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R10007 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R10008 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R10009 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R10010 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R10011 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R10012 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R10013 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R10014 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R10015 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R10016 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R10017 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R10018 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R10019 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R10020 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R10021 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R10022 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R10023 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R10024 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R10025 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R10026 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R10027 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R10028 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R10029 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R10030 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R10031 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R10032 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R10033 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R10034 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R10035 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R10036 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R10037 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R10038 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R10039 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R10040 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R10041 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R10042 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R10043 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R10044 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R10045 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R10046 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R10047 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R10048 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R10049 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R10050 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R10051 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R10052 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R10053 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R10054 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R10055 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R10056 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R10057 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R10058 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R10059 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R10060 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R10061 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R10062 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R10063 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R10064 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R10065 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R10066 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R10067 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R10068 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R10069 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R10070 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R10071 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R10072 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R10073 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R10074 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R10075 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R10076 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R10077 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R10078 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R10079 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R10080 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R10081 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R10082 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R10083 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R10084 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R10085 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R10086 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R10087 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R10088 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R10089 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R10090 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R10091 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R10092 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R10093 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R10094 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R10095 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R10096 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R10097 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R10098 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R10099 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R10100 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R10101 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R10102 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R10103 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R10104 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R10105 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R10106 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R10107 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R10108 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R10109 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R10110 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R10111 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R10112 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R10113 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R10114 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R10115 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R10116 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R10117 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R10118 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R10119 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R10120 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R10121 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R10122 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R10123 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R10124 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R10125 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R10126 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R10127 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R10128 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R10129 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R10130 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R10131 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R10132 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R10133 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R10134 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R10135 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R10136 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R10137 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R10138 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R10139 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R10140 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R10141 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R10142 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R10143 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R10144 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R10145 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R10146 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R10147 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R10148 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R10149 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R10150 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R10151 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R10152 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R10153 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R10154 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R10155 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R10156 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R10157 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R10158 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R10159 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R10160 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R10161 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R10162 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R10163 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R10164 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R10165 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R10166 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R10167 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R10168 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R10169 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R10170 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R10171 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R10172 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R10173 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R10174 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R10175 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R10176 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R10177 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R10178 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R10179 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R10180 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R10181 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R10182 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R10183 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R10184 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R10185 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R10186 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R10187 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R10188 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R10189 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R10190 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R10191 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R10192 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R10193 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R10194 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R10195 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R10196 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R10197 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R10198 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R10199 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R10200 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R10201 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R10202 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R10203 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R10204 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R10205 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R10206 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R10207 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R10208 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R10209 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R10210 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R10211 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R10212 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R10213 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R10214 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R10215 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R10216 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R10217 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R10218 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R10219 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R10220 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R10221 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R10222 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R10223 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R10224 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R10225 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R10226 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R10227 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R10228 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R10229 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R10230 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R10231 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R10232 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R10233 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R10234 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R10235 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R10236 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R10237 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R10238 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R10239 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R10240 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R10241 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R10242 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R10243 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R10244 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R10245 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R10246 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R10247 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R10248 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R10249 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R10250 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R10251 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R10252 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R10253 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R10254 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R10255 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R10256 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R10257 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R10258 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R10259 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R10260 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R10261 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R10262 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R10263 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R10264 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R10265 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R10266 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R10267 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R10268 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R10269 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R10270 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R10271 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R10272 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R10273 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R10274 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R10275 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R10276 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R10277 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R10278 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R10279 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R10280 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R10281 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R10282 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R10283 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R10284 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R10285 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R10286 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R10287 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R10288 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R10289 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R10290 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R10291 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R10292 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R10293 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R10294 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R10295 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R10296 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R10297 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R10298 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R10299 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R10300 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R10301 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R10302 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R10303 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R10304 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R10305 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R10306 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R10307 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R10308 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R10309 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R10310 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R10311 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R10312 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R10313 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R10314 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R10315 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R10316 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R10317 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R10318 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R10319 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R10320 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R10321 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R10322 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R10323 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R10324 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R10325 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R10326 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R10327 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R10328 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R10329 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R10330 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R10331 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R10332 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R10333 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R10334 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R10335 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R10336 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R10337 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R10338 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R10339 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R10340 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R10341 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R10342 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R10343 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R10344 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R10345 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R10346 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R10347 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R10348 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R10349 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R10350 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R10351 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R10352 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R10353 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R10354 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R10355 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R10356 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R10357 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R10358 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R10359 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R10360 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R10361 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R10362 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R10363 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R10364 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R10365 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R10366 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R10367 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R10368 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R10369 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R10370 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R10371 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R10372 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R10373 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R10374 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R10375 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R10376 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R10377 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R10378 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R10379 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R10380 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R10381 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R10382 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R10383 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R10384 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R10385 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R10386 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R10387 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R10388 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R10389 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R10390 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R10391 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R10392 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R10393 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R10394 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R10395 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R10396 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R10397 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R10398 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R10399 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R10400 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R10401 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R10402 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R10403 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R10404 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R10405 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R10406 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R10407 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R10408 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R10409 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R10410 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R10411 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R10412 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R10413 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R10414 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R10415 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R10416 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R10417 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R10418 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R10419 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R10420 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R10421 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R10422 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R10423 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R10424 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R10425 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R10426 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R10427 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R10428 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R10429 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R10430 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R10431 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R10432 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R10433 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R10434 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R10435 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R10436 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R10437 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R10438 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R10439 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R10440 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R10441 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R10442 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R10443 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R10444 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R10445 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R10446 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R10447 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R10448 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R10449 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R10450 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R10451 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R10452 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R10453 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R10454 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R10455 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R10456 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R10457 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R10458 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R10459 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R10460 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R10461 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R10462 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R10463 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R10464 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R10465 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R10466 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R10467 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R10468 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R10469 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R10470 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R10471 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R10472 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R10473 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R10474 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R10475 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R10476 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R10477 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R10478 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R10479 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R10480 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R10481 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R10482 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R10483 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R10484 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R10485 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R10486 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R10487 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R10488 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R10489 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R10490 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R10491 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R10492 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R10493 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R10494 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R10495 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R10496 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R10497 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R10498 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R10499 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R10500 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R10501 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R10502 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R10503 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R10504 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R10505 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R10506 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R10507 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R10508 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R10509 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R10510 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R10511 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R10512 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R10513 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R10514 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R10515 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R10516 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R10517 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R10518 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R10519 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R10520 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R10521 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R10522 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R10523 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R10524 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R10525 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R10526 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R10527 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R10528 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R10529 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R10530 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R10531 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R10532 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R10533 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R10534 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R10535 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R10536 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R10537 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R10538 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R10539 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R10540 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R10541 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R10542 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R10543 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R10544 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R10545 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R10546 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R10547 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R10548 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R10549 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R10550 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R10551 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R10552 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R10553 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R10554 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R10555 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R10556 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R10557 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R10558 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R10559 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R10560 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R10561 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R10562 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R10563 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R10564 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R10565 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R10566 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R10567 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R10568 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R10569 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R10570 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R10571 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R10572 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R10573 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R10574 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R10575 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R10576 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R10577 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R10578 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R10579 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R10580 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R10581 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R10582 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R10583 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R10584 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R10585 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R10586 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R10587 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R10588 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R10589 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R10590 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R10591 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R10592 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R10593 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R10594 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R10595 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R10596 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R10597 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R10598 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R10599 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R10600 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R10601 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R10602 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R10603 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R10604 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R10605 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R10606 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R10607 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R10608 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R10609 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R10610 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R10611 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R10612 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R10613 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R10614 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R10615 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R10616 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R10617 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R10618 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R10619 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R10620 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R10621 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R10622 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R10623 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R10624 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R10625 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R10626 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R10627 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R10628 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R10629 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R10630 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R10631 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R10632 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R10633 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R10634 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R10635 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R10636 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R10637 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R10638 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R10639 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R10640 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R10641 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R10642 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R10643 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R10644 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R10645 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R10646 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R10647 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R10648 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R10649 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R10650 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R10651 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R10652 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R10653 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R10654 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R10655 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R10656 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R10657 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R10658 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R10659 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R10660 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R10661 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R10662 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R10663 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R10664 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R10665 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R10666 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R10667 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R10668 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R10669 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R10670 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R10671 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R10672 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R10673 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R10674 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R10675 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R10676 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R10677 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R10678 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R10679 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R10680 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R10681 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R10682 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R10683 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R10684 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R10685 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R10686 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R10687 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R10688 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R10689 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R10690 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R10691 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R10692 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R10693 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R10694 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R10695 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R10696 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R10697 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R10698 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R10699 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R10700 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R10701 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R10702 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R10703 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R10704 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R10705 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R10706 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R10707 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R10708 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R10709 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R10710 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R10711 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R10712 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R10713 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R10714 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R10715 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R10716 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R10717 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R10718 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R10719 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R10720 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R10721 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R10722 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R10723 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R10724 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R10725 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R10726 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R10727 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R10728 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R10729 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R10730 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R10731 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R10732 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R10733 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R10734 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R10735 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R10736 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R10737 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R10738 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R10739 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R10740 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R10741 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R10742 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R10743 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R10744 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R10745 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R10746 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R10747 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R10748 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R10749 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R10750 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R10751 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R10752 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R10753 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R10754 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R10755 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R10756 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R10757 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R10758 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R10759 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R10760 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R10761 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R10762 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R10763 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R10764 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R10765 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R10766 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R10767 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R10768 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R10769 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R10770 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R10771 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R10772 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R10773 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R10774 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R10775 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R10776 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R10777 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R10778 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R10779 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R10780 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R10781 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R10782 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R10783 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R10784 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R10785 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R10786 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R10787 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R10788 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R10789 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R10790 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R10791 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R10792 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R10793 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R10794 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R10795 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R10796 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R10797 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R10798 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R10799 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R10800 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R10801 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R10802 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R10803 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R10804 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R10805 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R10806 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R10807 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R10808 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R10809 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R10810 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R10811 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R10812 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R10813 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R10814 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R10815 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R10816 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R10817 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R10818 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R10819 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R10820 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R10821 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R10822 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R10823 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R10824 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R10825 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R10826 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R10827 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R10828 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R10829 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R10830 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R10831 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R10832 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R10833 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R10834 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R10835 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R10836 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R10837 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R10838 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R10839 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R10840 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R10841 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R10842 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R10843 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R10844 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R10845 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R10846 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R10847 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R10848 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R10849 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R10850 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R10851 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R10852 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R10853 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R10854 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R10855 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R10856 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R10857 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R10858 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R10859 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R10860 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R10861 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R10862 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R10863 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R10864 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R10865 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R10866 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R10867 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R10868 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R10869 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R10870 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R10871 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R10872 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R10873 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R10874 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R10875 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R10876 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R10877 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R10878 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R10879 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R10880 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R10881 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R10882 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R10883 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R10884 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R10885 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R10886 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R10887 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R10888 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R10889 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R10890 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R10891 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R10892 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R10893 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R10894 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R10895 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R10896 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R10897 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R10898 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R10899 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R10900 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R10901 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R10902 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R10903 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R10904 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R10905 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R10906 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R10907 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R10908 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R10909 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R10910 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R10911 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R10912 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R10913 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R10914 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R10915 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R10916 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R10917 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R10918 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R10919 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R10920 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R10921 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R10922 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R10923 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R10924 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R10925 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R10926 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R10927 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R10928 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R10929 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R10930 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R10931 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R10932 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R10933 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R10934 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R10935 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R10936 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R10937 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R10938 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R10939 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R10940 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R10941 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R10942 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R10943 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R10944 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R10945 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R10946 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R10947 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R10948 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R10949 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R10950 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R10951 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R10952 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R10953 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R10954 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R10955 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R10956 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R10957 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R10958 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R10959 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R10960 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R10961 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R10962 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R10963 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R10964 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R10965 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R10966 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R10967 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R10968 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R10969 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R10970 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R10971 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R10972 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R10973 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R10974 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R10975 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R10976 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R10977 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R10978 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R10979 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R10980 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R10981 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R10982 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R10983 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R10984 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R10985 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R10986 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R10987 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R10988 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R10989 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R10990 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R10991 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R10992 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R10993 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R10994 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R10995 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R10996 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R10997 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R10998 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R10999 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R11000 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R11001 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R11002 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R11003 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R11004 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R11005 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R11006 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R11007 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R11008 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R11009 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R11010 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R11011 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R11012 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R11013 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R11014 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R11015 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R11016 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R11017 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R11018 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R11019 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R11020 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R11021 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R11022 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R11023 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R11024 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R11025 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R11026 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R11027 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R11028 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R11029 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R11030 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R11031 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R11032 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R11033 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R11034 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R11035 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R11036 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R11037 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R11038 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R11039 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R11040 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R11041 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R11042 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R11043 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R11044 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R11045 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R11046 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R11047 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R11048 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R11049 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R11050 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R11051 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R11052 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R11053 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R11054 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R11055 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R11056 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R11057 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R11058 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R11059 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R11060 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R11061 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R11062 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R11063 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R11064 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R11065 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R11066 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R11067 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R11068 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R11069 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R11070 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R11071 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R11072 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R11073 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R11074 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R11075 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R11076 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R11077 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R11078 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R11079 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R11080 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R11081 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R11082 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R11083 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R11084 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R11085 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R11086 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R11087 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R11088 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R11089 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R11090 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R11091 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R11092 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R11093 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R11094 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R11095 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R11096 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R11097 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R11098 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R11099 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R11100 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R11101 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R11102 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R11103 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R11104 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R11105 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R11106 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R11107 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R11108 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R11109 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R11110 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R11111 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R11112 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R11113 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R11114 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R11115 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R11116 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R11117 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R11118 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R11119 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R11120 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R11121 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R11122 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R11123 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R11124 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R11125 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R11126 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R11127 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R11128 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R11129 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R11130 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R11131 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R11132 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R11133 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R11134 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R11135 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R11136 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R11137 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R11138 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R11139 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R11140 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R11141 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R11142 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R11143 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R11144 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R11145 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R11146 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R11147 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R11148 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R11149 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R11150 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R11151 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R11152 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R11153 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R11154 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R11155 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R11156 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R11157 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R11158 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R11159 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R11160 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R11161 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R11162 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R11163 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R11164 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R11165 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R11166 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R11167 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R11168 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R11169 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R11170 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R11171 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R11172 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R11173 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R11174 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R11175 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R11176 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R11177 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R11178 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R11179 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R11180 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R11181 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R11182 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R11183 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R11184 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R11185 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R11186 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R11187 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R11188 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R11189 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R11190 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R11191 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R11192 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R11193 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R11194 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R11195 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R11196 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R11197 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R11198 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R11199 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R11200 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R11201 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R11202 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R11203 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R11204 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R11205 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R11206 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R11207 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R11208 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R11209 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R11210 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R11211 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R11212 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R11213 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R11214 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R11215 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R11216 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R11217 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R11218 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R11219 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R11220 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R11221 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R11222 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R11223 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R11224 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R11225 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R11226 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R11227 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R11228 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R11229 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R11230 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R11231 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R11232 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R11233 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R11234 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R11235 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R11236 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R11237 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R11238 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R11239 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R11240 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R11241 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R11242 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R11243 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R11244 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R11245 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R11246 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R11247 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R11248 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R11249 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R11250 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R11251 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R11252 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R11253 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R11254 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R11255 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R11256 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R11257 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R11258 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R11259 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R11260 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R11261 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R11262 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R11263 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R11264 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R11265 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R11266 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R11267 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R11268 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R11269 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R11270 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R11271 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R11272 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R11273 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R11274 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R11275 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R11276 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R11277 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R11278 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R11279 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R11280 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R11281 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R11282 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R11283 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R11284 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R11285 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R11286 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R11287 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R11288 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R11289 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R11290 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R11291 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R11292 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R11293 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R11294 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R11295 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R11296 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R11297 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R11298 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R11299 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R11300 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R11301 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R11302 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R11303 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R11304 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R11305 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R11306 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R11307 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R11308 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R11309 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R11310 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R11311 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R11312 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R11313 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R11314 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R11315 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R11316 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R11317 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R11318 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R11319 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R11320 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R11321 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R11322 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R11323 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R11324 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R11325 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R11326 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R11327 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R11328 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R11329 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R11330 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R11331 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R11332 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R11333 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R11334 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R11335 n1_m4_32000_196800 n1_m4_32000_201600 1.400000
R11336 n1_m4_32000_201600 n1_m4_32000_206400 1.400000
R11337 n1_m4_32000_206400 n1_m4_32000_211200 1.400000
R11338 n1_m4_32000_211200 n1_m4_32000_216000 1.400000
R11339 n1_m4_32000_216000 n1_m4_32000_220800 1.400000
R11340 n1_m4_32000_220800 n1_m4_32000_225600 1.400000
R11341 n1_m4_32000_225600 n1_m4_32000_230400 1.400000
R11342 n1_m4_32000_230400 n1_m4_32000_235200 1.400000
R11343 n1_m4_32000_235200 n1_m4_32000_240000 1.400000
R11344 n1_m4_32000_240000 n1_m4_32000_244000 1.166667
R11345 n1_m4_32000_244800 n1_m4_32000_244000 0.233333
R11346 n1_m4_32000_244800 n1_m4_32000_249600 1.400000
R11347 n1_m4_32000_249600 n1_m4_32000_254400 1.400000
R11348 n1_m4_32000_254400 n1_m4_32000_259200 1.400000
R11349 n1_m4_32000_259200 n1_m4_32000_264000 1.400000
R11350 n1_m4_32000_264000 n1_m4_32000_268800 1.400000
R11351 n1_m4_32000_268800 n1_m4_32000_273600 1.400000
R11352 n1_m4_32000_273600 n1_m4_32000_278400 1.400000
R11353 n1_m4_32000_278400 n1_m4_32000_283200 1.400000
R11354 n1_m4_32000_283200 n1_m4_32000_288000 1.400000
R11355 n1_m4_32000_288000 n1_m4_32000_292800 1.400000
R11356 n1_m4_32000_292800 n1_m4_32000_297600 1.400000
R11357 n1_m4_32000_297600 n1_m4_32000_302400 1.400000
R11358 n1_m4_32000_302400 n1_m4_32000_307200 1.400000
R11359 n1_m4_32000_307200 n1_m4_32000_312000 1.400000
R11360 n1_m4_32000_312000 n1_m4_32000_316800 1.400000
R11361 n1_m4_32000_316800 n1_m4_32000_321600 1.400000
R11362 n1_m4_32000_321600 n1_m4_32000_324000 0.700000
R11363 n1_m4_32000_326400 n1_m4_32000_324000 0.700000
R11364 n1_m4_32000_326400 n1_m4_32000_331200 1.400000
R11365 n1_m4_32000_331200 n1_m4_32000_336000 1.400000
R11366 n1_m4_32000_336000 n1_m4_32000_340800 1.400000
R11367 n1_m4_32000_340800 n1_m4_32000_345600 1.400000
R11368 n1_m4_32000_345600 n1_m4_32000_350400 1.400000
R11369 n1_m4_32000_350400 n1_m4_32000_355200 1.400000
R11370 n1_m4_32000_355200 n1_m4_32000_360000 1.400000
R11371 n1_m4_32000_360000 n1_m4_32000_364800 1.400000
R11372 n1_m4_32000_364800 n1_m4_32000_369600 1.400000
R11373 n1_m4_32000_369600 n1_m4_32000_374400 1.400000
R11374 n1_m4_32000_374400 n1_m4_32000_379200 1.400000
R11375 n1_m4_32000_379200 n1_m4_32000_384000 1.400000
R11376 n1_m4_32000_384000 n1_m4_32000_388800 1.400000
R11377 n1_m4_32000_388800 n1_m4_32000_393600 1.400000
R11378 n1_m4_32000_393600 n1_m4_32000_398400 1.400000
R11379 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R11380 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R11381 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R11382 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R11383 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R11384 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R11385 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R11386 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R11387 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R11388 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R11389 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R11390 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R11391 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R11392 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R11393 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R11394 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R11395 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R11396 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R11397 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R11398 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R11399 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R11400 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R11401 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R11402 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R11403 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R11404 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R11405 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R11406 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R11407 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R11408 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R11409 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R11410 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R11411 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R11412 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R11413 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R11414 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R11415 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R11416 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R11417 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R11418 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R11419 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R11420 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R11421 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R11422 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R11423 n1_m4_60000_196800 n1_m4_60000_201600 1.400000
R11424 n1_m4_60000_201600 n1_m4_60000_206400 1.400000
R11425 n1_m4_60000_206400 n1_m4_60000_211200 1.400000
R11426 n1_m4_60000_211200 n1_m4_60000_216000 1.400000
R11427 n1_m4_60000_216000 n1_m4_60000_220800 1.400000
R11428 n1_m4_60000_220800 n1_m4_60000_225600 1.400000
R11429 n1_m4_60000_225600 n1_m4_60000_230400 1.400000
R11430 n1_m4_60000_230400 n1_m4_60000_235200 1.400000
R11431 n1_m4_60000_235200 n1_m4_60000_240000 1.400000
R11432 n1_m4_60000_240000 n1_m4_60000_244000 1.166667
R11433 n1_m4_60000_244800 n1_m4_60000_244000 0.233333
R11434 n1_m4_60000_244800 n1_m4_60000_249600 1.400000
R11435 n1_m4_60000_249600 n1_m4_60000_254400 1.400000
R11436 n1_m4_60000_254400 n1_m4_60000_259200 1.400000
R11437 n1_m4_60000_259200 n1_m4_60000_264000 1.400000
R11438 n1_m4_60000_264000 n1_m4_60000_268800 1.400000
R11439 n1_m4_60000_268800 n1_m4_60000_273600 1.400000
R11440 n1_m4_60000_273600 n1_m4_60000_278400 1.400000
R11441 n1_m4_60000_278400 n1_m4_60000_283200 1.400000
R11442 n1_m4_60000_283200 n1_m4_60000_288000 1.400000
R11443 n1_m4_60000_288000 n1_m4_60000_292800 1.400000
R11444 n1_m4_60000_292800 n1_m4_60000_297600 1.400000
R11445 n1_m4_60000_297600 n1_m4_60000_302400 1.400000
R11446 n1_m4_60000_302400 n1_m4_60000_307200 1.400000
R11447 n1_m4_60000_307200 n1_m4_60000_312000 1.400000
R11448 n1_m4_60000_312000 n1_m4_60000_316800 1.400000
R11449 n1_m4_60000_316800 n1_m4_60000_321600 1.400000
R11450 n1_m4_60000_321600 n1_m4_60000_324000 0.700000
R11451 n1_m4_60000_326400 n1_m4_60000_324000 0.700000
R11452 n1_m4_60000_326400 n1_m4_60000_331200 1.400000
R11453 n1_m4_60000_331200 n1_m4_60000_336000 1.400000
R11454 n1_m4_60000_336000 n1_m4_60000_340800 1.400000
R11455 n1_m4_60000_340800 n1_m4_60000_345600 1.400000
R11456 n1_m4_60000_345600 n1_m4_60000_350400 1.400000
R11457 n1_m4_60000_350400 n1_m4_60000_355200 1.400000
R11458 n1_m4_60000_355200 n1_m4_60000_360000 1.400000
R11459 n1_m4_60000_360000 n1_m4_60000_364800 1.400000
R11460 n1_m4_60000_364800 n1_m4_60000_369600 1.400000
R11461 n1_m4_60000_369600 n1_m4_60000_374400 1.400000
R11462 n1_m4_60000_374400 n1_m4_60000_379200 1.400000
R11463 n1_m4_60000_379200 n1_m4_60000_384000 1.400000
R11464 n1_m4_60000_384000 n1_m4_60000_388800 1.400000
R11465 n1_m4_60000_388800 n1_m4_60000_393600 1.400000
R11466 n1_m4_60000_393600 n1_m4_60000_398400 1.400000
R11467 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R11468 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R11469 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R11470 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R11471 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R11472 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R11473 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R11474 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R11475 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R11476 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R11477 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R11478 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R11479 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R11480 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R11481 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R11482 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R11483 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R11484 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R11485 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R11486 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R11487 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R11488 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R11489 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R11490 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R11491 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R11492 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R11493 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R11494 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R11495 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R11496 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R11497 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R11498 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R11499 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R11500 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R11501 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R11502 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R11503 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R11504 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R11505 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R11506 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R11507 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R11508 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R11509 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R11510 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R11511 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R11512 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R11513 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R11514 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R11515 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R11516 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R11517 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R11518 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R11519 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R11520 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R11521 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R11522 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R11523 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R11524 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R11525 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R11526 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R11527 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R11528 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R11529 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R11530 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R11531 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R11532 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R11533 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R11534 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R11535 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R11536 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R11537 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R11538 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R11539 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R11540 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R11541 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R11542 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R11543 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R11544 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R11545 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R11546 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R11547 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R11548 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R11549 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R11550 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R11551 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R11552 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R11553 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R11554 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R11555 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R11556 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R11557 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R11558 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R11559 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R11560 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R11561 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R11562 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R11563 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R11564 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R11565 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R11566 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R11567 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R11568 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R11569 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R11570 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R11571 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R11572 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R11573 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R11574 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R11575 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R11576 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R11577 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R11578 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R11579 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R11580 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R11581 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R11582 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R11583 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R11584 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R11585 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R11586 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R11587 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R11588 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R11589 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R11590 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R11591 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R11592 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R11593 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R11594 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R11595 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R11596 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R11597 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R11598 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R11599 n1_m4_116000_196800 n1_m4_116000_201600 1.400000
R11600 n1_m4_116000_201600 n1_m4_116000_206400 1.400000
R11601 n1_m4_116000_206400 n1_m4_116000_211200 1.400000
R11602 n1_m4_116000_211200 n1_m4_116000_216000 1.400000
R11603 n1_m4_116000_216000 n1_m4_116000_220800 1.400000
R11604 n1_m4_116000_220800 n1_m4_116000_225600 1.400000
R11605 n1_m4_116000_225600 n1_m4_116000_230400 1.400000
R11606 n1_m4_116000_230400 n1_m4_116000_235200 1.400000
R11607 n1_m4_116000_235200 n1_m4_116000_240000 1.400000
R11608 n1_m4_116000_240000 n1_m4_116000_244000 1.166667
R11609 n1_m4_116000_244800 n1_m4_116000_244000 0.233333
R11610 n1_m4_116000_244800 n1_m4_116000_249600 1.400000
R11611 n1_m4_116000_249600 n1_m4_116000_254400 1.400000
R11612 n1_m4_116000_254400 n1_m4_116000_259200 1.400000
R11613 n1_m4_116000_259200 n1_m4_116000_264000 1.400000
R11614 n1_m4_116000_264000 n1_m4_116000_268800 1.400000
R11615 n1_m4_116000_268800 n1_m4_116000_273600 1.400000
R11616 n1_m4_116000_273600 n1_m4_116000_278400 1.400000
R11617 n1_m4_116000_278400 n1_m4_116000_283200 1.400000
R11618 n1_m4_116000_283200 n1_m4_116000_288000 1.400000
R11619 n1_m4_116000_288000 n1_m4_116000_292800 1.400000
R11620 n1_m4_116000_292800 n1_m4_116000_297600 1.400000
R11621 n1_m4_116000_297600 n1_m4_116000_302400 1.400000
R11622 n1_m4_116000_302400 n1_m4_116000_307200 1.400000
R11623 n1_m4_116000_307200 n1_m4_116000_312000 1.400000
R11624 n1_m4_116000_312000 n1_m4_116000_316800 1.400000
R11625 n1_m4_116000_316800 n1_m4_116000_321600 1.400000
R11626 n1_m4_116000_321600 n1_m4_116000_324000 0.700000
R11627 n1_m4_116000_326400 n1_m4_116000_324000 0.700000
R11628 n1_m4_116000_326400 n1_m4_116000_331200 1.400000
R11629 n1_m4_116000_331200 n1_m4_116000_336000 1.400000
R11630 n1_m4_116000_336000 n1_m4_116000_340800 1.400000
R11631 n1_m4_116000_340800 n1_m4_116000_345600 1.400000
R11632 n1_m4_116000_345600 n1_m4_116000_350400 1.400000
R11633 n1_m4_116000_350400 n1_m4_116000_355200 1.400000
R11634 n1_m4_116000_355200 n1_m4_116000_360000 1.400000
R11635 n1_m4_116000_360000 n1_m4_116000_364800 1.400000
R11636 n1_m4_116000_364800 n1_m4_116000_369600 1.400000
R11637 n1_m4_116000_369600 n1_m4_116000_374400 1.400000
R11638 n1_m4_116000_374400 n1_m4_116000_379200 1.400000
R11639 n1_m4_116000_379200 n1_m4_116000_384000 1.400000
R11640 n1_m4_116000_384000 n1_m4_116000_388800 1.400000
R11641 n1_m4_116000_388800 n1_m4_116000_393600 1.400000
R11642 n1_m4_116000_393600 n1_m4_116000_398400 1.400000
R11643 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R11644 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R11645 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R11646 n1_m4_116000_408000 n1_m4_116000_412800 1.400000
R11647 n1_m4_116000_412800 n1_m4_116000_417600 1.400000
R11648 n1_m4_116000_417600 n1_m4_116000_422400 1.400000
R11649 n1_m4_116000_422400 n1_m4_116000_427200 1.400000
R11650 n1_m4_116000_427200 n1_m4_116000_432000 1.400000
R11651 n1_m4_116000_432000 n1_m4_116000_436800 1.400000
R11652 n1_m4_116000_436800 n1_m4_116000_441600 1.400000
R11653 n1_m4_116000_441600 n1_m4_116000_446400 1.400000
R11654 n1_m4_116000_446400 n1_m4_116000_451200 1.400000
R11655 n1_m4_116000_451200 n1_m4_116000_456000 1.400000
R11656 n1_m4_116000_456000 n1_m4_116000_460800 1.400000
R11657 n1_m4_116000_460800 n1_m4_116000_465600 1.400000
R11658 n1_m4_116000_465600 n1_m4_116000_470400 1.400000
R11659 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R11660 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R11661 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R11662 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R11663 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R11664 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R11665 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R11666 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R11667 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R11668 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R11669 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R11670 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R11671 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R11672 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R11673 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R11674 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R11675 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R11676 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R11677 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R11678 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R11679 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R11680 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R11681 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R11682 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R11683 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R11684 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R11685 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R11686 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R11687 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R11688 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R11689 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R11690 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R11691 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R11692 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R11693 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R11694 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R11695 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R11696 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R11697 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R11698 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R11699 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R11700 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R11701 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R11702 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R11703 n1_m4_144000_196800 n1_m4_144000_201600 1.400000
R11704 n1_m4_144000_201600 n1_m4_144000_206400 1.400000
R11705 n1_m4_144000_206400 n1_m4_144000_211200 1.400000
R11706 n1_m4_144000_211200 n1_m4_144000_216000 1.400000
R11707 n1_m4_144000_216000 n1_m4_144000_220800 1.400000
R11708 n1_m4_144000_220800 n1_m4_144000_225600 1.400000
R11709 n1_m4_144000_225600 n1_m4_144000_230400 1.400000
R11710 n1_m4_144000_230400 n1_m4_144000_235200 1.400000
R11711 n1_m4_144000_235200 n1_m4_144000_240000 1.400000
R11712 n1_m4_144000_240000 n1_m4_144000_244000 1.166667
R11713 n1_m4_144000_244800 n1_m4_144000_244000 0.233333
R11714 n1_m4_144000_244800 n1_m4_144000_249600 1.400000
R11715 n1_m4_144000_249600 n1_m4_144000_254400 1.400000
R11716 n1_m4_144000_254400 n1_m4_144000_259200 1.400000
R11717 n1_m4_144000_259200 n1_m4_144000_264000 1.400000
R11718 n1_m4_144000_264000 n1_m4_144000_268800 1.400000
R11719 n1_m4_144000_268800 n1_m4_144000_273600 1.400000
R11720 n1_m4_144000_273600 n1_m4_144000_278400 1.400000
R11721 n1_m4_144000_278400 n1_m4_144000_283200 1.400000
R11722 n1_m4_144000_283200 n1_m4_144000_288000 1.400000
R11723 n1_m4_144000_288000 n1_m4_144000_292800 1.400000
R11724 n1_m4_144000_292800 n1_m4_144000_297600 1.400000
R11725 n1_m4_144000_297600 n1_m4_144000_302400 1.400000
R11726 n1_m4_144000_302400 n1_m4_144000_307200 1.400000
R11727 n1_m4_144000_307200 n1_m4_144000_312000 1.400000
R11728 n1_m4_144000_312000 n1_m4_144000_316800 1.400000
R11729 n1_m4_144000_316800 n1_m4_144000_321600 1.400000
R11730 n1_m4_144000_321600 n1_m4_144000_324000 0.700000
R11731 n1_m4_144000_326400 n1_m4_144000_324000 0.700000
R11732 n1_m4_144000_326400 n1_m4_144000_331200 1.400000
R11733 n1_m4_144000_331200 n1_m4_144000_336000 1.400000
R11734 n1_m4_144000_336000 n1_m4_144000_340800 1.400000
R11735 n1_m4_144000_340800 n1_m4_144000_345600 1.400000
R11736 n1_m4_144000_345600 n1_m4_144000_350400 1.400000
R11737 n1_m4_144000_350400 n1_m4_144000_355200 1.400000
R11738 n1_m4_144000_355200 n1_m4_144000_360000 1.400000
R11739 n1_m4_144000_360000 n1_m4_144000_364800 1.400000
R11740 n1_m4_144000_364800 n1_m4_144000_369600 1.400000
R11741 n1_m4_144000_369600 n1_m4_144000_374400 1.400000
R11742 n1_m4_144000_374400 n1_m4_144000_379200 1.400000
R11743 n1_m4_144000_379200 n1_m4_144000_384000 1.400000
R11744 n1_m4_144000_384000 n1_m4_144000_388800 1.400000
R11745 n1_m4_144000_388800 n1_m4_144000_393600 1.400000
R11746 n1_m4_144000_393600 n1_m4_144000_398400 1.400000
R11747 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R11748 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R11749 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R11750 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R11751 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R11752 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R11753 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R11754 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R11755 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R11756 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R11757 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R11758 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R11759 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R11760 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R11761 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R11762 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R11763 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R11764 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R11765 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R11766 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R11767 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R11768 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R11769 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R11770 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R11771 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R11772 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R11773 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R11774 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R11775 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R11776 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R11777 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R11778 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R11779 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R11780 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R11781 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R11782 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R11783 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R11784 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R11785 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R11786 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R11787 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R11788 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R11789 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R11790 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R11791 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R11792 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R11793 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R11794 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R11795 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R11796 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R11797 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R11798 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R11799 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R11800 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R11801 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R11802 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R11803 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R11804 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R11805 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R11806 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R11807 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R11808 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R11809 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R11810 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R11811 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R11812 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R11813 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R11814 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R11815 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R11816 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R11817 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R11818 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R11819 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R11820 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R11821 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R11822 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R11823 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R11824 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R11825 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R11826 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R11827 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R11828 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R11829 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R11830 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R11831 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R11832 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R11833 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R11834 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R11835 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R11836 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R11837 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R11838 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R11839 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R11840 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R11841 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R11842 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R11843 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R11844 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R11845 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R11846 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R11847 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R11848 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R11849 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R11850 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R11851 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R11852 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R11853 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R11854 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R11855 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R11856 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R11857 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R11858 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R11859 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R11860 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R11861 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R11862 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R11863 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R11864 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R11865 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R11866 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R11867 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R11868 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R11869 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R11870 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R11871 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R11872 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R11873 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R11874 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R11875 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R11876 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R11877 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R11878 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R11879 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R11880 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R11881 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R11882 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R11883 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R11884 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R11885 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R11886 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R11887 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R11888 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R11889 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R11890 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R11891 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R11892 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R11893 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R11894 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R11895 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R11896 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R11897 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R11898 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R11899 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R11900 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R11901 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R11902 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R11903 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R11904 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R11905 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R11906 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R11907 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R11908 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R11909 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R11910 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R11911 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R11912 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R11913 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R11914 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R11915 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R11916 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R11917 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R11918 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R11919 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R11920 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R11921 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R11922 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R11923 n1_m4_256000_196800 n1_m4_256000_201600 1.400000
R11924 n1_m4_256000_201600 n1_m4_256000_206400 1.400000
R11925 n1_m4_256000_206400 n1_m4_256000_211200 1.400000
R11926 n1_m4_256000_211200 n1_m4_256000_216000 1.400000
R11927 n1_m4_256000_216000 n1_m4_256000_220800 1.400000
R11928 n1_m4_256000_220800 n1_m4_256000_225600 1.400000
R11929 n1_m4_256000_225600 n1_m4_256000_230400 1.400000
R11930 n1_m4_256000_230400 n1_m4_256000_235200 1.400000
R11931 n1_m4_256000_235200 n1_m4_256000_240000 1.400000
R11932 n1_m4_256000_240000 n1_m4_256000_244000 1.166667
R11933 n1_m4_256000_244800 n1_m4_256000_244000 0.233333
R11934 n1_m4_256000_244800 n1_m4_256000_249600 1.400000
R11935 n1_m4_256000_249600 n1_m4_256000_254400 1.400000
R11936 n1_m4_256000_254400 n1_m4_256000_259200 1.400000
R11937 n1_m4_256000_259200 n1_m4_256000_264000 1.400000
R11938 n1_m4_256000_264000 n1_m4_256000_268800 1.400000
R11939 n1_m4_256000_268800 n1_m4_256000_273600 1.400000
R11940 n1_m4_256000_273600 n1_m4_256000_278400 1.400000
R11941 n1_m4_256000_278400 n1_m4_256000_283200 1.400000
R11942 n1_m4_256000_283200 n1_m4_256000_288000 1.400000
R11943 n1_m4_256000_288000 n1_m4_256000_292800 1.400000
R11944 n1_m4_256000_292800 n1_m4_256000_297600 1.400000
R11945 n1_m4_256000_297600 n1_m4_256000_302400 1.400000
R11946 n1_m4_256000_302400 n1_m4_256000_307200 1.400000
R11947 n1_m4_256000_307200 n1_m4_256000_312000 1.400000
R11948 n1_m4_256000_312000 n1_m4_256000_316800 1.400000
R11949 n1_m4_256000_316800 n1_m4_256000_321600 1.400000
R11950 n1_m4_256000_321600 n1_m4_256000_324000 0.700000
R11951 n1_m4_256000_326400 n1_m4_256000_324000 0.700000
R11952 n1_m4_256000_326400 n1_m4_256000_331200 1.400000
R11953 n1_m4_256000_331200 n1_m4_256000_336000 1.400000
R11954 n1_m4_256000_336000 n1_m4_256000_340800 1.400000
R11955 n1_m4_256000_340800 n1_m4_256000_345600 1.400000
R11956 n1_m4_256000_345600 n1_m4_256000_350400 1.400000
R11957 n1_m4_256000_350400 n1_m4_256000_355200 1.400000
R11958 n1_m4_256000_355200 n1_m4_256000_360000 1.400000
R11959 n1_m4_256000_360000 n1_m4_256000_364800 1.400000
R11960 n1_m4_256000_364800 n1_m4_256000_369600 1.400000
R11961 n1_m4_256000_369600 n1_m4_256000_374400 1.400000
R11962 n1_m4_256000_374400 n1_m4_256000_379200 1.400000
R11963 n1_m4_256000_379200 n1_m4_256000_384000 1.400000
R11964 n1_m4_256000_384000 n1_m4_256000_388800 1.400000
R11965 n1_m4_256000_388800 n1_m4_256000_393600 1.400000
R11966 n1_m4_256000_393600 n1_m4_256000_398400 1.400000
R11967 n1_m4_284000_398400 n1_m4_284000_403200 1.400000
R11968 n1_m4_284000_403200 n1_m4_284000_404000 0.233333
R11969 n1_m4_284000_408000 n1_m4_284000_404000 1.166667
R11970 n1_m4_284000_408000 n1_m4_284000_412800 1.400000
R11971 n1_m4_284000_412800 n1_m4_284000_417600 1.400000
R11972 n1_m4_284000_417600 n1_m4_284000_422400 1.400000
R11973 n1_m4_284000_422400 n1_m4_284000_427200 1.400000
R11974 n1_m4_284000_427200 n1_m4_284000_432000 1.400000
R11975 n1_m4_284000_432000 n1_m4_284000_436800 1.400000
R11976 n1_m4_284000_436800 n1_m4_284000_441600 1.400000
R11977 n1_m4_284000_441600 n1_m4_284000_446400 1.400000
R11978 n1_m4_284000_446400 n1_m4_284000_451200 1.400000
R11979 n1_m4_284000_451200 n1_m4_284000_456000 1.400000
R11980 n1_m4_284000_456000 n1_m4_284000_460800 1.400000
R11981 n1_m4_284000_460800 n1_m4_284000_465600 1.400000
R11982 n1_m4_284000_465600 n1_m4_284000_470400 1.400000
R11983 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R11984 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R11985 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R11986 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R11987 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R11988 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R11989 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R11990 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R11991 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R11992 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R11993 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R11994 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R11995 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R11996 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R11997 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R11998 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R11999 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R12000 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R12001 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R12002 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R12003 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R12004 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R12005 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R12006 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R12007 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R12008 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R12009 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R12010 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R12011 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R12012 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R12013 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R12014 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R12015 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R12016 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R12017 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R12018 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R12019 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R12020 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R12021 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R12022 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R12023 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R12024 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R12025 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R12026 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R12027 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R12028 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R12029 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R12030 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R12031 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R12032 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R12033 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R12034 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R12035 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R12036 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R12037 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R12038 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R12039 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R12040 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R12041 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R12042 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R12043 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R12044 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R12045 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R12046 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R12047 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R12048 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R12049 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R12050 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R12051 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R12052 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R12053 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R12054 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R12055 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R12056 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R12057 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R12058 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R12059 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R12060 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R12061 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R12062 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R12063 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R12064 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R12065 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R12066 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R12067 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R12068 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R12069 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R12070 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R12071 n1_m4_368000_196800 n1_m4_368000_201600 1.400000
R12072 n1_m4_368000_201600 n1_m4_368000_206400 1.400000
R12073 n1_m4_368000_206400 n1_m4_368000_211200 1.400000
R12074 n1_m4_368000_211200 n1_m4_368000_216000 1.400000
R12075 n1_m4_368000_216000 n1_m4_368000_220800 1.400000
R12076 n1_m4_368000_220800 n1_m4_368000_225600 1.400000
R12077 n1_m4_368000_225600 n1_m4_368000_230400 1.400000
R12078 n1_m4_368000_230400 n1_m4_368000_235200 1.400000
R12079 n1_m4_368000_235200 n1_m4_368000_240000 1.400000
R12080 n1_m4_368000_240000 n1_m4_368000_244000 1.166667
R12081 n1_m4_368000_244800 n1_m4_368000_244000 0.233333
R12082 n1_m4_368000_244800 n1_m4_368000_249600 1.400000
R12083 n1_m4_368000_249600 n1_m4_368000_254400 1.400000
R12084 n1_m4_368000_254400 n1_m4_368000_259200 1.400000
R12085 n1_m4_368000_259200 n1_m4_368000_264000 1.400000
R12086 n1_m4_368000_264000 n1_m4_368000_268800 1.400000
R12087 n1_m4_368000_268800 n1_m4_368000_273600 1.400000
R12088 n1_m4_368000_273600 n1_m4_368000_278400 1.400000
R12089 n1_m4_368000_278400 n1_m4_368000_283200 1.400000
R12090 n1_m4_368000_283200 n1_m4_368000_288000 1.400000
R12091 n1_m4_368000_288000 n1_m4_368000_292800 1.400000
R12092 n1_m4_368000_292800 n1_m4_368000_297600 1.400000
R12093 n1_m4_368000_297600 n1_m4_368000_302400 1.400000
R12094 n1_m4_368000_302400 n1_m4_368000_307200 1.400000
R12095 n1_m4_368000_307200 n1_m4_368000_312000 1.400000
R12096 n1_m4_368000_312000 n1_m4_368000_316800 1.400000
R12097 n1_m4_368000_316800 n1_m4_368000_321600 1.400000
R12098 n1_m4_368000_321600 n1_m4_368000_324000 0.700000
R12099 n1_m4_368000_326400 n1_m4_368000_324000 0.700000
R12100 n1_m4_368000_326400 n1_m4_368000_331200 1.400000
R12101 n1_m4_368000_331200 n1_m4_368000_336000 1.400000
R12102 n1_m4_368000_336000 n1_m4_368000_340800 1.400000
R12103 n1_m4_368000_340800 n1_m4_368000_345600 1.400000
R12104 n1_m4_368000_345600 n1_m4_368000_350400 1.400000
R12105 n1_m4_368000_350400 n1_m4_368000_355200 1.400000
R12106 n1_m4_368000_355200 n1_m4_368000_360000 1.400000
R12107 n1_m4_368000_360000 n1_m4_368000_364800 1.400000
R12108 n1_m4_368000_364800 n1_m4_368000_369600 1.400000
R12109 n1_m4_368000_369600 n1_m4_368000_374400 1.400000
R12110 n1_m4_368000_374400 n1_m4_368000_379200 1.400000
R12111 n1_m4_368000_379200 n1_m4_368000_384000 1.400000
R12112 n1_m4_368000_384000 n1_m4_368000_388800 1.400000
R12113 n1_m4_368000_388800 n1_m4_368000_393600 1.400000
R12114 n1_m4_368000_393600 n1_m4_368000_398400 1.400000
R12115 n1_m4_368000_398400 n1_m4_368000_403200 1.400000
R12116 n1_m4_368000_403200 n1_m4_368000_404000 0.233333
R12117 n1_m4_368000_408000 n1_m4_368000_404000 1.166667
R12118 n1_m4_368000_408000 n1_m4_368000_412800 1.400000
R12119 n1_m4_368000_412800 n1_m4_368000_417600 1.400000
R12120 n1_m4_368000_417600 n1_m4_368000_422400 1.400000
R12121 n1_m4_368000_422400 n1_m4_368000_427200 1.400000
R12122 n1_m4_368000_427200 n1_m4_368000_432000 1.400000
R12123 n1_m4_368000_432000 n1_m4_368000_436800 1.400000
R12124 n1_m4_368000_436800 n1_m4_368000_441600 1.400000
R12125 n1_m4_368000_441600 n1_m4_368000_446400 1.400000
R12126 n1_m4_368000_446400 n1_m4_368000_451200 1.400000
R12127 n1_m4_368000_451200 n1_m4_368000_456000 1.400000
R12128 n1_m4_368000_456000 n1_m4_368000_460800 1.400000
R12129 n1_m4_368000_460800 n1_m4_368000_465600 1.400000
R12130 n1_m4_368000_465600 n1_m4_368000_470400 1.400000
R12131 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R12132 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R12133 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R12134 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R12135 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R12136 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R12137 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R12138 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R12139 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R12140 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R12141 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R12142 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R12143 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R12144 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R12145 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R12146 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R12147 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R12148 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R12149 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R12150 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R12151 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R12152 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R12153 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R12154 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R12155 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R12156 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R12157 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R12158 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R12159 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R12160 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R12161 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R12162 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R12163 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R12164 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R12165 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R12166 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R12167 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R12168 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R12169 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R12170 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R12171 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R12172 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R12173 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R12174 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R12175 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R12176 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R12177 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R12178 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R12179 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R12180 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R12181 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R12182 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R12183 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R12184 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R12185 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R12186 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R12187 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R12188 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R12189 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R12190 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R12191 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R12192 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R12193 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R12194 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R12195 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R12196 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R12197 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R12198 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R12199 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R12200 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R12201 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R12202 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R12203 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R12204 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R12205 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R12206 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R12207 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R12208 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R12209 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R12210 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R12211 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R12212 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R12213 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R12214 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R12215 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R12216 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R12217 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R12218 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R12219 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R12220 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R12221 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R12222 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R12223 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R12224 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R12225 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R12226 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R12227 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R12228 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R12229 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R12230 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R12231 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R12232 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R12233 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R12234 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R12235 n1_m4_452000_196800 n1_m4_452000_201600 1.400000
R12236 n1_m4_452000_201600 n1_m4_452000_206400 1.400000
R12237 n1_m4_452000_206400 n1_m4_452000_211200 1.400000
R12238 n1_m4_452000_211200 n1_m4_452000_216000 1.400000
R12239 n1_m4_452000_216000 n1_m4_452000_220800 1.400000
R12240 n1_m4_452000_220800 n1_m4_452000_225600 1.400000
R12241 n1_m4_452000_225600 n1_m4_452000_230400 1.400000
R12242 n1_m4_452000_230400 n1_m4_452000_235200 1.400000
R12243 n1_m4_452000_235200 n1_m4_452000_240000 1.400000
R12244 n1_m4_452000_240000 n1_m4_452000_244000 1.166667
R12245 n1_m4_452000_244800 n1_m4_452000_244000 0.233333
R12246 n1_m4_452000_244800 n1_m4_452000_249600 1.400000
R12247 n1_m4_452000_249600 n1_m4_452000_254400 1.400000
R12248 n1_m4_452000_254400 n1_m4_452000_259200 1.400000
R12249 n1_m4_452000_259200 n1_m4_452000_264000 1.400000
R12250 n1_m4_452000_264000 n1_m4_452000_268800 1.400000
R12251 n1_m4_452000_268800 n1_m4_452000_273600 1.400000
R12252 n1_m4_452000_273600 n1_m4_452000_278400 1.400000
R12253 n1_m4_452000_278400 n1_m4_452000_283200 1.400000
R12254 n1_m4_452000_283200 n1_m4_452000_288000 1.400000
R12255 n1_m4_452000_288000 n1_m4_452000_292800 1.400000
R12256 n1_m4_452000_292800 n1_m4_452000_297600 1.400000
R12257 n1_m4_452000_297600 n1_m4_452000_302400 1.400000
R12258 n1_m4_452000_302400 n1_m4_452000_307200 1.400000
R12259 n1_m4_452000_307200 n1_m4_452000_312000 1.400000
R12260 n1_m4_452000_312000 n1_m4_452000_316800 1.400000
R12261 n1_m4_452000_316800 n1_m4_452000_321600 1.400000
R12262 n1_m4_452000_321600 n1_m4_452000_324000 0.700000
R12263 n1_m4_452000_326400 n1_m4_452000_324000 0.700000
R12264 n1_m4_452000_326400 n1_m4_452000_331200 1.400000
R12265 n1_m4_452000_331200 n1_m4_452000_336000 1.400000
R12266 n1_m4_452000_336000 n1_m4_452000_340800 1.400000
R12267 n1_m4_452000_340800 n1_m4_452000_345600 1.400000
R12268 n1_m4_452000_345600 n1_m4_452000_350400 1.400000
R12269 n1_m4_452000_350400 n1_m4_452000_355200 1.400000
R12270 n1_m4_452000_355200 n1_m4_452000_360000 1.400000
R12271 n1_m4_452000_360000 n1_m4_452000_364800 1.400000
R12272 n1_m4_452000_364800 n1_m4_452000_369600 1.400000
R12273 n1_m4_452000_369600 n1_m4_452000_374400 1.400000
R12274 n1_m4_452000_374400 n1_m4_452000_379200 1.400000
R12275 n1_m4_452000_379200 n1_m4_452000_384000 1.400000
R12276 n1_m4_452000_384000 n1_m4_452000_388800 1.400000
R12277 n1_m4_452000_388800 n1_m4_452000_393600 1.400000
R12278 n1_m4_452000_393600 n1_m4_452000_398400 1.400000
R12279 n1_m4_452000_398400 n1_m4_452000_403200 1.400000
R12280 n1_m4_452000_403200 n1_m4_452000_404000 0.233333
R12281 n1_m4_452000_408000 n1_m4_452000_404000 1.166667
R12282 n1_m4_452000_408000 n1_m4_452000_412800 1.400000
R12283 n1_m4_452000_412800 n1_m4_452000_417600 1.400000
R12284 n1_m4_452000_417600 n1_m4_452000_422400 1.400000
R12285 n1_m4_452000_422400 n1_m4_452000_427200 1.400000
R12286 n1_m4_452000_427200 n1_m4_452000_432000 1.400000
R12287 n1_m4_452000_432000 n1_m4_452000_436800 1.400000
R12288 n1_m4_452000_436800 n1_m4_452000_441600 1.400000
R12289 n1_m4_452000_441600 n1_m4_452000_446400 1.400000
R12290 n1_m4_452000_446400 n1_m4_452000_451200 1.400000
R12291 n1_m4_452000_451200 n1_m4_452000_456000 1.400000
R12292 n1_m4_452000_456000 n1_m4_452000_460800 1.400000
R12293 n1_m4_452000_460800 n1_m4_452000_465600 1.400000
R12294 n1_m4_452000_465600 n1_m4_452000_470400 1.400000
R12295 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R12296 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R12297 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R12298 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R12299 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R12300 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R12301 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R12302 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R12303 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R12304 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R12305 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R12306 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R12307 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R12308 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R12309 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R12310 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R12311 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R12312 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R12313 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R12314 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R12315 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R12316 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R12317 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R12318 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R12319 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R12320 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R12321 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R12322 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R12323 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R12324 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R12325 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R12326 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R12327 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R12328 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R12329 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R12330 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R12331 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R12332 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R12333 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R12334 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R12335 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R12336 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R12337 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R12338 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R12339 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R12340 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R12341 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R12342 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R12343 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R12344 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R12345 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R12346 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R12347 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R12348 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R12349 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R12350 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R12351 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R12352 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R12353 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R12354 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R12355 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R12356 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R12357 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R12358 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R12359 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R12360 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R12361 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R12362 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R12363 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R12364 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R12365 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R12366 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R12367 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R12368 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R12369 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R12370 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R12371 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R12372 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R12373 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R12374 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R12375 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R12376 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R12377 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R12378 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R12379 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R12380 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R12381 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R12382 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R12383 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R12384 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R12385 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R12386 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R12387 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R12388 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R12389 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R12390 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R12391 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R12392 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R12393 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R12394 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R12395 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R12396 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R12397 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R12398 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R12399 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R12400 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R12401 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R12402 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R12403 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R12404 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R12405 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R12406 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R12407 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R12408 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R12409 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R12410 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R12411 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R12412 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R12413 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R12414 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R12415 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R12416 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R12417 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R12418 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R12419 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R12420 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R12421 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R12422 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R12423 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R12424 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R12425 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R12426 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R12427 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R12428 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R12429 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R12430 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R12431 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R12432 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R12433 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R12434 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R12435 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R12436 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R12437 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R12438 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R12439 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R12440 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R12441 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R12442 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R12443 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R12444 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R12445 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R12446 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R12447 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R12448 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R12449 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R12450 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R12451 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R12452 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R12453 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R12454 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R12455 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R12456 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R12457 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R12458 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R12459 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R12460 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R12461 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R12462 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R12463 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R12464 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R12465 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R12466 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R12467 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R12468 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R12469 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R12470 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R12471 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R12472 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R12473 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R12474 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R12475 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R12476 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R12477 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R12478 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R12479 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R12480 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R12481 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R12482 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R12483 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R12484 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R12485 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R12486 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R12487 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R12488 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R12489 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R12490 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R12491 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R12492 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R12493 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R12494 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R12495 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R12496 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R12497 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R12498 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R12499 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R12500 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R12501 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R12502 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R12503 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R12504 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R12505 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R12506 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R12507 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R12508 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R12509 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R12510 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R12511 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R12512 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R12513 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R12514 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R12515 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R12516 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R12517 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R12518 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R12519 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R12520 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R12521 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R12522 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R12523 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R12524 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R12525 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R12526 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R12527 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R12528 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R12529 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R12530 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R12531 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R12532 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R12533 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R12534 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R12535 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R12536 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R12537 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R12538 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R12539 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R12540 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R12541 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R12542 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R12543 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R12544 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R12545 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R12546 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R12547 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R12548 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R12549 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R12550 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R12551 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R12552 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R12553 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R12554 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R12555 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R12556 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R12557 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R12558 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R12559 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R12560 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R12561 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R12562 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R12563 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R12564 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R12565 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R12566 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R12567 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R12568 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R12569 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R12570 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R12571 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R12572 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R12573 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R12574 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R12575 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R12576 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R12577 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R12578 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R12579 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R12580 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R12581 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R12582 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R12583 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R12584 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R12585 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R12586 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R12587 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R12588 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R12589 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R12590 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R12591 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R12592 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R12593 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R12594 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R12595 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R12596 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R12597 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R12598 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R12599 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R12600 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R12601 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R12602 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R12603 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R12604 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R12605 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R12606 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R12607 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R12608 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R12609 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R12610 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R12611 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R12612 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R12613 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R12614 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R12615 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R12616 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R12617 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R12618 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R12619 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R12620 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R12621 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R12622 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R12623 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R12624 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R12625 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R12626 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R12627 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R12628 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R12629 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R12630 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R12631 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R12632 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R12633 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R12634 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R12635 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R12636 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R12637 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R12638 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R12639 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R12640 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R12641 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R12642 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R12643 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R12644 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R12645 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R12646 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R12647 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R12648 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R12649 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R12650 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R12651 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R12652 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R12653 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R12654 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R12655 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R12656 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R12657 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R12658 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R12659 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R12660 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R12661 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R12662 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R12663 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R12664 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R12665 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R12666 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R12667 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R12668 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R12669 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R12670 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R12671 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R12672 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R12673 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R12674 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R12675 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R12676 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R12677 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R12678 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R12679 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R12680 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R12681 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R12682 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R12683 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R12684 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R12685 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R12686 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R12687 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R12688 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R12689 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R12690 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R12691 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R12692 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R12693 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R12694 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R12695 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R12696 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R12697 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R12698 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R12699 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R12700 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R12701 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R12702 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R12703 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R12704 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R12705 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R12706 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R12707 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R12708 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R12709 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R12710 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R12711 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R12712 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R12713 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R12714 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R12715 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R12716 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R12717 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R12718 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R12719 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R12720 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R12721 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R12722 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R12723 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R12724 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R12725 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R12726 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R12727 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R12728 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R12729 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R12730 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R12731 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R12732 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R12733 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R12734 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R12735 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R12736 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R12737 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R12738 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R12739 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R12740 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R12741 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R12742 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R12743 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R12744 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R12745 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R12746 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R12747 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R12748 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R12749 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R12750 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R12751 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R12752 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R12753 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R12754 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R12755 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R12756 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R12757 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R12758 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R12759 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R12760 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R12761 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R12762 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R12763 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R12764 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R12765 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R12766 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R12767 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R12768 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R12769 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R12770 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R12771 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R12772 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R12773 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R12774 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R12775 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R12776 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R12777 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R12778 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R12779 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R12780 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R12781 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R12782 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R12783 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R12784 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R12785 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R12786 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R12787 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R12788 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R12789 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R12790 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R12791 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R12792 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R12793 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R12794 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R12795 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R12796 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R12797 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R12798 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R12799 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R12800 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R12801 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R12802 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R12803 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R12804 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R12805 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R12806 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R12807 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R12808 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R12809 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R12810 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R12811 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R12812 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R12813 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R12814 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R12815 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R12816 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R12817 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R12818 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R12819 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R12820 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R12821 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R12822 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R12823 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R12824 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R12825 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R12826 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R12827 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R12828 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R12829 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R12830 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R12831 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R12832 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R12833 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R12834 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R12835 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R12836 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R12837 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R12838 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R12839 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R12840 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R12841 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R12842 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R12843 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R12844 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R12845 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R12846 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R12847 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R12848 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R12849 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R12850 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R12851 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R12852 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R12853 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R12854 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R12855 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R12856 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R12857 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R12858 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R12859 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R12860 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R12861 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R12862 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R12863 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R12864 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R12865 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R12866 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R12867 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R12868 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R12869 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R12870 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R12871 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R12872 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R12873 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R12874 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R12875 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R12876 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R12877 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R12878 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R12879 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R12880 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R12881 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R12882 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R12883 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R12884 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R12885 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R12886 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R12887 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R12888 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R12889 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R12890 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R12891 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R12892 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R12893 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R12894 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R12895 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R12896 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R12897 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R12898 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R12899 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R12900 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R12901 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R12902 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R12903 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R12904 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R12905 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R12906 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R12907 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R12908 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R12909 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R12910 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R12911 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R12912 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R12913 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R12914 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R12915 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R12916 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R12917 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R12918 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R12919 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R12920 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R12921 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R12922 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R12923 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R12924 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R12925 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R12926 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R12927 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R12928 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R12929 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R12930 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R12931 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R12932 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R12933 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R12934 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R12935 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R12936 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R12937 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R12938 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R12939 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R12940 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R12941 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R12942 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R12943 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R12944 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R12945 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R12946 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R12947 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R12948 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R12949 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R12950 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R12951 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R12952 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R12953 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R12954 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R12955 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R12956 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R12957 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R12958 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R12959 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R12960 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R12961 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R12962 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R12963 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R12964 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R12965 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R12966 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R12967 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R12968 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R12969 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R12970 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R12971 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R12972 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R12973 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R12974 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R12975 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R12976 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R12977 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R12978 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R12979 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R12980 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R12981 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R12982 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R12983 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R12984 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R12985 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R12986 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R12987 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R12988 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R12989 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R12990 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R12991 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R12992 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R12993 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R12994 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R12995 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R12996 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R12997 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R12998 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R12999 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R13000 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R13001 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R13002 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R13003 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R13004 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R13005 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R13006 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R13007 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R13008 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R13009 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R13010 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R13011 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R13012 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R13013 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R13014 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R13015 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R13016 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R13017 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R13018 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R13019 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R13020 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R13021 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R13022 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R13023 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R13024 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R13025 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R13026 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R13027 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R13028 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R13029 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R13030 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R13031 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R13032 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R13033 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R13034 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R13035 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R13036 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R13037 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R13038 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R13039 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R13040 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R13041 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R13042 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R13043 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R13044 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R13045 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R13046 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R13047 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R13048 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R13049 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R13050 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R13051 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R13052 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R13053 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R13054 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R13055 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R13056 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R13057 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R13058 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R13059 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R13060 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R13061 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R13062 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R13063 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R13064 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R13065 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R13066 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R13067 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R13068 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R13069 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R13070 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R13071 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R13072 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R13073 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R13074 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R13075 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R13076 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R13077 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R13078 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R13079 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R13080 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R13081 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R13082 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R13083 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R13084 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R13085 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R13086 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R13087 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R13088 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R13089 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R13090 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R13091 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R13092 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R13093 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R13094 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R13095 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R13096 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R13097 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R13098 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R13099 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R13100 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R13101 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R13102 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R13103 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R13104 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R13105 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R13106 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R13107 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R13108 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R13109 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R13110 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R13111 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R13112 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R13113 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R13114 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R13115 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R13116 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R13117 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R13118 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R13119 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R13120 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R13121 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R13122 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R13123 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R13124 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R13125 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R13126 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R13127 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R13128 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R13129 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R13130 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R13131 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R13132 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R13133 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R13134 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R13135 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R13136 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R13137 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R13138 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R13139 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R13140 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R13141 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R13142 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R13143 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R13144 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R13145 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R13146 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R13147 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R13148 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R13149 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R13150 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R13151 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R13152 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R13153 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R13154 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R13155 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R13156 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R13157 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R13158 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R13159 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R13160 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R13161 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R13162 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R13163 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R13164 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R13165 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R13166 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R13167 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R13168 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R13169 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R13170 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R13171 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R13172 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R13173 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R13174 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R13175 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R13176 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R13177 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R13178 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R13179 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R13180 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R13181 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R13182 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R13183 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R13184 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R13185 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R13186 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R13187 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R13188 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R13189 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R13190 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R13191 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R13192 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R13193 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R13194 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R13195 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R13196 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R13197 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R13198 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R13199 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R13200 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R13201 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R13202 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R13203 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R13204 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R13205 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R13206 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R13207 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R13208 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R13209 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R13210 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R13211 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R13212 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R13213 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R13214 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R13215 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R13216 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R13217 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R13218 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R13219 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R13220 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R13221 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R13222 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R13223 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R13224 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R13225 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R13226 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R13227 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R13228 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R13229 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R13230 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R13231 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R13232 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R13233 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R13234 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R13235 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R13236 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R13237 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R13238 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R13239 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R13240 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R13241 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R13242 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R13243 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R13244 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R13245 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R13246 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R13247 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R13248 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R13249 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R13250 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R13251 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R13252 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R13253 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R13254 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R13255 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R13256 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R13257 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R13258 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R13259 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R13260 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R13261 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R13262 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R13263 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R13264 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R13265 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R13266 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R13267 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R13268 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R13269 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R13270 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R13271 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R13272 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R13273 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R13274 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R13275 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R13276 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R13277 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R13278 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R13279 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R13280 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R13281 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R13282 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R13283 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R13284 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R13285 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R13286 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R13287 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R13288 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R13289 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R13290 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R13291 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R13292 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R13293 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R13294 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R13295 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R13296 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R13297 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R13298 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R13299 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R13300 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R13301 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R13302 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R13303 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R13304 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R13305 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R13306 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R13307 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R13308 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R13309 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R13310 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R13311 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R13312 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R13313 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R13314 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R13315 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R13316 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R13317 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R13318 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R13319 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R13320 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R13321 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R13322 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R13323 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R13324 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R13325 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R13326 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R13327 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R13328 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R13329 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R13330 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R13331 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R13332 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R13333 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R13334 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R13335 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R13336 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R13337 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R13338 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R13339 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R13340 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R13341 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R13342 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R13343 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R13344 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R13345 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R13346 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R13347 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R13348 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R13349 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R13350 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R13351 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R13352 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R13353 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R13354 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R13355 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R13356 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R13357 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R13358 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R13359 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R13360 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R13361 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R13362 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R13363 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R13364 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R13365 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R13366 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R13367 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R13368 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R13369 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R13370 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R13371 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R13372 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R13373 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R13374 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R13375 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R13376 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R13377 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R13378 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R13379 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R13380 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R13381 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R13382 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R13383 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R13384 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R13385 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R13386 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R13387 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R13388 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R13389 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R13390 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R13391 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R13392 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R13393 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R13394 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R13395 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R13396 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R13397 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R13398 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R13399 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R13400 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R13401 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R13402 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R13403 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R13404 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R13405 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R13406 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R13407 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R13408 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R13409 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R13410 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R13411 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R13412 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R13413 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R13414 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R13415 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R13416 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R13417 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R13418 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R13419 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R13420 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R13421 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R13422 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R13423 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R13424 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R13425 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R13426 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R13427 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R13428 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R13429 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R13430 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R13431 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R13432 n1_m1_4000_0 n1_m4_4000_0 15.000000
R13433 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R13434 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R13435 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R13436 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R13437 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R13438 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R13439 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R13440 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R13441 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R13442 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R13443 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R13444 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R13445 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R13446 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R13447 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R13448 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R13449 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R13450 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R13451 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R13452 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R13453 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R13454 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R13455 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R13456 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R13457 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R13458 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R13459 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R13460 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R13461 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R13462 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R13463 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R13464 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R13465 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R13466 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R13467 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R13468 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R13469 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R13470 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R13471 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R13472 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R13473 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R13474 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R13475 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R13476 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R13477 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R13478 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R13479 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R13480 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R13481 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R13482 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R13483 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R13484 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R13485 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R13486 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R13487 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R13488 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R13489 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R13490 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R13491 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R13492 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R13493 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R13494 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R13495 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R13496 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R13497 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R13498 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R13499 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R13500 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R13501 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R13502 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R13503 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R13504 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R13505 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R13506 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R13507 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R13508 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R13509 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R13510 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R13511 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R13512 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R13513 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R13514 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R13515 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R13516 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R13517 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R13518 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R13519 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R13520 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R13521 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R13522 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R13523 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R13524 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R13525 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R13526 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R13527 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R13528 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R13529 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R13530 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R13531 n1_m1_32000_0 n1_m4_32000_0 15.000000
R13532 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R13533 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R13534 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R13535 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R13536 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R13537 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R13538 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R13539 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R13540 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R13541 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R13542 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R13543 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R13544 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R13545 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R13546 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R13547 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R13548 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R13549 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R13550 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R13551 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R13552 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R13553 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R13554 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R13555 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R13556 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R13557 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R13558 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R13559 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R13560 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R13561 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R13562 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R13563 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R13564 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R13565 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R13566 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R13567 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R13568 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R13569 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R13570 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R13571 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R13572 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R13573 n1_m1_32000_201600 n1_m4_32000_201600 15.000000
R13574 n1_m1_32000_206400 n1_m4_32000_206400 15.000000
R13575 n1_m1_32000_211200 n1_m4_32000_211200 15.000000
R13576 n1_m1_32000_216000 n1_m4_32000_216000 15.000000
R13577 n1_m1_32000_220800 n1_m4_32000_220800 15.000000
R13578 n1_m1_32000_225600 n1_m4_32000_225600 15.000000
R13579 n1_m1_32000_230400 n1_m4_32000_230400 15.000000
R13580 n1_m1_32000_235200 n1_m4_32000_235200 15.000000
R13581 n1_m1_32000_240000 n1_m4_32000_240000 15.000000
R13582 n1_m1_32000_244800 n1_m4_32000_244800 15.000000
R13583 n1_m1_32000_249600 n1_m4_32000_249600 15.000000
R13584 n1_m1_32000_254400 n1_m4_32000_254400 15.000000
R13585 n1_m1_32000_259200 n1_m4_32000_259200 15.000000
R13586 n1_m1_32000_264000 n1_m4_32000_264000 15.000000
R13587 n1_m1_32000_268800 n1_m4_32000_268800 15.000000
R13588 n1_m1_32000_273600 n1_m4_32000_273600 15.000000
R13589 n1_m1_32000_278400 n1_m4_32000_278400 15.000000
R13590 n1_m1_32000_283200 n1_m4_32000_283200 15.000000
R13591 n1_m1_32000_288000 n1_m4_32000_288000 15.000000
R13592 n1_m1_32000_292800 n1_m4_32000_292800 15.000000
R13593 n1_m1_32000_297600 n1_m4_32000_297600 15.000000
R13594 n1_m1_32000_302400 n1_m4_32000_302400 15.000000
R13595 n1_m1_32000_307200 n1_m4_32000_307200 15.000000
R13596 n1_m1_32000_312000 n1_m4_32000_312000 15.000000
R13597 n1_m1_32000_316800 n1_m4_32000_316800 15.000000
R13598 n1_m1_32000_321600 n1_m4_32000_321600 15.000000
R13599 n1_m1_32000_326400 n1_m4_32000_326400 15.000000
R13600 n1_m1_32000_331200 n1_m4_32000_331200 15.000000
R13601 n1_m1_32000_336000 n1_m4_32000_336000 15.000000
R13602 n1_m1_32000_340800 n1_m4_32000_340800 15.000000
R13603 n1_m1_32000_345600 n1_m4_32000_345600 15.000000
R13604 n1_m1_32000_350400 n1_m4_32000_350400 15.000000
R13605 n1_m1_32000_355200 n1_m4_32000_355200 15.000000
R13606 n1_m1_32000_360000 n1_m4_32000_360000 15.000000
R13607 n1_m1_32000_364800 n1_m4_32000_364800 15.000000
R13608 n1_m1_32000_369600 n1_m4_32000_369600 15.000000
R13609 n1_m1_32000_374400 n1_m4_32000_374400 15.000000
R13610 n1_m1_32000_379200 n1_m4_32000_379200 15.000000
R13611 n1_m1_32000_384000 n1_m4_32000_384000 15.000000
R13612 n1_m1_32000_388800 n1_m4_32000_388800 15.000000
R13613 n1_m1_32000_393600 n1_m4_32000_393600 15.000000
R13614 n1_m1_32000_398400 n1_m4_32000_398400 15.000000
R13615 n1_m1_60000_0 n1_m4_60000_0 15.000000
R13616 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R13617 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R13618 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R13619 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R13620 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R13621 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R13622 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R13623 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R13624 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R13625 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R13626 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R13627 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R13628 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R13629 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R13630 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R13631 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R13632 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R13633 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R13634 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R13635 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R13636 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R13637 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R13638 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R13639 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R13640 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R13641 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R13642 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R13643 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R13644 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R13645 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R13646 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R13647 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R13648 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R13649 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R13650 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R13651 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R13652 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R13653 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R13654 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R13655 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R13656 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R13657 n1_m1_60000_201600 n1_m4_60000_201600 15.000000
R13658 n1_m1_60000_206400 n1_m4_60000_206400 15.000000
R13659 n1_m1_60000_211200 n1_m4_60000_211200 15.000000
R13660 n1_m1_60000_216000 n1_m4_60000_216000 15.000000
R13661 n1_m1_60000_220800 n1_m4_60000_220800 15.000000
R13662 n1_m1_60000_225600 n1_m4_60000_225600 15.000000
R13663 n1_m1_60000_230400 n1_m4_60000_230400 15.000000
R13664 n1_m1_60000_235200 n1_m4_60000_235200 15.000000
R13665 n1_m1_60000_240000 n1_m4_60000_240000 15.000000
R13666 n1_m1_60000_244800 n1_m4_60000_244800 15.000000
R13667 n1_m1_60000_249600 n1_m4_60000_249600 15.000000
R13668 n1_m1_60000_254400 n1_m4_60000_254400 15.000000
R13669 n1_m1_60000_259200 n1_m4_60000_259200 15.000000
R13670 n1_m1_60000_264000 n1_m4_60000_264000 15.000000
R13671 n1_m1_60000_268800 n1_m4_60000_268800 15.000000
R13672 n1_m1_60000_273600 n1_m4_60000_273600 15.000000
R13673 n1_m1_60000_278400 n1_m4_60000_278400 15.000000
R13674 n1_m1_60000_283200 n1_m4_60000_283200 15.000000
R13675 n1_m1_60000_288000 n1_m4_60000_288000 15.000000
R13676 n1_m1_60000_292800 n1_m4_60000_292800 15.000000
R13677 n1_m1_60000_297600 n1_m4_60000_297600 15.000000
R13678 n1_m1_60000_302400 n1_m4_60000_302400 15.000000
R13679 n1_m1_60000_307200 n1_m4_60000_307200 15.000000
R13680 n1_m1_60000_312000 n1_m4_60000_312000 15.000000
R13681 n1_m1_60000_316800 n1_m4_60000_316800 15.000000
R13682 n1_m1_60000_321600 n1_m4_60000_321600 15.000000
R13683 n1_m1_60000_326400 n1_m4_60000_326400 15.000000
R13684 n1_m1_60000_331200 n1_m4_60000_331200 15.000000
R13685 n1_m1_60000_336000 n1_m4_60000_336000 15.000000
R13686 n1_m1_60000_340800 n1_m4_60000_340800 15.000000
R13687 n1_m1_60000_345600 n1_m4_60000_345600 15.000000
R13688 n1_m1_60000_350400 n1_m4_60000_350400 15.000000
R13689 n1_m1_60000_355200 n1_m4_60000_355200 15.000000
R13690 n1_m1_60000_360000 n1_m4_60000_360000 15.000000
R13691 n1_m1_60000_364800 n1_m4_60000_364800 15.000000
R13692 n1_m1_60000_369600 n1_m4_60000_369600 15.000000
R13693 n1_m1_60000_374400 n1_m4_60000_374400 15.000000
R13694 n1_m1_60000_379200 n1_m4_60000_379200 15.000000
R13695 n1_m1_60000_384000 n1_m4_60000_384000 15.000000
R13696 n1_m1_60000_388800 n1_m4_60000_388800 15.000000
R13697 n1_m1_60000_393600 n1_m4_60000_393600 15.000000
R13698 n1_m1_60000_398400 n1_m4_60000_398400 15.000000
R13699 n1_m1_88000_0 n1_m4_88000_0 15.000000
R13700 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R13701 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R13702 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R13703 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R13704 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R13705 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R13706 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R13707 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R13708 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R13709 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R13710 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R13711 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R13712 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R13713 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R13714 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R13715 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R13716 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R13717 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R13718 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R13719 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R13720 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R13721 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R13722 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R13723 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R13724 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R13725 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R13726 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R13727 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R13728 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R13729 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R13730 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R13731 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R13732 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R13733 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R13734 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R13735 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R13736 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R13737 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R13738 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R13739 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R13740 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R13741 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R13742 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R13743 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R13744 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R13745 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R13746 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R13747 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R13748 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R13749 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R13750 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R13751 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R13752 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R13753 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R13754 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R13755 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R13756 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R13757 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R13758 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R13759 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R13760 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R13761 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R13762 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R13763 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R13764 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R13765 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R13766 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R13767 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R13768 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R13769 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R13770 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R13771 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R13772 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R13773 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R13774 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R13775 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R13776 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R13777 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R13778 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R13779 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R13780 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R13781 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R13782 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R13783 n1_m1_116000_0 n1_m4_116000_0 15.000000
R13784 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R13785 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R13786 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R13787 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R13788 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R13789 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R13790 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R13791 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R13792 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R13793 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R13794 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R13795 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R13796 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R13797 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R13798 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R13799 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R13800 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R13801 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R13802 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R13803 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R13804 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R13805 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R13806 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R13807 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R13808 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R13809 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R13810 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R13811 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R13812 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R13813 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R13814 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R13815 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R13816 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R13817 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R13818 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R13819 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R13820 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R13821 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R13822 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R13823 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R13824 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R13825 n1_m1_116000_201600 n1_m4_116000_201600 15.000000
R13826 n1_m1_116000_206400 n1_m4_116000_206400 15.000000
R13827 n1_m1_116000_211200 n1_m4_116000_211200 15.000000
R13828 n1_m1_116000_216000 n1_m4_116000_216000 15.000000
R13829 n1_m1_116000_220800 n1_m4_116000_220800 15.000000
R13830 n1_m1_116000_225600 n1_m4_116000_225600 15.000000
R13831 n1_m1_116000_230400 n1_m4_116000_230400 15.000000
R13832 n1_m1_116000_235200 n1_m4_116000_235200 15.000000
R13833 n1_m1_116000_240000 n1_m4_116000_240000 15.000000
R13834 n1_m1_116000_244800 n1_m4_116000_244800 15.000000
R13835 n1_m1_116000_249600 n1_m4_116000_249600 15.000000
R13836 n1_m1_116000_254400 n1_m4_116000_254400 15.000000
R13837 n1_m1_116000_259200 n1_m4_116000_259200 15.000000
R13838 n1_m1_116000_264000 n1_m4_116000_264000 15.000000
R13839 n1_m1_116000_268800 n1_m4_116000_268800 15.000000
R13840 n1_m1_116000_273600 n1_m4_116000_273600 15.000000
R13841 n1_m1_116000_278400 n1_m4_116000_278400 15.000000
R13842 n1_m1_116000_283200 n1_m4_116000_283200 15.000000
R13843 n1_m1_116000_288000 n1_m4_116000_288000 15.000000
R13844 n1_m1_116000_292800 n1_m4_116000_292800 15.000000
R13845 n1_m1_116000_297600 n1_m4_116000_297600 15.000000
R13846 n1_m1_116000_302400 n1_m4_116000_302400 15.000000
R13847 n1_m1_116000_307200 n1_m4_116000_307200 15.000000
R13848 n1_m1_116000_312000 n1_m4_116000_312000 15.000000
R13849 n1_m1_116000_316800 n1_m4_116000_316800 15.000000
R13850 n1_m1_116000_321600 n1_m4_116000_321600 15.000000
R13851 n1_m1_116000_326400 n1_m4_116000_326400 15.000000
R13852 n1_m1_116000_331200 n1_m4_116000_331200 15.000000
R13853 n1_m1_116000_336000 n1_m4_116000_336000 15.000000
R13854 n1_m1_116000_340800 n1_m4_116000_340800 15.000000
R13855 n1_m1_116000_345600 n1_m4_116000_345600 15.000000
R13856 n1_m1_116000_350400 n1_m4_116000_350400 15.000000
R13857 n1_m1_116000_355200 n1_m4_116000_355200 15.000000
R13858 n1_m1_116000_360000 n1_m4_116000_360000 15.000000
R13859 n1_m1_116000_364800 n1_m4_116000_364800 15.000000
R13860 n1_m1_116000_369600 n1_m4_116000_369600 15.000000
R13861 n1_m1_116000_374400 n1_m4_116000_374400 15.000000
R13862 n1_m1_116000_379200 n1_m4_116000_379200 15.000000
R13863 n1_m1_116000_384000 n1_m4_116000_384000 15.000000
R13864 n1_m1_116000_388800 n1_m4_116000_388800 15.000000
R13865 n1_m1_116000_393600 n1_m4_116000_393600 15.000000
R13866 n1_m1_116000_398400 n1_m4_116000_398400 15.000000
R13867 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R13868 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R13869 n1_m1_116000_412800 n1_m4_116000_412800 15.000000
R13870 n1_m1_116000_417600 n1_m4_116000_417600 15.000000
R13871 n1_m1_116000_422400 n1_m4_116000_422400 15.000000
R13872 n1_m1_116000_427200 n1_m4_116000_427200 15.000000
R13873 n1_m1_116000_432000 n1_m4_116000_432000 15.000000
R13874 n1_m1_116000_436800 n1_m4_116000_436800 15.000000
R13875 n1_m1_116000_441600 n1_m4_116000_441600 15.000000
R13876 n1_m1_116000_446400 n1_m4_116000_446400 15.000000
R13877 n1_m1_116000_451200 n1_m4_116000_451200 15.000000
R13878 n1_m1_116000_456000 n1_m4_116000_456000 15.000000
R13879 n1_m1_116000_460800 n1_m4_116000_460800 15.000000
R13880 n1_m1_116000_465600 n1_m4_116000_465600 15.000000
R13881 n1_m1_116000_470400 n1_m4_116000_470400 15.000000
R13882 n1_m1_144000_0 n1_m4_144000_0 15.000000
R13883 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R13884 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R13885 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R13886 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R13887 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R13888 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R13889 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R13890 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R13891 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R13892 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R13893 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R13894 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R13895 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R13896 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R13897 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R13898 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R13899 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R13900 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R13901 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R13902 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R13903 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R13904 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R13905 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R13906 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R13907 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R13908 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R13909 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R13910 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R13911 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R13912 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R13913 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R13914 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R13915 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R13916 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R13917 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R13918 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R13919 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R13920 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R13921 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R13922 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R13923 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R13924 n1_m1_144000_201600 n1_m4_144000_201600 15.000000
R13925 n1_m1_144000_206400 n1_m4_144000_206400 15.000000
R13926 n1_m1_144000_211200 n1_m4_144000_211200 15.000000
R13927 n1_m1_144000_216000 n1_m4_144000_216000 15.000000
R13928 n1_m1_144000_220800 n1_m4_144000_220800 15.000000
R13929 n1_m1_144000_225600 n1_m4_144000_225600 15.000000
R13930 n1_m1_144000_230400 n1_m4_144000_230400 15.000000
R13931 n1_m1_144000_235200 n1_m4_144000_235200 15.000000
R13932 n1_m1_144000_240000 n1_m4_144000_240000 15.000000
R13933 n1_m1_144000_244800 n1_m4_144000_244800 15.000000
R13934 n1_m1_144000_249600 n1_m4_144000_249600 15.000000
R13935 n1_m1_144000_254400 n1_m4_144000_254400 15.000000
R13936 n1_m1_144000_259200 n1_m4_144000_259200 15.000000
R13937 n1_m1_144000_264000 n1_m4_144000_264000 15.000000
R13938 n1_m1_144000_268800 n1_m4_144000_268800 15.000000
R13939 n1_m1_144000_273600 n1_m4_144000_273600 15.000000
R13940 n1_m1_144000_278400 n1_m4_144000_278400 15.000000
R13941 n1_m1_144000_283200 n1_m4_144000_283200 15.000000
R13942 n1_m1_144000_288000 n1_m4_144000_288000 15.000000
R13943 n1_m1_144000_292800 n1_m4_144000_292800 15.000000
R13944 n1_m1_144000_297600 n1_m4_144000_297600 15.000000
R13945 n1_m1_144000_302400 n1_m4_144000_302400 15.000000
R13946 n1_m1_144000_307200 n1_m4_144000_307200 15.000000
R13947 n1_m1_144000_312000 n1_m4_144000_312000 15.000000
R13948 n1_m1_144000_316800 n1_m4_144000_316800 15.000000
R13949 n1_m1_144000_321600 n1_m4_144000_321600 15.000000
R13950 n1_m1_144000_326400 n1_m4_144000_326400 15.000000
R13951 n1_m1_144000_331200 n1_m4_144000_331200 15.000000
R13952 n1_m1_144000_336000 n1_m4_144000_336000 15.000000
R13953 n1_m1_144000_340800 n1_m4_144000_340800 15.000000
R13954 n1_m1_144000_345600 n1_m4_144000_345600 15.000000
R13955 n1_m1_144000_350400 n1_m4_144000_350400 15.000000
R13956 n1_m1_144000_355200 n1_m4_144000_355200 15.000000
R13957 n1_m1_144000_360000 n1_m4_144000_360000 15.000000
R13958 n1_m1_144000_364800 n1_m4_144000_364800 15.000000
R13959 n1_m1_144000_369600 n1_m4_144000_369600 15.000000
R13960 n1_m1_144000_374400 n1_m4_144000_374400 15.000000
R13961 n1_m1_144000_379200 n1_m4_144000_379200 15.000000
R13962 n1_m1_144000_384000 n1_m4_144000_384000 15.000000
R13963 n1_m1_144000_388800 n1_m4_144000_388800 15.000000
R13964 n1_m1_144000_393600 n1_m4_144000_393600 15.000000
R13965 n1_m1_144000_398400 n1_m4_144000_398400 15.000000
R13966 n1_m1_172000_0 n1_m4_172000_0 15.000000
R13967 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R13968 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R13969 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R13970 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R13971 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R13972 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R13973 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R13974 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R13975 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R13976 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R13977 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R13978 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R13979 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R13980 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R13981 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R13982 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R13983 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R13984 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R13985 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R13986 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R13987 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R13988 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R13989 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R13990 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R13991 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R13992 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R13993 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R13994 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R13995 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R13996 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R13997 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R13998 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R13999 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R14000 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R14001 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R14002 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R14003 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R14004 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R14005 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R14006 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R14007 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R14008 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R14009 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R14010 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R14011 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R14012 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R14013 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R14014 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R14015 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R14016 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R14017 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R14018 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R14019 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R14020 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R14021 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R14022 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R14023 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R14024 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R14025 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R14026 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R14027 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R14028 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R14029 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R14030 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R14031 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R14032 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R14033 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R14034 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R14035 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R14036 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R14037 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R14038 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R14039 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R14040 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R14041 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R14042 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R14043 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R14044 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R14045 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R14046 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R14047 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R14048 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R14049 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R14050 n1_m1_200000_0 n1_m4_200000_0 15.000000
R14051 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R14052 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R14053 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R14054 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R14055 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R14056 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R14057 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R14058 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R14059 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R14060 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R14061 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R14062 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R14063 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R14064 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R14065 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R14066 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R14067 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R14068 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R14069 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R14070 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R14071 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R14072 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R14073 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R14074 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R14075 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R14076 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R14077 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R14078 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R14079 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R14080 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R14081 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R14082 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R14083 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R14084 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R14085 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R14086 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R14087 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R14088 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R14089 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R14090 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R14091 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R14092 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R14093 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R14094 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R14095 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R14096 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R14097 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R14098 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R14099 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R14100 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R14101 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R14102 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R14103 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R14104 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R14105 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R14106 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R14107 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R14108 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R14109 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R14110 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R14111 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R14112 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R14113 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R14114 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R14115 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R14116 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R14117 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R14118 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R14119 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R14120 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R14121 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R14122 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R14123 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R14124 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R14125 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R14126 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R14127 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R14128 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R14129 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R14130 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R14131 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R14132 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R14133 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R14134 n1_m1_228000_0 n1_m4_228000_0 15.000000
R14135 n1_m1_256000_0 n1_m4_256000_0 15.000000
R14136 n1_m1_256000_201600 n1_m4_256000_201600 15.000000
R14137 n1_m1_256000_206400 n1_m4_256000_206400 15.000000
R14138 n1_m1_256000_211200 n1_m4_256000_211200 15.000000
R14139 n1_m1_256000_216000 n1_m4_256000_216000 15.000000
R14140 n1_m1_256000_220800 n1_m4_256000_220800 15.000000
R14141 n1_m1_256000_225600 n1_m4_256000_225600 15.000000
R14142 n1_m1_256000_230400 n1_m4_256000_230400 15.000000
R14143 n1_m1_256000_235200 n1_m4_256000_235200 15.000000
R14144 n1_m1_256000_240000 n1_m4_256000_240000 15.000000
R14145 n1_m1_256000_244800 n1_m4_256000_244800 15.000000
R14146 n1_m1_256000_249600 n1_m4_256000_249600 15.000000
R14147 n1_m1_256000_254400 n1_m4_256000_254400 15.000000
R14148 n1_m1_256000_259200 n1_m4_256000_259200 15.000000
R14149 n1_m1_256000_264000 n1_m4_256000_264000 15.000000
R14150 n1_m1_256000_268800 n1_m4_256000_268800 15.000000
R14151 n1_m1_256000_273600 n1_m4_256000_273600 15.000000
R14152 n1_m1_256000_278400 n1_m4_256000_278400 15.000000
R14153 n1_m1_256000_283200 n1_m4_256000_283200 15.000000
R14154 n1_m1_256000_288000 n1_m4_256000_288000 15.000000
R14155 n1_m1_256000_292800 n1_m4_256000_292800 15.000000
R14156 n1_m1_256000_297600 n1_m4_256000_297600 15.000000
R14157 n1_m1_256000_302400 n1_m4_256000_302400 15.000000
R14158 n1_m1_256000_307200 n1_m4_256000_307200 15.000000
R14159 n1_m1_256000_312000 n1_m4_256000_312000 15.000000
R14160 n1_m1_256000_316800 n1_m4_256000_316800 15.000000
R14161 n1_m1_256000_321600 n1_m4_256000_321600 15.000000
R14162 n1_m1_256000_326400 n1_m4_256000_326400 15.000000
R14163 n1_m1_256000_331200 n1_m4_256000_331200 15.000000
R14164 n1_m1_256000_336000 n1_m4_256000_336000 15.000000
R14165 n1_m1_256000_340800 n1_m4_256000_340800 15.000000
R14166 n1_m1_256000_345600 n1_m4_256000_345600 15.000000
R14167 n1_m1_256000_350400 n1_m4_256000_350400 15.000000
R14168 n1_m1_256000_355200 n1_m4_256000_355200 15.000000
R14169 n1_m1_256000_360000 n1_m4_256000_360000 15.000000
R14170 n1_m1_256000_364800 n1_m4_256000_364800 15.000000
R14171 n1_m1_256000_369600 n1_m4_256000_369600 15.000000
R14172 n1_m1_256000_374400 n1_m4_256000_374400 15.000000
R14173 n1_m1_256000_379200 n1_m4_256000_379200 15.000000
R14174 n1_m1_256000_384000 n1_m4_256000_384000 15.000000
R14175 n1_m1_256000_388800 n1_m4_256000_388800 15.000000
R14176 n1_m1_256000_393600 n1_m4_256000_393600 15.000000
R14177 n1_m1_256000_398400 n1_m4_256000_398400 15.000000
R14178 n1_m1_284000_0 n1_m4_284000_0 15.000000
R14179 n1_m1_284000_403200 n1_m4_284000_403200 15.000000
R14180 n1_m1_284000_408000 n1_m4_284000_408000 15.000000
R14181 n1_m1_284000_412800 n1_m4_284000_412800 15.000000
R14182 n1_m1_284000_417600 n1_m4_284000_417600 15.000000
R14183 n1_m1_284000_422400 n1_m4_284000_422400 15.000000
R14184 n1_m1_284000_427200 n1_m4_284000_427200 15.000000
R14185 n1_m1_284000_432000 n1_m4_284000_432000 15.000000
R14186 n1_m1_284000_436800 n1_m4_284000_436800 15.000000
R14187 n1_m1_284000_441600 n1_m4_284000_441600 15.000000
R14188 n1_m1_284000_446400 n1_m4_284000_446400 15.000000
R14189 n1_m1_284000_451200 n1_m4_284000_451200 15.000000
R14190 n1_m1_284000_456000 n1_m4_284000_456000 15.000000
R14191 n1_m1_284000_460800 n1_m4_284000_460800 15.000000
R14192 n1_m1_284000_465600 n1_m4_284000_465600 15.000000
R14193 n1_m1_284000_470400 n1_m4_284000_470400 15.000000
R14194 n1_m1_312000_0 n1_m4_312000_0 15.000000
R14195 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R14196 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R14197 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R14198 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R14199 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R14200 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R14201 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R14202 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R14203 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R14204 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R14205 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R14206 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R14207 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R14208 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R14209 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R14210 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R14211 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R14212 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R14213 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R14214 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R14215 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R14216 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R14217 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R14218 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R14219 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R14220 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R14221 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R14222 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R14223 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R14224 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R14225 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R14226 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R14227 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R14228 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R14229 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R14230 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R14231 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R14232 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R14233 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R14234 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R14235 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R14236 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R14237 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R14238 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R14239 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R14240 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R14241 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R14242 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R14243 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R14244 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R14245 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R14246 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R14247 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R14248 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R14249 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R14250 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R14251 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R14252 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R14253 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R14254 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R14255 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R14256 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R14257 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R14258 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R14259 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R14260 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R14261 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R14262 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R14263 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R14264 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R14265 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R14266 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R14267 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R14268 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R14269 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R14270 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R14271 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R14272 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R14273 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R14274 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R14275 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R14276 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R14277 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R14278 n1_m1_340000_0 n1_m4_340000_0 15.000000
R14279 n1_m1_368000_0 n1_m4_368000_0 15.000000
R14280 n1_m1_368000_201600 n1_m4_368000_201600 15.000000
R14281 n1_m1_368000_206400 n1_m4_368000_206400 15.000000
R14282 n1_m1_368000_211200 n1_m4_368000_211200 15.000000
R14283 n1_m1_368000_216000 n1_m4_368000_216000 15.000000
R14284 n1_m1_368000_220800 n1_m4_368000_220800 15.000000
R14285 n1_m1_368000_225600 n1_m4_368000_225600 15.000000
R14286 n1_m1_368000_230400 n1_m4_368000_230400 15.000000
R14287 n1_m1_368000_235200 n1_m4_368000_235200 15.000000
R14288 n1_m1_368000_240000 n1_m4_368000_240000 15.000000
R14289 n1_m1_368000_244800 n1_m4_368000_244800 15.000000
R14290 n1_m1_368000_249600 n1_m4_368000_249600 15.000000
R14291 n1_m1_368000_254400 n1_m4_368000_254400 15.000000
R14292 n1_m1_368000_259200 n1_m4_368000_259200 15.000000
R14293 n1_m1_368000_264000 n1_m4_368000_264000 15.000000
R14294 n1_m1_368000_268800 n1_m4_368000_268800 15.000000
R14295 n1_m1_368000_273600 n1_m4_368000_273600 15.000000
R14296 n1_m1_368000_278400 n1_m4_368000_278400 15.000000
R14297 n1_m1_368000_283200 n1_m4_368000_283200 15.000000
R14298 n1_m1_368000_288000 n1_m4_368000_288000 15.000000
R14299 n1_m1_368000_292800 n1_m4_368000_292800 15.000000
R14300 n1_m1_368000_297600 n1_m4_368000_297600 15.000000
R14301 n1_m1_368000_302400 n1_m4_368000_302400 15.000000
R14302 n1_m1_368000_307200 n1_m4_368000_307200 15.000000
R14303 n1_m1_368000_312000 n1_m4_368000_312000 15.000000
R14304 n1_m1_368000_316800 n1_m4_368000_316800 15.000000
R14305 n1_m1_368000_321600 n1_m4_368000_321600 15.000000
R14306 n1_m1_368000_326400 n1_m4_368000_326400 15.000000
R14307 n1_m1_368000_331200 n1_m4_368000_331200 15.000000
R14308 n1_m1_368000_336000 n1_m4_368000_336000 15.000000
R14309 n1_m1_368000_340800 n1_m4_368000_340800 15.000000
R14310 n1_m1_368000_345600 n1_m4_368000_345600 15.000000
R14311 n1_m1_368000_350400 n1_m4_368000_350400 15.000000
R14312 n1_m1_368000_355200 n1_m4_368000_355200 15.000000
R14313 n1_m1_368000_360000 n1_m4_368000_360000 15.000000
R14314 n1_m1_368000_364800 n1_m4_368000_364800 15.000000
R14315 n1_m1_368000_369600 n1_m4_368000_369600 15.000000
R14316 n1_m1_368000_374400 n1_m4_368000_374400 15.000000
R14317 n1_m1_368000_379200 n1_m4_368000_379200 15.000000
R14318 n1_m1_368000_384000 n1_m4_368000_384000 15.000000
R14319 n1_m1_368000_388800 n1_m4_368000_388800 15.000000
R14320 n1_m1_368000_393600 n1_m4_368000_393600 15.000000
R14321 n1_m1_368000_398400 n1_m4_368000_398400 15.000000
R14322 n1_m1_368000_403200 n1_m4_368000_403200 15.000000
R14323 n1_m1_368000_408000 n1_m4_368000_408000 15.000000
R14324 n1_m1_368000_412800 n1_m4_368000_412800 15.000000
R14325 n1_m1_368000_417600 n1_m4_368000_417600 15.000000
R14326 n1_m1_368000_422400 n1_m4_368000_422400 15.000000
R14327 n1_m1_368000_427200 n1_m4_368000_427200 15.000000
R14328 n1_m1_368000_432000 n1_m4_368000_432000 15.000000
R14329 n1_m1_368000_436800 n1_m4_368000_436800 15.000000
R14330 n1_m1_368000_441600 n1_m4_368000_441600 15.000000
R14331 n1_m1_368000_446400 n1_m4_368000_446400 15.000000
R14332 n1_m1_368000_451200 n1_m4_368000_451200 15.000000
R14333 n1_m1_368000_456000 n1_m4_368000_456000 15.000000
R14334 n1_m1_368000_460800 n1_m4_368000_460800 15.000000
R14335 n1_m1_368000_465600 n1_m4_368000_465600 15.000000
R14336 n1_m1_368000_470400 n1_m4_368000_470400 15.000000
R14337 n1_m1_396000_0 n1_m4_396000_0 15.000000
R14338 n1_m1_424000_0 n1_m4_424000_0 15.000000
R14339 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R14340 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R14341 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R14342 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R14343 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R14344 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R14345 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R14346 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R14347 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R14348 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R14349 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R14350 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R14351 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R14352 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R14353 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R14354 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R14355 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R14356 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R14357 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R14358 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R14359 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R14360 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R14361 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R14362 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R14363 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R14364 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R14365 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R14366 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R14367 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R14368 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R14369 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R14370 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R14371 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R14372 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R14373 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R14374 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R14375 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R14376 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R14377 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R14378 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R14379 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R14380 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R14381 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R14382 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R14383 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R14384 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R14385 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R14386 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R14387 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R14388 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R14389 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R14390 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R14391 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R14392 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R14393 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R14394 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R14395 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R14396 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R14397 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R14398 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R14399 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R14400 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R14401 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R14402 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R14403 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R14404 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R14405 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R14406 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R14407 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R14408 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R14409 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R14410 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R14411 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R14412 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R14413 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R14414 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R14415 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R14416 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R14417 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R14418 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R14419 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R14420 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R14421 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R14422 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R14423 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R14424 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R14425 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R14426 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R14427 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R14428 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R14429 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R14430 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R14431 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R14432 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R14433 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R14434 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R14435 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R14436 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R14437 n1_m1_452000_0 n1_m4_452000_0 15.000000
R14438 n1_m1_452000_201600 n1_m4_452000_201600 15.000000
R14439 n1_m1_452000_206400 n1_m4_452000_206400 15.000000
R14440 n1_m1_452000_211200 n1_m4_452000_211200 15.000000
R14441 n1_m1_452000_216000 n1_m4_452000_216000 15.000000
R14442 n1_m1_452000_220800 n1_m4_452000_220800 15.000000
R14443 n1_m1_452000_225600 n1_m4_452000_225600 15.000000
R14444 n1_m1_452000_230400 n1_m4_452000_230400 15.000000
R14445 n1_m1_452000_235200 n1_m4_452000_235200 15.000000
R14446 n1_m1_452000_240000 n1_m4_452000_240000 15.000000
R14447 n1_m1_452000_244800 n1_m4_452000_244800 15.000000
R14448 n1_m1_452000_249600 n1_m4_452000_249600 15.000000
R14449 n1_m1_452000_254400 n1_m4_452000_254400 15.000000
R14450 n1_m1_452000_259200 n1_m4_452000_259200 15.000000
R14451 n1_m1_452000_264000 n1_m4_452000_264000 15.000000
R14452 n1_m1_452000_268800 n1_m4_452000_268800 15.000000
R14453 n1_m1_452000_273600 n1_m4_452000_273600 15.000000
R14454 n1_m1_452000_278400 n1_m4_452000_278400 15.000000
R14455 n1_m1_452000_283200 n1_m4_452000_283200 15.000000
R14456 n1_m1_452000_288000 n1_m4_452000_288000 15.000000
R14457 n1_m1_452000_292800 n1_m4_452000_292800 15.000000
R14458 n1_m1_452000_297600 n1_m4_452000_297600 15.000000
R14459 n1_m1_452000_302400 n1_m4_452000_302400 15.000000
R14460 n1_m1_452000_307200 n1_m4_452000_307200 15.000000
R14461 n1_m1_452000_312000 n1_m4_452000_312000 15.000000
R14462 n1_m1_452000_316800 n1_m4_452000_316800 15.000000
R14463 n1_m1_452000_321600 n1_m4_452000_321600 15.000000
R14464 n1_m1_452000_326400 n1_m4_452000_326400 15.000000
R14465 n1_m1_452000_331200 n1_m4_452000_331200 15.000000
R14466 n1_m1_452000_336000 n1_m4_452000_336000 15.000000
R14467 n1_m1_452000_340800 n1_m4_452000_340800 15.000000
R14468 n1_m1_452000_345600 n1_m4_452000_345600 15.000000
R14469 n1_m1_452000_350400 n1_m4_452000_350400 15.000000
R14470 n1_m1_452000_355200 n1_m4_452000_355200 15.000000
R14471 n1_m1_452000_360000 n1_m4_452000_360000 15.000000
R14472 n1_m1_452000_364800 n1_m4_452000_364800 15.000000
R14473 n1_m1_452000_369600 n1_m4_452000_369600 15.000000
R14474 n1_m1_452000_374400 n1_m4_452000_374400 15.000000
R14475 n1_m1_452000_379200 n1_m4_452000_379200 15.000000
R14476 n1_m1_452000_384000 n1_m4_452000_384000 15.000000
R14477 n1_m1_452000_388800 n1_m4_452000_388800 15.000000
R14478 n1_m1_452000_393600 n1_m4_452000_393600 15.000000
R14479 n1_m1_452000_398400 n1_m4_452000_398400 15.000000
R14480 n1_m1_452000_403200 n1_m4_452000_403200 15.000000
R14481 n1_m1_452000_408000 n1_m4_452000_408000 15.000000
R14482 n1_m1_452000_412800 n1_m4_452000_412800 15.000000
R14483 n1_m1_452000_417600 n1_m4_452000_417600 15.000000
R14484 n1_m1_452000_422400 n1_m4_452000_422400 15.000000
R14485 n1_m1_452000_427200 n1_m4_452000_427200 15.000000
R14486 n1_m1_452000_432000 n1_m4_452000_432000 15.000000
R14487 n1_m1_452000_436800 n1_m4_452000_436800 15.000000
R14488 n1_m1_452000_441600 n1_m4_452000_441600 15.000000
R14489 n1_m1_452000_446400 n1_m4_452000_446400 15.000000
R14490 n1_m1_452000_451200 n1_m4_452000_451200 15.000000
R14491 n1_m1_452000_456000 n1_m4_452000_456000 15.000000
R14492 n1_m1_452000_460800 n1_m4_452000_460800 15.000000
R14493 n1_m1_452000_465600 n1_m4_452000_465600 15.000000
R14494 n1_m1_452000_470400 n1_m4_452000_470400 15.000000
R14495 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R14496 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R14497 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R14498 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R14499 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R14500 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R14501 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R14502 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R14503 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R14504 n1_m4_32000_244000 n1_m7_32000_244000 9.000000
R14505 n1_m4_32000_324000 n1_m7_32000_324000 9.000000
R14506 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R14507 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R14508 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R14509 n1_m4_60000_244000 n1_m7_60000_244000 9.000000
R14510 n1_m4_60000_324000 n1_m7_60000_324000 9.000000
R14511 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R14512 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R14513 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R14514 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R14515 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R14516 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R14517 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R14518 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R14519 n1_m4_116000_244000 n1_m7_116000_244000 9.000000
R14520 n1_m4_116000_324000 n1_m7_116000_324000 9.000000
R14521 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R14522 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R14523 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R14524 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R14525 n1_m4_144000_244000 n1_m7_144000_244000 9.000000
R14526 n1_m4_144000_324000 n1_m7_144000_324000 9.000000
R14527 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R14528 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R14529 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R14530 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R14531 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R14532 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R14533 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R14534 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R14535 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R14536 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R14537 n1_m4_256000_244000 n1_m7_256000_244000 9.000000
R14538 n1_m4_256000_324000 n1_m7_256000_324000 9.000000
R14539 n1_m4_284000_404000 n1_m7_284000_404000 9.000000
R14540 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R14541 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R14542 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R14543 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R14544 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R14545 n1_m4_368000_244000 n1_m7_368000_244000 9.000000
R14546 n1_m4_368000_324000 n1_m7_368000_324000 9.000000
R14547 n1_m4_368000_404000 n1_m7_368000_404000 9.000000
R14548 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R14549 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R14550 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R14551 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R14552 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R14553 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R14554 n1_m4_452000_244000 n1_m7_452000_244000 9.000000
R14555 n1_m4_452000_324000 n1_m7_452000_324000 9.000000
R14556 n1_m4_452000_404000 n1_m7_452000_404000 9.000000
R14557 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R14558 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R14559 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R14560 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R14561 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R14562 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R14563 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R14564 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R14565 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R14566 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R14567 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R14568 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R14569 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R14570 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R14571 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R14572 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R14573 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R14574 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R14575 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R14576 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R14577 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R14578 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R14579 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R14580 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R14581 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R14582 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R14583 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R14584 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R14585 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R14586 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R14587 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R14588 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R14589 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R14590 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R14591 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R14592 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R14593 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R14594 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R14595 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R14596 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R14597 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R14598 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R14599 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R14600 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R14601 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R14602 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R14603 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R14604 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R14605 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R14606 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R14607 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R14608 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R14609 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R14610 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R14611 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R14612 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R14613 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R14614 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R14615 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R14616 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R14617 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R14618 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R14619 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R14620 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R14621 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R14622 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R14623 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R14624 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R14625 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R14626 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R14627 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R14628 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R14629 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R14630 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R14631 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R14632 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R14633 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R14634 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R14635 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R14636 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R14637 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R14638 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R14639 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R14640 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R14641 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R14642 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R14643 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R14644 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R14645 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R14646 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R14647 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R14648 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R14649 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R14650 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R14651 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R14652 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R14653 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R14654 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R14655 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R14656 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R14657 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R14658 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R14659 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R14660 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R14661 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R14662 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R14663 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R14664 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R14665 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R14666 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R14667 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R14668 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R14669 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R14670 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R14671 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R14672 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R14673 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R14674 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R14675 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R14676 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R14677 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R14678 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R14679 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R14680 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R14681 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R14682 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R14683 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R14684 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R14685 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R14686 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R14687 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R14688 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R14689 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R14690 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R14691 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R14692 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R14693 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R14694 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R14695 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R14696 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R14697 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R14698 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R14699 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R14700 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R14701 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R14702 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R14703 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R14704 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R14705 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R14706 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R14707 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R14708 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R14709 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R14710 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R14711 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R14712 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R14713 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R14714 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R14715 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R14716 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R14717 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R14718 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R14719 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R14720 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R14721 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R14722 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R14723 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R14724 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R14725 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R14726 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R14727 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R14728 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R14729 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R14730 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R14731 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R14732 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R14733 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R14734 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R14735 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R14736 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R14737 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R14738 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R14739 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R14740 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R14741 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R14742 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R14743 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R14744 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R14745 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R14746 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R14747 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R14748 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R14749 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R14750 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R14751 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R14752 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R14753 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R14754 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R14755 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R14756 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R14757 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R14758 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R14759 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R14760 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R14761 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R14762 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R14763 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R14764 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R14765 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R14766 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R14767 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R14768 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R14769 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R14770 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R14771 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R14772 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R14773 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R14774 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R14775 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R14776 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R14777 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R14778 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R14779 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R14780 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R14781 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R14782 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R14783 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R14784 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R14785 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R14786 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R14787 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R14788 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R14789 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R14790 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R14791 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R14792 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R14793 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R14794 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R14795 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R14796 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R14797 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R14798 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R14799 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R14800 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R14801 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R14802 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R14803 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R14804 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R14805 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R14806 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R14807 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R14808 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R14809 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R14810 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R14811 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R14812 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R14813 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R14814 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R14815 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R14816 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R14817 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R14818 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R14819 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R14820 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R14821 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R14822 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R14823 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R14824 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R14825 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R14826 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R14827 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R14828 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R14829 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R14830 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R14831 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R14832 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R14833 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R14834 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R14835 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R14836 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R14837 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R14838 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R14839 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R14840 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R14841 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R14842 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R14843 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R14844 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R14845 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R14846 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R14847 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R14848 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R14849 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R14850 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R14851 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R14852 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R14853 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R14854 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R14855 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R14856 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R14857 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R14858 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R14859 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R14860 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R14861 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R14862 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R14863 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R14864 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R14865 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R14866 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R14867 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R14868 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R14869 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R14870 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R14871 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R14872 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R14873 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R14874 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R14875 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R14876 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R14877 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R14878 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R14879 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R14880 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R14881 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R14882 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R14883 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R14884 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R14885 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R14886 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R14887 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R14888 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R14889 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R14890 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R14891 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R14892 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R14893 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R14894 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R14895 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R14896 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R14897 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R14898 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R14899 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R14900 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R14901 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R14902 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R14903 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R14904 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R14905 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R14906 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R14907 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R14908 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R14909 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R14910 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R14911 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R14912 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R14913 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R14914 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R14915 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R14916 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R14917 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R14918 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R14919 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R14920 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R14921 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R14922 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R14923 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R14924 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R14925 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R14926 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R14927 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R14928 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R14929 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R14930 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R14931 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R14932 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R14933 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R14934 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R14935 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R14936 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R14937 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R14938 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R14939 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R14940 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R14941 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R14942 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R14943 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R14944 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R14945 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R14946 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R14947 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R14948 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R14949 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R14950 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R14951 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R14952 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R14953 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R14954 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R14955 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R14956 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R14957 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R14958 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R14959 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R14960 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R14961 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R14962 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R14963 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R14964 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R14965 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R14966 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R14967 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R14968 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R14969 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R14970 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R14971 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R14972 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R14973 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R14974 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R14975 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R14976 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R14977 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R14978 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R14979 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R14980 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R14981 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R14982 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R14983 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R14984 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R14985 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R14986 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R14987 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R14988 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R14989 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R14990 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R14991 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R14992 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R14993 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R14994 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R14995 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R14996 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R14997 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R14998 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R14999 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R15000 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R15001 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R15002 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R15003 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R15004 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R15005 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R15006 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R15007 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R15008 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R15009 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R15010 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R15011 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R15012 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R15013 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R15014 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R15015 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R15016 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R15017 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R15018 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R15019 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R15020 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R15021 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R15022 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R15023 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R15024 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R15025 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R15026 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R15027 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R15028 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R15029 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R15030 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R15031 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R15032 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R15033 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R15034 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R15035 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R15036 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R15037 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R15038 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R15039 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R15040 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R15041 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R15042 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R15043 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R15044 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R15045 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R15046 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R15047 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R15048 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R15049 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R15050 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R15051 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R15052 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R15053 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R15054 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R15055 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R15056 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R15057 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R15058 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R15059 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R15060 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R15061 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R15062 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R15063 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R15064 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R15065 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R15066 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R15067 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R15068 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R15069 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R15070 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R15071 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R15072 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R15073 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R15074 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R15075 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R15076 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R15077 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R15078 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R15079 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R15080 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R15081 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R15082 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R15083 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R15084 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R15085 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R15086 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R15087 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R15088 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R15089 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R15090 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R15091 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R15092 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R15093 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R15094 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R15095 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R15096 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R15097 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R15098 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R15099 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R15100 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R15101 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R15102 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R15103 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R15104 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R15105 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R15106 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R15107 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R15108 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R15109 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R15110 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R15111 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R15112 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R15113 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R15114 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R15115 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R15116 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R15117 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R15118 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R15119 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R15120 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R15121 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R15122 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R15123 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_340000_160800 0 1.100000
V2 n1_m9_250400_452000 0 1.100000
V3 n1_m9_452000_452000 0 1.100000
R15124 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R15125 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R15126 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R15127 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R15128 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R15129 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R15130 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R15131 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R15132 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R15133 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R15134 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R15135 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R15136 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R15137 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R15138 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R15139 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R15140 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R15141 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R15142 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R15143 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R15144 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R15145 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R15146 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R15147 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R15148 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R15149 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R15150 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R15151 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R15152 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R15153 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R15154 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R15155 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
I0 n1_m1_0_0 0 1.732144e-07
I1 n1_m1_0_4800 0 1.705609e-07
I2 n1_m1_0_9600 0 2.218098e-07
I3 n1_m1_0_14400 0 1.357825e-07
I4 n1_m1_0_19200 0 1.454087e-07
I5 n1_m1_0_24000 0 2.087761e-07
I6 n1_m1_0_28800 0 1.332419e-07
I7 n1_m1_0_33600 0 2.056245e-07
I8 n1_m1_0_38400 0 1.506875e-07
I9 n1_m1_0_43200 0 1.571334e-07
I10 n1_m1_0_48000 0 2.322580e-07
I11 n1_m1_0_52800 0 1.472981e-07
I12 n1_m1_0_57600 0 2.225974e-07
I13 n1_m1_0_62400 0 1.507641e-07
I14 n1_m1_0_67200 0 1.439125e-07
I15 n1_m1_0_72000 0 2.061015e-07
I16 n1_m1_0_76800 0 1.368552e-07
I17 n1_m1_0_81600 0 2.148554e-07
I18 n1_m1_0_86400 0 1.470560e-07
I19 n1_m1_0_91200 0 1.447594e-07
I20 n1_m1_0_96000 0 2.174530e-07
I21 n1_m1_0_100800 0 1.460761e-07
I22 n1_m1_0_105600 0 2.172157e-07
I23 n1_m1_0_110400 0 1.462063e-07
I24 n1_m1_0_115200 0 1.463594e-07
I25 n1_m1_0_120000 0 2.173458e-07
I26 n1_m1_0_124800 0 1.447594e-07
I27 n1_m1_0_129600 0 2.176750e-07
I28 n1_m1_0_134400 0 1.484177e-07
I29 n1_m1_0_139200 0 1.514215e-07
I30 n1_m1_0_144000 0 2.290045e-07
I31 n1_m1_0_148800 0 1.612180e-07
I32 n1_m1_0_153600 0 2.404612e-07
I33 n1_m1_0_158400 0 1.640400e-07
I34 n1_m1_0_163200 0 1.644916e-07
I35 n1_m1_0_168000 0 2.335824e-07
I36 n1_m1_0_172800 0 1.489392e-07
I37 n1_m1_0_177600 0 2.263701e-07
I38 n1_m1_0_182400 0 1.514215e-07
I39 n1_m1_0_187200 0 1.514215e-07
I40 n1_m1_0_192000 0 2.284026e-07
I41 n1_m1_0_196800 0 1.578295e-07
I42 n1_m1_0_201600 0 2.373517e-07
I43 n1_m1_0_206400 0 1.616223e-07
I44 n1_m1_0_211200 0 1.587625e-07
I45 n1_m1_0_216000 0 2.371254e-07
I46 n1_m1_0_220800 0 1.546683e-07
I47 n1_m1_0_225600 0 2.276404e-07
I48 n1_m1_0_230400 0 1.465661e-07
I49 n1_m1_0_235200 0 1.456627e-07
I50 n1_m1_0_240000 0 2.174989e-07
I51 n1_m1_0_244800 0 1.481215e-07
I52 n1_m1_0_249600 0 2.352489e-07
I53 n1_m1_0_254400 0 1.618563e-07
I54 n1_m1_0_259200 0 1.661672e-07
I55 n1_m1_0_264000 0 2.481434e-07
I56 n1_m1_0_268800 0 1.721082e-07
I57 n1_m1_0_273600 0 2.629699e-07
I58 n1_m1_0_278400 0 1.842985e-07
I59 n1_m1_0_283200 0 1.888343e-07
I60 n1_m1_0_288000 0 2.501740e-07
I61 n1_m1_0_292800 0 1.680447e-07
I62 n1_m1_0_297600 0 2.481104e-07
I63 n1_m1_0_302400 0 1.641658e-07
I64 n1_m1_0_307200 0 1.630510e-07
I65 n1_m1_0_312000 0 2.534529e-07
I66 n1_m1_0_316800 0 1.621127e-07
I67 n1_m1_0_321600 0 2.119464e-07
I68 n1_m1_0_326400 0 1.417106e-07
I69 n1_m1_0_331200 0 1.488244e-07
I70 n1_m1_0_336000 0 2.356225e-07
I71 n1_m1_0_340800 0 1.603802e-07
I72 n1_m1_0_345600 0 2.337618e-07
I73 n1_m1_0_350400 0 1.548281e-07
I74 n1_m1_0_355200 0 1.534349e-07
I75 n1_m1_0_360000 0 2.253820e-07
I76 n1_m1_0_364800 0 1.479904e-07
I77 n1_m1_0_369600 0 2.329642e-07
I78 n1_m1_0_374400 0 1.576271e-07
I79 n1_m1_0_379200 0 1.550348e-07
I80 n1_m1_0_384000 0 2.266327e-07
I81 n1_m1_0_388800 0 1.478981e-07
I82 n1_m1_0_393600 0 2.194582e-07
I83 n1_m1_0_398400 0 1.424307e-07
I84 n1_m1_0_403200 0 1.417106e-07
I85 n1_m1_0_408000 0 2.138061e-07
I86 n1_m1_0_412800 0 1.409102e-07
I87 n1_m1_0_417600 0 2.168506e-07
I88 n1_m1_0_422400 0 1.489115e-07
I89 n1_m1_0_427200 0 1.514215e-07
I90 n1_m1_0_432000 0 2.271322e-07
I91 n1_m1_0_436800 0 1.500636e-07
I92 n1_m1_0_441600 0 2.214108e-07
I93 n1_m1_0_446400 0 1.492478e-07
I94 n1_m1_0_451200 0 1.543856e-07
I95 n1_m1_0_456000 0 2.291370e-07
I96 n1_m1_0_460800 0 1.449288e-07
I97 n1_m1_0_465600 0 2.058594e-07
I98 n1_m1_0_470400 0 6.773097e-08
I99 n1_m1_4800_0 0 8.528045e-08
I100 n1_m1_4800_4800 0 8.421791e-08
I101 n1_m1_4800_9600 0 1.136496e-07
I102 n1_m1_4800_14400 0 7.157266e-08
I103 n1_m1_4800_19200 0 7.536255e-08
I104 n1_m1_4800_24000 0 1.074232e-07
I105 n1_m1_4800_28800 0 6.794771e-08
I106 n1_m1_4800_33600 0 1.054375e-07
I107 n1_m1_4800_38400 0 7.511793e-08
I108 n1_m1_4800_43200 0 7.729158e-08
I109 n1_m1_4800_48000 0 1.138991e-07
I110 n1_m1_4800_52800 0 7.487117e-08
I111 n1_m1_4800_57600 0 1.139685e-07
I112 n1_m1_4800_62400 0 7.849097e-08
I113 n1_m1_4800_67200 0 7.659243e-08
I114 n1_m1_4800_72000 0 1.103339e-07
I115 n1_m1_4800_76800 0 7.241726e-08
I116 n1_m1_4800_81600 0 1.104058e-07
I117 n1_m1_4800_86400 0 7.249979e-08
I118 n1_m1_4800_91200 0 7.054791e-08
I119 n1_m1_4800_96000 0 1.058946e-07
I120 n1_m1_4800_100800 0 7.141273e-08
I121 n1_m1_4800_105600 0 1.050523e-07
I122 n1_m1_4800_110400 0 7.261965e-08
I123 n1_m1_4800_115200 0 7.290194e-08
I124 n1_m1_4800_120000 0 1.045333e-07
I125 n1_m1_4800_124800 0 6.951348e-08
I126 n1_m1_4800_129600 0 1.055225e-07
I127 n1_m1_4800_134400 0 7.246223e-08
I128 n1_m1_4800_139200 0 7.266462e-08
I129 n1_m1_4800_144000 0 1.092717e-07
I130 n1_m1_4800_148800 0 7.925172e-08
I131 n1_m1_4800_153600 0 1.256958e-07
I132 n1_m1_4800_158400 0 9.037690e-08
I133 n1_m1_4800_163200 0 9.085572e-08
I134 n1_m1_4800_168000 0 1.266487e-07
I135 n1_m1_4800_172800 0 7.542104e-08
I136 n1_m1_4800_177600 0 1.100939e-07
I137 n1_m1_4800_182400 0 7.328303e-08
I138 n1_m1_4800_187200 0 7.328303e-08
I139 n1_m1_4800_192000 0 1.103067e-07
I140 n1_m1_4800_196800 0 7.521087e-08
I141 n1_m1_4800_201600 0 1.129310e-07
I142 n1_m1_4800_206400 0 7.516925e-08
I143 n1_m1_4800_211200 0 7.432034e-08
I144 n1_m1_4800_216000 0 1.128017e-07
I145 n1_m1_4800_220800 0 7.528731e-08
I146 n1_m1_4800_225600 0 1.139382e-07
I147 n1_m1_4800_230400 0 7.516076e-08
I148 n1_m1_4800_235200 0 7.294428e-08
I149 n1_m1_4800_240000 0 1.053271e-07
I150 n1_m1_4800_244800 0 7.270135e-08
I151 n1_m1_4800_249600 0 1.147111e-07
I152 n1_m1_4800_254400 0 8.017324e-08
I153 n1_m1_4800_259200 0 8.224091e-08
I154 n1_m1_4800_264000 0 1.263504e-07
I155 n1_m1_4800_268800 0 1.091621e-07
I156 n1_m1_4800_273600 0 1.850428e-07
I157 n1_m1_4800_278400 0 1.174668e-07
I158 n1_m1_4800_283200 0 1.091143e-07
I159 n1_m1_4800_288000 0 1.536404e-07
I160 n1_m1_4800_292800 0 1.426451e-07
I161 n1_m1_4800_297600 0 2.164386e-07
I162 n1_m1_4800_302400 0 1.448395e-07
I163 n1_m1_4800_307200 0 1.165127e-07
I164 n1_m1_4800_312000 0 1.418716e-07
I165 n1_m1_4800_316800 0 8.700805e-08
I166 n1_m1_4800_321600 0 1.126189e-07
I167 n1_m1_4800_326400 0 7.387896e-08
I168 n1_m1_4800_331200 0 7.745833e-08
I169 n1_m1_4800_336000 0 1.224465e-07
I170 n1_m1_4800_340800 0 8.325931e-08
I171 n1_m1_4800_345600 0 1.221478e-07
I172 n1_m1_4800_350400 0 7.956403e-08
I173 n1_m1_4800_355200 0 7.678717e-08
I174 n1_m1_4800_360000 0 1.116847e-07
I175 n1_m1_4800_364800 0 7.481160e-08
I176 n1_m1_4800_369600 0 1.177137e-07
I177 n1_m1_4800_374400 0 7.932672e-08
I178 n1_m1_4800_379200 0 7.861836e-08
I179 n1_m1_4800_384000 0 1.186861e-07
I180 n1_m1_4800_388800 0 7.573898e-08
I181 n1_m1_4800_393600 0 1.088002e-07
I182 n1_m1_4800_398400 0 7.195626e-08
I183 n1_m1_4800_403200 0 7.217552e-08
I184 n1_m1_4800_408000 0 1.121268e-07
I185 n1_m1_4800_412800 0 7.161751e-08
I186 n1_m1_4800_417600 0 1.057263e-07
I187 n1_m1_4800_422400 0 7.259716e-08
I188 n1_m1_4800_427200 0 7.328303e-08
I189 n1_m1_4800_432000 0 1.099246e-07
I190 n1_m1_4800_436800 0 7.291199e-08
I191 n1_m1_4800_441600 0 1.109318e-07
I192 n1_m1_4800_446400 0 7.686611e-08
I193 n1_m1_4800_451200 0 7.962049e-08
I194 n1_m1_4800_456000 0 1.199177e-07
I195 n1_m1_4800_460800 0 7.832614e-08
I196 n1_m1_4800_465600 0 1.111949e-07
I197 n1_m1_4800_470400 0 3.602047e-08
I198 n1_m1_9600_0 0 2.399765e-07
I199 n1_m1_9600_4800 0 2.379639e-07
I200 n1_m1_9600_9600 0 3.375906e-07
I201 n1_m1_9600_14400 0 2.238086e-07
I202 n1_m1_9600_19200 0 2.278862e-07
I203 n1_m1_9600_24000 0 3.253924e-07
I204 n1_m1_9600_28800 0 2.097122e-07
I205 n1_m1_9600_33600 0 3.149612e-07
I206 n1_m1_9600_38400 0 2.120916e-07
I207 n1_m1_9600_43200 0 2.154255e-07
I208 n1_m1_9600_48000 0 3.289358e-07
I209 n1_m1_9600_52800 0 2.259116e-07
I210 n1_m1_9600_57600 0 3.450010e-07
I211 n1_m1_9600_62400 0 2.259805e-07
I212 n1_m1_9600_67200 0 2.198511e-07
I213 n1_m1_9600_72000 0 3.162602e-07
I214 n1_m1_9600_76800 0 2.068005e-07
I215 n1_m1_9600_81600 0 3.080183e-07
I216 n1_m1_9600_86400 0 2.070211e-07
I217 n1_m1_9600_91200 0 2.120368e-07
I218 n1_m1_9600_96000 0 3.170814e-07
I219 n1_m1_9600_100800 0 2.100000e-07
I220 n1_m1_9600_105600 0 3.150829e-07
I221 n1_m1_9600_110400 0 2.178589e-07
I222 n1_m1_9600_115200 0 2.181503e-07
I223 n1_m1_9600_120000 0 3.063109e-07
I224 n1_m1_9600_124800 0 2.033111e-07
I225 n1_m1_9600_129600 0 3.088977e-07
I226 n1_m1_9600_134400 0 2.119052e-07
I227 n1_m1_9600_139200 0 2.126459e-07
I228 n1_m1_9600_144000 0 3.160885e-07
I229 n1_m1_9600_148800 0 2.164190e-07
I230 n1_m1_9600_153600 0 3.504212e-07
I231 n1_m1_9600_158400 0 2.654194e-07
I232 n1_m1_9600_163200 0 2.727817e-07
I233 n1_m1_9600_168000 0 3.744897e-07
I234 n1_m1_9600_172800 0 2.150449e-07
I235 n1_m1_9600_177600 0 3.212202e-07
I236 n1_m1_9600_182400 0 2.149090e-07
I237 n1_m1_9600_187200 0 2.149090e-07
I238 n1_m1_9600_192000 0 3.233270e-07
I239 n1_m1_9600_196800 0 2.197693e-07
I240 n1_m1_9600_201600 0 3.297167e-07
I241 n1_m1_9600_206400 0 2.155592e-07
I242 n1_m1_9600_211200 0 2.115679e-07
I243 n1_m1_9600_216000 0 3.251905e-07
I244 n1_m1_9600_220800 0 2.199620e-07
I245 n1_m1_9600_225600 0 3.375929e-07
I246 n1_m1_9600_230400 0 2.314915e-07
I247 n1_m1_9600_235200 0 2.196233e-07
I248 n1_m1_9600_240000 0 3.074131e-07
I249 n1_m1_9600_244800 0 2.063280e-07
I250 n1_m1_9600_249600 0 3.195580e-07
I251 n1_m1_9600_254400 0 2.204193e-07
I252 n1_m1_9600_259200 0 2.302516e-07
I253 n1_m1_9600_264000 0 3.591384e-07
I254 n1_m1_9600_268800 0 3.112821e-07
I255 n1_m1_9600_273600 0 5.388455e-07
I256 n1_m1_9600_278400 0 3.202829e-07
I257 n1_m1_9600_283200 0 2.920932e-07
I258 n1_m1_9600_288000 0 4.895075e-07
I259 n1_m1_9600_292800 0 5.883364e-07
I260 n1_m1_9600_297600 0 9.798155e-07
I261 n1_m1_9600_302400 0 6.506879e-07
I262 n1_m1_9600_307200 0 4.555404e-07
I263 n1_m1_9600_312000 0 4.176182e-07
I264 n1_m1_9600_316800 0 2.404325e-07
I265 n1_m1_9600_321600 0 3.269217e-07
I266 n1_m1_9600_326400 0 2.170898e-07
I267 n1_m1_9600_331200 0 2.251148e-07
I268 n1_m1_9600_336000 0 3.470930e-07
I269 n1_m1_9600_340800 0 2.384005e-07
I270 n1_m1_9600_345600 0 3.481887e-07
I271 n1_m1_9600_350400 0 2.287369e-07
I272 n1_m1_9600_355200 0 2.203211e-07
I273 n1_m1_9600_360000 0 3.228131e-07
I274 n1_m1_9600_364800 0 2.151826e-07
I275 n1_m1_9600_369600 0 3.373417e-07
I276 n1_m1_9600_374400 0 2.276920e-07
I277 n1_m1_9600_379200 0 2.250531e-07
I278 n1_m1_9600_384000 0 3.419016e-07
I279 n1_m1_9600_388800 0 2.221938e-07
I280 n1_m1_9600_393600 0 3.183137e-07
I281 n1_m1_9600_398400 0 2.100661e-07
I282 n1_m1_9600_403200 0 2.108559e-07
I283 n1_m1_9600_408000 0 3.254654e-07
I284 n1_m1_9600_412800 0 2.086562e-07
I285 n1_m1_9600_417600 0 3.094202e-07
I286 n1_m1_9600_422400 0 2.123990e-07
I287 n1_m1_9600_427200 0 2.149090e-07
I288 n1_m1_9600_432000 0 3.223635e-07
I289 n1_m1_9600_436800 0 2.135511e-07
I290 n1_m1_9600_441600 0 3.198727e-07
I291 n1_m1_9600_446400 0 2.205118e-07
I292 n1_m1_9600_451200 0 2.288348e-07
I293 n1_m1_9600_456000 0 3.448010e-07
I294 n1_m1_9600_460800 0 2.295707e-07
I295 n1_m1_9600_465600 0 3.358378e-07
I296 n1_m1_9600_470400 0 1.103615e-07
I297 n1_m1_14400_0 0 1.426838e-07
I298 n1_m1_14400_4800 0 1.422292e-07
I299 n1_m1_14400_9600 0 2.159999e-07
I300 n1_m1_14400_14400 0 1.512131e-07
I301 n1_m1_14400_19200 0 1.479326e-07
I302 n1_m1_14400_24000 0 2.120493e-07
I303 n1_m1_14400_28800 0 1.432233e-07
I304 n1_m1_14400_33600 0 2.176896e-07
I305 n1_m1_14400_38400 0 1.451264e-07
I306 n1_m1_14400_43200 0 1.472249e-07
I307 n1_m1_14400_48000 0 2.382202e-07
I308 n1_m1_14400_52800 0 1.698318e-07
I309 n1_m1_14400_57600 0 2.579545e-07
I310 n1_m1_14400_62400 0 1.589905e-07
I311 n1_m1_14400_67200 0 1.464064e-07
I312 n1_m1_14400_72000 0 2.052528e-07
I313 n1_m1_14400_76800 0 1.332419e-07
I314 n1_m1_14400_81600 0 2.064049e-07
I315 n1_m1_14400_86400 0 1.390884e-07
I316 n1_m1_14400_91200 0 1.397018e-07
I317 n1_m1_14400_96000 0 2.098560e-07
I318 n1_m1_14400_100800 0 1.399040e-07
I319 n1_m1_14400_105600 0 2.100536e-07
I320 n1_m1_14400_110400 0 1.452393e-07
I321 n1_m1_14400_115200 0 1.456392e-07
I322 n1_m1_14400_120000 0 2.055695e-07
I323 n1_m1_14400_124800 0 1.332419e-07
I324 n1_m1_14400_129600 0 2.018389e-07
I325 n1_m1_14400_134400 0 1.399040e-07
I326 n1_m1_14400_139200 0 1.399040e-07
I327 n1_m1_14400_144000 0 2.108075e-07
I328 n1_m1_14400_148800 0 1.448830e-07
I329 n1_m1_14400_153600 0 2.246514e-07
I330 n1_m1_14400_158400 0 1.700928e-07
I331 n1_m1_14400_163200 0 1.825084e-07
I332 n1_m1_14400_168000 0 2.591230e-07
I333 n1_m1_14400_172800 0 1.511093e-07
I334 n1_m1_14400_177600 0 2.112300e-07
I335 n1_m1_14400_182400 0 1.396832e-07
I336 n1_m1_14400_187200 0 1.399040e-07
I337 n1_m1_14400_192000 0 2.101305e-07
I338 n1_m1_14400_196800 0 1.412888e-07
I339 n1_m1_14400_201600 0 2.119484e-07
I340 n1_m1_14400_206400 0 1.401663e-07
I341 n1_m1_14400_211200 0 1.399040e-07
I342 n1_m1_14400_216000 0 2.107466e-07
I343 n1_m1_14400_220800 0 1.413437e-07
I344 n1_m1_14400_225600 0 2.120295e-07
I345 n1_m1_14400_230400 0 1.424164e-07
I346 n1_m1_14400_235200 0 1.380126e-07
I347 n1_m1_14400_240000 0 2.003402e-07
I348 n1_m1_14400_244800 0 1.332528e-07
I349 n1_m1_14400_249600 0 2.012974e-07
I350 n1_m1_14400_254400 0 1.396460e-07
I351 n1_m1_14400_259200 0 1.458923e-07
I352 n1_m1_14400_264000 0 2.254331e-07
I353 n1_m1_14400_268800 0 1.732994e-07
I354 n1_m1_14400_273600 0 2.633514e-07
I355 n1_m1_14400_278400 0 1.712721e-07
I356 n1_m1_14400_283200 0 1.740996e-07
I357 n1_m1_14400_288000 0 3.074074e-07
I358 n1_m1_14400_292800 0 3.612813e-07
I359 n1_m1_14400_297600 0 6.668261e-07
I360 n1_m1_14400_302400 0 4.356440e-07
I361 n1_m1_14400_307200 0 2.789852e-07
I362 n1_m1_14400_312000 0 2.556758e-07
I363 n1_m1_14400_316800 0 1.483352e-07
I364 n1_m1_14400_321600 0 2.112697e-07
I365 n1_m1_14400_326400 0 1.399040e-07
I366 n1_m1_14400_331200 0 1.380803e-07
I367 n1_m1_14400_336000 0 2.104750e-07
I368 n1_m1_14400_340800 0 1.423929e-07
I369 n1_m1_14400_345600 0 2.120155e-07
I370 n1_m1_14400_350400 0 1.411790e-07
I371 n1_m1_14400_355200 0 1.393075e-07
I372 n1_m1_14400_360000 0 2.061732e-07
I373 n1_m1_14400_364800 0 1.402608e-07
I374 n1_m1_14400_369600 0 2.189599e-07
I375 n1_m1_14400_374400 0 1.469330e-07
I376 n1_m1_14400_379200 0 1.440563e-07
I377 n1_m1_14400_384000 0 2.121492e-07
I378 n1_m1_14400_388800 0 1.411553e-07
I379 n1_m1_14400_393600 0 2.146808e-07
I380 n1_m1_14400_398400 0 1.413129e-07
I381 n1_m1_14400_403200 0 1.402492e-07
I382 n1_m1_14400_408000 0 2.065463e-07
I383 n1_m1_14400_412800 0 1.336935e-07
I384 n1_m1_14400_417600 0 2.025164e-07
I385 n1_m1_14400_422400 0 1.399040e-07
I386 n1_m1_14400_427200 0 1.399040e-07
I387 n1_m1_14400_432000 0 2.098560e-07
I388 n1_m1_14400_436800 0 1.399040e-07
I389 n1_m1_14400_441600 0 2.094239e-07
I390 n1_m1_14400_446400 0 1.359166e-07
I391 n1_m1_14400_451200 0 1.371915e-07
I392 n1_m1_14400_456000 0 2.120062e-07
I393 n1_m1_14400_460800 0 1.417106e-07
I394 n1_m1_14400_465600 0 2.125660e-07
I395 n1_m1_14400_470400 0 7.085532e-08
I396 n1_m1_19200_0 0 1.388844e-07
I397 n1_m1_19200_4800 0 1.358095e-07
I398 n1_m1_19200_9600 0 2.141743e-07
I399 n1_m1_19200_14400 0 1.471064e-07
I400 n1_m1_19200_19200 0 1.421060e-07
I401 n1_m1_19200_24000 0 2.100080e-07
I402 n1_m1_19200_28800 0 1.437257e-07
I403 n1_m1_19200_33600 0 2.188752e-07
I404 n1_m1_19200_38400 0 1.459168e-07
I405 n1_m1_19200_43200 0 1.466976e-07
I406 n1_m1_19200_48000 0 2.357180e-07
I407 n1_m1_19200_52800 0 1.719178e-07
I408 n1_m1_19200_57600 0 2.620767e-07
I409 n1_m1_19200_62400 0 1.646057e-07
I410 n1_m1_19200_67200 0 1.482430e-07
I411 n1_m1_19200_72000 0 2.029623e-07
I412 n1_m1_19200_76800 0 1.332419e-07
I413 n1_m1_19200_81600 0 2.088164e-07
I414 n1_m1_19200_86400 0 1.409841e-07
I415 n1_m1_19200_91200 0 1.365801e-07
I416 n1_m1_19200_96000 0 2.095533e-07
I417 n1_m1_19200_100800 0 1.397637e-07
I418 n1_m1_19200_105600 0 2.095804e-07
I419 n1_m1_19200_110400 0 1.452393e-07
I420 n1_m1_19200_115200 0 1.458039e-07
I421 n1_m1_19200_120000 0 2.067225e-07
I422 n1_m1_19200_124800 0 1.332419e-07
I423 n1_m1_19200_129600 0 2.018389e-07
I424 n1_m1_19200_134400 0 1.399040e-07
I425 n1_m1_19200_139200 0 1.399040e-07
I426 n1_m1_19200_144000 0 2.109515e-07
I427 n1_m1_19200_148800 0 1.456365e-07
I428 n1_m1_19200_153600 0 2.250349e-07
I429 n1_m1_19200_158400 0 1.664643e-07
I430 n1_m1_19200_163200 0 1.836838e-07
I431 n1_m1_19200_168000 0 2.706918e-07
I432 n1_m1_19200_172800 0 1.616706e-07
I433 n1_m1_19200_177600 0 2.125891e-07
I434 n1_m1_19200_182400 0 1.369825e-07
I435 n1_m1_19200_187200 0 1.399040e-07
I436 n1_m1_19200_192000 0 2.098560e-07
I437 n1_m1_19200_196800 0 1.399040e-07
I438 n1_m1_19200_201600 0 2.098560e-07
I439 n1_m1_19200_206400 0 1.399040e-07
I440 n1_m1_19200_211200 0 1.399040e-07
I441 n1_m1_19200_216000 0 2.098560e-07
I442 n1_m1_19200_220800 0 1.394473e-07
I443 n1_m1_19200_225600 0 2.027716e-07
I444 n1_m1_19200_230400 0 1.343993e-07
I445 n1_m1_19200_235200 0 1.365729e-07
I446 n1_m1_19200_240000 0 2.071529e-07
I447 n1_m1_19200_244800 0 1.340352e-07
I448 n1_m1_19200_249600 0 2.011679e-07
I449 n1_m1_19200_254400 0 1.394454e-07
I450 n1_m1_19200_259200 0 1.451270e-07
I451 n1_m1_19200_264000 0 2.261957e-07
I452 n1_m1_19200_268800 0 1.686997e-07
I453 n1_m1_19200_273600 0 2.423316e-07
I454 n1_m1_19200_278400 0 1.629000e-07
I455 n1_m1_19200_283200 0 1.750752e-07
I456 n1_m1_19200_288000 0 2.880932e-07
I457 n1_m1_19200_292800 0 2.736915e-07
I458 n1_m1_19200_297600 0 4.738327e-07
I459 n1_m1_19200_302400 0 3.070128e-07
I460 n1_m1_19200_307200 0 2.023637e-07
I461 n1_m1_19200_312000 0 2.306935e-07
I462 n1_m1_19200_316800 0 1.426616e-07
I463 n1_m1_19200_321600 0 2.103525e-07
I464 n1_m1_19200_326400 0 1.402616e-07
I465 n1_m1_19200_331200 0 1.392860e-07
I466 n1_m1_19200_336000 0 2.094146e-07
I467 n1_m1_19200_340800 0 1.399040e-07
I468 n1_m1_19200_345600 0 2.098560e-07
I469 n1_m1_19200_350400 0 1.399040e-07
I470 n1_m1_19200_355200 0 1.397225e-07
I471 n1_m1_19200_360000 0 2.089781e-07
I472 n1_m1_19200_364800 0 1.440705e-07
I473 n1_m1_19200_369600 0 2.269141e-07
I474 n1_m1_19200_374400 0 1.524174e-07
I475 n1_m1_19200_379200 0 1.487586e-07
I476 n1_m1_19200_384000 0 2.120985e-07
I477 n1_m1_19200_388800 0 1.426696e-07
I478 n1_m1_19200_393600 0 2.262838e-07
I479 n1_m1_19200_398400 0 1.497593e-07
I480 n1_m1_19200_403200 0 1.445401e-07
I481 n1_m1_19200_408000 0 2.093701e-07
I482 n1_m1_19200_412800 0 1.346181e-07
I483 n1_m1_19200_417600 0 2.025164e-07
I484 n1_m1_19200_422400 0 1.399040e-07
I485 n1_m1_19200_427200 0 1.402726e-07
I486 n1_m1_19200_432000 0 2.106786e-07
I487 n1_m1_19200_436800 0 1.399040e-07
I488 n1_m1_19200_441600 0 2.103142e-07
I489 n1_m1_19200_446400 0 1.394724e-07
I490 n1_m1_19200_451200 0 1.390109e-07
I491 n1_m1_19200_456000 0 2.136642e-07
I492 n1_m1_19200_460800 0 1.454087e-07
I493 n1_m1_19200_465600 0 2.181130e-07
I494 n1_m1_19200_470400 0 7.270434e-08
I495 n1_m1_24000_0 0 2.164659e-07
I496 n1_m1_24000_4800 0 2.016781e-07
I497 n1_m1_24000_9600 0 3.152990e-07
I498 n1_m1_24000_14400 0 2.219732e-07
I499 n1_m1_24000_19200 0 2.118720e-07
I500 n1_m1_24000_24000 0 3.117828e-07
I501 n1_m1_24000_28800 0 2.127447e-07
I502 n1_m1_24000_33600 0 3.216013e-07
I503 n1_m1_24000_38400 0 2.131258e-07
I504 n1_m1_24000_43200 0 2.146719e-07
I505 n1_m1_24000_48000 0 3.333496e-07
I506 n1_m1_24000_52800 0 2.338516e-07
I507 n1_m1_24000_57600 0 3.626113e-07
I508 n1_m1_24000_62400 0 2.331542e-07
I509 n1_m1_24000_67200 0 2.237018e-07
I510 n1_m1_24000_72000 0 3.151343e-07
I511 n1_m1_24000_76800 0 2.035326e-07
I512 n1_m1_24000_81600 0 3.081464e-07
I513 n1_m1_24000_86400 0 2.067706e-07
I514 n1_m1_24000_91200 0 2.002559e-07
I515 n1_m1_24000_96000 0 3.073774e-07
I516 n1_m1_24000_100800 0 2.084764e-07
I517 n1_m1_24000_105600 0 3.111096e-07
I518 n1_m1_24000_110400 0 2.178589e-07
I519 n1_m1_24000_115200 0 2.187058e-07
I520 n1_m1_24000_120000 0 3.100838e-07
I521 n1_m1_24000_124800 0 2.023197e-07
I522 n1_m1_24000_129600 0 3.071745e-07
I523 n1_m1_24000_134400 0 2.098560e-07
I524 n1_m1_24000_139200 0 2.098560e-07
I525 n1_m1_24000_144000 0 3.149434e-07
I526 n1_m1_24000_148800 0 2.115144e-07
I527 n1_m1_24000_153600 0 3.343306e-07
I528 n1_m1_24000_158400 0 2.534694e-07
I529 n1_m1_24000_163200 0 3.024819e-07
I530 n1_m1_24000_168000 0 4.463999e-07
I531 n1_m1_24000_172800 0 2.435131e-07
I532 n1_m1_24000_177600 0 3.206423e-07
I533 n1_m1_24000_182400 0 2.093294e-07
I534 n1_m1_24000_187200 0 2.098560e-07
I535 n1_m1_24000_192000 0 3.147839e-07
I536 n1_m1_24000_196800 0 2.098560e-07
I537 n1_m1_24000_201600 0 3.146129e-07
I538 n1_m1_24000_206400 0 2.068548e-07
I539 n1_m1_24000_211200 0 2.061862e-07
I540 n1_m1_24000_216000 0 3.092792e-07
I541 n1_m1_24000_220800 0 2.023539e-07
I542 n1_m1_24000_225600 0 3.000056e-07
I543 n1_m1_24000_230400 0 1.998628e-07
I544 n1_m1_24000_235200 0 2.030245e-07
I545 n1_m1_24000_240000 0 3.098358e-07
I546 n1_m1_24000_244800 0 2.088980e-07
I547 n1_m1_24000_249600 0 3.133173e-07
I548 n1_m1_24000_254400 0 2.067570e-07
I549 n1_m1_24000_259200 0 2.069463e-07
I550 n1_m1_24000_264000 0 3.174997e-07
I551 n1_m1_24000_268800 0 2.349699e-07
I552 n1_m1_24000_273600 0 3.420201e-07
I553 n1_m1_24000_278400 0 2.351888e-07
I554 n1_m1_24000_283200 0 2.474862e-07
I555 n1_m1_24000_288000 0 3.873650e-07
I556 n1_m1_24000_292800 0 3.005658e-07
I557 n1_m1_24000_297600 0 4.430595e-07
I558 n1_m1_24000_302400 0 2.810673e-07
I559 n1_m1_24000_307200 0 2.400562e-07
I560 n1_m1_24000_312000 0 3.190268e-07
I561 n1_m1_24000_316800 0 2.100896e-07
I562 n1_m1_24000_321600 0 3.181066e-07
I563 n1_m1_24000_326400 0 2.148786e-07
I564 n1_m1_24000_331200 0 2.078967e-07
I565 n1_m1_24000_336000 0 3.092792e-07
I566 n1_m1_24000_340800 0 2.061862e-07
I567 n1_m1_24000_345600 0 3.123270e-07
I568 n1_m1_24000_350400 0 2.098560e-07
I569 n1_m1_24000_355200 0 2.098560e-07
I570 n1_m1_24000_360000 0 3.147839e-07
I571 n1_m1_24000_364800 0 2.173932e-07
I572 n1_m1_24000_369600 0 3.446816e-07
I573 n1_m1_24000_374400 0 2.327511e-07
I574 n1_m1_24000_379200 0 2.273387e-07
I575 n1_m1_24000_384000 0 3.204109e-07
I576 n1_m1_24000_388800 0 2.107979e-07
I577 n1_m1_24000_393600 0 3.203724e-07
I578 n1_m1_24000_398400 0 2.157331e-07
I579 n1_m1_24000_403200 0 2.112563e-07
I580 n1_m1_24000_408000 0 3.148396e-07
I581 n1_m1_24000_412800 0 2.051135e-07
I582 n1_m1_24000_417600 0 3.078175e-07
I583 n1_m1_24000_422400 0 2.116287e-07
I584 n1_m1_24000_427200 0 2.166193e-07
I585 n1_m1_24000_432000 0 3.271913e-07
I586 n1_m1_24000_436800 0 2.124995e-07
I587 n1_m1_24000_441600 0 3.223391e-07
I588 n1_m1_24000_446400 0 2.151017e-07
I589 n1_m1_24000_451200 0 2.103869e-07
I590 n1_m1_24000_456000 0 3.192317e-07
I591 n1_m1_24000_460800 0 2.161793e-07
I592 n1_m1_24000_465600 0 3.257929e-07
I593 n1_m1_24000_470400 0 1.095047e-07
I594 n1_m1_28800_0 0 1.385499e-07
I595 n1_m1_28800_4800 0 1.346098e-07
I596 n1_m1_28800_9600 0 2.128600e-07
I597 n1_m1_28800_14400 0 1.479684e-07
I598 n1_m1_28800_19200 0 1.412465e-07
I599 n1_m1_28800_24000 0 2.078706e-07
I600 n1_m1_28800_28800 0 1.414470e-07
I601 n1_m1_28800_33600 0 2.175345e-07
I602 n1_m1_28800_38400 0 1.414882e-07
I603 n1_m1_28800_43200 0 1.482737e-07
I604 n1_m1_28800_48000 0 2.277861e-07
I605 n1_m1_28800_52800 0 1.590324e-07
I606 n1_m1_28800_57600 0 2.551629e-07
I607 n1_m1_28800_62400 0 1.608733e-07
I608 n1_m1_28800_67200 0 1.589458e-07
I609 n1_m1_28800_72000 0 2.217115e-07
I610 n1_m1_28800_76800 0 1.470809e-07
I611 n1_m1_28800_81600 0 2.069493e-07
I612 n1_m1_28800_86400 0 1.390193e-07
I613 n1_m1_28800_91200 0 1.393781e-07
I614 n1_m1_28800_96000 0 2.078742e-07
I615 n1_m1_28800_100800 0 1.366842e-07
I616 n1_m1_28800_105600 0 2.098741e-07
I617 n1_m1_28800_110400 0 1.424582e-07
I618 n1_m1_28800_115200 0 1.482261e-07
I619 n1_m1_28800_120000 0 2.121590e-07
I620 n1_m1_28800_124800 0 1.405011e-07
I621 n1_m1_28800_129600 0 2.126011e-07
I622 n1_m1_28800_134400 0 1.372844e-07
I623 n1_m1_28800_139200 0 1.477986e-07
I624 n1_m1_28800_144000 0 2.130138e-07
I625 n1_m1_28800_148800 0 1.371657e-07
I626 n1_m1_28800_153600 0 2.225706e-07
I627 n1_m1_28800_158400 0 2.349814e-07
I628 n1_m1_28800_163200 0 2.869803e-07
I629 n1_m1_28800_168000 0 5.114140e-07
I630 n1_m1_28800_172800 0 1.834176e-07
I631 n1_m1_28800_177600 0 2.227830e-07
I632 n1_m1_28800_182400 0 1.399040e-07
I633 n1_m1_28800_187200 0 1.399040e-07
I634 n1_m1_28800_192000 0 2.098560e-07
I635 n1_m1_28800_196800 0 1.399040e-07
I636 n1_m1_28800_201600 0 2.064414e-07
I637 n1_m1_28800_206400 0 1.336842e-07
I638 n1_m1_28800_211200 0 1.332419e-07
I639 n1_m1_28800_216000 0 2.024824e-07
I640 n1_m1_28800_220800 0 1.344978e-07
I641 n1_m1_28800_225600 0 2.051917e-07
I642 n1_m1_28800_230400 0 1.357179e-07
I643 n1_m1_28800_235200 0 1.332419e-07
I644 n1_m1_28800_240000 0 2.011896e-07
I645 n1_m1_28800_244800 0 1.386837e-07
I646 n1_m1_28800_249600 0 2.036039e-07
I647 n1_m1_28800_254400 0 1.371624e-07
I648 n1_m1_28800_259200 0 1.374763e-07
I649 n1_m1_28800_264000 0 2.104488e-07
I650 n1_m1_28800_268800 0 1.463345e-07
I651 n1_m1_28800_273600 0 2.183326e-07
I652 n1_m1_28800_278400 0 1.486646e-07
I653 n1_m1_28800_283200 0 1.536105e-07
I654 n1_m1_28800_288000 0 2.456061e-07
I655 n1_m1_28800_292800 0 1.834959e-07
I656 n1_m1_28800_297600 0 3.506068e-07
I657 n1_m1_28800_302400 0 1.909902e-07
I658 n1_m1_28800_307200 0 1.611362e-07
I659 n1_m1_28800_312000 0 2.153425e-07
I660 n1_m1_28800_316800 0 1.387916e-07
I661 n1_m1_28800_321600 0 2.161413e-07
I662 n1_m1_28800_326400 0 1.454757e-07
I663 n1_m1_28800_331200 0 1.405815e-07
I664 n1_m1_28800_336000 0 2.014776e-07
I665 n1_m1_28800_340800 0 1.332419e-07
I666 n1_m1_28800_345600 0 2.053957e-07
I667 n1_m1_28800_350400 0 1.418417e-07
I668 n1_m1_28800_355200 0 1.515844e-07
I669 n1_m1_28800_360000 0 2.078644e-07
I670 n1_m1_28800_364800 0 2.528876e-07
I671 n1_m1_28800_369600 0 2.598375e-07
I672 n1_m1_28800_374400 0 1.557760e-07
I673 n1_m1_28800_379200 0 1.476565e-07
I674 n1_m1_28800_384000 0 2.161413e-07
I675 n1_m1_28800_388800 0 1.381435e-07
I676 n1_m1_28800_393600 0 2.039876e-07
I677 n1_m1_28800_398400 0 1.426300e-07
I678 n1_m1_28800_403200 0 1.403525e-07
I679 n1_m1_28800_408000 0 2.127626e-07
I680 n1_m1_28800_412800 0 1.409626e-07
I681 n1_m1_28800_417600 0 2.098560e-07
I682 n1_m1_28800_422400 0 1.410767e-07
I683 n1_m1_28800_427200 0 1.423317e-07
I684 n1_m1_28800_432000 0 2.134975e-07
I685 n1_m1_28800_436800 0 1.416528e-07
I686 n1_m1_28800_441600 0 2.150219e-07
I687 n1_m1_28800_446400 0 1.408355e-07
I688 n1_m1_28800_451200 0 1.399040e-07
I689 n1_m1_28800_456000 0 2.098560e-07
I690 n1_m1_28800_460800 0 1.431156e-07
I691 n1_m1_28800_465600 0 2.172157e-07
I692 n1_m1_28800_470400 0 7.300529e-08
I693 n1_m1_33600_0 0 1.337242e-07
I694 n1_m1_33600_4800 0 1.358648e-07
I695 n1_m1_33600_9600 0 2.097320e-07
I696 n1_m1_33600_14400 0 1.399306e-07
I697 n1_m1_33600_19200 0 1.397356e-07
I698 n1_m1_33600_24000 0 2.047473e-07
I699 n1_m1_33600_28800 0 1.332701e-07
I700 n1_m1_33600_33600 0 2.089018e-07
I701 n1_m1_33600_38400 0 1.385140e-07
I702 n1_m1_33600_43200 0 1.409626e-07
I703 n1_m1_33600_48000 0 2.188874e-07
I704 n1_m1_33600_52800 0 1.770606e-07
I705 n1_m1_33600_57600 0 3.183553e-07
I706 n1_m1_33600_62400 0 1.670471e-07
I707 n1_m1_33600_67200 0 1.864153e-07
I708 n1_m1_33600_72000 0 2.315635e-07
I709 n1_m1_33600_76800 0 1.481940e-07
I710 n1_m1_33600_81600 0 2.061796e-07
I711 n1_m1_33600_86400 0 1.416824e-07
I712 n1_m1_33600_91200 0 1.484531e-07
I713 n1_m1_33600_96000 0 2.252512e-07
I714 n1_m1_33600_100800 0 1.434609e-07
I715 n1_m1_33600_105600 0 2.160092e-07
I716 n1_m1_33600_110400 0 1.403859e-07
I717 n1_m1_33600_115200 0 1.455389e-07
I718 n1_m1_33600_120000 0 2.237089e-07
I719 n1_m1_33600_124800 0 1.442984e-07
I720 n1_m1_33600_129600 0 2.249063e-07
I721 n1_m1_33600_134400 0 1.450907e-07
I722 n1_m1_33600_139200 0 1.529301e-07
I723 n1_m1_33600_144000 0 2.269204e-07
I724 n1_m1_33600_148800 0 1.432938e-07
I725 n1_m1_33600_153600 0 2.225109e-07
I726 n1_m1_33600_158400 0 1.753538e-07
I727 n1_m1_33600_163200 0 2.052097e-07
I728 n1_m1_33600_168000 0 5.278649e-07
I729 n1_m1_33600_172800 0 1.939775e-07
I730 n1_m1_33600_177600 0 2.227830e-07
I731 n1_m1_33600_182400 0 1.379700e-07
I732 n1_m1_33600_187200 0 1.341895e-07
I733 n1_m1_33600_192000 0 2.069888e-07
I734 n1_m1_33600_196800 0 1.399040e-07
I735 n1_m1_33600_201600 0 2.046618e-07
I736 n1_m1_33600_206400 0 1.332419e-07
I737 n1_m1_33600_211200 0 1.332419e-07
I738 n1_m1_33600_216000 0 1.998803e-07
I739 n1_m1_33600_220800 0 1.332503e-07
I740 n1_m1_33600_225600 0 1.998983e-07
I741 n1_m1_33600_230400 0 1.352746e-07
I742 n1_m1_33600_235200 0 1.389865e-07
I743 n1_m1_33600_240000 0 2.098192e-07
I744 n1_m1_33600_244800 0 1.387236e-07
I745 n1_m1_33600_249600 0 2.048137e-07
I746 n1_m1_33600_254400 0 1.360514e-07
I747 n1_m1_33600_259200 0 1.392662e-07
I748 n1_m1_33600_264000 0 2.140903e-07
I749 n1_m1_33600_268800 0 1.417671e-07
I750 n1_m1_33600_273600 0 2.121708e-07
I751 n1_m1_33600_278400 0 1.465661e-07
I752 n1_m1_33600_283200 0 1.465807e-07
I753 n1_m1_33600_288000 0 2.313749e-07
I754 n1_m1_33600_292800 0 1.744571e-07
I755 n1_m1_33600_297600 0 3.993661e-07
I756 n1_m1_33600_302400 0 2.057359e-07
I757 n1_m1_33600_307200 0 1.640718e-07
I758 n1_m1_33600_312000 0 2.189893e-07
I759 n1_m1_33600_316800 0 1.381257e-07
I760 n1_m1_33600_321600 0 2.116613e-07
I761 n1_m1_33600_326400 0 1.426068e-07
I762 n1_m1_33600_331200 0 1.399171e-07
I763 n1_m1_33600_336000 0 2.040086e-07
I764 n1_m1_33600_340800 0 1.337242e-07
I765 n1_m1_33600_345600 0 2.065864e-07
I766 n1_m1_33600_350400 0 1.399169e-07
I767 n1_m1_33600_355200 0 1.433808e-07
I768 n1_m1_33600_360000 0 2.339784e-07
I769 n1_m1_33600_364800 0 1.629086e-07
I770 n1_m1_33600_369600 0 2.526132e-07
I771 n1_m1_33600_374400 0 1.708035e-07
I772 n1_m1_33600_379200 0 1.646832e-07
I773 n1_m1_33600_384000 0 2.375568e-07
I774 n1_m1_33600_388800 0 1.412715e-07
I775 n1_m1_33600_393600 0 2.098398e-07
I776 n1_m1_33600_398400 0 1.399245e-07
I777 n1_m1_33600_403200 0 1.410032e-07
I778 n1_m1_33600_408000 0 2.239582e-07
I779 n1_m1_33600_412800 0 1.432280e-07
I780 n1_m1_33600_417600 0 2.098560e-07
I781 n1_m1_33600_422400 0 1.399040e-07
I782 n1_m1_33600_427200 0 1.399040e-07
I783 n1_m1_33600_432000 0 2.098560e-07
I784 n1_m1_33600_436800 0 1.399040e-07
I785 n1_m1_33600_441600 0 2.150219e-07
I786 n1_m1_33600_446400 0 1.408355e-07
I787 n1_m1_33600_451200 0 1.399040e-07
I788 n1_m1_33600_456000 0 2.111069e-07
I789 n1_m1_33600_460800 0 1.453865e-07
I790 n1_m1_33600_465600 0 2.198491e-07
I791 n1_m1_33600_470400 0 7.328303e-08
I792 n1_m1_38400_0 0 1.367356e-07
I793 n1_m1_38400_4800 0 1.395908e-07
I794 n1_m1_38400_9600 0 2.098560e-07
I795 n1_m1_38400_14400 0 1.399040e-07
I796 n1_m1_38400_19200 0 1.392547e-07
I797 n1_m1_38400_24000 0 2.007379e-07
I798 n1_m1_38400_28800 0 1.391270e-07
I799 n1_m1_38400_33600 0 2.218902e-07
I800 n1_m1_38400_38400 0 1.427408e-07
I801 n1_m1_38400_43200 0 1.423724e-07
I802 n1_m1_38400_48000 0 2.901894e-07
I803 n1_m1_38400_52800 0 3.665647e-07
I804 n1_m1_38400_57600 0 7.690288e-07
I805 n1_m1_38400_62400 0 3.987216e-07
I806 n1_m1_38400_67200 0 4.330875e-07
I807 n1_m1_38400_72000 0 3.744866e-07
I808 n1_m1_38400_76800 0 1.858980e-07
I809 n1_m1_38400_81600 0 2.188235e-07
I810 n1_m1_38400_86400 0 1.488809e-07
I811 n1_m1_38400_91200 0 1.578578e-07
I812 n1_m1_38400_96000 0 2.403586e-07
I813 n1_m1_38400_100800 0 1.508150e-07
I814 n1_m1_38400_105600 0 2.230550e-07
I815 n1_m1_38400_110400 0 1.411784e-07
I816 n1_m1_38400_115200 0 1.531330e-07
I817 n1_m1_38400_120000 0 2.810065e-07
I818 n1_m1_38400_124800 0 1.658079e-07
I819 n1_m1_38400_129600 0 2.452207e-07
I820 n1_m1_38400_134400 0 1.613687e-07
I821 n1_m1_38400_139200 0 1.496651e-07
I822 n1_m1_38400_144000 0 2.216938e-07
I823 n1_m1_38400_148800 0 1.457606e-07
I824 n1_m1_38400_153600 0 2.242005e-07
I825 n1_m1_38400_158400 0 1.706209e-07
I826 n1_m1_38400_163200 0 1.837487e-07
I827 n1_m1_38400_168000 0 3.949915e-07
I828 n1_m1_38400_172800 0 1.766508e-07
I829 n1_m1_38400_177600 0 2.257409e-07
I830 n1_m1_38400_182400 0 1.399040e-07
I831 n1_m1_38400_187200 0 1.366858e-07
I832 n1_m1_38400_192000 0 2.069766e-07
I833 n1_m1_38400_196800 0 1.399040e-07
I834 n1_m1_38400_201600 0 2.046618e-07
I835 n1_m1_38400_206400 0 1.332419e-07
I836 n1_m1_38400_211200 0 1.332419e-07
I837 n1_m1_38400_216000 0 1.998628e-07
I838 n1_m1_38400_220800 0 1.332419e-07
I839 n1_m1_38400_225600 0 1.998628e-07
I840 n1_m1_38400_230400 0 1.332419e-07
I841 n1_m1_38400_235200 0 1.365729e-07
I842 n1_m1_38400_240000 0 2.098560e-07
I843 n1_m1_38400_244800 0 1.399040e-07
I844 n1_m1_38400_249600 0 2.047883e-07
I845 n1_m1_38400_254400 0 1.368339e-07
I846 n1_m1_38400_259200 0 1.375892e-07
I847 n1_m1_38400_264000 0 2.106182e-07
I848 n1_m1_38400_268800 0 1.411197e-07
I849 n1_m1_38400_273600 0 2.121708e-07
I850 n1_m1_38400_278400 0 1.465661e-07
I851 n1_m1_38400_283200 0 1.453694e-07
I852 n1_m1_38400_288000 0 2.278662e-07
I853 n1_m1_38400_292800 0 1.721417e-07
I854 n1_m1_38400_297600 0 4.360724e-07
I855 n1_m1_38400_302400 0 2.322968e-07
I856 n1_m1_38400_307200 0 1.748321e-07
I857 n1_m1_38400_312000 0 2.235189e-07
I858 n1_m1_38400_316800 0 1.381157e-07
I859 n1_m1_38400_321600 0 2.077471e-07
I860 n1_m1_38400_326400 0 1.399040e-07
I861 n1_m1_38400_331200 0 1.399040e-07
I862 n1_m1_38400_336000 0 2.089165e-07
I863 n1_m1_38400_340800 0 1.367356e-07
I864 n1_m1_38400_345600 0 2.098560e-07
I865 n1_m1_38400_350400 0 1.399040e-07
I866 n1_m1_38400_355200 0 1.429932e-07
I867 n1_m1_38400_360000 0 2.292612e-07
I868 n1_m1_38400_364800 0 1.575460e-07
I869 n1_m1_38400_369600 0 3.552898e-07
I870 n1_m1_38400_374400 0 2.687311e-07
I871 n1_m1_38400_379200 0 1.811698e-07
I872 n1_m1_38400_384000 0 2.582509e-07
I873 n1_m1_38400_388800 0 1.482943e-07
I874 n1_m1_38400_393600 0 2.098560e-07
I875 n1_m1_38400_398400 0 1.399040e-07
I876 n1_m1_38400_403200 0 1.410049e-07
I877 n1_m1_38400_408000 0 2.239988e-07
I878 n1_m1_38400_412800 0 1.432350e-07
I879 n1_m1_38400_417600 0 2.098560e-07
I880 n1_m1_38400_422400 0 1.399040e-07
I881 n1_m1_38400_427200 0 1.399040e-07
I882 n1_m1_38400_432000 0 2.098560e-07
I883 n1_m1_38400_436800 0 1.399040e-07
I884 n1_m1_38400_441600 0 2.150219e-07
I885 n1_m1_38400_446400 0 1.408355e-07
I886 n1_m1_38400_451200 0 1.399040e-07
I887 n1_m1_38400_456000 0 2.145420e-07
I888 n1_m1_38400_460800 0 1.482531e-07
I889 n1_m1_38400_465600 0 2.203101e-07
I890 n1_m1_38400_470400 0 7.328303e-08
I891 n1_m1_43200_0 0 1.420025e-07
I892 n1_m1_43200_4800 0 1.401114e-07
I893 n1_m1_43200_9600 0 2.098560e-07
I894 n1_m1_43200_14400 0 1.399040e-07
I895 n1_m1_43200_19200 0 1.392547e-07
I896 n1_m1_43200_24000 0 2.007379e-07
I897 n1_m1_43200_28800 0 1.428590e-07
I898 n1_m1_43200_33600 0 2.220338e-07
I899 n1_m1_43200_38400 0 1.394365e-07
I900 n1_m1_43200_43200 0 1.469072e-07
I901 n1_m1_43200_48000 0 4.647923e-07
I902 n1_m1_43200_52800 0 5.895556e-07
I903 n1_m1_43200_57600 0 1.229415e-06
I904 n1_m1_43200_62400 0 5.842729e-07
I905 n1_m1_43200_67200 0 6.039319e-07
I906 n1_m1_43200_72000 0 4.679028e-07
I907 n1_m1_43200_76800 0 2.131392e-07
I908 n1_m1_43200_81600 0 2.375739e-07
I909 n1_m1_43200_86400 0 1.644773e-07
I910 n1_m1_43200_91200 0 1.679638e-07
I911 n1_m1_43200_96000 0 2.533031e-07
I912 n1_m1_43200_100800 0 1.547796e-07
I913 n1_m1_43200_105600 0 2.296178e-07
I914 n1_m1_43200_110400 0 1.482706e-07
I915 n1_m1_43200_115200 0 1.737597e-07
I916 n1_m1_43200_120000 0 3.758459e-07
I917 n1_m1_43200_124800 0 2.099928e-07
I918 n1_m1_43200_129600 0 2.725664e-07
I919 n1_m1_43200_134400 0 1.797579e-07
I920 n1_m1_43200_139200 0 1.507698e-07
I921 n1_m1_43200_144000 0 2.220493e-07
I922 n1_m1_43200_148800 0 1.425580e-07
I923 n1_m1_43200_153600 0 2.207840e-07
I924 n1_m1_43200_158400 0 2.500364e-07
I925 n1_m1_43200_163200 0 2.298427e-07
I926 n1_m1_43200_168000 0 3.598507e-07
I927 n1_m1_43200_172800 0 1.738929e-07
I928 n1_m1_43200_177600 0 2.234766e-07
I929 n1_m1_43200_182400 0 1.399040e-07
I930 n1_m1_43200_187200 0 1.366858e-07
I931 n1_m1_43200_192000 0 2.069766e-07
I932 n1_m1_43200_196800 0 1.399040e-07
I933 n1_m1_43200_201600 0 2.046618e-07
I934 n1_m1_43200_206400 0 1.332419e-07
I935 n1_m1_43200_211200 0 1.332419e-07
I936 n1_m1_43200_216000 0 1.998628e-07
I937 n1_m1_43200_220800 0 1.332419e-07
I938 n1_m1_43200_225600 0 1.998628e-07
I939 n1_m1_43200_230400 0 1.332419e-07
I940 n1_m1_43200_235200 0 1.351332e-07
I941 n1_m1_43200_240000 0 2.055369e-07
I942 n1_m1_43200_244800 0 1.370246e-07
I943 n1_m1_43200_249600 0 2.025235e-07
I944 n1_m1_43200_254400 0 1.332419e-07
I945 n1_m1_43200_259200 0 1.332419e-07
I946 n1_m1_43200_264000 0 2.040972e-07
I947 n1_m1_43200_268800 0 1.399040e-07
I948 n1_m1_43200_273600 0 2.121708e-07
I949 n1_m1_43200_278400 0 1.465661e-07
I950 n1_m1_43200_283200 0 1.431221e-07
I951 n1_m1_43200_288000 0 2.207474e-07
I952 n1_m1_43200_292800 0 1.635364e-07
I953 n1_m1_43200_297600 0 3.905945e-07
I954 n1_m1_43200_302400 0 2.260741e-07
I955 n1_m1_43200_307200 0 1.722472e-07
I956 n1_m1_43200_312000 0 2.207493e-07
I957 n1_m1_43200_316800 0 1.367674e-07
I958 n1_m1_43200_321600 0 2.031400e-07
I959 n1_m1_43200_326400 0 1.399040e-07
I960 n1_m1_43200_331200 0 1.399040e-07
I961 n1_m1_43200_336000 0 2.098560e-07
I962 n1_m1_43200_340800 0 1.399040e-07
I963 n1_m1_43200_345600 0 2.074646e-07
I964 n1_m1_43200_350400 0 1.370246e-07
I965 n1_m1_43200_355200 0 1.380691e-07
I966 n1_m1_43200_360000 0 2.246887e-07
I967 n1_m1_43200_364800 0 4.314517e-07
I968 n1_m1_43200_369600 0 4.849738e-07
I969 n1_m1_43200_374400 0 3.446284e-07
I970 n1_m1_43200_379200 0 1.975428e-07
I971 n1_m1_43200_384000 0 2.771549e-07
I972 n1_m1_43200_388800 0 1.568030e-07
I973 n1_m1_43200_393600 0 2.098560e-07
I974 n1_m1_43200_398400 0 1.399040e-07
I975 n1_m1_43200_403200 0 1.410049e-07
I976 n1_m1_43200_408000 0 2.220223e-07
I977 n1_m1_43200_412800 0 1.425152e-07
I978 n1_m1_43200_417600 0 2.098560e-07
I979 n1_m1_43200_422400 0 1.399040e-07
I980 n1_m1_43200_427200 0 1.399040e-07
I981 n1_m1_43200_432000 0 2.098560e-07
I982 n1_m1_43200_436800 0 1.399040e-07
I983 n1_m1_43200_441600 0 2.150219e-07
I984 n1_m1_43200_446400 0 1.408355e-07
I985 n1_m1_43200_451200 0 1.404042e-07
I986 n1_m1_43200_456000 0 2.187025e-07
I987 n1_m1_43200_460800 0 1.521169e-07
I988 n1_m1_43200_465600 0 2.211759e-07
I989 n1_m1_43200_470400 0 7.328303e-08
I990 n1_m1_48000_0 0 2.197788e-07
I991 n1_m1_48000_4800 0 2.155928e-07
I992 n1_m1_48000_9600 0 3.099611e-07
I993 n1_m1_48000_14400 0 2.030810e-07
I994 n1_m1_48000_19200 0 2.027673e-07
I995 n1_m1_48000_24000 0 3.002170e-07
I996 n1_m1_48000_28800 0 2.040613e-07
I997 n1_m1_48000_33600 0 3.189652e-07
I998 n1_m1_48000_38400 0 2.317090e-07
I999 n1_m1_48000_43200 0 2.513278e-07
I1000 n1_m1_48000_48000 0 8.767076e-07
I1001 n1_m1_48000_52800 0 4.955016e-07
I1002 n1_m1_48000_57600 0 9.186990e-07
I1003 n1_m1_48000_62400 0 4.314587e-07
I1004 n1_m1_48000_67200 0 4.286099e-07
I1005 n1_m1_48000_72000 0 4.026711e-07
I1006 n1_m1_48000_76800 0 2.521632e-07
I1007 n1_m1_48000_81600 0 3.936672e-07
I1008 n1_m1_48000_86400 0 3.114287e-07
I1009 n1_m1_48000_91200 0 2.664194e-07
I1010 n1_m1_48000_96000 0 3.852441e-07
I1011 n1_m1_48000_100800 0 2.307053e-07
I1012 n1_m1_48000_105600 0 3.383565e-07
I1013 n1_m1_48000_110400 0 2.372495e-07
I1014 n1_m1_48000_115200 0 2.899866e-07
I1015 n1_m1_48000_120000 0 5.083325e-07
I1016 n1_m1_48000_124800 0 3.271541e-07
I1017 n1_m1_48000_129600 0 3.657655e-07
I1018 n1_m1_48000_134400 0 2.430600e-07
I1019 n1_m1_48000_139200 0 2.179063e-07
I1020 n1_m1_48000_144000 0 3.167842e-07
I1021 n1_m1_48000_148800 0 2.142805e-07
I1022 n1_m1_48000_153600 0 3.320660e-07
I1023 n1_m1_48000_158400 0 5.491534e-07
I1024 n1_m1_48000_163200 0 5.308243e-07
I1025 n1_m1_48000_168000 0 7.017731e-07
I1026 n1_m1_48000_172800 0 2.733846e-07
I1027 n1_m1_48000_177600 0 3.375014e-07
I1028 n1_m1_48000_182400 0 2.071574e-07
I1029 n1_m1_48000_187200 0 2.015264e-07
I1030 n1_m1_48000_192000 0 3.104649e-07
I1031 n1_m1_48000_196800 0 2.098560e-07
I1032 n1_m1_48000_201600 0 3.069927e-07
I1033 n1_m1_48000_206400 0 1.998628e-07
I1034 n1_m1_48000_211200 0 1.998628e-07
I1035 n1_m1_48000_216000 0 2.997942e-07
I1036 n1_m1_48000_220800 0 1.998628e-07
I1037 n1_m1_48000_225600 0 2.997942e-07
I1038 n1_m1_48000_230400 0 1.998628e-07
I1039 n1_m1_48000_235200 0 1.998628e-07
I1040 n1_m1_48000_240000 0 2.997942e-07
I1041 n1_m1_48000_244800 0 1.998628e-07
I1042 n1_m1_48000_249600 0 2.997942e-07
I1043 n1_m1_48000_254400 0 1.999701e-07
I1044 n1_m1_48000_259200 0 2.016126e-07
I1045 n1_m1_48000_264000 0 3.114973e-07
I1046 n1_m1_48000_268800 0 2.098560e-07
I1047 n1_m1_48000_273600 0 3.206102e-07
I1048 n1_m1_48000_278400 0 2.236959e-07
I1049 n1_m1_48000_283200 0 2.146832e-07
I1050 n1_m1_48000_288000 0 3.224790e-07
I1051 n1_m1_48000_292800 0 2.326581e-07
I1052 n1_m1_48000_297600 0 5.874871e-07
I1053 n1_m1_48000_302400 0 3.806081e-07
I1054 n1_m1_48000_307200 0 2.711576e-07
I1055 n1_m1_48000_312000 0 3.359982e-07
I1056 n1_m1_48000_316800 0 2.096608e-07
I1057 n1_m1_48000_321600 0 3.054518e-07
I1058 n1_m1_48000_326400 0 2.098560e-07
I1059 n1_m1_48000_331200 0 2.098560e-07
I1060 n1_m1_48000_336000 0 3.147839e-07
I1061 n1_m1_48000_340800 0 2.095714e-07
I1062 n1_m1_48000_345600 0 3.058268e-07
I1063 n1_m1_48000_350400 0 2.037656e-07
I1064 n1_m1_48000_355200 0 2.202442e-07
I1065 n1_m1_48000_360000 0 3.421180e-07
I1066 n1_m1_48000_364800 0 1.302059e-06
I1067 n1_m1_48000_369600 0 1.082749e-06
I1068 n1_m1_48000_374400 0 8.282207e-07
I1069 n1_m1_48000_379200 0 5.094916e-07
I1070 n1_m1_48000_384000 0 4.775615e-07
I1071 n1_m1_48000_388800 0 2.344649e-07
I1072 n1_m1_48000_393600 0 3.148726e-07
I1073 n1_m1_48000_398400 0 2.106583e-07
I1074 n1_m1_48000_403200 0 2.114421e-07
I1075 n1_m1_48000_408000 0 3.283128e-07
I1076 n1_m1_48000_412800 0 2.123542e-07
I1077 n1_m1_48000_417600 0 3.147839e-07
I1078 n1_m1_48000_422400 0 2.098560e-07
I1079 n1_m1_48000_427200 0 2.098560e-07
I1080 n1_m1_48000_432000 0 3.147839e-07
I1081 n1_m1_48000_436800 0 2.098560e-07
I1082 n1_m1_48000_441600 0 3.225329e-07
I1083 n1_m1_48000_446400 0 2.112533e-07
I1084 n1_m1_48000_451200 0 2.115921e-07
I1085 n1_m1_48000_456000 0 3.362523e-07
I1086 n1_m1_48000_460800 0 2.295458e-07
I1087 n1_m1_48000_465600 0 3.317638e-07
I1088 n1_m1_48000_470400 0 1.099246e-07
I1089 n1_m1_52800_0 0 1.511129e-07
I1090 n1_m1_52800_4800 0 1.456887e-07
I1091 n1_m1_52800_9600 0 2.051135e-07
I1092 n1_m1_52800_14400 0 1.332419e-07
I1093 n1_m1_52800_19200 0 1.332419e-07
I1094 n1_m1_52800_24000 0 1.998628e-07
I1095 n1_m1_52800_28800 0 1.517583e-07
I1096 n1_m1_52800_33600 0 2.256244e-07
I1097 n1_m1_52800_38400 0 1.449489e-07
I1098 n1_m1_52800_43200 0 1.568470e-07
I1099 n1_m1_52800_48000 0 9.007226e-07
I1100 n1_m1_52800_52800 0 6.456992e-07
I1101 n1_m1_52800_57600 0 1.403146e-06
I1102 n1_m1_52800_62400 0 6.729028e-07
I1103 n1_m1_52800_67200 0 4.943418e-07
I1104 n1_m1_52800_72000 0 2.958496e-07
I1105 n1_m1_52800_76800 0 1.596443e-07
I1106 n1_m1_52800_81600 0 2.328325e-07
I1107 n1_m1_52800_86400 0 1.662744e-07
I1108 n1_m1_52800_91200 0 1.743793e-07
I1109 n1_m1_52800_96000 0 2.571342e-07
I1110 n1_m1_52800_100800 0 1.516820e-07
I1111 n1_m1_52800_105600 0 2.156621e-07
I1112 n1_m1_52800_110400 0 1.476657e-07
I1113 n1_m1_52800_115200 0 1.754509e-07
I1114 n1_m1_52800_120000 0 4.518825e-07
I1115 n1_m1_52800_124800 0 3.374432e-07
I1116 n1_m1_52800_129600 0 2.679050e-07
I1117 n1_m1_52800_134400 0 1.669961e-07
I1118 n1_m1_52800_139200 0 1.546963e-07
I1119 n1_m1_52800_144000 0 2.315248e-07
I1120 n1_m1_52800_148800 0 1.405517e-07
I1121 n1_m1_52800_153600 0 2.204756e-07
I1122 n1_m1_52800_158400 0 2.243173e-07
I1123 n1_m1_52800_163200 0 2.475954e-07
I1124 n1_m1_52800_168000 0 5.639539e-07
I1125 n1_m1_52800_172800 0 1.920452e-07
I1126 n1_m1_52800_177600 0 2.203713e-07
I1127 n1_m1_52800_182400 0 1.372504e-07
I1128 n1_m1_52800_187200 0 1.332419e-07
I1129 n1_m1_52800_192000 0 2.069766e-07
I1130 n1_m1_52800_196800 0 1.399040e-07
I1131 n1_m1_52800_201600 0 2.046618e-07
I1132 n1_m1_52800_206400 0 1.332419e-07
I1133 n1_m1_52800_211200 0 1.332419e-07
I1134 n1_m1_52800_216000 0 1.998628e-07
I1135 n1_m1_52800_220800 0 1.332419e-07
I1136 n1_m1_52800_225600 0 1.998628e-07
I1137 n1_m1_52800_230400 0 1.332419e-07
I1138 n1_m1_52800_235200 0 1.332419e-07
I1139 n1_m1_52800_240000 0 2.001383e-07
I1140 n1_m1_52800_244800 0 1.345841e-07
I1141 n1_m1_52800_249600 0 2.008358e-07
I1142 n1_m1_52800_254400 0 1.338499e-07
I1143 n1_m1_52800_259200 0 1.387203e-07
I1144 n1_m1_52800_264000 0 2.098183e-07
I1145 n1_m1_52800_268800 0 1.399040e-07
I1146 n1_m1_52800_273600 0 2.144856e-07
I1147 n1_m1_52800_278400 0 1.503488e-07
I1148 n1_m1_52800_283200 0 1.431221e-07
I1149 n1_m1_52800_288000 0 2.126224e-07
I1150 n1_m1_52800_292800 0 1.579707e-07
I1151 n1_m1_52800_297600 0 5.468579e-07
I1152 n1_m1_52800_302400 0 4.107963e-07
I1153 n1_m1_52800_307200 0 2.389459e-07
I1154 n1_m1_52800_312000 0 2.484229e-07
I1155 n1_m1_52800_316800 0 1.509228e-07
I1156 n1_m1_52800_321600 0 2.062782e-07
I1157 n1_m1_52800_326400 0 1.399040e-07
I1158 n1_m1_52800_331200 0 1.399040e-07
I1159 n1_m1_52800_336000 0 2.098560e-07
I1160 n1_m1_52800_340800 0 1.382914e-07
I1161 n1_m1_52800_345600 0 2.004961e-07
I1162 n1_m1_52800_350400 0 1.391963e-07
I1163 n1_m1_52800_355200 0 1.500541e-07
I1164 n1_m1_52800_360000 0 2.216637e-07
I1165 n1_m1_52800_364800 0 7.026991e-07
I1166 n1_m1_52800_369600 0 8.582234e-07
I1167 n1_m1_52800_374400 0 7.380841e-07
I1168 n1_m1_52800_379200 0 4.104889e-07
I1169 n1_m1_52800_384000 0 3.117955e-07
I1170 n1_m1_52800_388800 0 1.536857e-07
I1171 n1_m1_52800_393600 0 2.103582e-07
I1172 n1_m1_52800_398400 0 1.446208e-07
I1173 n1_m1_52800_403200 0 1.418715e-07
I1174 n1_m1_52800_408000 0 2.158720e-07
I1175 n1_m1_52800_412800 0 1.415695e-07
I1176 n1_m1_52800_417600 0 2.098560e-07
I1177 n1_m1_52800_422400 0 1.399040e-07
I1178 n1_m1_52800_427200 0 1.399040e-07
I1179 n1_m1_52800_432000 0 2.098560e-07
I1180 n1_m1_52800_436800 0 1.399040e-07
I1181 n1_m1_52800_441600 0 2.150219e-07
I1182 n1_m1_52800_446400 0 1.410172e-07
I1183 n1_m1_52800_451200 0 1.423098e-07
I1184 n1_m1_52800_456000 0 2.262430e-07
I1185 n1_m1_52800_460800 0 1.544138e-07
I1186 n1_m1_52800_465600 0 2.226763e-07
I1187 n1_m1_52800_470400 0 7.344129e-08
I1188 n1_m1_57600_0 0 1.497560e-07
I1189 n1_m1_57600_4800 0 1.443854e-07
I1190 n1_m1_57600_9600 0 2.062991e-07
I1191 n1_m1_57600_14400 0 1.349074e-07
I1192 n1_m1_57600_19200 0 1.349074e-07
I1193 n1_m1_57600_24000 0 2.023611e-07
I1194 n1_m1_57600_28800 0 1.343871e-07
I1195 n1_m1_57600_33600 0 2.084988e-07
I1196 n1_m1_57600_38400 0 1.472799e-07
I1197 n1_m1_57600_43200 0 1.648536e-07
I1198 n1_m1_57600_48000 0 7.471323e-07
I1199 n1_m1_57600_52800 0 4.973882e-07
I1200 n1_m1_57600_57600 0 1.128980e-06
I1201 n1_m1_57600_62400 0 5.005062e-07
I1202 n1_m1_57600_67200 0 3.328979e-07
I1203 n1_m1_57600_72000 0 2.466944e-07
I1204 n1_m1_57600_76800 0 1.469249e-07
I1205 n1_m1_57600_81600 0 2.187299e-07
I1206 n1_m1_57600_86400 0 1.567659e-07
I1207 n1_m1_57600_91200 0 1.667641e-07
I1208 n1_m1_57600_96000 0 2.519287e-07
I1209 n1_m1_57600_100800 0 1.490677e-07
I1210 n1_m1_57600_105600 0 2.160865e-07
I1211 n1_m1_57600_110400 0 1.431426e-07
I1212 n1_m1_57600_115200 0 1.583881e-07
I1213 n1_m1_57600_120000 0 4.139094e-07
I1214 n1_m1_57600_124800 0 3.067822e-07
I1215 n1_m1_57600_129600 0 2.499237e-07
I1216 n1_m1_57600_134400 0 1.537222e-07
I1217 n1_m1_57600_139200 0 1.395511e-07
I1218 n1_m1_57600_144000 0 2.043827e-07
I1219 n1_m1_57600_148800 0 1.371322e-07
I1220 n1_m1_57600_153600 0 2.235639e-07
I1221 n1_m1_57600_158400 0 1.543003e-07
I1222 n1_m1_57600_163200 0 1.880238e-07
I1223 n1_m1_57600_168000 0 4.944230e-07
I1224 n1_m1_57600_172800 0 1.829947e-07
I1225 n1_m1_57600_177600 0 2.154736e-07
I1226 n1_m1_57600_182400 0 1.372504e-07
I1227 n1_m1_57600_187200 0 1.340464e-07
I1228 n1_m1_57600_192000 0 2.073789e-07
I1229 n1_m1_57600_196800 0 1.386901e-07
I1230 n1_m1_57600_201600 0 2.071812e-07
I1231 n1_m1_57600_206400 0 1.350627e-07
I1232 n1_m1_57600_211200 0 1.334748e-07
I1233 n1_m1_57600_216000 0 1.998628e-07
I1234 n1_m1_57600_220800 0 1.332419e-07
I1235 n1_m1_57600_225600 0 1.998628e-07
I1236 n1_m1_57600_230400 0 1.339335e-07
I1237 n1_m1_57600_235200 0 1.349074e-07
I1238 n1_m1_57600_240000 0 2.033281e-07
I1239 n1_m1_57600_244800 0 1.396188e-07
I1240 n1_m1_57600_249600 0 2.057764e-07
I1241 n1_m1_57600_254400 0 1.353944e-07
I1242 n1_m1_57600_259200 0 1.392476e-07
I1243 n1_m1_57600_264000 0 2.087974e-07
I1244 n1_m1_57600_268800 0 1.418377e-07
I1245 n1_m1_57600_273600 0 2.135258e-07
I1246 n1_m1_57600_278400 0 1.475117e-07
I1247 n1_m1_57600_283200 0 1.439831e-07
I1248 n1_m1_57600_288000 0 2.129400e-07
I1249 n1_m1_57600_292800 0 1.571097e-07
I1250 n1_m1_57600_297600 0 5.416026e-07
I1251 n1_m1_57600_302400 0 4.475360e-07
I1252 n1_m1_57600_307200 0 2.598820e-07
I1253 n1_m1_57600_312000 0 2.480430e-07
I1254 n1_m1_57600_316800 0 1.446812e-07
I1255 n1_m1_57600_321600 0 2.082080e-07
I1256 n1_m1_57600_326400 0 1.408214e-07
I1257 n1_m1_57600_331200 0 1.390148e-07
I1258 n1_m1_57600_336000 0 2.095807e-07
I1259 n1_m1_57600_340800 0 1.402568e-07
I1260 n1_m1_57600_345600 0 2.034863e-07
I1261 n1_m1_57600_350400 0 1.352654e-07
I1262 n1_m1_57600_355200 0 1.395938e-07
I1263 n1_m1_57600_360000 0 2.371346e-07
I1264 n1_m1_57600_364800 0 3.842596e-07
I1265 n1_m1_57600_369600 0 5.098942e-07
I1266 n1_m1_57600_374400 0 4.415434e-07
I1267 n1_m1_57600_379200 0 2.563744e-07
I1268 n1_m1_57600_384000 0 2.871801e-07
I1269 n1_m1_57600_388800 0 1.488926e-07
I1270 n1_m1_57600_393600 0 2.174849e-07
I1271 n1_m1_57600_398400 0 1.458924e-07
I1272 n1_m1_57600_403200 0 1.437369e-07
I1273 n1_m1_57600_408000 0 2.228465e-07
I1274 n1_m1_57600_412800 0 1.420212e-07
I1275 n1_m1_57600_417600 0 2.095102e-07
I1276 n1_m1_57600_422400 0 1.390994e-07
I1277 n1_m1_57600_427200 0 1.382385e-07
I1278 n1_m1_57600_432000 0 2.111969e-07
I1279 n1_m1_57600_436800 0 1.406379e-07
I1280 n1_m1_57600_441600 0 2.152548e-07
I1281 n1_m1_57600_446400 0 1.414874e-07
I1282 n1_m1_57600_451200 0 1.439404e-07
I1283 n1_m1_57600_456000 0 2.301245e-07
I1284 n1_m1_57600_460800 0 1.590998e-07
I1285 n1_m1_57600_465600 0 2.267745e-07
I1286 n1_m1_57600_470400 0 7.383853e-08
I1287 n1_m1_62400_0 0 1.404887e-07
I1288 n1_m1_62400_4800 0 1.395802e-07
I1289 n1_m1_62400_9600 0 2.092262e-07
I1290 n1_m1_62400_14400 0 1.398125e-07
I1291 n1_m1_62400_19200 0 1.399040e-07
I1292 n1_m1_62400_24000 0 2.098560e-07
I1293 n1_m1_62400_28800 0 1.359387e-07
I1294 n1_m1_62400_33600 0 2.071058e-07
I1295 n1_m1_62400_38400 0 1.369399e-07
I1296 n1_m1_62400_43200 0 1.486565e-07
I1297 n1_m1_62400_48000 0 2.601924e-07
I1298 n1_m1_62400_52800 0 2.708282e-07
I1299 n1_m1_62400_57600 0 5.485300e-07
I1300 n1_m1_62400_62400 0 2.081318e-07
I1301 n1_m1_62400_67200 0 1.646853e-07
I1302 n1_m1_62400_72000 0 2.117894e-07
I1303 n1_m1_62400_76800 0 1.346251e-07
I1304 n1_m1_62400_81600 0 2.006189e-07
I1305 n1_m1_62400_86400 0 1.398303e-07
I1306 n1_m1_62400_91200 0 1.489091e-07
I1307 n1_m1_62400_96000 0 2.264742e-07
I1308 n1_m1_62400_100800 0 1.475177e-07
I1309 n1_m1_62400_105600 0 2.155488e-07
I1310 n1_m1_62400_110400 0 1.412872e-07
I1311 n1_m1_62400_115200 0 1.430312e-07
I1312 n1_m1_62400_120000 0 2.402825e-07
I1313 n1_m1_62400_124800 0 1.599749e-07
I1314 n1_m1_62400_129600 0 2.289019e-07
I1315 n1_m1_62400_134400 0 1.526002e-07
I1316 n1_m1_62400_139200 0 1.367988e-07
I1317 n1_m1_62400_144000 0 2.067659e-07
I1318 n1_m1_62400_148800 0 1.395131e-07
I1319 n1_m1_62400_153600 0 2.162738e-07
I1320 n1_m1_62400_158400 0 1.531815e-07
I1321 n1_m1_62400_163200 0 1.549358e-07
I1322 n1_m1_62400_168000 0 2.473752e-07
I1323 n1_m1_62400_172800 0 1.516076e-07
I1324 n1_m1_62400_177600 0 2.107593e-07
I1325 n1_m1_62400_182400 0 1.393530e-07
I1326 n1_m1_62400_187200 0 1.391889e-07
I1327 n1_m1_62400_192000 0 2.085856e-07
I1328 n1_m1_62400_196800 0 1.338183e-07
I1329 n1_m1_62400_201600 0 2.103806e-07
I1330 n1_m1_62400_206400 0 1.370703e-07
I1331 n1_m1_62400_211200 0 1.372826e-07
I1332 n1_m1_62400_216000 0 2.003773e-07
I1333 n1_m1_62400_220800 0 1.369550e-07
I1334 n1_m1_62400_225600 0 2.011378e-07
I1335 n1_m1_62400_230400 0 1.338163e-07
I1336 n1_m1_62400_235200 0 1.372645e-07
I1337 n1_m1_62400_240000 0 2.098560e-07
I1338 n1_m1_62400_244800 0 1.410767e-07
I1339 n1_m1_62400_249600 0 2.174764e-07
I1340 n1_m1_62400_254400 0 1.446684e-07
I1341 n1_m1_62400_259200 0 1.405974e-07
I1342 n1_m1_62400_264000 0 2.056216e-07
I1343 n1_m1_62400_268800 0 1.476388e-07
I1344 n1_m1_62400_273600 0 2.151109e-07
I1345 n1_m1_62400_278400 0 1.388176e-07
I1346 n1_m1_62400_283200 0 1.461426e-07
I1347 n1_m1_62400_288000 0 2.222863e-07
I1348 n1_m1_62400_292800 0 1.619301e-07
I1349 n1_m1_62400_297600 0 3.175550e-07
I1350 n1_m1_62400_302400 0 3.035978e-07
I1351 n1_m1_62400_307200 0 2.060524e-07
I1352 n1_m1_62400_312000 0 2.420636e-07
I1353 n1_m1_62400_316800 0 1.425635e-07
I1354 n1_m1_62400_321600 0 2.162138e-07
I1355 n1_m1_62400_326400 0 1.406659e-07
I1356 n1_m1_62400_331200 0 1.391655e-07
I1357 n1_m1_62400_336000 0 2.107681e-07
I1358 n1_m1_62400_340800 0 1.464814e-07
I1359 n1_m1_62400_345600 0 2.143162e-07
I1360 n1_m1_62400_350400 0 1.401107e-07
I1361 n1_m1_62400_355200 0 1.422475e-07
I1362 n1_m1_62400_360000 0 2.248000e-07
I1363 n1_m1_62400_364800 0 4.260829e-07
I1364 n1_m1_62400_369600 0 4.883125e-07
I1365 n1_m1_62400_374400 0 5.755357e-07
I1366 n1_m1_62400_379200 0 6.657843e-07
I1367 n1_m1_62400_384000 0 1.008260e-06
I1368 n1_m1_62400_388800 0 1.655306e-07
I1369 n1_m1_62400_393600 0 2.308462e-07
I1370 n1_m1_62400_398400 0 1.549484e-07
I1371 n1_m1_62400_403200 0 1.548592e-07
I1372 n1_m1_62400_408000 0 2.243842e-07
I1373 n1_m1_62400_412800 0 1.394110e-07
I1374 n1_m1_62400_417600 0 2.095688e-07
I1375 n1_m1_62400_422400 0 1.394403e-07
I1376 n1_m1_62400_427200 0 1.389442e-07
I1377 n1_m1_62400_432000 0 2.155812e-07
I1378 n1_m1_62400_436800 0 1.406320e-07
I1379 n1_m1_62400_441600 0 2.117571e-07
I1380 n1_m1_62400_446400 0 1.412260e-07
I1381 n1_m1_62400_451200 0 1.457707e-07
I1382 n1_m1_62400_456000 0 2.377257e-07
I1383 n1_m1_62400_460800 0 1.636181e-07
I1384 n1_m1_62400_465600 0 2.282361e-07
I1385 n1_m1_62400_470400 0 7.405025e-08
I1386 n1_m1_67200_0 0 1.343428e-07
I1387 n1_m1_67200_4800 0 1.343428e-07
I1388 n1_m1_67200_9600 0 2.015849e-07
I1389 n1_m1_67200_14400 0 1.387022e-07
I1390 n1_m1_67200_19200 0 1.399040e-07
I1391 n1_m1_67200_24000 0 2.098560e-07
I1392 n1_m1_67200_28800 0 1.392042e-07
I1393 n1_m1_67200_33600 0 2.139328e-07
I1394 n1_m1_67200_38400 0 1.360172e-07
I1395 n1_m1_67200_43200 0 1.435642e-07
I1396 n1_m1_67200_48000 0 2.301979e-07
I1397 n1_m1_67200_52800 0 1.901229e-07
I1398 n1_m1_67200_57600 0 3.652232e-07
I1399 n1_m1_67200_62400 0 1.731121e-07
I1400 n1_m1_67200_67200 0 1.510152e-07
I1401 n1_m1_67200_72000 0 2.071625e-07
I1402 n1_m1_67200_76800 0 1.332419e-07
I1403 n1_m1_67200_81600 0 1.998628e-07
I1404 n1_m1_67200_86400 0 1.360708e-07
I1405 n1_m1_67200_91200 0 1.410049e-07
I1406 n1_m1_67200_96000 0 2.166309e-07
I1407 n1_m1_67200_100800 0 1.413330e-07
I1408 n1_m1_67200_105600 0 2.106723e-07
I1409 n1_m1_67200_110400 0 1.399548e-07
I1410 n1_m1_67200_115200 0 1.406702e-07
I1411 n1_m1_67200_120000 0 2.240307e-07
I1412 n1_m1_67200_124800 0 1.525432e-07
I1413 n1_m1_67200_129600 0 2.207599e-07
I1414 n1_m1_67200_134400 0 1.446819e-07
I1415 n1_m1_67200_139200 0 1.364220e-07
I1416 n1_m1_67200_144000 0 2.087616e-07
I1417 n1_m1_67200_148800 0 1.474957e-07
I1418 n1_m1_67200_153600 0 2.162767e-07
I1419 n1_m1_67200_158400 0 1.718792e-07
I1420 n1_m1_67200_163200 0 1.640116e-07
I1421 n1_m1_67200_168000 0 2.503856e-07
I1422 n1_m1_67200_172800 0 1.570848e-07
I1423 n1_m1_67200_177600 0 2.143112e-07
I1424 n1_m1_67200_182400 0 1.396229e-07
I1425 n1_m1_67200_187200 0 1.395391e-07
I1426 n1_m1_67200_192000 0 2.085856e-07
I1427 n1_m1_67200_196800 0 1.334959e-07
I1428 n1_m1_67200_201600 0 2.055535e-07
I1429 n1_m1_67200_206400 0 1.352491e-07
I1430 n1_m1_67200_211200 0 1.380973e-07
I1431 n1_m1_67200_216000 0 2.005121e-07
I1432 n1_m1_67200_220800 0 1.374315e-07
I1433 n1_m1_67200_225600 0 2.013014e-07
I1434 n1_m1_67200_230400 0 1.332419e-07
I1435 n1_m1_67200_235200 0 1.365729e-07
I1436 n1_m1_67200_240000 0 2.098560e-07
I1437 n1_m1_67200_244800 0 1.401699e-07
I1438 n1_m1_67200_249600 0 2.159374e-07
I1439 n1_m1_67200_254400 0 1.459168e-07
I1440 n1_m1_67200_259200 0 1.407791e-07
I1441 n1_m1_67200_264000 0 2.056216e-07
I1442 n1_m1_67200_268800 0 1.471304e-07
I1443 n1_m1_67200_273600 0 2.114942e-07
I1444 n1_m1_67200_278400 0 1.369021e-07
I1445 n1_m1_67200_283200 0 1.417106e-07
I1446 n1_m1_67200_288000 0 2.291997e-07
I1447 n1_m1_67200_292800 0 1.709591e-07
I1448 n1_m1_67200_297600 0 2.901165e-07
I1449 n1_m1_67200_302400 0 2.540704e-07
I1450 n1_m1_67200_307200 0 2.004306e-07
I1451 n1_m1_67200_312000 0 2.309809e-07
I1452 n1_m1_67200_316800 0 1.447584e-07
I1453 n1_m1_67200_321600 0 2.165312e-07
I1454 n1_m1_67200_326400 0 1.402210e-07
I1455 n1_m1_67200_331200 0 1.402329e-07
I1456 n1_m1_67200_336000 0 2.111431e-07
I1457 n1_m1_67200_340800 0 1.457846e-07
I1458 n1_m1_67200_345600 0 2.138437e-07
I1459 n1_m1_67200_350400 0 1.404595e-07
I1460 n1_m1_67200_355200 0 1.468815e-07
I1461 n1_m1_67200_360000 0 2.362351e-07
I1462 n1_m1_67200_364800 0 6.238637e-07
I1463 n1_m1_67200_369600 0 6.519312e-07
I1464 n1_m1_67200_374400 0 5.545832e-07
I1465 n1_m1_67200_379200 0 3.561153e-07
I1466 n1_m1_67200_384000 0 5.243381e-07
I1467 n1_m1_67200_388800 0 1.508897e-07
I1468 n1_m1_67200_393600 0 2.261349e-07
I1469 n1_m1_67200_398400 0 1.489505e-07
I1470 n1_m1_67200_403200 0 1.573404e-07
I1471 n1_m1_67200_408000 0 2.292620e-07
I1472 n1_m1_67200_412800 0 1.399816e-07
I1473 n1_m1_67200_417600 0 2.101371e-07
I1474 n1_m1_67200_422400 0 1.432960e-07
I1475 n1_m1_67200_427200 0 1.461709e-07
I1476 n1_m1_67200_432000 0 2.123968e-07
I1477 n1_m1_67200_436800 0 1.416566e-07
I1478 n1_m1_67200_441600 0 2.197407e-07
I1479 n1_m1_67200_446400 0 1.463522e-07
I1480 n1_m1_67200_451200 0 1.505866e-07
I1481 n1_m1_67200_456000 0 2.305260e-07
I1482 n1_m1_67200_460800 0 1.551733e-07
I1483 n1_m1_67200_465600 0 2.289055e-07
I1484 n1_m1_67200_470400 0 7.583670e-08
I1485 n1_m1_72000_0 0 2.026197e-07
I1486 n1_m1_72000_4800 0 2.001353e-07
I1487 n1_m1_72000_9600 0 2.998732e-07
I1488 n1_m1_72000_14400 0 2.047312e-07
I1489 n1_m1_72000_19200 0 2.064419e-07
I1490 n1_m1_72000_24000 0 3.142871e-07
I1491 n1_m1_72000_28800 0 2.074517e-07
I1492 n1_m1_72000_33600 0 3.235592e-07
I1493 n1_m1_72000_38400 0 2.068534e-07
I1494 n1_m1_72000_43200 0 2.181403e-07
I1495 n1_m1_72000_48000 0 3.436886e-07
I1496 n1_m1_72000_52800 0 2.785428e-07
I1497 n1_m1_72000_57600 0 5.007948e-07
I1498 n1_m1_72000_62400 0 2.436514e-07
I1499 n1_m1_72000_67200 0 2.222286e-07
I1500 n1_m1_72000_72000 0 3.103378e-07
I1501 n1_m1_72000_76800 0 1.998628e-07
I1502 n1_m1_72000_81600 0 2.997942e-07
I1503 n1_m1_72000_86400 0 2.021259e-07
I1504 n1_m1_72000_91200 0 2.077723e-07
I1505 n1_m1_72000_96000 0 3.154881e-07
I1506 n1_m1_72000_100800 0 2.099011e-07
I1507 n1_m1_72000_105600 0 3.147839e-07
I1508 n1_m1_72000_110400 0 2.105168e-07
I1509 n1_m1_72000_115200 0 2.169752e-07
I1510 n1_m1_72000_120000 0 3.408171e-07
I1511 n1_m1_72000_124800 0 2.401624e-07
I1512 n1_m1_72000_129600 0 3.313793e-07
I1513 n1_m1_72000_134400 0 2.068637e-07
I1514 n1_m1_72000_139200 0 2.002999e-07
I1515 n1_m1_72000_144000 0 3.076012e-07
I1516 n1_m1_72000_148800 0 2.120456e-07
I1517 n1_m1_72000_153600 0 3.309041e-07
I1518 n1_m1_72000_158400 0 3.848845e-07
I1519 n1_m1_72000_163200 0 3.020307e-07
I1520 n1_m1_72000_168000 0 4.607076e-07
I1521 n1_m1_72000_172800 0 2.463882e-07
I1522 n1_m1_72000_177600 0 3.432014e-07
I1523 n1_m1_72000_182400 0 2.062017e-07
I1524 n1_m1_72000_187200 0 2.051132e-07
I1525 n1_m1_72000_192000 0 3.135998e-07
I1526 n1_m1_72000_196800 0 2.030008e-07
I1527 n1_m1_72000_201600 0 3.071197e-07
I1528 n1_m1_72000_206400 0 2.025728e-07
I1529 n1_m1_72000_211200 0 2.071460e-07
I1530 n1_m1_72000_216000 0 3.007681e-07
I1531 n1_m1_72000_220800 0 2.004387e-07
I1532 n1_m1_72000_225600 0 2.999920e-07
I1533 n1_m1_72000_230400 0 1.998628e-07
I1534 n1_m1_72000_235200 0 2.048594e-07
I1535 n1_m1_72000_240000 0 3.147839e-07
I1536 n1_m1_72000_244800 0 2.098560e-07
I1537 n1_m1_72000_249600 0 3.197312e-07
I1538 n1_m1_72000_254400 0 2.154611e-07
I1539 n1_m1_72000_259200 0 2.106717e-07
I1540 n1_m1_72000_264000 0 3.108366e-07
I1541 n1_m1_72000_268800 0 2.131825e-07
I1542 n1_m1_72000_273600 0 3.094717e-07
I1543 n1_m1_72000_278400 0 2.114169e-07
I1544 n1_m1_72000_283200 0 2.246404e-07
I1545 n1_m1_72000_288000 0 3.441908e-07
I1546 n1_m1_72000_292800 0 2.649844e-07
I1547 n1_m1_72000_297600 0 7.711344e-07
I1548 n1_m1_72000_302400 0 6.127104e-07
I1549 n1_m1_72000_307200 0 4.360342e-07
I1550 n1_m1_72000_312000 0 3.701759e-07
I1551 n1_m1_72000_316800 0 2.186300e-07
I1552 n1_m1_72000_321600 0 3.294908e-07
I1553 n1_m1_72000_326400 0 2.160604e-07
I1554 n1_m1_72000_331200 0 2.161518e-07
I1555 n1_m1_72000_336000 0 3.206349e-07
I1556 n1_m1_72000_340800 0 2.134692e-07
I1557 n1_m1_72000_345600 0 3.184736e-07
I1558 n1_m1_72000_350400 0 2.137323e-07
I1559 n1_m1_72000_355200 0 2.182185e-07
I1560 n1_m1_72000_360000 0 3.643749e-07
I1561 n1_m1_72000_364800 0 1.063208e-06
I1562 n1_m1_72000_369600 0 1.216511e-06
I1563 n1_m1_72000_374400 0 8.902333e-07
I1564 n1_m1_72000_379200 0 6.441145e-07
I1565 n1_m1_72000_384000 0 9.890651e-07
I1566 n1_m1_72000_388800 0 2.392768e-07
I1567 n1_m1_72000_393600 0 3.610405e-07
I1568 n1_m1_72000_398400 0 2.153945e-07
I1569 n1_m1_72000_403200 0 2.091907e-07
I1570 n1_m1_72000_408000 0 3.457667e-07
I1571 n1_m1_72000_412800 0 2.182259e-07
I1572 n1_m1_72000_417600 0 3.226056e-07
I1573 n1_m1_72000_422400 0 2.238577e-07
I1574 n1_m1_72000_427200 0 2.268758e-07
I1575 n1_m1_72000_432000 0 3.151719e-07
I1576 n1_m1_72000_436800 0 2.141585e-07
I1577 n1_m1_72000_441600 0 3.444957e-07
I1578 n1_m1_72000_446400 0 2.207883e-07
I1579 n1_m1_72000_451200 0 2.129648e-07
I1580 n1_m1_72000_456000 0 3.371410e-07
I1581 n1_m1_72000_460800 0 2.423729e-07
I1582 n1_m1_72000_465600 0 3.458919e-07
I1583 n1_m1_72000_470400 0 1.116322e-07
I1584 n1_m1_76800_0 0 1.424446e-07
I1585 n1_m1_76800_4800 0 1.380691e-07
I1586 n1_m1_76800_9600 0 2.063285e-07
I1587 n1_m1_76800_14400 0 1.341813e-07
I1588 n1_m1_76800_19200 0 1.334675e-07
I1589 n1_m1_76800_24000 0 2.054257e-07
I1590 n1_m1_76800_28800 0 1.356696e-07
I1591 n1_m1_76800_33600 0 2.115196e-07
I1592 n1_m1_76800_38400 0 1.368830e-07
I1593 n1_m1_76800_43200 0 1.413154e-07
I1594 n1_m1_76800_48000 0 2.217323e-07
I1595 n1_m1_76800_52800 0 1.611819e-07
I1596 n1_m1_76800_57600 0 2.791118e-07
I1597 n1_m1_76800_62400 0 1.618098e-07
I1598 n1_m1_76800_67200 0 1.480622e-07
I1599 n1_m1_76800_72000 0 2.068919e-07
I1600 n1_m1_76800_76800 0 1.360787e-07
I1601 n1_m1_76800_81600 0 2.010233e-07
I1602 n1_m1_76800_86400 0 1.348261e-07
I1603 n1_m1_76800_91200 0 1.386289e-07
I1604 n1_m1_76800_96000 0 2.098560e-07
I1605 n1_m1_76800_100800 0 1.399040e-07
I1606 n1_m1_76800_105600 0 2.099849e-07
I1607 n1_m1_76800_110400 0 1.435522e-07
I1608 n1_m1_76800_115200 0 1.462032e-07
I1609 n1_m1_76800_120000 0 2.430578e-07
I1610 n1_m1_76800_124800 0 1.817961e-07
I1611 n1_m1_76800_129600 0 2.305178e-07
I1612 n1_m1_76800_134400 0 1.373633e-07
I1613 n1_m1_76800_139200 0 1.332419e-07
I1614 n1_m1_76800_144000 0 2.006549e-07
I1615 n1_m1_76800_148800 0 1.408353e-07
I1616 n1_m1_76800_153600 0 2.380802e-07
I1617 n1_m1_76800_158400 0 3.545438e-07
I1618 n1_m1_76800_163200 0 2.961962e-07
I1619 n1_m1_76800_168000 0 5.337130e-07
I1620 n1_m1_76800_172800 0 1.690370e-07
I1621 n1_m1_76800_177600 0 2.373371e-07
I1622 n1_m1_76800_182400 0 1.398662e-07
I1623 n1_m1_76800_187200 0 1.364600e-07
I1624 n1_m1_76800_192000 0 2.098560e-07
I1625 n1_m1_76800_196800 0 1.383514e-07
I1626 n1_m1_76800_201600 0 2.049491e-07
I1627 n1_m1_76800_206400 0 1.378301e-07
I1628 n1_m1_76800_211200 0 1.361079e-07
I1629 n1_m1_76800_216000 0 2.034963e-07
I1630 n1_m1_76800_220800 0 1.332419e-07
I1631 n1_m1_76800_225600 0 1.998628e-07
I1632 n1_m1_76800_230400 0 1.332419e-07
I1633 n1_m1_76800_235200 0 1.365729e-07
I1634 n1_m1_76800_240000 0 2.098560e-07
I1635 n1_m1_76800_244800 0 1.399040e-07
I1636 n1_m1_76800_249600 0 2.098560e-07
I1637 n1_m1_76800_254400 0 1.399040e-07
I1638 n1_m1_76800_259200 0 1.399040e-07
I1639 n1_m1_76800_264000 0 2.098560e-07
I1640 n1_m1_76800_268800 0 1.399040e-07
I1641 n1_m1_76800_273600 0 2.014154e-07
I1642 n1_m1_76800_278400 0 1.447594e-07
I1643 n1_m1_76800_283200 0 1.564463e-07
I1644 n1_m1_76800_288000 0 2.323444e-07
I1645 n1_m1_76800_292800 0 1.811677e-07
I1646 n1_m1_76800_297600 0 8.227985e-07
I1647 n1_m1_76800_302400 0 8.821983e-07
I1648 n1_m1_76800_307200 0 8.509174e-07
I1649 n1_m1_76800_312000 0 7.075037e-07
I1650 n1_m1_76800_316800 0 1.716831e-07
I1651 n1_m1_76800_321600 0 2.190747e-07
I1652 n1_m1_76800_326400 0 1.485187e-07
I1653 n1_m1_76800_331200 0 1.555554e-07
I1654 n1_m1_76800_336000 0 2.336094e-07
I1655 n1_m1_76800_340800 0 1.492466e-07
I1656 n1_m1_76800_345600 0 2.182994e-07
I1657 n1_m1_76800_350400 0 1.460687e-07
I1658 n1_m1_76800_355200 0 1.444864e-07
I1659 n1_m1_76800_360000 0 2.383727e-07
I1660 n1_m1_76800_364800 0 5.645634e-07
I1661 n1_m1_76800_369600 0 6.287669e-07
I1662 n1_m1_76800_374400 0 6.592033e-07
I1663 n1_m1_76800_379200 0 8.561198e-07
I1664 n1_m1_76800_384000 0 1.539294e-06
I1665 n1_m1_76800_388800 0 3.598095e-07
I1666 n1_m1_76800_393600 0 2.542246e-07
I1667 n1_m1_76800_398400 0 1.602206e-07
I1668 n1_m1_76800_403200 0 1.410267e-07
I1669 n1_m1_76800_408000 0 2.117033e-07
I1670 n1_m1_76800_412800 0 1.456419e-07
I1671 n1_m1_76800_417600 0 2.289305e-07
I1672 n1_m1_76800_422400 0 1.544262e-07
I1673 n1_m1_76800_427200 0 1.450982e-07
I1674 n1_m1_76800_432000 0 2.116734e-07
I1675 n1_m1_76800_436800 0 1.448986e-07
I1676 n1_m1_76800_441600 0 2.212572e-07
I1677 n1_m1_76800_446400 0 1.434173e-07
I1678 n1_m1_76800_451200 0 1.497421e-07
I1679 n1_m1_76800_456000 0 3.680558e-07
I1680 n1_m1_76800_460800 0 3.227331e-07
I1681 n1_m1_76800_465600 0 2.869741e-07
I1682 n1_m1_76800_470400 0 7.873797e-08
I1683 n1_m1_81600_0 0 2.294446e-07
I1684 n1_m1_81600_4800 0 2.266406e-07
I1685 n1_m1_81600_9600 0 3.240066e-07
I1686 n1_m1_81600_14400 0 2.085146e-07
I1687 n1_m1_81600_19200 0 2.026478e-07
I1688 n1_m1_81600_24000 0 3.010186e-07
I1689 n1_m1_81600_28800 0 2.045479e-07
I1690 n1_m1_81600_33600 0 3.252985e-07
I1691 n1_m1_81600_38400 0 2.073749e-07
I1692 n1_m1_81600_43200 0 2.113021e-07
I1693 n1_m1_81600_48000 0 3.215694e-07
I1694 n1_m1_81600_52800 0 2.266378e-07
I1695 n1_m1_81600_57600 0 3.867896e-07
I1696 n1_m1_81600_62400 0 2.340741e-07
I1697 n1_m1_81600_67200 0 2.142436e-07
I1698 n1_m1_81600_72000 0 3.078205e-07
I1699 n1_m1_81600_76800 0 2.063838e-07
I1700 n1_m1_81600_81600 0 3.102937e-07
I1701 n1_m1_81600_86400 0 2.005109e-07
I1702 n1_m1_81600_91200 0 2.044941e-07
I1703 n1_m1_81600_96000 0 3.139155e-07
I1704 n1_m1_81600_100800 0 2.098560e-07
I1705 n1_m1_81600_105600 0 3.148367e-07
I1706 n1_m1_81600_110400 0 2.112802e-07
I1707 n1_m1_81600_115200 0 2.125742e-07
I1708 n1_m1_81600_120000 0 3.889520e-07
I1709 n1_m1_81600_124800 0 3.019653e-07
I1710 n1_m1_81600_129600 0 3.548365e-07
I1711 n1_m1_81600_134400 0 2.091777e-07
I1712 n1_m1_81600_139200 0 2.042486e-07
I1713 n1_m1_81600_144000 0 3.095685e-07
I1714 n1_m1_81600_148800 0 2.222114e-07
I1715 n1_m1_81600_153600 0 3.731779e-07
I1716 n1_m1_81600_158400 0 5.557102e-07
I1717 n1_m1_81600_163200 0 6.091061e-07
I1718 n1_m1_81600_168000 0 1.494863e-06
I1719 n1_m1_81600_172800 0 3.987259e-07
I1720 n1_m1_81600_177600 0 3.765284e-07
I1721 n1_m1_81600_182400 0 2.118885e-07
I1722 n1_m1_81600_187200 0 2.046900e-07
I1723 n1_m1_81600_192000 0 3.147839e-07
I1724 n1_m1_81600_196800 0 2.075271e-07
I1725 n1_m1_81600_201600 0 3.011808e-07
I1726 n1_m1_81600_206400 0 2.016488e-07
I1727 n1_m1_81600_211200 0 2.027820e-07
I1728 n1_m1_81600_216000 0 3.128914e-07
I1729 n1_m1_81600_220800 0 2.022994e-07
I1730 n1_m1_81600_225600 0 3.025093e-07
I1731 n1_m1_81600_230400 0 2.046663e-07
I1732 n1_m1_81600_235200 0 2.048594e-07
I1733 n1_m1_81600_240000 0 3.147839e-07
I1734 n1_m1_81600_244800 0 2.098560e-07
I1735 n1_m1_81600_249600 0 3.147839e-07
I1736 n1_m1_81600_254400 0 2.098560e-07
I1737 n1_m1_81600_259200 0 2.098560e-07
I1738 n1_m1_81600_264000 0 3.095627e-07
I1739 n1_m1_81600_268800 0 2.089007e-07
I1740 n1_m1_81600_273600 0 3.094852e-07
I1741 n1_m1_81600_278400 0 2.185056e-07
I1742 n1_m1_81600_283200 0 2.245916e-07
I1743 n1_m1_81600_288000 0 4.253806e-07
I1744 n1_m1_81600_292800 0 5.005513e-07
I1745 n1_m1_81600_297600 0 1.260282e-06
I1746 n1_m1_81600_302400 0 1.087422e-06
I1747 n1_m1_81600_307200 0 9.308922e-07
I1748 n1_m1_81600_312000 0 6.275408e-07
I1749 n1_m1_81600_316800 0 2.401422e-07
I1750 n1_m1_81600_321600 0 3.333962e-07
I1751 n1_m1_81600_326400 0 2.381050e-07
I1752 n1_m1_81600_331200 0 2.554143e-07
I1753 n1_m1_81600_336000 0 3.846459e-07
I1754 n1_m1_81600_340800 0 2.354453e-07
I1755 n1_m1_81600_345600 0 3.316127e-07
I1756 n1_m1_81600_350400 0 2.254195e-07
I1757 n1_m1_81600_355200 0 2.221712e-07
I1758 n1_m1_81600_360000 0 3.539143e-07
I1759 n1_m1_81600_364800 0 1.049141e-06
I1760 n1_m1_81600_369600 0 1.106948e-06
I1761 n1_m1_81600_374400 0 9.657570e-07
I1762 n1_m1_81600_379200 0 9.308779e-07
I1763 n1_m1_81600_384000 0 1.742107e-06
I1764 n1_m1_81600_388800 0 5.381332e-07
I1765 n1_m1_81600_393600 0 4.634183e-07
I1766 n1_m1_81600_398400 0 2.121436e-07
I1767 n1_m1_81600_403200 0 2.072920e-07
I1768 n1_m1_81600_408000 0 3.435566e-07
I1769 n1_m1_81600_412800 0 2.239367e-07
I1770 n1_m1_81600_417600 0 4.087427e-07
I1771 n1_m1_81600_422400 0 2.636125e-07
I1772 n1_m1_81600_427200 0 2.177255e-07
I1773 n1_m1_81600_432000 0 3.384287e-07
I1774 n1_m1_81600_436800 0 2.279296e-07
I1775 n1_m1_81600_441600 0 3.294765e-07
I1776 n1_m1_81600_446400 0 2.177003e-07
I1777 n1_m1_81600_451200 0 2.501181e-07
I1778 n1_m1_81600_456000 0 6.435719e-07
I1779 n1_m1_81600_460800 0 5.311666e-07
I1780 n1_m1_81600_465600 0 4.449144e-07
I1781 n1_m1_81600_470400 0 1.199981e-07
I1782 n1_m1_86400_0 0 7.974513e-08
I1783 n1_m1_86400_4800 0 8.003963e-08
I1784 n1_m1_86400_9600 0 1.127615e-07
I1785 n1_m1_86400_14400 0 7.060473e-08
I1786 n1_m1_86400_19200 0 6.962735e-08
I1787 n1_m1_86400_24000 0 1.005400e-07
I1788 n1_m1_86400_28800 0 6.673410e-08
I1789 n1_m1_86400_33600 0 9.993141e-08
I1790 n1_m1_86400_38400 0 6.662094e-08
I1791 n1_m1_86400_43200 0 6.792642e-08
I1792 n1_m1_86400_48000 0 1.047780e-07
I1793 n1_m1_86400_52800 0 7.308770e-08
I1794 n1_m1_86400_57600 0 1.228295e-07
I1795 n1_m1_86400_62400 0 7.409929e-08
I1796 n1_m1_86400_67200 0 7.009828e-08
I1797 n1_m1_86400_72000 0 1.003407e-07
I1798 n1_m1_86400_76800 0 6.859196e-08
I1799 n1_m1_86400_81600 0 1.040872e-07
I1800 n1_m1_86400_86400 0 6.701567e-08
I1801 n1_m1_86400_91200 0 6.662094e-08
I1802 n1_m1_86400_96000 0 1.033754e-07
I1803 n1_m1_86400_100800 0 6.995199e-08
I1804 n1_m1_86400_105600 0 1.049280e-07
I1805 n1_m1_86400_110400 0 6.995199e-08
I1806 n1_m1_86400_115200 0 7.033308e-08
I1807 n1_m1_86400_120000 0 1.289721e-07
I1808 n1_m1_86400_124800 0 1.026723e-07
I1809 n1_m1_86400_129600 0 1.191909e-07
I1810 n1_m1_86400_134400 0 6.983357e-08
I1811 n1_m1_86400_139200 0 6.823359e-08
I1812 n1_m1_86400_144000 0 1.028249e-07
I1813 n1_m1_86400_148800 0 6.888095e-08
I1814 n1_m1_86400_153600 0 1.131612e-07
I1815 n1_m1_86400_158400 0 1.453711e-07
I1816 n1_m1_86400_163200 0 1.918954e-07
I1817 n1_m1_86400_168000 0 5.972183e-07
I1818 n1_m1_86400_172800 0 1.749714e-07
I1819 n1_m1_86400_177600 0 1.312362e-07
I1820 n1_m1_86400_182400 0 7.094001e-08
I1821 n1_m1_86400_187200 0 6.824053e-08
I1822 n1_m1_86400_192000 0 1.049122e-07
I1823 n1_m1_86400_196800 0 6.977304e-08
I1824 n1_m1_86400_201600 0 1.006209e-07
I1825 n1_m1_86400_206400 0 6.720024e-08
I1826 n1_m1_86400_211200 0 6.952963e-08
I1827 n1_m1_86400_216000 0 1.055043e-07
I1828 n1_m1_86400_220800 0 6.854053e-08
I1829 n1_m1_86400_225600 0 1.014429e-07
I1830 n1_m1_86400_230400 0 6.864507e-08
I1831 n1_m1_86400_235200 0 6.859699e-08
I1832 n1_m1_86400_240000 0 1.049280e-07
I1833 n1_m1_86400_244800 0 6.987699e-08
I1834 n1_m1_86400_249600 0 1.044793e-07
I1835 n1_m1_86400_254400 0 6.989804e-08
I1836 n1_m1_86400_259200 0 6.995199e-08
I1837 n1_m1_86400_264000 0 1.028108e-07
I1838 n1_m1_86400_268800 0 7.119623e-08
I1839 n1_m1_86400_273600 0 1.093509e-07
I1840 n1_m1_86400_278400 0 7.306462e-08
I1841 n1_m1_86400_283200 0 7.171105e-08
I1842 n1_m1_86400_288000 0 1.714982e-07
I1843 n1_m1_86400_292800 0 2.607947e-07
I1844 n1_m1_86400_297600 0 3.634212e-07
I1845 n1_m1_86400_302400 0 3.313351e-07
I1846 n1_m1_86400_307200 0 3.118890e-07
I1847 n1_m1_86400_312000 0 1.960361e-07
I1848 n1_m1_86400_316800 0 7.746012e-08
I1849 n1_m1_86400_321600 0 1.103743e-07
I1850 n1_m1_86400_326400 0 8.203744e-08
I1851 n1_m1_86400_331200 0 8.859044e-08
I1852 n1_m1_86400_336000 0 1.324920e-07
I1853 n1_m1_86400_340800 0 8.116652e-08
I1854 n1_m1_86400_345600 0 1.123722e-07
I1855 n1_m1_86400_350400 0 7.513887e-08
I1856 n1_m1_86400_355200 0 7.469342e-08
I1857 n1_m1_86400_360000 0 1.303844e-07
I1858 n1_m1_86400_364800 0 4.635853e-07
I1859 n1_m1_86400_369600 0 4.164665e-07
I1860 n1_m1_86400_374400 0 3.373374e-07
I1861 n1_m1_86400_379200 0 3.156213e-07
I1862 n1_m1_86400_384000 0 8.435542e-07
I1863 n1_m1_86400_388800 0 4.279147e-07
I1864 n1_m1_86400_393600 0 3.136470e-07
I1865 n1_m1_86400_398400 0 7.030138e-08
I1866 n1_m1_86400_403200 0 6.768504e-08
I1867 n1_m1_86400_408000 0 1.044622e-07
I1868 n1_m1_86400_412800 0 7.232145e-08
I1869 n1_m1_86400_417600 0 1.612863e-07
I1870 n1_m1_86400_422400 0 1.028484e-07
I1871 n1_m1_86400_427200 0 7.287347e-08
I1872 n1_m1_86400_432000 0 1.193189e-07
I1873 n1_m1_86400_436800 0 7.896572e-08
I1874 n1_m1_86400_441600 0 1.103473e-07
I1875 n1_m1_86400_446400 0 7.638980e-08
I1876 n1_m1_86400_451200 0 7.982264e-08
I1877 n1_m1_86400_456000 0 1.345085e-07
I1878 n1_m1_86400_460800 0 9.294982e-08
I1879 n1_m1_86400_465600 0 1.238853e-07
I1880 n1_m1_86400_470400 0 3.894949e-08
I1881 n1_m1_91200_0 0 1.585917e-07
I1882 n1_m1_91200_4800 0 1.778158e-07
I1883 n1_m1_91200_9600 0 2.327329e-07
I1884 n1_m1_91200_14400 0 1.400688e-07
I1885 n1_m1_91200_19200 0 1.414355e-07
I1886 n1_m1_91200_24000 0 2.031525e-07
I1887 n1_m1_91200_28800 0 1.345792e-07
I1888 n1_m1_91200_33600 0 1.998628e-07
I1889 n1_m1_91200_38400 0 1.332419e-07
I1890 n1_m1_91200_43200 0 1.332419e-07
I1891 n1_m1_91200_48000 0 2.066378e-07
I1892 n1_m1_91200_52800 0 1.399040e-07
I1893 n1_m1_91200_57600 0 2.125306e-07
I1894 n1_m1_91200_62400 0 1.406659e-07
I1895 n1_m1_91200_67200 0 1.391982e-07
I1896 n1_m1_91200_72000 0 2.006815e-07
I1897 n1_m1_91200_76800 0 1.332419e-07
I1898 n1_m1_91200_81600 0 2.062510e-07
I1899 n1_m1_91200_86400 0 1.398088e-07
I1900 n1_m1_91200_91200 0 1.332419e-07
I1901 n1_m1_91200_96000 0 2.067508e-07
I1902 n1_m1_91200_100800 0 1.399040e-07
I1903 n1_m1_91200_105600 0 2.098560e-07
I1904 n1_m1_91200_110400 0 1.399040e-07
I1905 n1_m1_91200_115200 0 1.403238e-07
I1906 n1_m1_91200_120000 0 2.166905e-07
I1907 n1_m1_91200_124800 0 1.510263e-07
I1908 n1_m1_91200_129600 0 2.230627e-07
I1909 n1_m1_91200_134400 0 1.373633e-07
I1910 n1_m1_91200_139200 0 1.332419e-07
I1911 n1_m1_91200_144000 0 2.061950e-07
I1912 n1_m1_91200_148800 0 1.379014e-07
I1913 n1_m1_91200_153600 0 2.176647e-07
I1914 n1_m1_91200_158400 0 1.621115e-07
I1915 n1_m1_91200_163200 0 2.293832e-07
I1916 n1_m1_91200_168000 0 5.817557e-07
I1917 n1_m1_91200_172800 0 2.959015e-07
I1918 n1_m1_91200_177600 0 2.707672e-07
I1919 n1_m1_91200_182400 0 1.479211e-07
I1920 n1_m1_91200_187200 0 1.366858e-07
I1921 n1_m1_91200_192000 0 2.089466e-07
I1922 n1_m1_91200_196800 0 1.482892e-07
I1923 n1_m1_91200_201600 0 2.103060e-07
I1924 n1_m1_91200_206400 0 1.393588e-07
I1925 n1_m1_91200_211200 0 1.399040e-07
I1926 n1_m1_91200_216000 0 2.222204e-07
I1927 n1_m1_91200_220800 0 1.552042e-07
I1928 n1_m1_91200_225600 0 2.080955e-07
I1929 n1_m1_91200_230400 0 1.387748e-07
I1930 n1_m1_91200_235200 0 1.432350e-07
I1931 n1_m1_91200_240000 0 2.098560e-07
I1932 n1_m1_91200_244800 0 1.382949e-07
I1933 n1_m1_91200_249600 0 2.002298e-07
I1934 n1_m1_91200_254400 0 1.387466e-07
I1935 n1_m1_91200_259200 0 1.399040e-07
I1936 n1_m1_91200_264000 0 2.075235e-07
I1937 n1_m1_91200_268800 0 1.388777e-07
I1938 n1_m1_91200_273600 0 2.075412e-07
I1939 n1_m1_91200_278400 0 1.418800e-07
I1940 n1_m1_91200_283200 0 1.463402e-07
I1941 n1_m1_91200_288000 0 4.195631e-07
I1942 n1_m1_91200_292800 0 8.428671e-07
I1943 n1_m1_91200_297600 0 8.252293e-07
I1944 n1_m1_91200_302400 0 8.963894e-07
I1945 n1_m1_91200_307200 0 1.047902e-06
I1946 n1_m1_91200_312000 0 5.430848e-07
I1947 n1_m1_91200_316800 0 1.529705e-07
I1948 n1_m1_91200_321600 0 2.084206e-07
I1949 n1_m1_91200_326400 0 1.435738e-07
I1950 n1_m1_91200_331200 0 1.435738e-07
I1951 n1_m1_91200_336000 0 2.161537e-07
I1952 n1_m1_91200_340800 0 1.471969e-07
I1953 n1_m1_91200_345600 0 2.178176e-07
I1954 n1_m1_91200_350400 0 1.435738e-07
I1955 n1_m1_91200_355200 0 1.434676e-07
I1956 n1_m1_91200_360000 0 2.326877e-07
I1957 n1_m1_91200_364800 0 8.431578e-07
I1958 n1_m1_91200_369600 0 8.831076e-07
I1959 n1_m1_91200_374400 0 8.623981e-07
I1960 n1_m1_91200_379200 0 1.006826e-06
I1961 n1_m1_91200_384000 0 1.645252e-06
I1962 n1_m1_91200_388800 0 4.456194e-07
I1963 n1_m1_91200_393600 0 5.081356e-07
I1964 n1_m1_91200_398400 0 1.436355e-07
I1965 n1_m1_91200_403200 0 1.363143e-07
I1966 n1_m1_91200_408000 0 2.108937e-07
I1967 n1_m1_91200_412800 0 1.439831e-07
I1968 n1_m1_91200_417600 0 2.198491e-07
I1969 n1_m1_91200_422400 0 1.465661e-07
I1970 n1_m1_91200_427200 0 1.465661e-07
I1971 n1_m1_91200_432000 0 2.164004e-07
I1972 n1_m1_91200_436800 0 1.435738e-07
I1973 n1_m1_91200_441600 0 2.121885e-07
I1974 n1_m1_91200_446400 0 1.399040e-07
I1975 n1_m1_91200_451200 0 1.405415e-07
I1976 n1_m1_91200_456000 0 2.245306e-07
I1977 n1_m1_91200_460800 0 1.690760e-07
I1978 n1_m1_91200_465600 0 2.428559e-07
I1979 n1_m1_91200_470400 0 7.556960e-08
I1980 n1_m1_96000_0 0 2.484123e-07
I1981 n1_m1_96000_4800 0 2.713528e-07
I1982 n1_m1_96000_9600 0 3.482545e-07
I1983 n1_m1_96000_14400 0 2.100270e-07
I1984 n1_m1_96000_19200 0 2.111452e-07
I1985 n1_m1_96000_24000 0 3.015148e-07
I1986 n1_m1_96000_28800 0 1.998628e-07
I1987 n1_m1_96000_33600 0 2.997942e-07
I1988 n1_m1_96000_38400 0 1.998628e-07
I1989 n1_m1_96000_43200 0 1.998628e-07
I1990 n1_m1_96000_48000 0 3.099568e-07
I1991 n1_m1_96000_52800 0 2.098560e-07
I1992 n1_m1_96000_57600 0 3.156520e-07
I1993 n1_m1_96000_62400 0 2.110134e-07
I1994 n1_m1_96000_67200 0 2.100774e-07
I1995 n1_m1_96000_72000 0 3.043522e-07
I1996 n1_m1_96000_76800 0 2.021776e-07
I1997 n1_m1_96000_81600 0 3.112009e-07
I1998 n1_m1_96000_86400 0 2.073718e-07
I1999 n1_m1_96000_91200 0 2.010202e-07
I2000 n1_m1_96000_96000 0 3.106656e-07
I2001 n1_m1_96000_100800 0 2.101061e-07
I2002 n1_m1_96000_105600 0 3.156275e-07
I2003 n1_m1_96000_110400 0 2.098560e-07
I2004 n1_m1_96000_115200 0 2.097235e-07
I2005 n1_m1_96000_120000 0 3.156728e-07
I2006 n1_m1_96000_124800 0 2.196515e-07
I2007 n1_m1_96000_129600 0 3.276122e-07
I2008 n1_m1_96000_134400 0 2.060450e-07
I2009 n1_m1_96000_139200 0 1.998628e-07
I2010 n1_m1_96000_144000 0 3.102955e-07
I2011 n1_m1_96000_148800 0 2.121002e-07
I2012 n1_m1_96000_153600 0 3.298497e-07
I2013 n1_m1_96000_158400 0 2.255804e-07
I2014 n1_m1_96000_163200 0 2.721264e-07
I2015 n1_m1_96000_168000 0 5.356578e-07
I2016 n1_m1_96000_172800 0 2.817771e-07
I2017 n1_m1_96000_177600 0 3.602612e-07
I2018 n1_m1_96000_182400 0 2.170408e-07
I2019 n1_m1_96000_187200 0 2.050288e-07
I2020 n1_m1_96000_192000 0 3.110570e-07
I2021 n1_m1_96000_196800 0 2.121191e-07
I2022 n1_m1_96000_201600 0 3.083608e-07
I2023 n1_m1_96000_206400 0 2.091926e-07
I2024 n1_m1_96000_211200 0 2.119181e-07
I2025 n1_m1_96000_216000 0 3.354889e-07
I2026 n1_m1_96000_220800 0 2.251043e-07
I2027 n1_m1_96000_225600 0 3.050919e-07
I2028 n1_m1_96000_230400 0 2.048214e-07
I2029 n1_m1_96000_235200 0 2.102512e-07
I2030 n1_m1_96000_240000 0 3.119066e-07
I2031 n1_m1_96000_244800 0 2.037721e-07
I2032 n1_m1_96000_249600 0 3.094831e-07
I2033 n1_m1_96000_254400 0 2.093165e-07
I2034 n1_m1_96000_259200 0 2.098560e-07
I2035 n1_m1_96000_264000 0 3.147839e-07
I2036 n1_m1_96000_268800 0 2.048943e-07
I2037 n1_m1_96000_273600 0 3.131640e-07
I2038 n1_m1_96000_278400 0 2.137540e-07
I2039 n1_m1_96000_283200 0 2.167815e-07
I2040 n1_m1_96000_288000 0 5.868176e-07
I2041 n1_m1_96000_292800 0 1.107624e-06
I2042 n1_m1_96000_297600 0 1.772729e-06
I2043 n1_m1_96000_302400 0 1.707027e-06
I2044 n1_m1_96000_307200 0 1.575161e-06
I2045 n1_m1_96000_312000 0 1.076846e-06
I2046 n1_m1_96000_316800 0 2.165373e-07
I2047 n1_m1_96000_321600 0 3.177376e-07
I2048 n1_m1_96000_326400 0 2.098560e-07
I2049 n1_m1_96000_331200 0 2.092380e-07
I2050 n1_m1_96000_336000 0 3.081259e-07
I2051 n1_m1_96000_340800 0 2.097684e-07
I2052 n1_m1_96000_345600 0 3.094763e-07
I2053 n1_m1_96000_350400 0 2.078001e-07
I2054 n1_m1_96000_355200 0 2.126065e-07
I2055 n1_m1_96000_360000 0 3.494924e-07
I2056 n1_m1_96000_364800 0 5.450862e-07
I2057 n1_m1_96000_369600 0 9.081812e-07
I2058 n1_m1_96000_374400 0 1.255177e-06
I2059 n1_m1_96000_379200 0 1.507758e-06
I2060 n1_m1_96000_384000 0 2.409384e-06
I2061 n1_m1_96000_388800 0 1.019663e-06
I2062 n1_m1_96000_393600 0 1.004146e-06
I2063 n1_m1_96000_398400 0 2.080541e-07
I2064 n1_m1_96000_403200 0 2.075531e-07
I2065 n1_m1_96000_408000 0 3.353351e-07
I2066 n1_m1_96000_412800 0 2.105843e-07
I2067 n1_m1_96000_417600 0 3.245652e-07
I2068 n1_m1_96000_422400 0 2.129612e-07
I2069 n1_m1_96000_427200 0 2.129612e-07
I2070 n1_m1_96000_432000 0 3.158629e-07
I2071 n1_m1_96000_436800 0 2.098560e-07
I2072 n1_m1_96000_441600 0 3.192275e-07
I2073 n1_m1_96000_446400 0 2.106573e-07
I2074 n1_m1_96000_451200 0 2.100570e-07
I2075 n1_m1_96000_456000 0 3.305144e-07
I2076 n1_m1_96000_460800 0 2.523940e-07
I2077 n1_m1_96000_465600 0 3.615886e-07
I2078 n1_m1_96000_470400 0 1.149084e-07
I2079 n1_m1_100800_0 0 1.675074e-07
I2080 n1_m1_100800_4800 0 1.819747e-07
I2081 n1_m1_100800_9600 0 2.317712e-07
I2082 n1_m1_100800_14400 0 1.410325e-07
I2083 n1_m1_100800_19200 0 1.406944e-07
I2084 n1_m1_100800_24000 0 2.021044e-07
I2085 n1_m1_100800_28800 0 1.332419e-07
I2086 n1_m1_100800_33600 0 2.002471e-07
I2087 n1_m1_100800_38400 0 1.346816e-07
I2088 n1_m1_100800_43200 0 1.346816e-07
I2089 n1_m1_100800_48000 0 2.073333e-07
I2090 n1_m1_100800_52800 0 1.399040e-07
I2091 n1_m1_100800_57600 0 2.145773e-07
I2092 n1_m1_100800_62400 0 1.461991e-07
I2093 n1_m1_100800_67200 0 1.461602e-07
I2094 n1_m1_100800_72000 0 2.187933e-07
I2095 n1_m1_100800_76800 0 1.458321e-07
I2096 n1_m1_100800_81600 0 2.192007e-07
I2097 n1_m1_100800_86400 0 1.437714e-07
I2098 n1_m1_100800_91200 0 1.395370e-07
I2099 n1_m1_100800_96000 0 2.099350e-07
I2100 n1_m1_100800_100800 0 1.423136e-07
I2101 n1_m1_100800_105600 0 2.155115e-07
I2102 n1_m1_100800_110400 0 1.401907e-07
I2103 n1_m1_100800_115200 0 1.391838e-07
I2104 n1_m1_100800_120000 0 2.039727e-07
I2105 n1_m1_100800_124800 0 1.438884e-07
I2106 n1_m1_100800_129600 0 2.178731e-07
I2107 n1_m1_100800_134400 0 1.373633e-07
I2108 n1_m1_100800_139200 0 1.332419e-07
I2109 n1_m1_100800_144000 0 2.066014e-07
I2110 n1_m1_100800_148800 0 1.400275e-07
I2111 n1_m1_100800_153600 0 2.187655e-07
I2112 n1_m1_100800_158400 0 1.485956e-07
I2113 n1_m1_100800_163200 0 1.757335e-07
I2114 n1_m1_100800_168000 0 3.277642e-07
I2115 n1_m1_100800_172800 0 1.831772e-07
I2116 n1_m1_100800_177600 0 2.296797e-07
I2117 n1_m1_100800_182400 0 1.401248e-07
I2118 n1_m1_100800_187200 0 1.366858e-07
I2119 n1_m1_100800_192000 0 2.069766e-07
I2120 n1_m1_100800_196800 0 1.399040e-07
I2121 n1_m1_100800_201600 0 2.098804e-07
I2122 n1_m1_100800_206400 0 1.451133e-07
I2123 n1_m1_100800_211200 0 1.481235e-07
I2124 n1_m1_100800_216000 0 2.281192e-07
I2125 n1_m1_100800_220800 0 1.426745e-07
I2126 n1_m1_100800_225600 0 2.012128e-07
I2127 n1_m1_100800_230400 0 1.333943e-07
I2128 n1_m1_100800_235200 0 1.336089e-07
I2129 n1_m1_100800_240000 0 2.003402e-07
I2130 n1_m1_100800_244800 0 1.336891e-07
I2131 n1_m1_100800_249600 0 2.064407e-07
I2132 n1_m1_100800_254400 0 1.399040e-07
I2133 n1_m1_100800_259200 0 1.399040e-07
I2134 n1_m1_100800_264000 0 2.089409e-07
I2135 n1_m1_100800_268800 0 1.347024e-07
I2136 n1_m1_100800_273600 0 2.159157e-07
I2137 n1_m1_100800_278400 0 1.429786e-07
I2138 n1_m1_100800_283200 0 1.456809e-07
I2139 n1_m1_100800_288000 0 3.104077e-07
I2140 n1_m1_100800_292800 0 5.025039e-07
I2141 n1_m1_100800_297600 0 1.282743e-06
I2142 n1_m1_100800_302400 0 1.198576e-06
I2143 n1_m1_100800_307200 0 1.096898e-06
I2144 n1_m1_100800_312000 0 7.368019e-07
I2145 n1_m1_100800_316800 0 1.428427e-07
I2146 n1_m1_100800_321600 0 2.201641e-07
I2147 n1_m1_100800_326400 0 1.399040e-07
I2148 n1_m1_100800_331200 0 1.365430e-07
I2149 n1_m1_100800_336000 0 2.014425e-07
I2150 n1_m1_100800_340800 0 1.398193e-07
I2151 n1_m1_100800_345600 0 2.054414e-07
I2152 n1_m1_100800_350400 0 1.337770e-07
I2153 n1_m1_100800_355200 0 1.375035e-07
I2154 n1_m1_100800_360000 0 2.272117e-07
I2155 n1_m1_100800_364800 0 1.508750e-07
I2156 n1_m1_100800_369600 0 4.170640e-07
I2157 n1_m1_100800_374400 0 6.355209e-07
I2158 n1_m1_100800_379200 0 9.348357e-07
I2159 n1_m1_100800_384000 0 1.482738e-06
I2160 n1_m1_100800_388800 0 6.718981e-07
I2161 n1_m1_100800_393600 0 5.909123e-07
I2162 n1_m1_100800_398400 0 1.386337e-07
I2163 n1_m1_100800_403200 0 1.376298e-07
I2164 n1_m1_100800_408000 0 2.154030e-07
I2165 n1_m1_100800_412800 0 1.396859e-07
I2166 n1_m1_100800_417600 0 2.123436e-07
I2167 n1_m1_100800_422400 0 1.413437e-07
I2168 n1_m1_100800_427200 0 1.413437e-07
I2169 n1_m1_100800_432000 0 2.120155e-07
I2170 n1_m1_100800_436800 0 1.413437e-07
I2171 n1_m1_100800_441600 0 2.110556e-07
I2172 n1_m1_100800_446400 0 1.401444e-07
I2173 n1_m1_100800_451200 0 1.422970e-07
I2174 n1_m1_100800_456000 0 2.314962e-07
I2175 n1_m1_100800_460800 0 1.714439e-07
I2176 n1_m1_100800_465600 0 2.423722e-07
I2177 n1_m1_100800_470400 0 7.511399e-08
I2178 n1_m1_105600_0 0 2.469927e-07
I2179 n1_m1_105600_4800 0 2.726068e-07
I2180 n1_m1_105600_9600 0 3.534983e-07
I2181 n1_m1_105600_14400 0 2.097438e-07
I2182 n1_m1_105600_19200 0 2.091769e-07
I2183 n1_m1_105600_24000 0 3.050517e-07
I2184 n1_m1_105600_28800 0 1.998628e-07
I2185 n1_m1_105600_33600 0 3.024393e-07
I2186 n1_m1_105600_38400 0 2.097713e-07
I2187 n1_m1_105600_43200 0 2.097713e-07
I2188 n1_m1_105600_48000 0 3.147430e-07
I2189 n1_m1_105600_52800 0 2.098560e-07
I2190 n1_m1_105600_57600 0 3.148021e-07
I2191 n1_m1_105600_62400 0 2.135904e-07
I2192 n1_m1_105600_67200 0 2.146194e-07
I2193 n1_m1_105600_72000 0 3.221698e-07
I2194 n1_m1_105600_76800 0 2.147961e-07
I2195 n1_m1_105600_81600 0 3.221941e-07
I2196 n1_m1_105600_86400 0 2.129959e-07
I2197 n1_m1_105600_91200 0 2.099447e-07
I2198 n1_m1_105600_96000 0 3.209439e-07
I2199 n1_m1_105600_100800 0 2.195153e-07
I2200 n1_m1_105600_105600 0 3.294203e-07
I2201 n1_m1_105600_110400 0 2.119733e-07
I2202 n1_m1_105600_115200 0 2.093218e-07
I2203 n1_m1_105600_120000 0 3.081040e-07
I2204 n1_m1_105600_124800 0 2.150068e-07
I2205 n1_m1_105600_129600 0 3.270549e-07
I2206 n1_m1_105600_134400 0 2.062426e-07
I2207 n1_m1_105600_139200 0 2.023235e-07
I2208 n1_m1_105600_144000 0 3.107597e-07
I2209 n1_m1_105600_148800 0 2.037884e-07
I2210 n1_m1_105600_153600 0 3.259579e-07
I2211 n1_m1_105600_158400 0 2.177732e-07
I2212 n1_m1_105600_163200 0 2.434345e-07
I2213 n1_m1_105600_168000 0 4.338051e-07
I2214 n1_m1_105600_172800 0 2.569633e-07
I2215 n1_m1_105600_177600 0 3.326884e-07
I2216 n1_m1_105600_182400 0 2.099347e-07
I2217 n1_m1_105600_187200 0 2.076672e-07
I2218 n1_m1_105600_192000 0 3.129075e-07
I2219 n1_m1_105600_196800 0 2.098635e-07
I2220 n1_m1_105600_201600 0 3.153854e-07
I2221 n1_m1_105600_206400 0 2.192516e-07
I2222 n1_m1_105600_211200 0 2.327020e-07
I2223 n1_m1_105600_216000 0 3.399528e-07
I2224 n1_m1_105600_220800 0 2.077921e-07
I2225 n1_m1_105600_225600 0 3.028408e-07
I2226 n1_m1_105600_230400 0 2.028176e-07
I2227 n1_m1_105600_235200 0 1.998628e-07
I2228 n1_m1_105600_240000 0 3.009756e-07
I2229 n1_m1_105600_244800 0 2.059445e-07
I2230 n1_m1_105600_249600 0 3.147244e-07
I2231 n1_m1_105600_254400 0 2.098560e-07
I2232 n1_m1_105600_259200 0 2.098560e-07
I2233 n1_m1_105600_264000 0 3.118235e-07
I2234 n1_m1_105600_268800 0 2.013549e-07
I2235 n1_m1_105600_273600 0 3.388434e-07
I2236 n1_m1_105600_278400 0 2.155186e-07
I2237 n1_m1_105600_283200 0 2.151650e-07
I2238 n1_m1_105600_288000 0 3.567027e-07
I2239 n1_m1_105600_292800 0 3.729169e-07
I2240 n1_m1_105600_297600 0 1.469395e-06
I2241 n1_m1_105600_302400 0 1.481300e-06
I2242 n1_m1_105600_307200 0 1.544536e-06
I2243 n1_m1_105600_312000 0 7.965637e-07
I2244 n1_m1_105600_316800 0 2.164407e-07
I2245 n1_m1_105600_321600 0 3.274191e-07
I2246 n1_m1_105600_326400 0 2.071814e-07
I2247 n1_m1_105600_331200 0 2.045206e-07
I2248 n1_m1_105600_336000 0 3.019538e-07
I2249 n1_m1_105600_340800 0 2.097289e-07
I2250 n1_m1_105600_345600 0 3.101673e-07
I2251 n1_m1_105600_350400 0 2.012022e-07
I2252 n1_m1_105600_355200 0 2.082280e-07
I2253 n1_m1_105600_360000 0 3.295582e-07
I2254 n1_m1_105600_364800 0 2.177038e-07
I2255 n1_m1_105600_369600 0 4.096578e-07
I2256 n1_m1_105600_374400 0 4.664983e-07
I2257 n1_m1_105600_379200 0 1.014448e-06
I2258 n1_m1_105600_384000 0 1.928217e-06
I2259 n1_m1_105600_388800 0 7.557398e-07
I2260 n1_m1_105600_393600 0 5.444207e-07
I2261 n1_m1_105600_398400 0 2.213772e-07
I2262 n1_m1_105600_403200 0 2.071266e-07
I2263 n1_m1_105600_408000 0 3.143781e-07
I2264 n1_m1_105600_412800 0 2.171179e-07
I2265 n1_m1_105600_417600 0 3.294289e-07
I2266 n1_m1_105600_422400 0 2.196690e-07
I2267 n1_m1_105600_427200 0 2.195668e-07
I2268 n1_m1_105600_432000 0 3.293502e-07
I2269 n1_m1_105600_436800 0 2.196221e-07
I2270 n1_m1_105600_441600 0 3.212349e-07
I2271 n1_m1_105600_446400 0 2.111592e-07
I2272 n1_m1_105600_451200 0 2.203222e-07
I2273 n1_m1_105600_456000 0 3.645316e-07
I2274 n1_m1_105600_460800 0 2.664604e-07
I2275 n1_m1_105600_465600 0 3.640266e-07
I2276 n1_m1_105600_470400 0 1.114596e-07
I2277 n1_m1_110400_0 0 1.654643e-07
I2278 n1_m1_110400_4800 0 1.910652e-07
I2279 n1_m1_110400_9600 0 2.508394e-07
I2280 n1_m1_110400_14400 0 1.368452e-07
I2281 n1_m1_110400_19200 0 1.334086e-07
I2282 n1_m1_110400_24000 0 2.006559e-07
I2283 n1_m1_110400_28800 0 1.337665e-07
I2284 n1_m1_110400_33600 0 2.020988e-07
I2285 n1_m1_110400_38400 0 1.399040e-07
I2286 n1_m1_110400_43200 0 1.399040e-07
I2287 n1_m1_110400_48000 0 2.098560e-07
I2288 n1_m1_110400_52800 0 1.399040e-07
I2289 n1_m1_110400_57600 0 2.048875e-07
I2290 n1_m1_110400_62400 0 1.343237e-07
I2291 n1_m1_110400_67200 0 1.355344e-07
I2292 n1_m1_110400_72000 0 2.099202e-07
I2293 n1_m1_110400_76800 0 1.403839e-07
I2294 n1_m1_110400_81600 0 2.099841e-07
I2295 n1_m1_110400_86400 0 1.399040e-07
I2296 n1_m1_110400_91200 0 1.423003e-07
I2297 n1_m1_110400_96000 0 2.192307e-07
I2298 n1_m1_110400_100800 0 1.465661e-07
I2299 n1_m1_110400_105600 0 2.198098e-07
I2300 n1_m1_110400_110400 0 1.451192e-07
I2301 n1_m1_110400_115200 0 1.407953e-07
I2302 n1_m1_110400_120000 0 2.133601e-07
I2303 n1_m1_110400_124800 0 1.464488e-07
I2304 n1_m1_110400_129600 0 2.246210e-07
I2305 n1_m1_110400_134400 0 1.426987e-07
I2306 n1_m1_110400_139200 0 1.391956e-07
I2307 n1_m1_110400_144000 0 2.086421e-07
I2308 n1_m1_110400_148800 0 1.365447e-07
I2309 n1_m1_110400_153600 0 2.195386e-07
I2310 n1_m1_110400_158400 0 1.422470e-07
I2311 n1_m1_110400_163200 0 1.538711e-07
I2312 n1_m1_110400_168000 0 2.558343e-07
I2313 n1_m1_110400_172800 0 1.543102e-07
I2314 n1_m1_110400_177600 0 2.132461e-07
I2315 n1_m1_110400_182400 0 1.423178e-07
I2316 n1_m1_110400_187200 0 1.452393e-07
I2317 n1_m1_110400_192000 0 2.169331e-07
I2318 n1_m1_110400_196800 0 1.405690e-07
I2319 n1_m1_110400_201600 0 2.141746e-07
I2320 n1_m1_110400_206400 0 1.436215e-07
I2321 n1_m1_110400_211200 0 1.572181e-07
I2322 n1_m1_110400_216000 0 2.270948e-07
I2323 n1_m1_110400_220800 0 1.361512e-07
I2324 n1_m1_110400_225600 0 2.074948e-07
I2325 n1_m1_110400_230400 0 1.374181e-07
I2326 n1_m1_110400_235200 0 1.332419e-07
I2327 n1_m1_110400_240000 0 2.059145e-07
I2328 n1_m1_110400_244800 0 1.398646e-07
I2329 n1_m1_110400_249600 0 2.098560e-07
I2330 n1_m1_110400_254400 0 1.399040e-07
I2331 n1_m1_110400_259200 0 1.398369e-07
I2332 n1_m1_110400_264000 0 2.134850e-07
I2333 n1_m1_110400_268800 0 1.368655e-07
I2334 n1_m1_110400_273600 0 2.283874e-07
I2335 n1_m1_110400_278400 0 1.434142e-07
I2336 n1_m1_110400_283200 0 1.463541e-07
I2337 n1_m1_110400_288000 0 2.334262e-07
I2338 n1_m1_110400_292800 0 1.917713e-07
I2339 n1_m1_110400_297600 0 8.617398e-07
I2340 n1_m1_110400_302400 0 8.776254e-07
I2341 n1_m1_110400_307200 0 8.577922e-07
I2342 n1_m1_110400_312000 0 4.130278e-07
I2343 n1_m1_110400_316800 0 1.505788e-07
I2344 n1_m1_110400_321600 0 2.083225e-07
I2345 n1_m1_110400_326400 0 1.389088e-07
I2346 n1_m1_110400_331200 0 1.363471e-07
I2347 n1_m1_110400_336000 0 2.017356e-07
I2348 n1_m1_110400_340800 0 1.398254e-07
I2349 n1_m1_110400_345600 0 2.046870e-07
I2350 n1_m1_110400_350400 0 1.340793e-07
I2351 n1_m1_110400_355200 0 1.403943e-07
I2352 n1_m1_110400_360000 0 2.159153e-07
I2353 n1_m1_110400_364800 0 1.533205e-07
I2354 n1_m1_110400_369600 0 2.758126e-07
I2355 n1_m1_110400_374400 0 2.795137e-07
I2356 n1_m1_110400_379200 0 5.086251e-07
I2357 n1_m1_110400_384000 0 1.000538e-06
I2358 n1_m1_110400_388800 0 4.182880e-07
I2359 n1_m1_110400_393600 0 2.542439e-07
I2360 n1_m1_110400_398400 0 1.437309e-07
I2361 n1_m1_110400_403200 0 1.350584e-07
I2362 n1_m1_110400_408000 0 2.051863e-07
I2363 n1_m1_110400_412800 0 1.410190e-07
I2364 n1_m1_110400_417600 0 2.137801e-07
I2365 n1_m1_110400_422400 0 1.437408e-07
I2366 n1_m1_110400_427200 0 1.412307e-07
I2367 n1_m1_110400_432000 0 2.118461e-07
I2368 n1_m1_110400_436800 0 1.425886e-07
I2369 n1_m1_110400_441600 0 2.179225e-07
I2370 n1_m1_110400_446400 0 1.407613e-07
I2371 n1_m1_110400_451200 0 1.409822e-07
I2372 n1_m1_110400_456000 0 2.271198e-07
I2373 n1_m1_110400_460800 0 1.703170e-07
I2374 n1_m1_110400_465600 0 2.382041e-07
I2375 n1_m1_110400_470400 0 7.495920e-08
I2376 n1_m1_115200_0 0 9.810560e-08
I2377 n1_m1_115200_4800 0 1.365949e-07
I2378 n1_m1_115200_9600 0 1.591175e-07
I2379 n1_m1_115200_14400 0 7.287598e-08
I2380 n1_m1_115200_19200 0 6.741543e-08
I2381 n1_m1_115200_24000 0 1.037101e-07
I2382 n1_m1_115200_28800 0 6.912066e-08
I2383 n1_m1_115200_33600 0 1.030006e-07
I2384 n1_m1_115200_38400 0 6.995199e-08
I2385 n1_m1_115200_43200 0 6.995199e-08
I2386 n1_m1_115200_48000 0 1.049280e-07
I2387 n1_m1_115200_52800 0 6.995199e-08
I2388 n1_m1_115200_57600 0 1.024297e-07
I2389 n1_m1_115200_62400 0 6.676627e-08
I2390 n1_m1_115200_67200 0 6.888251e-08
I2391 n1_m1_115200_72000 0 1.079485e-07
I2392 n1_m1_115200_76800 0 7.223855e-08
I2393 n1_m1_115200_81600 0 1.055384e-07
I2394 n1_m1_115200_86400 0 6.995199e-08
I2395 n1_m1_115200_91200 0 7.144814e-08
I2396 n1_m1_115200_96000 0 1.099246e-07
I2397 n1_m1_115200_100800 0 7.328303e-08
I2398 n1_m1_115200_105600 0 1.099246e-07
I2399 n1_m1_115200_110400 0 7.304309e-08
I2400 n1_m1_115200_115200 0 7.073583e-08
I2401 n1_m1_115200_120000 0 1.087070e-07
I2402 n1_m1_115200_124800 0 7.481387e-08
I2403 n1_m1_115200_129600 0 1.136631e-07
I2404 n1_m1_115200_134400 0 7.201272e-08
I2405 n1_m1_115200_139200 0 6.995199e-08
I2406 n1_m1_115200_144000 0 1.043211e-07
I2407 n1_m1_115200_148800 0 6.827235e-08
I2408 n1_m1_115200_153600 0 1.097693e-07
I2409 n1_m1_115200_158400 0 7.112350e-08
I2410 n1_m1_115200_163200 0 7.685403e-08
I2411 n1_m1_115200_168000 0 1.282238e-07
I2412 n1_m1_115200_172800 0 7.713345e-08
I2413 n1_m1_115200_177600 0 1.064777e-07
I2414 n1_m1_115200_182400 0 7.265458e-08
I2415 n1_m1_115200_187200 0 7.328303e-08
I2416 n1_m1_115200_192000 0 1.097254e-07
I2417 n1_m1_115200_196800 0 7.227839e-08
I2418 n1_m1_115200_201600 0 1.090169e-07
I2419 n1_m1_115200_206400 0 7.144814e-08
I2420 n1_m1_115200_211200 0 7.824743e-08
I2421 n1_m1_115200_216000 0 1.119431e-07
I2422 n1_m1_115200_220800 0 6.760896e-08
I2423 n1_m1_115200_225600 0 1.048792e-07
I2424 n1_m1_115200_230400 0 6.990582e-08
I2425 n1_m1_115200_235200 0 6.662094e-08
I2426 n1_m1_115200_240000 0 1.035448e-07
I2427 n1_m1_115200_244800 0 6.995199e-08
I2428 n1_m1_115200_249600 0 1.049280e-07
I2429 n1_m1_115200_254400 0 6.995199e-08
I2430 n1_m1_115200_259200 0 6.963226e-08
I2431 n1_m1_115200_264000 0 1.081788e-07
I2432 n1_m1_115200_268800 0 6.976300e-08
I2433 n1_m1_115200_273600 0 1.116007e-07
I2434 n1_m1_115200_278400 0 7.054504e-08
I2435 n1_m1_115200_283200 0 7.457799e-08
I2436 n1_m1_115200_288000 0 1.224702e-07
I2437 n1_m1_115200_292800 0 1.027745e-07
I2438 n1_m1_115200_297600 0 5.300176e-07
I2439 n1_m1_115200_302400 0 4.670262e-07
I2440 n1_m1_115200_307200 0 3.865229e-07
I2441 n1_m1_115200_312000 0 2.032225e-07
I2442 n1_m1_115200_316800 0 7.357035e-08
I2443 n1_m1_115200_321600 0 1.015292e-07
I2444 n1_m1_115200_326400 0 6.869244e-08
I2445 n1_m1_115200_331200 0 6.817355e-08
I2446 n1_m1_115200_336000 0 1.027150e-07
I2447 n1_m1_115200_340800 0 6.993871e-08
I2448 n1_m1_115200_345600 0 1.038958e-07
I2449 n1_m1_115200_350400 0 6.736052e-08
I2450 n1_m1_115200_355200 0 7.009313e-08
I2451 n1_m1_115200_360000 0 1.074545e-07
I2452 n1_m1_115200_364800 0 8.061043e-08
I2453 n1_m1_115200_369600 0 1.756529e-07
I2454 n1_m1_115200_374400 0 2.122318e-07
I2455 n1_m1_115200_379200 0 2.705167e-07
I2456 n1_m1_115200_384000 0 4.909217e-07
I2457 n1_m1_115200_388800 0 2.400670e-07
I2458 n1_m1_115200_393600 0 1.309855e-07
I2459 n1_m1_115200_398400 0 7.309823e-08
I2460 n1_m1_115200_403200 0 7.092685e-08
I2461 n1_m1_115200_408000 0 1.057932e-07
I2462 n1_m1_115200_412800 0 7.052363e-08
I2463 n1_m1_115200_417600 0 1.053440e-07
I2464 n1_m1_115200_422400 0 7.049193e-08
I2465 n1_m1_115200_427200 0 6.995199e-08
I2466 n1_m1_115200_432000 0 1.049280e-07
I2467 n1_m1_115200_436800 0 7.024409e-08
I2468 n1_m1_115200_441600 0 1.081748e-07
I2469 n1_m1_115200_446400 0 7.011742e-08
I2470 n1_m1_115200_451200 0 6.828551e-08
I2471 n1_m1_115200_456000 0 1.086144e-07
I2472 n1_m1_115200_460800 0 8.036306e-08
I2473 n1_m1_115200_465600 0 1.175673e-07
I2474 n1_m1_115200_470400 0 3.740371e-08
I2475 n1_m1_120000_0 0 1.674232e-07
I2476 n1_m1_120000_4800 0 1.816866e-07
I2477 n1_m1_120000_9600 0 2.316020e-07
I2478 n1_m1_120000_14400 0 1.449118e-07
I2479 n1_m1_120000_19200 0 1.426980e-07
I2480 n1_m1_120000_24000 0 2.033637e-07
I2481 n1_m1_120000_28800 0 1.332419e-07
I2482 n1_m1_120000_33600 0 2.016413e-07
I2483 n1_m1_120000_38400 0 1.399040e-07
I2484 n1_m1_120000_43200 0 1.399040e-07
I2485 n1_m1_120000_48000 0 2.098560e-07
I2486 n1_m1_120000_52800 0 1.399040e-07
I2487 n1_m1_120000_57600 0 2.068756e-07
I2488 n1_m1_120000_62400 0 1.342397e-07
I2489 n1_m1_120000_67200 0 1.412133e-07
I2490 n1_m1_120000_72000 0 2.471838e-07
I2491 n1_m1_120000_76800 0 1.627146e-07
I2492 n1_m1_120000_81600 0 2.285604e-07
I2493 n1_m1_120000_86400 0 1.535344e-07
I2494 n1_m1_120000_91200 0 1.466216e-07
I2495 n1_m1_120000_96000 0 2.128475e-07
I2496 n1_m1_120000_100800 0 1.573709e-07
I2497 n1_m1_120000_105600 0 2.367634e-07
I2498 n1_m1_120000_110400 0 1.539073e-07
I2499 n1_m1_120000_115200 0 1.590211e-07
I2500 n1_m1_120000_120000 0 2.311614e-07
I2501 n1_m1_120000_124800 0 1.639443e-07
I2502 n1_m1_120000_129600 0 2.211476e-07
I2503 n1_m1_120000_134400 0 1.467919e-07
I2504 n1_m1_120000_139200 0 1.382758e-07
I2505 n1_m1_120000_144000 0 2.053788e-07
I2506 n1_m1_120000_148800 0 1.387100e-07
I2507 n1_m1_120000_153600 0 2.156712e-07
I2508 n1_m1_120000_158400 0 1.443360e-07
I2509 n1_m1_120000_163200 0 1.514509e-07
I2510 n1_m1_120000_168000 0 2.481240e-07
I2511 n1_m1_120000_172800 0 1.574061e-07
I2512 n1_m1_120000_177600 0 2.194257e-07
I2513 n1_m1_120000_182400 0 1.414556e-07
I2514 n1_m1_120000_187200 0 1.483541e-07
I2515 n1_m1_120000_192000 0 2.285719e-07
I2516 n1_m1_120000_196800 0 1.477280e-07
I2517 n1_m1_120000_201600 0 2.286521e-07
I2518 n1_m1_120000_206400 0 1.676571e-07
I2519 n1_m1_120000_211200 0 1.725604e-07
I2520 n1_m1_120000_216000 0 2.376385e-07
I2521 n1_m1_120000_220800 0 1.422149e-07
I2522 n1_m1_120000_225600 0 2.098560e-07
I2523 n1_m1_120000_230400 0 1.399040e-07
I2524 n1_m1_120000_235200 0 1.399040e-07
I2525 n1_m1_120000_240000 0 2.026293e-07
I2526 n1_m1_120000_244800 0 1.332419e-07
I2527 n1_m1_120000_249600 0 2.053845e-07
I2528 n1_m1_120000_254400 0 1.433924e-07
I2529 n1_m1_120000_259200 0 1.467474e-07
I2530 n1_m1_120000_264000 0 2.278219e-07
I2531 n1_m1_120000_268800 0 1.535439e-07
I2532 n1_m1_120000_273600 0 2.227553e-07
I2533 n1_m1_120000_278400 0 1.538291e-07
I2534 n1_m1_120000_283200 0 2.353044e-07
I2535 n1_m1_120000_288000 0 3.148813e-07
I2536 n1_m1_120000_292800 0 2.749798e-07
I2537 n1_m1_120000_297600 0 1.034287e-06
I2538 n1_m1_120000_302400 0 8.420195e-07
I2539 n1_m1_120000_307200 0 5.271516e-07
I2540 n1_m1_120000_312000 0 2.885521e-07
I2541 n1_m1_120000_316800 0 1.447972e-07
I2542 n1_m1_120000_321600 0 2.184707e-07
I2543 n1_m1_120000_326400 0 1.383801e-07
I2544 n1_m1_120000_331200 0 1.399040e-07
I2545 n1_m1_120000_336000 0 2.098560e-07
I2546 n1_m1_120000_340800 0 1.399040e-07
I2547 n1_m1_120000_345600 0 2.098560e-07
I2548 n1_m1_120000_350400 0 1.402205e-07
I2549 n1_m1_120000_355200 0 1.429647e-07
I2550 n1_m1_120000_360000 0 2.151083e-07
I2551 n1_m1_120000_364800 0 1.450278e-07
I2552 n1_m1_120000_369600 0 4.418714e-07
I2553 n1_m1_120000_374400 0 5.241858e-07
I2554 n1_m1_120000_379200 0 7.532123e-07
I2555 n1_m1_120000_384000 0 1.555840e-06
I2556 n1_m1_120000_388800 0 5.381509e-07
I2557 n1_m1_120000_393600 0 3.473136e-07
I2558 n1_m1_120000_398400 0 1.510748e-07
I2559 n1_m1_120000_403200 0 1.502450e-07
I2560 n1_m1_120000_408000 0 2.164422e-07
I2561 n1_m1_120000_412800 0 1.396217e-07
I2562 n1_m1_120000_417600 0 2.098560e-07
I2563 n1_m1_120000_422400 0 1.399040e-07
I2564 n1_m1_120000_427200 0 1.399040e-07
I2565 n1_m1_120000_432000 0 2.098560e-07
I2566 n1_m1_120000_436800 0 1.399040e-07
I2567 n1_m1_120000_441600 0 2.064886e-07
I2568 n1_m1_120000_446400 0 1.365201e-07
I2569 n1_m1_120000_451200 0 1.413585e-07
I2570 n1_m1_120000_456000 0 2.411150e-07
I2571 n1_m1_120000_460800 0 1.931706e-07
I2572 n1_m1_120000_465600 0 2.613616e-07
I2573 n1_m1_120000_470400 0 7.909825e-08
I2574 n1_m1_124800_0 0 1.806411e-07
I2575 n1_m1_124800_4800 0 2.116734e-07
I2576 n1_m1_124800_9600 0 2.464200e-07
I2577 n1_m1_124800_14400 0 1.424726e-07
I2578 n1_m1_124800_19200 0 1.396372e-07
I2579 n1_m1_124800_24000 0 2.031948e-07
I2580 n1_m1_124800_28800 0 1.348672e-07
I2581 n1_m1_124800_33600 0 2.058936e-07
I2582 n1_m1_124800_38400 0 1.399040e-07
I2583 n1_m1_124800_43200 0 1.399040e-07
I2584 n1_m1_124800_48000 0 2.098560e-07
I2585 n1_m1_124800_52800 0 1.399040e-07
I2586 n1_m1_124800_57600 0 2.081101e-07
I2587 n1_m1_124800_62400 0 1.345914e-07
I2588 n1_m1_124800_67200 0 1.404477e-07
I2589 n1_m1_124800_72000 0 2.362701e-07
I2590 n1_m1_124800_76800 0 1.614204e-07
I2591 n1_m1_124800_81600 0 2.377361e-07
I2592 n1_m1_124800_86400 0 1.550348e-07
I2593 n1_m1_124800_91200 0 1.455771e-07
I2594 n1_m1_124800_96000 0 2.200185e-07
I2595 n1_m1_124800_100800 0 1.622857e-07
I2596 n1_m1_124800_105600 0 2.349714e-07
I2597 n1_m1_124800_110400 0 1.572800e-07
I2598 n1_m1_124800_115200 0 1.628022e-07
I2599 n1_m1_124800_120000 0 2.521108e-07
I2600 n1_m1_124800_124800 0 1.695006e-07
I2601 n1_m1_124800_129600 0 2.250112e-07
I2602 n1_m1_124800_134400 0 1.529459e-07
I2603 n1_m1_124800_139200 0 1.436403e-07
I2604 n1_m1_124800_144000 0 2.069543e-07
I2605 n1_m1_124800_148800 0 1.412975e-07
I2606 n1_m1_124800_153600 0 2.198209e-07
I2607 n1_m1_124800_158400 0 1.471024e-07
I2608 n1_m1_124800_163200 0 1.538774e-07
I2609 n1_m1_124800_168000 0 2.484171e-07
I2610 n1_m1_124800_172800 0 1.574061e-07
I2611 n1_m1_124800_177600 0 2.194257e-07
I2612 n1_m1_124800_182400 0 1.425575e-07
I2613 n1_m1_124800_187200 0 1.519387e-07
I2614 n1_m1_124800_192000 0 2.304997e-07
I2615 n1_m1_124800_196800 0 1.483727e-07
I2616 n1_m1_124800_201600 0 2.342513e-07
I2617 n1_m1_124800_206400 0 1.758166e-07
I2618 n1_m1_124800_211200 0 1.946256e-07
I2619 n1_m1_124800_216000 0 2.728456e-07
I2620 n1_m1_124800_220800 0 1.496392e-07
I2621 n1_m1_124800_225600 0 2.109332e-07
I2622 n1_m1_124800_230400 0 1.399040e-07
I2623 n1_m1_124800_235200 0 1.399040e-07
I2624 n1_m1_124800_240000 0 2.065792e-07
I2625 n1_m1_124800_244800 0 1.333742e-07
I2626 n1_m1_124800_249600 0 2.019838e-07
I2627 n1_m1_124800_254400 0 1.409485e-07
I2628 n1_m1_124800_259200 0 1.430374e-07
I2629 n1_m1_124800_264000 0 2.324633e-07
I2630 n1_m1_124800_268800 0 1.563386e-07
I2631 n1_m1_124800_273600 0 2.268160e-07
I2632 n1_m1_124800_278400 0 1.679074e-07
I2633 n1_m1_124800_283200 0 3.087075e-07
I2634 n1_m1_124800_288000 0 3.803520e-07
I2635 n1_m1_124800_292800 0 3.365027e-07
I2636 n1_m1_124800_297600 0 1.127106e-06
I2637 n1_m1_124800_302400 0 9.132126e-07
I2638 n1_m1_124800_307200 0 4.740113e-07
I2639 n1_m1_124800_312000 0 2.694993e-07
I2640 n1_m1_124800_316800 0 1.438991e-07
I2641 n1_m1_124800_321600 0 2.123050e-07
I2642 n1_m1_124800_326400 0 1.399040e-07
I2643 n1_m1_124800_331200 0 1.399040e-07
I2644 n1_m1_124800_336000 0 2.098560e-07
I2645 n1_m1_124800_340800 0 1.399040e-07
I2646 n1_m1_124800_345600 0 2.098560e-07
I2647 n1_m1_124800_350400 0 1.393937e-07
I2648 n1_m1_124800_355200 0 1.383971e-07
I2649 n1_m1_124800_360000 0 2.179707e-07
I2650 n1_m1_124800_364800 0 1.417908e-07
I2651 n1_m1_124800_369600 0 5.259963e-07
I2652 n1_m1_124800_374400 0 7.143220e-07
I2653 n1_m1_124800_379200 0 8.878848e-07
I2654 n1_m1_124800_384000 0 1.487843e-06
I2655 n1_m1_124800_388800 0 8.525909e-07
I2656 n1_m1_124800_393600 0 7.194770e-07
I2657 n1_m1_124800_398400 0 1.519600e-07
I2658 n1_m1_124800_403200 0 1.439405e-07
I2659 n1_m1_124800_408000 0 2.102335e-07
I2660 n1_m1_124800_412800 0 1.426987e-07
I2661 n1_m1_124800_417600 0 2.147698e-07
I2662 n1_m1_124800_422400 0 1.399040e-07
I2663 n1_m1_124800_427200 0 1.399040e-07
I2664 n1_m1_124800_432000 0 2.108954e-07
I2665 n1_m1_124800_436800 0 1.443642e-07
I2666 n1_m1_124800_441600 0 2.107875e-07
I2667 n1_m1_124800_446400 0 1.385772e-07
I2668 n1_m1_124800_451200 0 1.452548e-07
I2669 n1_m1_124800_456000 0 2.434121e-07
I2670 n1_m1_124800_460800 0 1.794100e-07
I2671 n1_m1_124800_465600 0 2.444734e-07
I2672 n1_m1_124800_470400 0 7.703106e-08
I2673 n1_m1_129600_0 0 2.902183e-07
I2674 n1_m1_129600_4800 0 3.725827e-07
I2675 n1_m1_129600_9600 0 4.148211e-07
I2676 n1_m1_129600_14400 0 2.133473e-07
I2677 n1_m1_129600_19200 0 2.028539e-07
I2678 n1_m1_129600_24000 0 3.089928e-07
I2679 n1_m1_129600_28800 0 2.057984e-07
I2680 n1_m1_129600_33600 0 3.119893e-07
I2681 n1_m1_129600_38400 0 2.098560e-07
I2682 n1_m1_129600_43200 0 2.098560e-07
I2683 n1_m1_129600_48000 0 3.134171e-07
I2684 n1_m1_129600_52800 0 2.021105e-07
I2685 n1_m1_129600_57600 0 3.191602e-07
I2686 n1_m1_129600_62400 0 2.116253e-07
I2687 n1_m1_129600_67200 0 2.106031e-07
I2688 n1_m1_129600_72000 0 3.338699e-07
I2689 n1_m1_129600_76800 0 2.295882e-07
I2690 n1_m1_129600_81600 0 3.443823e-07
I2691 n1_m1_129600_86400 0 2.320673e-07
I2692 n1_m1_129600_91200 0 2.326764e-07
I2693 n1_m1_129600_96000 0 3.521170e-07
I2694 n1_m1_129600_100800 0 2.495407e-07
I2695 n1_m1_129600_105600 0 3.498888e-07
I2696 n1_m1_129600_110400 0 2.466195e-07
I2697 n1_m1_129600_115200 0 3.068790e-07
I2698 n1_m1_129600_120000 0 4.141513e-07
I2699 n1_m1_129600_124800 0 2.578655e-07
I2700 n1_m1_129600_129600 0 3.412570e-07
I2701 n1_m1_129600_134400 0 2.383809e-07
I2702 n1_m1_129600_139200 0 2.301827e-07
I2703 n1_m1_129600_144000 0 3.230796e-07
I2704 n1_m1_129600_148800 0 2.119498e-07
I2705 n1_m1_129600_153600 0 3.219476e-07
I2706 n1_m1_129600_158400 0 2.123825e-07
I2707 n1_m1_129600_163200 0 2.225450e-07
I2708 n1_m1_129600_168000 0 3.602189e-07
I2709 n1_m1_129600_172800 0 2.278380e-07
I2710 n1_m1_129600_177600 0 3.270707e-07
I2711 n1_m1_129600_182400 0 2.138363e-07
I2712 n1_m1_129600_187200 0 2.295035e-07
I2713 n1_m1_129600_192000 0 3.492870e-07
I2714 n1_m1_129600_196800 0 2.240746e-07
I2715 n1_m1_129600_201600 0 3.599231e-07
I2716 n1_m1_129600_206400 0 2.690965e-07
I2717 n1_m1_129600_211200 0 3.194050e-07
I2718 n1_m1_129600_216000 0 4.715729e-07
I2719 n1_m1_129600_220800 0 2.311946e-07
I2720 n1_m1_129600_225600 0 3.171975e-07
I2721 n1_m1_129600_230400 0 2.106765e-07
I2722 n1_m1_129600_235200 0 2.108440e-07
I2723 n1_m1_129600_240000 0 3.131873e-07
I2724 n1_m1_129600_244800 0 2.020767e-07
I2725 n1_m1_129600_249600 0 3.078679e-07
I2726 n1_m1_129600_254400 0 2.095568e-07
I2727 n1_m1_129600_259200 0 2.112533e-07
I2728 n1_m1_129600_264000 0 3.269108e-07
I2729 n1_m1_129600_268800 0 2.366718e-07
I2730 n1_m1_129600_273600 0 3.744774e-07
I2731 n1_m1_129600_278400 0 2.687134e-07
I2732 n1_m1_129600_283200 0 4.518839e-07
I2733 n1_m1_129600_288000 0 7.491547e-07
I2734 n1_m1_129600_292800 0 1.000853e-06
I2735 n1_m1_129600_297600 0 2.410376e-06
I2736 n1_m1_129600_302400 0 1.398329e-06
I2737 n1_m1_129600_307200 0 4.765559e-07
I2738 n1_m1_129600_312000 0 3.753270e-07
I2739 n1_m1_129600_316800 0 2.185354e-07
I2740 n1_m1_129600_321600 0 3.322203e-07
I2741 n1_m1_129600_326400 0 2.061410e-07
I2742 n1_m1_129600_331200 0 2.015848e-07
I2743 n1_m1_129600_336000 0 3.023772e-07
I2744 n1_m1_129600_340800 0 2.037227e-07
I2745 n1_m1_129600_345600 0 3.147839e-07
I2746 n1_m1_129600_350400 0 2.096590e-07
I2747 n1_m1_129600_355200 0 2.121017e-07
I2748 n1_m1_129600_360000 0 3.315961e-07
I2749 n1_m1_129600_364800 0 2.115470e-07
I2750 n1_m1_129600_369600 0 6.487579e-07
I2751 n1_m1_129600_374400 0 8.008075e-07
I2752 n1_m1_129600_379200 0 1.236894e-06
I2753 n1_m1_129600_384000 0 2.640148e-06
I2754 n1_m1_129600_388800 0 1.502628e-06
I2755 n1_m1_129600_393600 0 1.030283e-06
I2756 n1_m1_129600_398400 0 2.316514e-07
I2757 n1_m1_129600_403200 0 2.238890e-07
I2758 n1_m1_129600_408000 0 3.287377e-07
I2759 n1_m1_129600_412800 0 2.204984e-07
I2760 n1_m1_129600_417600 0 3.236163e-07
I2761 n1_m1_129600_422400 0 2.098560e-07
I2762 n1_m1_129600_427200 0 2.098560e-07
I2763 n1_m1_129600_432000 0 3.166523e-07
I2764 n1_m1_129600_436800 0 2.178731e-07
I2765 n1_m1_129600_441600 0 3.206156e-07
I2766 n1_m1_129600_446400 0 2.171968e-07
I2767 n1_m1_129600_451200 0 2.210741e-07
I2768 n1_m1_129600_456000 0 3.552371e-07
I2769 n1_m1_129600_460800 0 2.560915e-07
I2770 n1_m1_129600_465600 0 3.587125e-07
I2771 n1_m1_129600_470400 0 1.153025e-07
I2772 n1_m1_134400_0 0 1.970055e-07
I2773 n1_m1_134400_4800 0 2.569854e-07
I2774 n1_m1_134400_9600 0 2.726949e-07
I2775 n1_m1_134400_14400 0 1.420073e-07
I2776 n1_m1_134400_19200 0 1.362509e-07
I2777 n1_m1_134400_24000 0 2.038663e-07
I2778 n1_m1_134400_28800 0 1.372844e-07
I2779 n1_m1_134400_33600 0 2.087034e-07
I2780 n1_m1_134400_38400 0 1.399040e-07
I2781 n1_m1_134400_43200 0 1.399040e-07
I2782 n1_m1_134400_48000 0 2.087550e-07
I2783 n1_m1_134400_52800 0 1.336653e-07
I2784 n1_m1_134400_57600 0 2.060115e-07
I2785 n1_m1_134400_62400 0 1.402322e-07
I2786 n1_m1_134400_67200 0 1.401731e-07
I2787 n1_m1_134400_72000 0 2.156949e-07
I2788 n1_m1_134400_76800 0 1.515397e-07
I2789 n1_m1_134400_81600 0 2.337041e-07
I2790 n1_m1_134400_86400 0 1.562659e-07
I2791 n1_m1_134400_91200 0 1.557568e-07
I2792 n1_m1_134400_96000 0 2.250033e-07
I2793 n1_m1_134400_100800 0 1.554030e-07
I2794 n1_m1_134400_105600 0 2.237050e-07
I2795 n1_m1_134400_110400 0 1.738927e-07
I2796 n1_m1_134400_115200 0 2.521077e-07
I2797 n1_m1_134400_120000 0 2.737542e-07
I2798 n1_m1_134400_124800 0 1.640754e-07
I2799 n1_m1_134400_129600 0 2.252851e-07
I2800 n1_m1_134400_134400 0 1.491067e-07
I2801 n1_m1_134400_139200 0 1.482019e-07
I2802 n1_m1_134400_144000 0 2.136669e-07
I2803 n1_m1_134400_148800 0 1.424446e-07
I2804 n1_m1_134400_153600 0 2.117184e-07
I2805 n1_m1_134400_158400 0 1.404403e-07
I2806 n1_m1_134400_163200 0 1.472153e-07
I2807 n1_m1_134400_168000 0 2.384239e-07
I2808 n1_m1_134400_172800 0 1.507440e-07
I2809 n1_m1_134400_177600 0 2.177601e-07
I2810 n1_m1_134400_182400 0 1.425575e-07
I2811 n1_m1_134400_187200 0 1.530023e-07
I2812 n1_m1_134400_192000 0 2.385651e-07
I2813 n1_m1_134400_196800 0 1.540743e-07
I2814 n1_m1_134400_201600 0 2.442336e-07
I2815 n1_m1_134400_206400 0 1.747493e-07
I2816 n1_m1_134400_211200 0 1.963937e-07
I2817 n1_m1_134400_216000 0 2.873523e-07
I2818 n1_m1_134400_220800 0 1.555037e-07
I2819 n1_m1_134400_225600 0 2.144363e-07
I2820 n1_m1_134400_230400 0 1.426704e-07
I2821 n1_m1_134400_235200 0 1.432350e-07
I2822 n1_m1_134400_240000 0 2.093500e-07
I2823 n1_m1_134400_244800 0 1.374387e-07
I2824 n1_m1_134400_249600 0 2.061850e-07
I2825 n1_m1_134400_254400 0 1.394626e-07
I2826 n1_m1_134400_259200 0 1.408355e-07
I2827 n1_m1_134400_264000 0 2.166367e-07
I2828 n1_m1_134400_268800 0 1.531813e-07
I2829 n1_m1_134400_273600 0 2.435396e-07
I2830 n1_m1_134400_278400 0 1.853611e-07
I2831 n1_m1_134400_283200 0 3.883679e-07
I2832 n1_m1_134400_288000 0 8.139317e-07
I2833 n1_m1_134400_292800 0 8.030481e-07
I2834 n1_m1_134400_297600 0 1.141080e-06
I2835 n1_m1_134400_302400 0 9.043908e-07
I2836 n1_m1_134400_307200 0 3.777097e-07
I2837 n1_m1_134400_312000 0 3.350578e-07
I2838 n1_m1_134400_316800 0 1.467682e-07
I2839 n1_m1_134400_321600 0 2.103703e-07
I2840 n1_m1_134400_326400 0 1.366533e-07
I2841 n1_m1_134400_331200 0 1.357825e-07
I2842 n1_m1_134400_336000 0 2.031247e-07
I2843 n1_m1_134400_340800 0 1.343395e-07
I2844 n1_m1_134400_345600 0 2.081550e-07
I2845 n1_m1_134400_350400 0 1.399040e-07
I2846 n1_m1_134400_355200 0 1.395057e-07
I2847 n1_m1_134400_360000 0 2.079290e-07
I2848 n1_m1_134400_364800 0 1.485474e-07
I2849 n1_m1_134400_369600 0 3.183092e-07
I2850 n1_m1_134400_374400 0 3.145040e-07
I2851 n1_m1_134400_379200 0 7.710254e-07
I2852 n1_m1_134400_384000 0 1.586627e-06
I2853 n1_m1_134400_388800 0 1.024243e-06
I2854 n1_m1_134400_393600 0 7.523494e-07
I2855 n1_m1_134400_398400 0 1.575020e-07
I2856 n1_m1_134400_403200 0 1.480041e-07
I2857 n1_m1_134400_408000 0 2.237024e-07
I2858 n1_m1_134400_412800 0 1.436302e-07
I2859 n1_m1_134400_417600 0 2.098560e-07
I2860 n1_m1_134400_422400 0 1.399040e-07
I2861 n1_m1_134400_427200 0 1.399040e-07
I2862 n1_m1_134400_432000 0 2.098560e-07
I2863 n1_m1_134400_436800 0 1.399040e-07
I2864 n1_m1_134400_441600 0 2.104488e-07
I2865 n1_m1_134400_446400 0 1.453008e-07
I2866 n1_m1_134400_451200 0 1.442730e-07
I2867 n1_m1_134400_456000 0 2.207242e-07
I2868 n1_m1_134400_460800 0 1.606713e-07
I2869 n1_m1_134400_465600 0 2.361783e-07
I2870 n1_m1_134400_470400 0 7.578706e-08
I2871 n1_m1_139200_0 0 1.925472e-07
I2872 n1_m1_139200_4800 0 2.346252e-07
I2873 n1_m1_139200_9600 0 2.524146e-07
I2874 n1_m1_139200_14400 0 1.415147e-07
I2875 n1_m1_139200_19200 0 1.415178e-07
I2876 n1_m1_139200_24000 0 2.031051e-07
I2877 n1_m1_139200_28800 0 1.387724e-07
I2878 n1_m1_139200_33600 0 2.098560e-07
I2879 n1_m1_139200_38400 0 1.399040e-07
I2880 n1_m1_139200_43200 0 1.399040e-07
I2881 n1_m1_139200_48000 0 2.061103e-07
I2882 n1_m1_139200_52800 0 1.334680e-07
I2883 n1_m1_139200_57600 0 2.023329e-07
I2884 n1_m1_139200_62400 0 1.418233e-07
I2885 n1_m1_139200_67200 0 1.459780e-07
I2886 n1_m1_139200_72000 0 2.258330e-07
I2887 n1_m1_139200_76800 0 1.658184e-07
I2888 n1_m1_139200_81600 0 2.646273e-07
I2889 n1_m1_139200_86400 0 1.672299e-07
I2890 n1_m1_139200_91200 0 1.556162e-07
I2891 n1_m1_139200_96000 0 2.179470e-07
I2892 n1_m1_139200_100800 0 1.525676e-07
I2893 n1_m1_139200_105600 0 2.271318e-07
I2894 n1_m1_139200_110400 0 1.622187e-07
I2895 n1_m1_139200_115200 0 2.026592e-07
I2896 n1_m1_139200_120000 0 2.910606e-07
I2897 n1_m1_139200_124800 0 1.864032e-07
I2898 n1_m1_139200_129600 0 2.376916e-07
I2899 n1_m1_139200_134400 0 1.529487e-07
I2900 n1_m1_139200_139200 0 1.501230e-07
I2901 n1_m1_139200_144000 0 2.225464e-07
I2902 n1_m1_139200_148800 0 1.474082e-07
I2903 n1_m1_139200_153600 0 2.192659e-07
I2904 n1_m1_139200_158400 0 1.410324e-07
I2905 n1_m1_139200_163200 0 1.472153e-07
I2906 n1_m1_139200_168000 0 2.384239e-07
I2907 n1_m1_139200_172800 0 1.507440e-07
I2908 n1_m1_139200_177600 0 2.177601e-07
I2909 n1_m1_139200_182400 0 1.425575e-07
I2910 n1_m1_139200_187200 0 1.515024e-07
I2911 n1_m1_139200_192000 0 2.344993e-07
I2912 n1_m1_139200_196800 0 1.549164e-07
I2913 n1_m1_139200_201600 0 2.503685e-07
I2914 n1_m1_139200_206400 0 1.769395e-07
I2915 n1_m1_139200_211200 0 1.869649e-07
I2916 n1_m1_139200_216000 0 2.633910e-07
I2917 n1_m1_139200_220800 0 1.562592e-07
I2918 n1_m1_139200_225600 0 2.231641e-07
I2919 n1_m1_139200_230400 0 1.431967e-07
I2920 n1_m1_139200_235200 0 1.416824e-07
I2921 n1_m1_139200_240000 0 2.091476e-07
I2922 n1_m1_139200_244800 0 1.364526e-07
I2923 n1_m1_139200_249600 0 2.024140e-07
I2924 n1_m1_139200_254400 0 1.387466e-07
I2925 n1_m1_139200_259200 0 1.408355e-07
I2926 n1_m1_139200_264000 0 2.192563e-07
I2927 n1_m1_139200_268800 0 1.491282e-07
I2928 n1_m1_139200_273600 0 2.265435e-07
I2929 n1_m1_139200_278400 0 1.797718e-07
I2930 n1_m1_139200_283200 0 4.168450e-07
I2931 n1_m1_139200_288000 0 8.199849e-07
I2932 n1_m1_139200_292800 0 7.502241e-07
I2933 n1_m1_139200_297600 0 1.275487e-06
I2934 n1_m1_139200_302400 0 1.008824e-06
I2935 n1_m1_139200_307200 0 4.435060e-07
I2936 n1_m1_139200_312000 0 3.525396e-07
I2937 n1_m1_139200_316800 0 1.554193e-07
I2938 n1_m1_139200_321600 0 2.219507e-07
I2939 n1_m1_139200_326400 0 1.410499e-07
I2940 n1_m1_139200_331200 0 1.430092e-07
I2941 n1_m1_139200_336000 0 2.165477e-07
I2942 n1_m1_139200_340800 0 1.395370e-07
I2943 n1_m1_139200_345600 0 2.095536e-07
I2944 n1_m1_139200_350400 0 1.399040e-07
I2945 n1_m1_139200_355200 0 1.403200e-07
I2946 n1_m1_139200_360000 0 2.181054e-07
I2947 n1_m1_139200_364800 0 1.592259e-07
I2948 n1_m1_139200_369600 0 2.791211e-07
I2949 n1_m1_139200_374400 0 2.355498e-07
I2950 n1_m1_139200_379200 0 6.947037e-07
I2951 n1_m1_139200_384000 0 1.512687e-06
I2952 n1_m1_139200_388800 0 1.162848e-06
I2953 n1_m1_139200_393600 0 8.696748e-07
I2954 n1_m1_139200_398400 0 1.576326e-07
I2955 n1_m1_139200_403200 0 1.533284e-07
I2956 n1_m1_139200_408000 0 2.200737e-07
I2957 n1_m1_139200_412800 0 1.415695e-07
I2958 n1_m1_139200_417600 0 2.098560e-07
I2959 n1_m1_139200_422400 0 1.399040e-07
I2960 n1_m1_139200_427200 0 1.399040e-07
I2961 n1_m1_139200_432000 0 2.098560e-07
I2962 n1_m1_139200_436800 0 1.399040e-07
I2963 n1_m1_139200_441600 0 2.080409e-07
I2964 n1_m1_139200_446400 0 1.447331e-07
I2965 n1_m1_139200_451200 0 1.433558e-07
I2966 n1_m1_139200_456000 0 2.191998e-07
I2967 n1_m1_139200_460800 0 1.574221e-07
I2968 n1_m1_139200_465600 0 2.370689e-07
I2969 n1_m1_139200_470400 0 7.737627e-08
I2970 n1_m1_144000_0 0 2.828720e-07
I2971 n1_m1_144000_4800 0 3.228489e-07
I2972 n1_m1_144000_9600 0 3.674252e-07
I2973 n1_m1_144000_14400 0 2.188153e-07
I2974 n1_m1_144000_19200 0 2.175923e-07
I2975 n1_m1_144000_24000 0 3.037568e-07
I2976 n1_m1_144000_28800 0 2.063276e-07
I2977 n1_m1_144000_33600 0 3.144445e-07
I2978 n1_m1_144000_38400 0 2.098560e-07
I2979 n1_m1_144000_43200 0 2.093313e-07
I2980 n1_m1_144000_48000 0 3.040351e-07
I2981 n1_m1_144000_52800 0 2.013164e-07
I2982 n1_m1_144000_57600 0 3.171174e-07
I2983 n1_m1_144000_62400 0 2.304741e-07
I2984 n1_m1_144000_67200 0 2.385397e-07
I2985 n1_m1_144000_72000 0 3.626725e-07
I2986 n1_m1_144000_76800 0 2.668256e-07
I2987 n1_m1_144000_81600 0 4.073676e-07
I2988 n1_m1_144000_86400 0 2.558612e-07
I2989 n1_m1_144000_91200 0 2.419033e-07
I2990 n1_m1_144000_96000 0 3.446263e-07
I2991 n1_m1_144000_100800 0 2.434626e-07
I2992 n1_m1_144000_105600 0 3.597597e-07
I2993 n1_m1_144000_110400 0 2.309932e-07
I2994 n1_m1_144000_115200 0 2.452592e-07
I2995 n1_m1_144000_120000 0 4.521308e-07
I2996 n1_m1_144000_124800 0 3.043932e-07
I2997 n1_m1_144000_129600 0 3.622863e-07
I2998 n1_m1_144000_134400 0 2.290236e-07
I2999 n1_m1_144000_139200 0 2.181836e-07
I3000 n1_m1_144000_144000 0 3.292285e-07
I3001 n1_m1_144000_148800 0 2.279661e-07
I3002 n1_m1_144000_153600 0 3.480102e-07
I3003 n1_m1_144000_158400 0 2.188159e-07
I3004 n1_m1_144000_163200 0 2.263117e-07
I3005 n1_m1_144000_168000 0 3.636623e-07
I3006 n1_m1_144000_172800 0 2.315224e-07
I3007 n1_m1_144000_177600 0 3.337705e-07
I3008 n1_m1_144000_182400 0 2.138363e-07
I3009 n1_m1_144000_187200 0 2.246763e-07
I3010 n1_m1_144000_192000 0 3.443930e-07
I3011 n1_m1_144000_196800 0 2.347789e-07
I3012 n1_m1_144000_201600 0 3.747503e-07
I3013 n1_m1_144000_206400 0 2.962585e-07
I3014 n1_m1_144000_211200 0 3.041780e-07
I3015 n1_m1_144000_216000 0 3.876894e-07
I3016 n1_m1_144000_220800 0 2.320862e-07
I3017 n1_m1_144000_225600 0 3.399329e-07
I3018 n1_m1_144000_230400 0 2.175099e-07
I3019 n1_m1_144000_235200 0 2.128906e-07
I3020 n1_m1_144000_240000 0 3.147839e-07
I3021 n1_m1_144000_244800 0 2.095628e-07
I3022 n1_m1_144000_249600 0 3.148128e-07
I3023 n1_m1_144000_254400 0 2.156317e-07
I3024 n1_m1_144000_259200 0 2.145245e-07
I3025 n1_m1_144000_264000 0 3.215127e-07
I3026 n1_m1_144000_268800 0 2.205855e-07
I3027 n1_m1_144000_273600 0 3.529416e-07
I3028 n1_m1_144000_278400 0 2.425968e-07
I3029 n1_m1_144000_283200 0 3.448823e-07
I3030 n1_m1_144000_288000 0 6.353191e-07
I3031 n1_m1_144000_292800 0 8.366121e-07
I3032 n1_m1_144000_297600 0 1.920553e-06
I3033 n1_m1_144000_302400 0 1.158162e-06
I3034 n1_m1_144000_307200 0 5.137615e-07
I3035 n1_m1_144000_312000 0 5.559680e-07
I3036 n1_m1_144000_316800 0 2.732347e-07
I3037 n1_m1_144000_321600 0 3.532501e-07
I3038 n1_m1_144000_326400 0 2.330908e-07
I3039 n1_m1_144000_331200 0 2.374239e-07
I3040 n1_m1_144000_336000 0 3.663853e-07
I3041 n1_m1_144000_340800 0 2.362307e-07
I3042 n1_m1_144000_345600 0 3.545198e-07
I3043 n1_m1_144000_350400 0 2.302404e-07
I3044 n1_m1_144000_355200 0 2.221342e-07
I3045 n1_m1_144000_360000 0 3.725385e-07
I3046 n1_m1_144000_364800 0 2.979865e-07
I3047 n1_m1_144000_369600 0 5.584672e-07
I3048 n1_m1_144000_374400 0 4.990355e-07
I3049 n1_m1_144000_379200 0 9.058474e-07
I3050 n1_m1_144000_384000 0 2.384131e-06
I3051 n1_m1_144000_388800 0 1.451498e-06
I3052 n1_m1_144000_393600 0 9.262317e-07
I3053 n1_m1_144000_398400 0 2.278765e-07
I3054 n1_m1_144000_403200 0 2.221361e-07
I3055 n1_m1_144000_408000 0 3.354933e-07
I3056 n1_m1_144000_412800 0 2.166945e-07
I3057 n1_m1_144000_417600 0 3.152674e-07
I3058 n1_m1_144000_422400 0 2.104835e-07
I3059 n1_m1_144000_427200 0 2.098560e-07
I3060 n1_m1_144000_432000 0 3.150668e-07
I3061 n1_m1_144000_436800 0 2.117488e-07
I3062 n1_m1_144000_441600 0 3.131706e-07
I3063 n1_m1_144000_446400 0 2.201280e-07
I3064 n1_m1_144000_451200 0 2.317198e-07
I3065 n1_m1_144000_456000 0 3.594460e-07
I3066 n1_m1_144000_460800 0 2.535355e-07
I3067 n1_m1_144000_465600 0 3.658993e-07
I3068 n1_m1_144000_470400 0 1.184898e-07
I3069 n1_m1_148800_0 0 1.913543e-07
I3070 n1_m1_148800_4800 0 2.267221e-07
I3071 n1_m1_148800_9600 0 2.528233e-07
I3072 n1_m1_148800_14400 0 1.499812e-07
I3073 n1_m1_148800_19200 0 1.447607e-07
I3074 n1_m1_148800_24000 0 2.075899e-07
I3075 n1_m1_148800_28800 0 1.375232e-07
I3076 n1_m1_148800_33600 0 2.062539e-07
I3077 n1_m1_148800_38400 0 1.389277e-07
I3078 n1_m1_148800_43200 0 1.371588e-07
I3079 n1_m1_148800_48000 0 2.002601e-07
I3080 n1_m1_148800_52800 0 1.360262e-07
I3081 n1_m1_148800_57600 0 2.126088e-07
I3082 n1_m1_148800_62400 0 1.566086e-07
I3083 n1_m1_148800_67200 0 1.519407e-07
I3084 n1_m1_148800_72000 0 2.315088e-07
I3085 n1_m1_148800_76800 0 1.689404e-07
I3086 n1_m1_148800_81600 0 2.422723e-07
I3087 n1_m1_148800_86400 0 1.577910e-07
I3088 n1_m1_148800_91200 0 1.574183e-07
I3089 n1_m1_148800_96000 0 2.394775e-07
I3090 n1_m1_148800_100800 0 1.588611e-07
I3091 n1_m1_148800_105600 0 2.294750e-07
I3092 n1_m1_148800_110400 0 1.522119e-07
I3093 n1_m1_148800_115200 0 1.585317e-07
I3094 n1_m1_148800_120000 0 2.540859e-07
I3095 n1_m1_148800_124800 0 1.703733e-07
I3096 n1_m1_148800_129600 0 2.413270e-07
I3097 n1_m1_148800_134400 0 1.497620e-07
I3098 n1_m1_148800_139200 0 1.448556e-07
I3099 n1_m1_148800_144000 0 2.169116e-07
I3100 n1_m1_148800_148800 0 1.501163e-07
I3101 n1_m1_148800_153600 0 2.345053e-07
I3102 n1_m1_148800_158400 0 1.452041e-07
I3103 n1_m1_148800_163200 0 1.492868e-07
I3104 n1_m1_148800_168000 0 2.339476e-07
I3105 n1_m1_148800_172800 0 1.525243e-07
I3106 n1_m1_148800_177600 0 2.413199e-07
I3107 n1_m1_148800_182400 0 1.437494e-07
I3108 n1_m1_148800_187200 0 1.520538e-07
I3109 n1_m1_148800_192000 0 2.260977e-07
I3110 n1_m1_148800_196800 0 1.636585e-07
I3111 n1_m1_148800_201600 0 2.374899e-07
I3112 n1_m1_148800_206400 0 1.730312e-07
I3113 n1_m1_148800_211200 0 1.828795e-07
I3114 n1_m1_148800_216000 0 2.603707e-07
I3115 n1_m1_148800_220800 0 1.563685e-07
I3116 n1_m1_148800_225600 0 2.235079e-07
I3117 n1_m1_148800_230400 0 1.501667e-07
I3118 n1_m1_148800_235200 0 1.520425e-07
I3119 n1_m1_148800_240000 0 2.166457e-07
I3120 n1_m1_148800_244800 0 1.443608e-07
I3121 n1_m1_148800_249600 0 2.176549e-07
I3122 n1_m1_148800_254400 0 1.637360e-07
I3123 n1_m1_148800_259200 0 1.545608e-07
I3124 n1_m1_148800_264000 0 2.215386e-07
I3125 n1_m1_148800_268800 0 1.449974e-07
I3126 n1_m1_148800_273600 0 2.533776e-07
I3127 n1_m1_148800_278400 0 1.516734e-07
I3128 n1_m1_148800_283200 0 1.698351e-07
I3129 n1_m1_148800_288000 0 2.948266e-07
I3130 n1_m1_148800_292800 0 4.401305e-07
I3131 n1_m1_148800_297600 0 1.045075e-06
I3132 n1_m1_148800_302400 0 6.360478e-07
I3133 n1_m1_148800_307200 0 3.507239e-07
I3134 n1_m1_148800_312000 0 2.722784e-07
I3135 n1_m1_148800_316800 0 2.734484e-07
I3136 n1_m1_148800_321600 0 4.211039e-07
I3137 n1_m1_148800_326400 0 2.325726e-07
I3138 n1_m1_148800_331200 0 2.274275e-07
I3139 n1_m1_148800_336000 0 5.514342e-07
I3140 n1_m1_148800_340800 0 3.988261e-07
I3141 n1_m1_148800_345600 0 6.420586e-07
I3142 n1_m1_148800_350400 0 3.772529e-07
I3143 n1_m1_148800_355200 0 2.503624e-07
I3144 n1_m1_148800_360000 0 5.048295e-07
I3145 n1_m1_148800_364800 0 6.232369e-07
I3146 n1_m1_148800_369600 0 9.067850e-07
I3147 n1_m1_148800_374400 0 5.615623e-07
I3148 n1_m1_148800_379200 0 4.160393e-07
I3149 n1_m1_148800_384000 0 1.305606e-06
I3150 n1_m1_148800_388800 0 9.044658e-07
I3151 n1_m1_148800_393600 0 7.171453e-07
I3152 n1_m1_148800_398400 0 1.412199e-07
I3153 n1_m1_148800_403200 0 1.380383e-07
I3154 n1_m1_148800_408000 0 2.173318e-07
I3155 n1_m1_148800_412800 0 1.410860e-07
I3156 n1_m1_148800_417600 0 2.137235e-07
I3157 n1_m1_148800_422400 0 1.431874e-07
I3158 n1_m1_148800_427200 0 1.399040e-07
I3159 n1_m1_148800_432000 0 2.127119e-07
I3160 n1_m1_148800_436800 0 1.498081e-07
I3161 n1_m1_148800_441600 0 2.328677e-07
I3162 n1_m1_148800_446400 0 1.543958e-07
I3163 n1_m1_148800_451200 0 1.571682e-07
I3164 n1_m1_148800_456000 0 2.543811e-07
I3165 n1_m1_148800_460800 0 1.835901e-07
I3166 n1_m1_148800_465600 0 2.419650e-07
I3167 n1_m1_148800_470400 0 7.583048e-08
I3168 n1_m1_153600_0 0 3.209805e-07
I3169 n1_m1_153600_4800 0 3.943747e-07
I3170 n1_m1_153600_9600 0 3.937280e-07
I3171 n1_m1_153600_14400 0 2.173863e-07
I3172 n1_m1_153600_19200 0 2.180338e-07
I3173 n1_m1_153600_24000 0 3.241129e-07
I3174 n1_m1_153600_28800 0 2.089842e-07
I3175 n1_m1_153600_33600 0 3.018160e-07
I3176 n1_m1_153600_38400 0 2.069417e-07
I3177 n1_m1_153600_43200 0 2.079993e-07
I3178 n1_m1_153600_48000 0 3.136216e-07
I3179 n1_m1_153600_52800 0 2.179495e-07
I3180 n1_m1_153600_57600 0 3.454886e-07
I3181 n1_m1_153600_62400 0 2.572225e-07
I3182 n1_m1_153600_67200 0 2.548643e-07
I3183 n1_m1_153600_72000 0 3.643480e-07
I3184 n1_m1_153600_76800 0 2.508632e-07
I3185 n1_m1_153600_81600 0 3.637104e-07
I3186 n1_m1_153600_86400 0 2.441949e-07
I3187 n1_m1_153600_91200 0 2.500388e-07
I3188 n1_m1_153600_96000 0 3.753001e-07
I3189 n1_m1_153600_100800 0 2.469145e-07
I3190 n1_m1_153600_105600 0 3.458096e-07
I3191 n1_m1_153600_110400 0 2.256433e-07
I3192 n1_m1_153600_115200 0 2.287517e-07
I3193 n1_m1_153600_120000 0 3.379819e-07
I3194 n1_m1_153600_124800 0 2.284923e-07
I3195 n1_m1_153600_129600 0 3.376760e-07
I3196 n1_m1_153600_134400 0 2.200237e-07
I3197 n1_m1_153600_139200 0 2.220991e-07
I3198 n1_m1_153600_144000 0 3.449760e-07
I3199 n1_m1_153600_148800 0 2.215201e-07
I3200 n1_m1_153600_153600 0 3.310380e-07
I3201 n1_m1_153600_158400 0 2.220960e-07
I3202 n1_m1_153600_163200 0 2.310348e-07
I3203 n1_m1_153600_168000 0 3.631133e-07
I3204 n1_m1_153600_172800 0 2.370577e-07
I3205 n1_m1_153600_177600 0 3.365476e-07
I3206 n1_m1_153600_182400 0 2.258964e-07
I3207 n1_m1_153600_187200 0 2.474121e-07
I3208 n1_m1_153600_192000 0 3.367389e-07
I3209 n1_m1_153600_196800 0 2.226469e-07
I3210 n1_m1_153600_201600 0 3.663145e-07
I3211 n1_m1_153600_206400 0 2.371405e-07
I3212 n1_m1_153600_211200 0 2.804438e-07
I3213 n1_m1_153600_216000 0 4.204858e-07
I3214 n1_m1_153600_220800 0 2.386895e-07
I3215 n1_m1_153600_225600 0 3.385769e-07
I3216 n1_m1_153600_230400 0 2.201158e-07
I3217 n1_m1_153600_235200 0 2.232084e-07
I3218 n1_m1_153600_240000 0 3.424303e-07
I3219 n1_m1_153600_244800 0 2.335793e-07
I3220 n1_m1_153600_249600 0 3.519081e-07
I3221 n1_m1_153600_254400 0 2.295219e-07
I3222 n1_m1_153600_259200 0 2.161470e-07
I3223 n1_m1_153600_264000 0 3.419870e-07
I3224 n1_m1_153600_268800 0 2.214866e-07
I3225 n1_m1_153600_273600 0 4.089753e-07
I3226 n1_m1_153600_278400 0 2.588308e-07
I3227 n1_m1_153600_283200 0 5.051335e-07
I3228 n1_m1_153600_288000 0 8.083462e-07
I3229 n1_m1_153600_292800 0 1.017696e-06
I3230 n1_m1_153600_297600 0 1.947779e-06
I3231 n1_m1_153600_302400 0 8.804782e-07
I3232 n1_m1_153600_307200 0 3.895180e-07
I3233 n1_m1_153600_312000 0 5.029686e-07
I3234 n1_m1_153600_316800 0 7.832128e-07
I3235 n1_m1_153600_321600 0 1.222801e-06
I3236 n1_m1_153600_326400 0 8.349476e-07
I3237 n1_m1_153600_331200 0 8.050414e-07
I3238 n1_m1_153600_336000 0 2.218075e-06
I3239 n1_m1_153600_340800 0 1.545775e-06
I3240 n1_m1_153600_345600 0 2.246187e-06
I3241 n1_m1_153600_350400 0 1.372198e-06
I3242 n1_m1_153600_355200 0 7.797965e-07
I3243 n1_m1_153600_360000 0 1.825797e-06
I3244 n1_m1_153600_364800 0 1.975260e-06
I3245 n1_m1_153600_369600 0 2.765195e-06
I3246 n1_m1_153600_374400 0 1.303610e-06
I3247 n1_m1_153600_379200 0 6.413402e-07
I3248 n1_m1_153600_384000 0 1.908231e-06
I3249 n1_m1_153600_388800 0 9.241617e-07
I3250 n1_m1_153600_393600 0 6.460533e-07
I3251 n1_m1_153600_398400 0 2.197697e-07
I3252 n1_m1_153600_403200 0 2.107193e-07
I3253 n1_m1_153600_408000 0 3.147904e-07
I3254 n1_m1_153600_412800 0 2.101323e-07
I3255 n1_m1_153600_417600 0 3.274464e-07
I3256 n1_m1_153600_422400 0 2.174901e-07
I3257 n1_m1_153600_427200 0 2.122086e-07
I3258 n1_m1_153600_432000 0 3.263638e-07
I3259 n1_m1_153600_436800 0 2.239385e-07
I3260 n1_m1_153600_441600 0 3.481760e-07
I3261 n1_m1_153600_446400 0 2.394331e-07
I3262 n1_m1_153600_451200 0 2.485518e-07
I3263 n1_m1_153600_456000 0 3.846231e-07
I3264 n1_m1_153600_460800 0 2.710458e-07
I3265 n1_m1_153600_465600 0 3.710334e-07
I3266 n1_m1_153600_470400 0 1.171645e-07
I3267 n1_m1_158400_0 0 2.060536e-07
I3268 n1_m1_158400_4800 0 2.532926e-07
I3269 n1_m1_158400_9600 0 2.583987e-07
I3270 n1_m1_158400_14400 0 1.474765e-07
I3271 n1_m1_158400_19200 0 1.478937e-07
I3272 n1_m1_158400_24000 0 2.149110e-07
I3273 n1_m1_158400_28800 0 1.410217e-07
I3274 n1_m1_158400_33600 0 2.155308e-07
I3275 n1_m1_158400_38400 0 1.452958e-07
I3276 n1_m1_158400_43200 0 1.452958e-07
I3277 n1_m1_158400_48000 0 2.200379e-07
I3278 n1_m1_158400_52800 0 1.527599e-07
I3279 n1_m1_158400_57600 0 2.394160e-07
I3280 n1_m1_158400_62400 0 1.799295e-07
I3281 n1_m1_158400_67200 0 1.826600e-07
I3282 n1_m1_158400_72000 0 2.682182e-07
I3283 n1_m1_158400_76800 0 1.883171e-07
I3284 n1_m1_158400_81600 0 2.689704e-07
I3285 n1_m1_158400_86400 0 1.778474e-07
I3286 n1_m1_158400_91200 0 1.721417e-07
I3287 n1_m1_158400_96000 0 2.629436e-07
I3288 n1_m1_158400_100800 0 1.722806e-07
I3289 n1_m1_158400_105600 0 2.496505e-07
I3290 n1_m1_158400_110400 0 1.595869e-07
I3291 n1_m1_158400_115200 0 1.573023e-07
I3292 n1_m1_158400_120000 0 2.248105e-07
I3293 n1_m1_158400_124800 0 1.564181e-07
I3294 n1_m1_158400_129600 0 2.362720e-07
I3295 n1_m1_158400_134400 0 1.513835e-07
I3296 n1_m1_158400_139200 0 1.504615e-07
I3297 n1_m1_158400_144000 0 2.434590e-07
I3298 n1_m1_158400_148800 0 1.682853e-07
I3299 n1_m1_158400_153600 0 2.441566e-07
I3300 n1_m1_158400_158400 0 1.773567e-07
I3301 n1_m1_158400_163200 0 1.729479e-07
I3302 n1_m1_158400_168000 0 2.601190e-07
I3303 n1_m1_158400_172800 0 1.695430e-07
I3304 n1_m1_158400_177600 0 2.517385e-07
I3305 n1_m1_158400_182400 0 1.591864e-07
I3306 n1_m1_158400_187200 0 1.779361e-07
I3307 n1_m1_158400_192000 0 2.424507e-07
I3308 n1_m1_158400_196800 0 1.605654e-07
I3309 n1_m1_158400_201600 0 2.420654e-07
I3310 n1_m1_158400_206400 0 1.899767e-07
I3311 n1_m1_158400_211200 0 3.864515e-07
I3312 n1_m1_158400_216000 0 4.824889e-07
I3313 n1_m1_158400_220800 0 2.011616e-07
I3314 n1_m1_158400_225600 0 2.677120e-07
I3315 n1_m1_158400_230400 0 1.747065e-07
I3316 n1_m1_158400_235200 0 1.740472e-07
I3317 n1_m1_158400_240000 0 2.513835e-07
I3318 n1_m1_158400_244800 0 1.591233e-07
I3319 n1_m1_158400_249600 0 2.388578e-07
I3320 n1_m1_158400_254400 0 1.541183e-07
I3321 n1_m1_158400_259200 0 1.607493e-07
I3322 n1_m1_158400_264000 0 2.693544e-07
I3323 n1_m1_158400_268800 0 1.552951e-07
I3324 n1_m1_158400_273600 0 2.382153e-07
I3325 n1_m1_158400_278400 0 2.178850e-07
I3326 n1_m1_158400_283200 0 6.226979e-07
I3327 n1_m1_158400_288000 0 7.999196e-07
I3328 n1_m1_158400_292800 0 5.494728e-07
I3329 n1_m1_158400_297600 0 1.063373e-06
I3330 n1_m1_158400_302400 0 7.089520e-07
I3331 n1_m1_158400_307200 0 3.525184e-07
I3332 n1_m1_158400_312000 0 3.442686e-07
I3333 n1_m1_158400_316800 0 2.412006e-07
I3334 n1_m1_158400_321600 0 4.940868e-07
I3335 n1_m1_158400_326400 0 5.087961e-07
I3336 n1_m1_158400_331200 0 4.901854e-07
I3337 n1_m1_158400_336000 0 8.642869e-07
I3338 n1_m1_158400_340800 0 4.188613e-07
I3339 n1_m1_158400_345600 0 6.685814e-07
I3340 n1_m1_158400_350400 0 5.521990e-07
I3341 n1_m1_158400_355200 0 3.215774e-07
I3342 n1_m1_158400_360000 0 6.363333e-07
I3343 n1_m1_158400_364800 0 8.052373e-07
I3344 n1_m1_158400_369600 0 1.331113e-06
I3345 n1_m1_158400_374400 0 8.675445e-07
I3346 n1_m1_158400_379200 0 4.120013e-07
I3347 n1_m1_158400_384000 0 9.593656e-07
I3348 n1_m1_158400_388800 0 5.056549e-07
I3349 n1_m1_158400_393600 0 4.446930e-07
I3350 n1_m1_158400_398400 0 1.550216e-07
I3351 n1_m1_158400_403200 0 1.367189e-07
I3352 n1_m1_158400_408000 0 2.091454e-07
I3353 n1_m1_158400_412800 0 1.413282e-07
I3354 n1_m1_158400_417600 0 2.134316e-07
I3355 n1_m1_158400_422400 0 1.460297e-07
I3356 n1_m1_158400_427200 0 1.453084e-07
I3357 n1_m1_158400_432000 0 2.192214e-07
I3358 n1_m1_158400_436800 0 1.469213e-07
I3359 n1_m1_158400_441600 0 2.181187e-07
I3360 n1_m1_158400_446400 0 1.532267e-07
I3361 n1_m1_158400_451200 0 1.599749e-07
I3362 n1_m1_158400_456000 0 2.422071e-07
I3363 n1_m1_158400_460800 0 1.672486e-07
I3364 n1_m1_158400_465600 0 2.400267e-07
I3365 n1_m1_158400_470400 0 7.752160e-08
I3366 n1_m1_163200_0 0 2.155310e-07
I3367 n1_m1_163200_4800 0 2.959316e-07
I3368 n1_m1_163200_9600 0 3.133791e-07
I3369 n1_m1_163200_14400 0 1.578253e-07
I3370 n1_m1_163200_19200 0 1.654112e-07
I3371 n1_m1_163200_24000 0 2.273137e-07
I3372 n1_m1_163200_28800 0 1.472917e-07
I3373 n1_m1_163200_33600 0 2.252113e-07
I3374 n1_m1_163200_38400 0 1.465661e-07
I3375 n1_m1_163200_43200 0 1.465661e-07
I3376 n1_m1_163200_48000 0 2.201477e-07
I3377 n1_m1_163200_52800 0 1.496411e-07
I3378 n1_m1_163200_57600 0 2.328381e-07
I3379 n1_m1_163200_62400 0 1.705930e-07
I3380 n1_m1_163200_67200 0 1.695614e-07
I3381 n1_m1_163200_72000 0 2.593815e-07
I3382 n1_m1_163200_76800 0 1.826712e-07
I3383 n1_m1_163200_81600 0 2.566154e-07
I3384 n1_m1_163200_86400 0 1.662083e-07
I3385 n1_m1_163200_91200 0 1.622340e-07
I3386 n1_m1_163200_96000 0 2.500395e-07
I3387 n1_m1_163200_100800 0 1.673191e-07
I3388 n1_m1_163200_105600 0 2.439175e-07
I3389 n1_m1_163200_110400 0 1.609057e-07
I3390 n1_m1_163200_115200 0 1.600210e-07
I3391 n1_m1_163200_120000 0 2.333098e-07
I3392 n1_m1_163200_124800 0 1.595962e-07
I3393 n1_m1_163200_129600 0 2.454261e-07
I3394 n1_m1_163200_134400 0 1.790801e-07
I3395 n1_m1_163200_139200 0 2.291793e-07
I3396 n1_m1_163200_144000 0 4.955749e-07
I3397 n1_m1_163200_148800 0 3.009326e-07
I3398 n1_m1_163200_153600 0 3.919028e-07
I3399 n1_m1_163200_158400 0 2.633496e-07
I3400 n1_m1_163200_163200 0 2.483363e-07
I3401 n1_m1_163200_168000 0 4.159497e-07
I3402 n1_m1_163200_172800 0 1.684650e-07
I3403 n1_m1_163200_177600 0 2.482681e-07
I3404 n1_m1_163200_182400 0 2.302056e-07
I3405 n1_m1_163200_187200 0 3.364927e-07
I3406 n1_m1_163200_192000 0 3.483863e-07
I3407 n1_m1_163200_196800 0 1.701725e-07
I3408 n1_m1_163200_201600 0 2.465420e-07
I3409 n1_m1_163200_206400 0 2.506363e-07
I3410 n1_m1_163200_211200 0 5.391690e-07
I3411 n1_m1_163200_216000 0 4.946646e-07
I3412 n1_m1_163200_220800 0 1.773173e-07
I3413 n1_m1_163200_225600 0 3.191285e-07
I3414 n1_m1_163200_230400 0 3.394754e-07
I3415 n1_m1_163200_235200 0 3.636064e-07
I3416 n1_m1_163200_240000 0 4.970250e-07
I3417 n1_m1_163200_244800 0 2.817635e-07
I3418 n1_m1_163200_249600 0 4.396922e-07
I3419 n1_m1_163200_254400 0 2.884899e-07
I3420 n1_m1_163200_259200 0 2.431553e-07
I3421 n1_m1_163200_264000 0 2.995829e-07
I3422 n1_m1_163200_268800 0 2.249928e-07
I3423 n1_m1_163200_273600 0 4.215926e-07
I3424 n1_m1_163200_278400 0 2.958369e-07
I3425 n1_m1_163200_283200 0 4.518683e-07
I3426 n1_m1_163200_288000 0 5.685315e-07
I3427 n1_m1_163200_292800 0 6.300558e-07
I3428 n1_m1_163200_297600 0 1.535334e-06
I3429 n1_m1_163200_302400 0 8.702964e-07
I3430 n1_m1_163200_307200 0 3.490888e-07
I3431 n1_m1_163200_312000 0 2.905028e-07
I3432 n1_m1_163200_316800 0 2.693936e-07
I3433 n1_m1_163200_321600 0 6.041629e-07
I3434 n1_m1_163200_326400 0 3.158303e-07
I3435 n1_m1_163200_331200 0 3.448237e-07
I3436 n1_m1_163200_336000 0 5.610951e-07
I3437 n1_m1_163200_340800 0 3.961624e-07
I3438 n1_m1_163200_345600 0 7.316487e-07
I3439 n1_m1_163200_350400 0 4.012511e-07
I3440 n1_m1_163200_355200 0 2.101746e-07
I3441 n1_m1_163200_360000 0 4.497600e-07
I3442 n1_m1_163200_364800 0 5.219684e-07
I3443 n1_m1_163200_369600 0 8.027380e-07
I3444 n1_m1_163200_374400 0 6.576667e-07
I3445 n1_m1_163200_379200 0 3.383666e-07
I3446 n1_m1_163200_384000 0 1.235525e-06
I3447 n1_m1_163200_388800 0 6.559928e-07
I3448 n1_m1_163200_393600 0 4.690880e-07
I3449 n1_m1_163200_398400 0 1.440885e-07
I3450 n1_m1_163200_403200 0 1.436757e-07
I3451 n1_m1_163200_408000 0 2.103476e-07
I3452 n1_m1_163200_412800 0 1.395338e-07
I3453 n1_m1_163200_417600 0 2.104195e-07
I3454 n1_m1_163200_422400 0 1.408920e-07
I3455 n1_m1_163200_427200 0 1.413568e-07
I3456 n1_m1_163200_432000 0 2.181621e-07
I3457 n1_m1_163200_436800 0 1.465661e-07
I3458 n1_m1_163200_441600 0 2.154787e-07
I3459 n1_m1_163200_446400 0 1.481781e-07
I3460 n1_m1_163200_451200 0 1.545278e-07
I3461 n1_m1_163200_456000 0 2.377262e-07
I3462 n1_m1_163200_460800 0 1.663587e-07
I3463 n1_m1_163200_465600 0 2.394468e-07
I3464 n1_m1_163200_470400 0 7.746993e-08
I3465 n1_m1_168000_0 0 3.879713e-07
I3466 n1_m1_168000_4800 0 6.191464e-07
I3467 n1_m1_168000_9600 0 6.456917e-07
I3468 n1_m1_168000_14400 0 2.726301e-07
I3469 n1_m1_168000_19200 0 3.103230e-07
I3470 n1_m1_168000_24000 0 3.965408e-07
I3471 n1_m1_168000_28800 0 2.400031e-07
I3472 n1_m1_168000_33600 0 3.539240e-07
I3473 n1_m1_168000_38400 0 2.264734e-07
I3474 n1_m1_168000_43200 0 2.238577e-07
I3475 n1_m1_168000_48000 0 3.379837e-07
I3476 n1_m1_168000_52800 0 2.383834e-07
I3477 n1_m1_168000_57600 0 3.709468e-07
I3478 n1_m1_168000_62400 0 2.623171e-07
I3479 n1_m1_168000_67200 0 2.517444e-07
I3480 n1_m1_168000_72000 0 4.334249e-07
I3481 n1_m1_168000_76800 0 3.735749e-07
I3482 n1_m1_168000_81600 0 4.165465e-07
I3483 n1_m1_168000_86400 0 2.442925e-07
I3484 n1_m1_168000_91200 0 2.480154e-07
I3485 n1_m1_168000_96000 0 3.896326e-07
I3486 n1_m1_168000_100800 0 2.666897e-07
I3487 n1_m1_168000_105600 0 3.924868e-07
I3488 n1_m1_168000_110400 0 2.539297e-07
I3489 n1_m1_168000_115200 0 2.550304e-07
I3490 n1_m1_168000_120000 0 4.120721e-07
I3491 n1_m1_168000_124800 0 2.996552e-07
I3492 n1_m1_168000_129600 0 4.946386e-07
I3493 n1_m1_168000_134400 0 4.618421e-07
I3494 n1_m1_168000_139200 0 7.763488e-07
I3495 n1_m1_168000_144000 0 1.886308e-06
I3496 n1_m1_168000_148800 0 1.614643e-06
I3497 n1_m1_168000_153600 0 2.158775e-06
I3498 n1_m1_168000_158400 0 1.211655e-06
I3499 n1_m1_168000_163200 0 8.033711e-07
I3500 n1_m1_168000_168000 0 1.109894e-06
I3501 n1_m1_168000_172800 0 3.433627e-07
I3502 n1_m1_168000_177600 0 3.977622e-07
I3503 n1_m1_168000_182400 0 5.933984e-07
I3504 n1_m1_168000_187200 0 1.075974e-06
I3505 n1_m1_168000_192000 0 1.025279e-06
I3506 n1_m1_168000_196800 0 3.200075e-07
I3507 n1_m1_168000_201600 0 4.515600e-07
I3508 n1_m1_168000_206400 0 4.885541e-07
I3509 n1_m1_168000_211200 0 9.292243e-07
I3510 n1_m1_168000_216000 0 8.668464e-07
I3511 n1_m1_168000_220800 0 3.985441e-07
I3512 n1_m1_168000_225600 0 9.918013e-07
I3513 n1_m1_168000_230400 0 1.618928e-06
I3514 n1_m1_168000_235200 0 1.764834e-06
I3515 n1_m1_168000_240000 0 2.544611e-06
I3516 n1_m1_168000_244800 0 1.503351e-06
I3517 n1_m1_168000_249600 0 2.090755e-06
I3518 n1_m1_168000_254400 0 1.429278e-06
I3519 n1_m1_168000_259200 0 1.225584e-06
I3520 n1_m1_168000_264000 0 1.354368e-06
I3521 n1_m1_168000_268800 0 9.557062e-07
I3522 n1_m1_168000_273600 0 1.788028e-06
I3523 n1_m1_168000_278400 0 9.702139e-07
I3524 n1_m1_168000_283200 0 9.062386e-07
I3525 n1_m1_168000_288000 0 9.821525e-07
I3526 n1_m1_168000_292800 0 1.030901e-06
I3527 n1_m1_168000_297600 0 2.199642e-06
I3528 n1_m1_168000_302400 0 1.221484e-06
I3529 n1_m1_168000_307200 0 6.717207e-07
I3530 n1_m1_168000_312000 0 5.745399e-07
I3531 n1_m1_168000_316800 0 3.804423e-07
I3532 n1_m1_168000_321600 0 4.825981e-07
I3533 n1_m1_168000_326400 0 5.992674e-07
I3534 n1_m1_168000_331200 0 7.163806e-07
I3535 n1_m1_168000_336000 0 7.478485e-07
I3536 n1_m1_168000_340800 0 3.581335e-07
I3537 n1_m1_168000_345600 0 5.362165e-07
I3538 n1_m1_168000_350400 0 3.444231e-07
I3539 n1_m1_168000_355200 0 2.565251e-07
I3540 n1_m1_168000_360000 0 3.779407e-07
I3541 n1_m1_168000_364800 0 3.861640e-07
I3542 n1_m1_168000_369600 0 9.459616e-07
I3543 n1_m1_168000_374400 0 9.774121e-07
I3544 n1_m1_168000_379200 0 5.400777e-07
I3545 n1_m1_168000_384000 0 1.296226e-06
I3546 n1_m1_168000_388800 0 8.144296e-07
I3547 n1_m1_168000_393600 0 7.490728e-07
I3548 n1_m1_168000_398400 0 2.169125e-07
I3549 n1_m1_168000_403200 0 2.109116e-07
I3550 n1_m1_168000_408000 0 3.258802e-07
I3551 n1_m1_168000_412800 0 2.293912e-07
I3552 n1_m1_168000_417600 0 3.279736e-07
I3553 n1_m1_168000_422400 0 2.138645e-07
I3554 n1_m1_168000_427200 0 2.168618e-07
I3555 n1_m1_168000_432000 0 3.341485e-07
I3556 n1_m1_168000_436800 0 2.238577e-07
I3557 n1_m1_168000_441600 0 3.360657e-07
I3558 n1_m1_168000_446400 0 2.330604e-07
I3559 n1_m1_168000_451200 0 2.437778e-07
I3560 n1_m1_168000_456000 0 3.879755e-07
I3561 n1_m1_168000_460800 0 2.851209e-07
I3562 n1_m1_168000_465600 0 3.814074e-07
I3563 n1_m1_168000_470400 0 1.180442e-07
I3564 n1_m1_172800_0 0 1.163407e-07
I3565 n1_m1_172800_4800 0 1.805314e-07
I3566 n1_m1_172800_9600 0 1.819834e-07
I3567 n1_m1_172800_14400 0 8.364316e-08
I3568 n1_m1_172800_19200 0 8.876712e-08
I3569 n1_m1_172800_24000 0 1.309667e-07
I3570 n1_m1_172800_28800 0 8.722827e-08
I3571 n1_m1_172800_33600 0 1.335947e-07
I3572 n1_m1_172800_38400 0 8.627589e-08
I3573 n1_m1_172800_43200 0 8.618378e-08
I3574 n1_m1_172800_48000 0 1.336206e-07
I3575 n1_m1_172800_52800 0 1.016024e-07
I3576 n1_m1_172800_57600 0 1.580823e-07
I3577 n1_m1_172800_62400 0 8.893506e-08
I3578 n1_m1_172800_67200 0 8.485617e-08
I3579 n1_m1_172800_72000 0 1.945944e-07
I3580 n1_m1_172800_76800 0 2.268411e-07
I3581 n1_m1_172800_81600 0 2.236762e-07
I3582 n1_m1_172800_86400 0 8.733113e-08
I3583 n1_m1_172800_91200 0 8.477232e-08
I3584 n1_m1_172800_96000 0 1.367988e-07
I3585 n1_m1_172800_100800 0 9.257997e-08
I3586 n1_m1_172800_105600 0 1.325344e-07
I3587 n1_m1_172800_110400 0 8.385093e-08
I3588 n1_m1_172800_115200 0 8.187082e-08
I3589 n1_m1_172800_120000 0 1.457094e-07
I3590 n1_m1_172800_124800 0 1.467024e-07
I3591 n1_m1_172800_129600 0 2.512469e-07
I3592 n1_m1_172800_134400 0 1.494361e-07
I3593 n1_m1_172800_139200 0 1.497727e-07
I3594 n1_m1_172800_144000 0 3.332115e-07
I3595 n1_m1_172800_148800 0 4.704359e-07
I3596 n1_m1_172800_153600 0 3.706554e-07
I3597 n1_m1_172800_158400 0 1.747171e-07
I3598 n1_m1_172800_163200 0 2.780150e-07
I3599 n1_m1_172800_168000 0 7.223779e-07
I3600 n1_m1_172800_172800 0 1.994490e-07
I3601 n1_m1_172800_177600 0 1.697498e-07
I3602 n1_m1_172800_182400 0 1.221351e-07
I3603 n1_m1_172800_187200 0 1.812433e-07
I3604 n1_m1_172800_192000 0 2.380239e-07
I3605 n1_m1_172800_196800 0 1.382748e-07
I3606 n1_m1_172800_201600 0 1.731122e-07
I3607 n1_m1_172800_206400 0 3.502612e-07
I3608 n1_m1_172800_211200 0 5.454806e-07
I3609 n1_m1_172800_216000 0 6.461168e-07
I3610 n1_m1_172800_220800 0 2.540100e-07
I3611 n1_m1_172800_225600 0 2.307243e-07
I3612 n1_m1_172800_230400 0 3.537534e-07
I3613 n1_m1_172800_235200 0 4.871939e-07
I3614 n1_m1_172800_240000 0 7.539741e-07
I3615 n1_m1_172800_244800 0 3.353319e-07
I3616 n1_m1_172800_249600 0 3.609924e-07
I3617 n1_m1_172800_254400 0 3.738208e-07
I3618 n1_m1_172800_259200 0 4.443216e-07
I3619 n1_m1_172800_264000 0 4.583105e-07
I3620 n1_m1_172800_268800 0 1.496490e-07
I3621 n1_m1_172800_273600 0 3.065391e-07
I3622 n1_m1_172800_278400 0 2.106320e-07
I3623 n1_m1_172800_283200 0 2.658371e-07
I3624 n1_m1_172800_288000 0 2.592791e-07
I3625 n1_m1_172800_292800 0 2.370119e-07
I3626 n1_m1_172800_297600 0 6.612124e-07
I3627 n1_m1_172800_302400 0 4.618604e-07
I3628 n1_m1_172800_307200 0 2.876619e-07
I3629 n1_m1_172800_312000 0 1.761872e-07
I3630 n1_m1_172800_316800 0 1.683207e-07
I3631 n1_m1_172800_321600 0 1.580493e-07
I3632 n1_m1_172800_326400 0 1.438508e-07
I3633 n1_m1_172800_331200 0 1.442594e-07
I3634 n1_m1_172800_336000 0 2.137624e-07
I3635 n1_m1_172800_340800 0 1.804097e-07
I3636 n1_m1_172800_345600 0 1.686846e-07
I3637 n1_m1_172800_350400 0 8.756558e-08
I3638 n1_m1_172800_355200 0 8.110504e-08
I3639 n1_m1_172800_360000 0 1.218494e-07
I3640 n1_m1_172800_364800 0 1.281680e-07
I3641 n1_m1_172800_369600 0 2.230931e-07
I3642 n1_m1_172800_374400 0 2.001946e-07
I3643 n1_m1_172800_379200 0 9.763408e-08
I3644 n1_m1_172800_384000 0 4.199826e-07
I3645 n1_m1_172800_388800 0 1.227784e-07
I3646 n1_m1_172800_393600 0 1.331949e-07
I3647 n1_m1_172800_398400 0 8.077610e-08
I3648 n1_m1_172800_403200 0 7.469773e-08
I3649 n1_m1_172800_408000 0 1.278206e-07
I3650 n1_m1_172800_412800 0 8.871736e-08
I3651 n1_m1_172800_417600 0 1.184919e-07
I3652 n1_m1_172800_422400 0 7.328303e-08
I3653 n1_m1_172800_427200 0 7.509425e-08
I3654 n1_m1_172800_432000 0 1.185486e-07
I3655 n1_m1_172800_436800 0 7.891189e-08
I3656 n1_m1_172800_441600 0 1.152175e-07
I3657 n1_m1_172800_446400 0 7.991690e-08
I3658 n1_m1_172800_451200 0 8.353024e-08
I3659 n1_m1_172800_456000 0 1.411446e-07
I3660 n1_m1_172800_460800 0 1.238943e-07
I3661 n1_m1_172800_465600 0 1.378017e-07
I3662 n1_m1_172800_470400 0 3.983142e-08
I3663 n1_m1_177600_0 0 3.805384e-07
I3664 n1_m1_177600_4800 0 6.881982e-07
I3665 n1_m1_177600_9600 0 7.665133e-07
I3666 n1_m1_177600_14400 0 2.683047e-07
I3667 n1_m1_177600_19200 0 2.483886e-07
I3668 n1_m1_177600_24000 0 3.540614e-07
I3669 n1_m1_177600_28800 0 2.409729e-07
I3670 n1_m1_177600_33600 0 3.605364e-07
I3671 n1_m1_177600_38400 0 2.397143e-07
I3672 n1_m1_177600_43200 0 2.446767e-07
I3673 n1_m1_177600_48000 0 3.760066e-07
I3674 n1_m1_177600_52800 0 2.553460e-07
I3675 n1_m1_177600_57600 0 3.917072e-07
I3676 n1_m1_177600_62400 0 2.495771e-07
I3677 n1_m1_177600_67200 0 2.575352e-07
I3678 n1_m1_177600_72000 0 4.289553e-07
I3679 n1_m1_177600_76800 0 4.023376e-07
I3680 n1_m1_177600_81600 0 6.705908e-07
I3681 n1_m1_177600_86400 0 6.505348e-07
I3682 n1_m1_177600_91200 0 2.934656e-07
I3683 n1_m1_177600_96000 0 5.086732e-07
I3684 n1_m1_177600_100800 0 3.960826e-07
I3685 n1_m1_177600_105600 0 4.658310e-07
I3686 n1_m1_177600_110400 0 2.789108e-07
I3687 n1_m1_177600_115200 0 4.175206e-07
I3688 n1_m1_177600_120000 0 5.188442e-07
I3689 n1_m1_177600_124800 0 4.104891e-07
I3690 n1_m1_177600_129600 0 9.314141e-07
I3691 n1_m1_177600_134400 0 5.364481e-07
I3692 n1_m1_177600_139200 0 5.150228e-07
I3693 n1_m1_177600_144000 0 7.090669e-07
I3694 n1_m1_177600_148800 0 7.252931e-07
I3695 n1_m1_177600_153600 0 8.847670e-07
I3696 n1_m1_177600_158400 0 7.352875e-07
I3697 n1_m1_177600_163200 0 1.333788e-06
I3698 n1_m1_177600_168000 0 2.075258e-06
I3699 n1_m1_177600_172800 0 1.167569e-06
I3700 n1_m1_177600_177600 0 8.472831e-07
I3701 n1_m1_177600_182400 0 4.800715e-07
I3702 n1_m1_177600_187200 0 6.939542e-07
I3703 n1_m1_177600_192000 0 8.873466e-07
I3704 n1_m1_177600_196800 0 4.451834e-07
I3705 n1_m1_177600_201600 0 1.452550e-06
I3706 n1_m1_177600_206400 0 1.615361e-06
I3707 n1_m1_177600_211200 0 1.833628e-06
I3708 n1_m1_177600_216000 0 2.406079e-06
I3709 n1_m1_177600_220800 0 1.239926e-06
I3710 n1_m1_177600_225600 0 8.857372e-07
I3711 n1_m1_177600_230400 0 8.067528e-07
I3712 n1_m1_177600_235200 0 9.138784e-07
I3713 n1_m1_177600_240000 0 1.360626e-06
I3714 n1_m1_177600_244800 0 6.603718e-07
I3715 n1_m1_177600_249600 0 9.614724e-07
I3716 n1_m1_177600_254400 0 6.887033e-07
I3717 n1_m1_177600_259200 0 6.829356e-07
I3718 n1_m1_177600_264000 0 1.001491e-06
I3719 n1_m1_177600_268800 0 4.701319e-07
I3720 n1_m1_177600_273600 0 7.914911e-07
I3721 n1_m1_177600_278400 0 5.545557e-07
I3722 n1_m1_177600_283200 0 6.500843e-07
I3723 n1_m1_177600_288000 0 1.123950e-06
I3724 n1_m1_177600_292800 0 1.139650e-06
I3725 n1_m1_177600_297600 0 1.993289e-06
I3726 n1_m1_177600_302400 0 1.261197e-06
I3727 n1_m1_177600_307200 0 8.656331e-07
I3728 n1_m1_177600_312000 0 6.524775e-07
I3729 n1_m1_177600_316800 0 4.229652e-07
I3730 n1_m1_177600_321600 0 4.636045e-07
I3731 n1_m1_177600_326400 0 3.358178e-07
I3732 n1_m1_177600_331200 0 3.555283e-07
I3733 n1_m1_177600_336000 0 8.456617e-07
I3734 n1_m1_177600_340800 0 3.758110e-07
I3735 n1_m1_177600_345600 0 3.987623e-07
I3736 n1_m1_177600_350400 0 2.478355e-07
I3737 n1_m1_177600_355200 0 2.313779e-07
I3738 n1_m1_177600_360000 0 3.436588e-07
I3739 n1_m1_177600_364800 0 2.623396e-07
I3740 n1_m1_177600_369600 0 4.267130e-07
I3741 n1_m1_177600_374400 0 3.200910e-07
I3742 n1_m1_177600_379200 0 2.744793e-07
I3743 n1_m1_177600_384000 0 5.527464e-07
I3744 n1_m1_177600_388800 0 2.715772e-07
I3745 n1_m1_177600_393600 0 3.524690e-07
I3746 n1_m1_177600_398400 0 2.219585e-07
I3747 n1_m1_177600_403200 0 2.189099e-07
I3748 n1_m1_177600_408000 0 3.388930e-07
I3749 n1_m1_177600_412800 0 2.324130e-07
I3750 n1_m1_177600_417600 0 3.470248e-07
I3751 n1_m1_177600_422400 0 2.272521e-07
I3752 n1_m1_177600_427200 0 2.237866e-07
I3753 n1_m1_177600_432000 0 3.378118e-07
I3754 n1_m1_177600_436800 0 2.298054e-07
I3755 n1_m1_177600_441600 0 3.458629e-07
I3756 n1_m1_177600_446400 0 2.332553e-07
I3757 n1_m1_177600_451200 0 2.391346e-07
I3758 n1_m1_177600_456000 0 3.776278e-07
I3759 n1_m1_177600_460800 0 2.821671e-07
I3760 n1_m1_177600_465600 0 3.772697e-07
I3761 n1_m1_177600_470400 0 1.175888e-07
I3762 n1_m1_182400_0 0 2.880901e-07
I3763 n1_m1_182400_4800 0 5.373134e-07
I3764 n1_m1_182400_9600 0 6.090412e-07
I3765 n1_m1_182400_14400 0 1.815815e-07
I3766 n1_m1_182400_19200 0 1.546210e-07
I3767 n1_m1_182400_24000 0 2.372129e-07
I3768 n1_m1_182400_28800 0 1.521832e-07
I3769 n1_m1_182400_33600 0 2.158688e-07
I3770 n1_m1_182400_38400 0 1.462273e-07
I3771 n1_m1_182400_43200 0 1.534540e-07
I3772 n1_m1_182400_48000 0 2.347541e-07
I3773 n1_m1_182400_52800 0 1.509981e-07
I3774 n1_m1_182400_57600 0 2.311121e-07
I3775 n1_m1_182400_62400 0 1.657914e-07
I3776 n1_m1_182400_67200 0 1.572807e-07
I3777 n1_m1_182400_72000 0 2.521665e-07
I3778 n1_m1_182400_76800 0 4.747130e-07
I3779 n1_m1_182400_81600 0 5.878183e-07
I3780 n1_m1_182400_86400 0 3.550235e-07
I3781 n1_m1_182400_91200 0 4.236525e-07
I3782 n1_m1_182400_96000 0 8.409939e-07
I3783 n1_m1_182400_100800 0 6.587440e-07
I3784 n1_m1_182400_105600 0 6.896002e-07
I3785 n1_m1_182400_110400 0 4.226973e-07
I3786 n1_m1_182400_115200 0 2.808936e-07
I3787 n1_m1_182400_120000 0 6.173858e-07
I3788 n1_m1_182400_124800 0 6.754227e-07
I3789 n1_m1_182400_129600 0 1.217715e-06
I3790 n1_m1_182400_134400 0 7.187411e-07
I3791 n1_m1_182400_139200 0 5.710741e-07
I3792 n1_m1_182400_144000 0 8.747986e-07
I3793 n1_m1_182400_148800 0 7.289665e-07
I3794 n1_m1_182400_153600 0 5.731953e-07
I3795 n1_m1_182400_158400 0 3.745304e-07
I3796 n1_m1_182400_163200 0 5.533940e-07
I3797 n1_m1_182400_168000 0 1.192030e-06
I3798 n1_m1_182400_172800 0 7.409599e-07
I3799 n1_m1_182400_177600 0 6.539067e-07
I3800 n1_m1_182400_182400 0 3.393391e-07
I3801 n1_m1_182400_187200 0 3.598995e-07
I3802 n1_m1_182400_192000 0 7.872591e-07
I3803 n1_m1_182400_196800 0 3.474698e-07
I3804 n1_m1_182400_201600 0 6.732588e-07
I3805 n1_m1_182400_206400 0 8.150640e-07
I3806 n1_m1_182400_211200 0 1.219179e-06
I3807 n1_m1_182400_216000 0 1.760226e-06
I3808 n1_m1_182400_220800 0 1.001548e-06
I3809 n1_m1_182400_225600 0 6.567813e-07
I3810 n1_m1_182400_230400 0 3.633545e-07
I3811 n1_m1_182400_235200 0 5.407588e-07
I3812 n1_m1_182400_240000 0 5.176135e-07
I3813 n1_m1_182400_244800 0 3.373252e-07
I3814 n1_m1_182400_249600 0 3.547608e-07
I3815 n1_m1_182400_254400 0 2.642742e-07
I3816 n1_m1_182400_259200 0 4.116257e-07
I3817 n1_m1_182400_264000 0 5.361840e-07
I3818 n1_m1_182400_268800 0 1.890065e-07
I3819 n1_m1_182400_273600 0 2.929329e-07
I3820 n1_m1_182400_278400 0 2.539103e-07
I3821 n1_m1_182400_283200 0 3.331798e-07
I3822 n1_m1_182400_288000 0 5.328678e-07
I3823 n1_m1_182400_292800 0 4.003168e-07
I3824 n1_m1_182400_297600 0 1.165351e-06
I3825 n1_m1_182400_302400 0 8.739054e-07
I3826 n1_m1_182400_307200 0 4.024926e-07
I3827 n1_m1_182400_312000 0 4.759766e-07
I3828 n1_m1_182400_316800 0 1.942698e-07
I3829 n1_m1_182400_321600 0 3.891844e-07
I3830 n1_m1_182400_326400 0 1.784837e-07
I3831 n1_m1_182400_331200 0 1.718896e-07
I3832 n1_m1_182400_336000 0 2.771862e-07
I3833 n1_m1_182400_340800 0 1.690796e-07
I3834 n1_m1_182400_345600 0 2.378227e-07
I3835 n1_m1_182400_350400 0 1.576463e-07
I3836 n1_m1_182400_355200 0 1.451120e-07
I3837 n1_m1_182400_360000 0 2.146049e-07
I3838 n1_m1_182400_364800 0 1.467017e-07
I3839 n1_m1_182400_369600 0 2.360898e-07
I3840 n1_m1_182400_374400 0 1.645304e-07
I3841 n1_m1_182400_379200 0 1.630457e-07
I3842 n1_m1_182400_384000 0 2.509505e-07
I3843 n1_m1_182400_388800 0 1.603702e-07
I3844 n1_m1_182400_393600 0 2.198934e-07
I3845 n1_m1_182400_398400 0 1.404985e-07
I3846 n1_m1_182400_403200 0 1.410049e-07
I3847 n1_m1_182400_408000 0 2.194257e-07
I3848 n1_m1_182400_412800 0 1.447733e-07
I3849 n1_m1_182400_417600 0 2.305616e-07
I3850 n1_m1_182400_422400 0 1.611721e-07
I3851 n1_m1_182400_427200 0 1.617744e-07
I3852 n1_m1_182400_432000 0 2.433358e-07
I3853 n1_m1_182400_436800 0 1.708351e-07
I3854 n1_m1_182400_441600 0 2.583224e-07
I3855 n1_m1_182400_446400 0 1.643447e-07
I3856 n1_m1_182400_451200 0 1.558676e-07
I3857 n1_m1_182400_456000 0 2.289738e-07
I3858 n1_m1_182400_460800 0 1.665830e-07
I3859 n1_m1_182400_465600 0 2.461958e-07
I3860 n1_m1_182400_470400 0 7.916165e-08
I3861 n1_m1_187200_0 0 2.276949e-07
I3862 n1_m1_187200_4800 0 3.274806e-07
I3863 n1_m1_187200_9600 0 3.688417e-07
I3864 n1_m1_187200_14400 0 1.670244e-07
I3865 n1_m1_187200_19200 0 1.599099e-07
I3866 n1_m1_187200_24000 0 2.296497e-07
I3867 n1_m1_187200_28800 0 1.423317e-07
I3868 n1_m1_187200_33600 0 2.137832e-07
I3869 n1_m1_187200_38400 0 1.443187e-07
I3870 n1_m1_187200_43200 0 1.494454e-07
I3871 n1_m1_187200_48000 0 2.260004e-07
I3872 n1_m1_187200_52800 0 1.474531e-07
I3873 n1_m1_187200_57600 0 2.253373e-07
I3874 n1_m1_187200_62400 0 1.690482e-07
I3875 n1_m1_187200_67200 0 1.532301e-07
I3876 n1_m1_187200_72000 0 2.612324e-07
I3877 n1_m1_187200_76800 0 6.948061e-07
I3878 n1_m1_187200_81600 0 7.989511e-07
I3879 n1_m1_187200_86400 0 4.241267e-07
I3880 n1_m1_187200_91200 0 6.779987e-07
I3881 n1_m1_187200_96000 0 1.167008e-06
I3882 n1_m1_187200_100800 0 1.049375e-06
I3883 n1_m1_187200_105600 0 1.035151e-06
I3884 n1_m1_187200_110400 0 5.809701e-07
I3885 n1_m1_187200_115200 0 4.167309e-07
I3886 n1_m1_187200_120000 0 9.523606e-07
I3887 n1_m1_187200_124800 0 8.066153e-07
I3888 n1_m1_187200_129600 0 1.354172e-06
I3889 n1_m1_187200_134400 0 1.067766e-06
I3890 n1_m1_187200_139200 0 7.580601e-07
I3891 n1_m1_187200_144000 0 9.916410e-07
I3892 n1_m1_187200_148800 0 7.301414e-07
I3893 n1_m1_187200_153600 0 3.621215e-07
I3894 n1_m1_187200_158400 0 2.296061e-07
I3895 n1_m1_187200_163200 0 3.928258e-07
I3896 n1_m1_187200_168000 0 9.311439e-07
I3897 n1_m1_187200_172800 0 4.359241e-07
I3898 n1_m1_187200_177600 0 5.184929e-07
I3899 n1_m1_187200_182400 0 3.447495e-07
I3900 n1_m1_187200_187200 0 2.331197e-07
I3901 n1_m1_187200_192000 0 5.204737e-07
I3902 n1_m1_187200_196800 0 2.733028e-07
I3903 n1_m1_187200_201600 0 5.273860e-07
I3904 n1_m1_187200_206400 0 5.181474e-07
I3905 n1_m1_187200_211200 0 1.002600e-06
I3906 n1_m1_187200_216000 0 1.493274e-06
I3907 n1_m1_187200_220800 0 9.995840e-07
I3908 n1_m1_187200_225600 0 5.805632e-07
I3909 n1_m1_187200_230400 0 3.696936e-07
I3910 n1_m1_187200_235200 0 6.852924e-07
I3911 n1_m1_187200_240000 0 8.897848e-07
I3912 n1_m1_187200_244800 0 2.380337e-07
I3913 n1_m1_187200_249600 0 3.211611e-07
I3914 n1_m1_187200_254400 0 3.004028e-07
I3915 n1_m1_187200_259200 0 3.321928e-07
I3916 n1_m1_187200_264000 0 5.363160e-07
I3917 n1_m1_187200_268800 0 1.958442e-07
I3918 n1_m1_187200_273600 0 3.116995e-07
I3919 n1_m1_187200_278400 0 2.305097e-07
I3920 n1_m1_187200_283200 0 2.478525e-07
I3921 n1_m1_187200_288000 0 3.408651e-07
I3922 n1_m1_187200_292800 0 2.777728e-07
I3923 n1_m1_187200_297600 0 1.002085e-06
I3924 n1_m1_187200_302400 0 5.784441e-07
I3925 n1_m1_187200_307200 0 3.766516e-07
I3926 n1_m1_187200_312000 0 4.020483e-07
I3927 n1_m1_187200_316800 0 1.823590e-07
I3928 n1_m1_187200_321600 0 4.188112e-07
I3929 n1_m1_187200_326400 0 2.148942e-07
I3930 n1_m1_187200_331200 0 2.071417e-07
I3931 n1_m1_187200_336000 0 2.333726e-07
I3932 n1_m1_187200_340800 0 1.605965e-07
I3933 n1_m1_187200_345600 0 2.344960e-07
I3934 n1_m1_187200_350400 0 1.567910e-07
I3935 n1_m1_187200_355200 0 1.473859e-07
I3936 n1_m1_187200_360000 0 2.172207e-07
I3937 n1_m1_187200_364800 0 1.466508e-07
I3938 n1_m1_187200_369600 0 2.309432e-07
I3939 n1_m1_187200_374400 0 1.567850e-07
I3940 n1_m1_187200_379200 0 1.532282e-07
I3941 n1_m1_187200_384000 0 2.405452e-07
I3942 n1_m1_187200_388800 0 1.572070e-07
I3943 n1_m1_187200_393600 0 2.190305e-07
I3944 n1_m1_187200_398400 0 1.431221e-07
I3945 n1_m1_187200_403200 0 1.442230e-07
I3946 n1_m1_187200_408000 0 2.242529e-07
I3947 n1_m1_187200_412800 0 1.425881e-07
I3948 n1_m1_187200_417600 0 2.255703e-07
I3949 n1_m1_187200_422400 0 1.614448e-07
I3950 n1_m1_187200_427200 0 1.703351e-07
I3951 n1_m1_187200_432000 0 2.613743e-07
I3952 n1_m1_187200_436800 0 1.808397e-07
I3953 n1_m1_187200_441600 0 2.714110e-07
I3954 n1_m1_187200_446400 0 1.723958e-07
I3955 n1_m1_187200_451200 0 1.594331e-07
I3956 n1_m1_187200_456000 0 2.274966e-07
I3957 n1_m1_187200_460800 0 1.680660e-07
I3958 n1_m1_187200_465600 0 2.498575e-07
I3959 n1_m1_187200_470400 0 7.983460e-08
I3960 n1_m1_192000_0 0 3.612043e-07
I3961 n1_m1_192000_4800 0 6.735872e-07
I3962 n1_m1_192000_9600 0 1.318664e-06
I3963 n1_m1_192000_14400 0 3.770724e-07
I3964 n1_m1_192000_19200 0 2.416468e-07
I3965 n1_m1_192000_24000 0 3.488076e-07
I3966 n1_m1_192000_28800 0 2.222778e-07
I3967 n1_m1_192000_33600 0 3.360897e-07
I3968 n1_m1_192000_38400 0 2.206780e-07
I3969 n1_m1_192000_43200 0 2.210936e-07
I3970 n1_m1_192000_48000 0 3.325500e-07
I3971 n1_m1_192000_52800 0 2.295114e-07
I3972 n1_m1_192000_57600 0 3.442258e-07
I3973 n1_m1_192000_62400 0 2.514031e-07
I3974 n1_m1_192000_67200 0 2.456142e-07
I3975 n1_m1_192000_72000 0 4.272376e-07
I3976 n1_m1_192000_76800 0 8.337204e-07
I3977 n1_m1_192000_81600 0 9.749007e-07
I3978 n1_m1_192000_86400 0 6.749124e-07
I3979 n1_m1_192000_91200 0 6.220278e-07
I3980 n1_m1_192000_96000 0 1.126258e-06
I3981 n1_m1_192000_100800 0 9.749427e-07
I3982 n1_m1_192000_105600 0 1.039831e-06
I3983 n1_m1_192000_110400 0 4.227991e-07
I3984 n1_m1_192000_115200 0 4.610847e-07
I3985 n1_m1_192000_120000 0 6.756254e-07
I3986 n1_m1_192000_124800 0 7.076958e-07
I3987 n1_m1_192000_129600 0 1.708482e-06
I3988 n1_m1_192000_134400 0 9.626537e-07
I3989 n1_m1_192000_139200 0 7.455175e-07
I3990 n1_m1_192000_144000 0 6.773310e-07
I3991 n1_m1_192000_148800 0 5.118704e-07
I3992 n1_m1_192000_153600 0 6.854029e-07
I3993 n1_m1_192000_158400 0 3.077857e-07
I3994 n1_m1_192000_163200 0 2.884651e-07
I3995 n1_m1_192000_168000 0 4.585656e-07
I3996 n1_m1_192000_172800 0 8.815272e-07
I3997 n1_m1_192000_177600 0 6.737634e-07
I3998 n1_m1_192000_182400 0 3.300823e-07
I3999 n1_m1_192000_187200 0 2.795898e-07
I4000 n1_m1_192000_192000 0 6.509813e-07
I4001 n1_m1_192000_196800 0 5.976826e-07
I4002 n1_m1_192000_201600 0 5.201536e-07
I4003 n1_m1_192000_206400 0 5.037999e-07
I4004 n1_m1_192000_211200 0 1.207405e-06
I4005 n1_m1_192000_216000 0 1.726618e-06
I4006 n1_m1_192000_220800 0 1.326691e-06
I4007 n1_m1_192000_225600 0 7.830994e-07
I4008 n1_m1_192000_230400 0 5.996444e-07
I4009 n1_m1_192000_235200 0 5.713875e-07
I4010 n1_m1_192000_240000 0 1.858007e-06
I4011 n1_m1_192000_244800 0 4.230768e-07
I4012 n1_m1_192000_249600 0 4.162946e-07
I4013 n1_m1_192000_254400 0 3.289813e-07
I4014 n1_m1_192000_259200 0 7.376788e-07
I4015 n1_m1_192000_264000 0 1.494980e-06
I4016 n1_m1_192000_268800 0 2.879767e-07
I4017 n1_m1_192000_273600 0 4.392906e-07
I4018 n1_m1_192000_278400 0 3.089678e-07
I4019 n1_m1_192000_283200 0 3.671324e-07
I4020 n1_m1_192000_288000 0 5.296756e-07
I4021 n1_m1_192000_292800 0 2.788599e-07
I4022 n1_m1_192000_297600 0 6.397132e-07
I4023 n1_m1_192000_302400 0 5.757600e-07
I4024 n1_m1_192000_307200 0 9.398666e-07
I4025 n1_m1_192000_312000 0 6.622516e-07
I4026 n1_m1_192000_316800 0 2.606746e-07
I4027 n1_m1_192000_321600 0 3.715832e-07
I4028 n1_m1_192000_326400 0 3.580952e-07
I4029 n1_m1_192000_331200 0 3.740682e-07
I4030 n1_m1_192000_336000 0 3.558409e-07
I4031 n1_m1_192000_340800 0 2.320642e-07
I4032 n1_m1_192000_345600 0 3.422931e-07
I4033 n1_m1_192000_350400 0 2.406851e-07
I4034 n1_m1_192000_355200 0 2.352623e-07
I4035 n1_m1_192000_360000 0 3.353465e-07
I4036 n1_m1_192000_364800 0 2.199600e-07
I4037 n1_m1_192000_369600 0 3.447838e-07
I4038 n1_m1_192000_374400 0 2.344993e-07
I4039 n1_m1_192000_379200 0 2.291425e-07
I4040 n1_m1_192000_384000 0 3.461277e-07
I4041 n1_m1_192000_388800 0 2.291228e-07
I4042 n1_m1_192000_393600 0 3.305760e-07
I4043 n1_m1_192000_398400 0 2.185788e-07
I4044 n1_m1_192000_403200 0 2.202302e-07
I4045 n1_m1_192000_408000 0 3.422227e-07
I4046 n1_m1_192000_412800 0 2.147198e-07
I4047 n1_m1_192000_417600 0 3.272040e-07
I4048 n1_m1_192000_422400 0 2.270626e-07
I4049 n1_m1_192000_427200 0 2.387344e-07
I4050 n1_m1_192000_432000 0 3.706243e-07
I4051 n1_m1_192000_436800 0 2.459329e-07
I4052 n1_m1_192000_441600 0 3.686431e-07
I4053 n1_m1_192000_446400 0 2.438010e-07
I4054 n1_m1_192000_451200 0 2.463793e-07
I4055 n1_m1_192000_456000 0 3.929725e-07
I4056 n1_m1_192000_460800 0 3.082727e-07
I4057 n1_m1_192000_465600 0 3.895448e-07
I4058 n1_m1_192000_470400 0 1.183510e-07
I4059 n1_m1_196800_0 0 2.099861e-07
I4060 n1_m1_196800_4800 0 3.874358e-07
I4061 n1_m1_196800_9600 0 1.061380e-06
I4062 n1_m1_196800_14400 0 3.429618e-07
I4063 n1_m1_196800_19200 0 1.853302e-07
I4064 n1_m1_196800_24000 0 2.354522e-07
I4065 n1_m1_196800_28800 0 1.477381e-07
I4066 n1_m1_196800_33600 0 2.283455e-07
I4067 n1_m1_196800_38400 0 1.512870e-07
I4068 n1_m1_196800_43200 0 1.474476e-07
I4069 n1_m1_196800_48000 0 2.233313e-07
I4070 n1_m1_196800_52800 0 1.589569e-07
I4071 n1_m1_196800_57600 0 2.349030e-07
I4072 n1_m1_196800_62400 0 1.626719e-07
I4073 n1_m1_196800_67200 0 1.663966e-07
I4074 n1_m1_196800_72000 0 2.633056e-07
I4075 n1_m1_196800_76800 0 2.546765e-07
I4076 n1_m1_196800_81600 0 3.231605e-07
I4077 n1_m1_196800_86400 0 2.620951e-07
I4078 n1_m1_196800_91200 0 2.213718e-07
I4079 n1_m1_196800_96000 0 3.984590e-07
I4080 n1_m1_196800_100800 0 2.704514e-07
I4081 n1_m1_196800_105600 0 3.882635e-07
I4082 n1_m1_196800_110400 0 2.788124e-07
I4083 n1_m1_196800_115200 0 1.972442e-07
I4084 n1_m1_196800_120000 0 3.122383e-07
I4085 n1_m1_196800_124800 0 1.965672e-07
I4086 n1_m1_196800_129600 0 4.303365e-07
I4087 n1_m1_196800_134400 0 3.120763e-07
I4088 n1_m1_196800_139200 0 2.777226e-07
I4089 n1_m1_196800_144000 0 3.073012e-07
I4090 n1_m1_196800_148800 0 1.916173e-07
I4091 n1_m1_196800_153600 0 2.752595e-07
I4092 n1_m1_196800_158400 0 1.759448e-07
I4093 n1_m1_196800_163200 0 2.459262e-07
I4094 n1_m1_196800_168000 0 2.940515e-07
I4095 n1_m1_196800_172800 0 2.748561e-07
I4096 n1_m1_196800_177600 0 3.188530e-07
I4097 n1_m1_196800_182400 0 2.535203e-07
I4098 n1_m1_196800_187200 0 2.496670e-07
I4099 n1_m1_196800_192000 0 3.050790e-07
I4100 n1_m1_196800_196800 0 3.013749e-07
I4101 n1_m1_196800_201600 0 3.930054e-07
I4102 n1_m1_196800_206400 0 5.277372e-07
I4103 n1_m1_196800_211200 0 8.335085e-07
I4104 n1_m1_196800_216000 0 6.819492e-07
I4105 n1_m1_196800_220800 0 4.519361e-07
I4106 n1_m1_196800_225600 0 7.786648e-07
I4107 n1_m1_196800_230400 0 5.544167e-07
I4108 n1_m1_196800_235200 0 4.535446e-07
I4109 n1_m1_196800_240000 0 6.358284e-07
I4110 n1_m1_196800_244800 0 2.369084e-07
I4111 n1_m1_196800_249600 0 4.558921e-07
I4112 n1_m1_196800_254400 0 2.860430e-07
I4113 n1_m1_196800_259200 0 4.126148e-07
I4114 n1_m1_196800_264000 0 4.805808e-07
I4115 n1_m1_196800_268800 0 2.019405e-07
I4116 n1_m1_196800_273600 0 4.583258e-07
I4117 n1_m1_196800_278400 0 2.577573e-07
I4118 n1_m1_196800_283200 0 1.916170e-07
I4119 n1_m1_196800_288000 0 3.231974e-07
I4120 n1_m1_196800_292800 0 1.771297e-07
I4121 n1_m1_196800_297600 0 4.069700e-07
I4122 n1_m1_196800_302400 0 2.158108e-07
I4123 n1_m1_196800_307200 0 2.033794e-07
I4124 n1_m1_196800_312000 0 3.833168e-07
I4125 n1_m1_196800_316800 0 2.119269e-07
I4126 n1_m1_196800_321600 0 2.534273e-07
I4127 n1_m1_196800_326400 0 1.716819e-07
I4128 n1_m1_196800_331200 0 1.830951e-07
I4129 n1_m1_196800_336000 0 2.407949e-07
I4130 n1_m1_196800_340800 0 1.469378e-07
I4131 n1_m1_196800_345600 0 2.268116e-07
I4132 n1_m1_196800_350400 0 1.560607e-07
I4133 n1_m1_196800_355200 0 1.514697e-07
I4134 n1_m1_196800_360000 0 2.182111e-07
I4135 n1_m1_196800_364800 0 1.461877e-07
I4136 n1_m1_196800_369600 0 2.241172e-07
I4137 n1_m1_196800_374400 0 1.526401e-07
I4138 n1_m1_196800_379200 0 1.490010e-07
I4139 n1_m1_196800_384000 0 2.216447e-07
I4140 n1_m1_196800_388800 0 1.467589e-07
I4141 n1_m1_196800_393600 0 2.156093e-07
I4142 n1_m1_196800_398400 0 1.403883e-07
I4143 n1_m1_196800_403200 0 1.410024e-07
I4144 n1_m1_196800_408000 0 2.175765e-07
I4145 n1_m1_196800_412800 0 1.435134e-07
I4146 n1_m1_196800_417600 0 2.108290e-07
I4147 n1_m1_196800_422400 0 1.402808e-07
I4148 n1_m1_196800_427200 0 1.433133e-07
I4149 n1_m1_196800_432000 0 2.199436e-07
I4150 n1_m1_196800_436800 0 1.459558e-07
I4151 n1_m1_196800_441600 0 2.206113e-07
I4152 n1_m1_196800_446400 0 1.483831e-07
I4153 n1_m1_196800_451200 0 1.580689e-07
I4154 n1_m1_196800_456000 0 2.808331e-07
I4155 n1_m1_196800_460800 0 2.384169e-07
I4156 n1_m1_196800_465600 0 2.669601e-07
I4157 n1_m1_196800_470400 0 7.890065e-08
I4158 n1_m1_201600_0 0 2.171984e-07
I4159 n1_m1_201600_4800 0 3.659431e-07
I4160 n1_m1_201600_9600 0 9.965971e-07
I4161 n1_m1_201600_14400 0 3.259424e-07
I4162 n1_m1_201600_19200 0 1.824838e-07
I4163 n1_m1_201600_24000 0 2.352687e-07
I4164 n1_m1_201600_28800 0 1.541128e-07
I4165 n1_m1_201600_33600 0 2.430216e-07
I4166 n1_m1_201600_38400 0 1.586099e-07
I4167 n1_m1_201600_43200 0 1.579659e-07
I4168 n1_m1_201600_48000 0 2.386731e-07
I4169 n1_m1_201600_52800 0 1.723951e-07
I4170 n1_m1_201600_57600 0 2.609507e-07
I4171 n1_m1_201600_62400 0 1.682639e-07
I4172 n1_m1_201600_67200 0 1.688522e-07
I4173 n1_m1_201600_72000 0 2.462676e-07
I4174 n1_m1_201600_76800 0 2.773537e-07
I4175 n1_m1_201600_81600 0 3.074333e-07
I4176 n1_m1_201600_86400 0 2.427200e-07
I4177 n1_m1_201600_91200 0 3.307830e-07
I4178 n1_m1_201600_96000 0 3.888684e-07
I4179 n1_m1_201600_100800 0 4.366099e-07
I4180 n1_m1_201600_105600 0 5.101104e-07
I4181 n1_m1_201600_110400 0 3.379024e-07
I4182 n1_m1_201600_115200 0 2.161510e-07
I4183 n1_m1_201600_120000 0 4.827493e-07
I4184 n1_m1_201600_124800 0 5.204711e-07
I4185 n1_m1_201600_129600 0 8.742039e-07
I4186 n1_m1_201600_134400 0 5.886425e-07
I4187 n1_m1_201600_139200 0 3.579187e-07
I4188 n1_m1_201600_144000 0 4.871254e-07
I4189 n1_m1_201600_148800 0 2.651205e-07
I4190 n1_m1_201600_153600 0 3.557302e-07
I4191 n1_m1_201600_158400 0 1.953002e-07
I4192 n1_m1_201600_163200 0 2.164291e-07
I4193 n1_m1_201600_168000 0 5.968415e-07
I4194 n1_m1_201600_172800 0 2.900686e-07
I4195 n1_m1_201600_177600 0 3.586175e-07
I4196 n1_m1_201600_182400 0 3.381089e-07
I4197 n1_m1_201600_187200 0 3.188310e-07
I4198 n1_m1_201600_192000 0 5.243417e-07
I4199 n1_m1_201600_196800 0 2.045724e-07
I4200 n1_m1_201600_201600 0 4.024444e-07
I4201 n1_m1_201600_206400 0 4.342213e-07
I4202 n1_m1_201600_211200 0 9.391532e-07
I4203 n1_m1_201600_216000 0 7.376250e-07
I4204 n1_m1_201600_220800 0 8.496677e-07
I4205 n1_m1_201600_225600 0 8.389739e-07
I4206 n1_m1_201600_230400 0 5.240945e-07
I4207 n1_m1_201600_235200 0 8.772228e-07
I4208 n1_m1_201600_240000 0 9.343904e-07
I4209 n1_m1_201600_244800 0 5.733827e-07
I4210 n1_m1_201600_249600 0 5.606817e-07
I4211 n1_m1_201600_254400 0 4.174322e-07
I4212 n1_m1_201600_259200 0 5.645024e-07
I4213 n1_m1_201600_264000 0 1.367314e-06
I4214 n1_m1_201600_268800 0 5.519208e-07
I4215 n1_m1_201600_273600 0 6.909681e-07
I4216 n1_m1_201600_278400 0 6.798262e-07
I4217 n1_m1_201600_283200 0 8.832176e-07
I4218 n1_m1_201600_288000 0 1.333981e-06
I4219 n1_m1_201600_292800 0 3.348849e-07
I4220 n1_m1_201600_297600 0 4.573850e-07
I4221 n1_m1_201600_302400 0 3.040917e-07
I4222 n1_m1_201600_307200 0 1.934159e-07
I4223 n1_m1_201600_312000 0 4.836135e-07
I4224 n1_m1_201600_316800 0 2.519716e-07
I4225 n1_m1_201600_321600 0 3.238825e-07
I4226 n1_m1_201600_326400 0 2.349931e-07
I4227 n1_m1_201600_331200 0 1.719382e-07
I4228 n1_m1_201600_336000 0 2.587717e-07
I4229 n1_m1_201600_340800 0 1.522965e-07
I4230 n1_m1_201600_345600 0 2.411449e-07
I4231 n1_m1_201600_350400 0 1.505290e-07
I4232 n1_m1_201600_355200 0 1.502386e-07
I4233 n1_m1_201600_360000 0 2.144131e-07
I4234 n1_m1_201600_364800 0 1.458301e-07
I4235 n1_m1_201600_369600 0 2.304792e-07
I4236 n1_m1_201600_374400 0 1.553099e-07
I4237 n1_m1_201600_379200 0 1.517636e-07
I4238 n1_m1_201600_384000 0 2.337805e-07
I4239 n1_m1_201600_388800 0 1.516774e-07
I4240 n1_m1_201600_393600 0 2.226589e-07
I4241 n1_m1_201600_398400 0 1.452458e-07
I4242 n1_m1_201600_403200 0 1.450699e-07
I4243 n1_m1_201600_408000 0 2.176049e-07
I4244 n1_m1_201600_412800 0 1.543281e-07
I4245 n1_m1_201600_417600 0 2.183085e-07
I4246 n1_m1_201600_422400 0 1.400645e-07
I4247 n1_m1_201600_427200 0 1.399040e-07
I4248 n1_m1_201600_432000 0 2.171856e-07
I4249 n1_m1_201600_436800 0 1.454883e-07
I4250 n1_m1_201600_441600 0 2.236141e-07
I4251 n1_m1_201600_446400 0 1.472450e-07
I4252 n1_m1_201600_451200 0 1.468260e-07
I4253 n1_m1_201600_456000 0 2.332693e-07
I4254 n1_m1_201600_460800 0 1.800146e-07
I4255 n1_m1_201600_465600 0 2.549159e-07
I4256 n1_m1_201600_470400 0 7.933090e-08
I4257 n1_m1_206400_0 0 2.362264e-07
I4258 n1_m1_206400_4800 0 3.789974e-07
I4259 n1_m1_206400_9600 0 6.338126e-07
I4260 n1_m1_206400_14400 0 2.313838e-07
I4261 n1_m1_206400_19200 0 1.770968e-07
I4262 n1_m1_206400_24000 0 2.377457e-07
I4263 n1_m1_206400_28800 0 1.553267e-07
I4264 n1_m1_206400_33600 0 2.628740e-07
I4265 n1_m1_206400_38400 0 1.648368e-07
I4266 n1_m1_206400_43200 0 1.639787e-07
I4267 n1_m1_206400_48000 0 2.559088e-07
I4268 n1_m1_206400_52800 0 2.672152e-07
I4269 n1_m1_206400_57600 0 5.209340e-07
I4270 n1_m1_206400_62400 0 1.978667e-07
I4271 n1_m1_206400_67200 0 2.072772e-07
I4272 n1_m1_206400_72000 0 2.694009e-07
I4273 n1_m1_206400_76800 0 5.062481e-07
I4274 n1_m1_206400_81600 0 4.420458e-07
I4275 n1_m1_206400_86400 0 2.480594e-07
I4276 n1_m1_206400_91200 0 3.019700e-07
I4277 n1_m1_206400_96000 0 4.477270e-07
I4278 n1_m1_206400_100800 0 8.794656e-07
I4279 n1_m1_206400_105600 0 3.969233e-07
I4280 n1_m1_206400_110400 0 3.730136e-07
I4281 n1_m1_206400_115200 0 3.104094e-07
I4282 n1_m1_206400_120000 0 8.525576e-07
I4283 n1_m1_206400_124800 0 8.216619e-07
I4284 n1_m1_206400_129600 0 6.791383e-07
I4285 n1_m1_206400_134400 0 7.012366e-07
I4286 n1_m1_206400_139200 0 5.906520e-07
I4287 n1_m1_206400_144000 0 9.413054e-07
I4288 n1_m1_206400_148800 0 3.928036e-07
I4289 n1_m1_206400_153600 0 3.831172e-07
I4290 n1_m1_206400_158400 0 2.636220e-07
I4291 n1_m1_206400_163200 0 3.497666e-07
I4292 n1_m1_206400_168000 0 1.257164e-06
I4293 n1_m1_206400_172800 0 4.000766e-07
I4294 n1_m1_206400_177600 0 4.583037e-07
I4295 n1_m1_206400_182400 0 2.380761e-07
I4296 n1_m1_206400_187200 0 6.389187e-07
I4297 n1_m1_206400_192000 0 9.799698e-07
I4298 n1_m1_206400_196800 0 2.673450e-07
I4299 n1_m1_206400_201600 0 4.221973e-07
I4300 n1_m1_206400_206400 0 4.350081e-07
I4301 n1_m1_206400_211200 0 1.190153e-06
I4302 n1_m1_206400_216000 0 1.001912e-06
I4303 n1_m1_206400_220800 0 8.649287e-07
I4304 n1_m1_206400_225600 0 7.133204e-07
I4305 n1_m1_206400_230400 0 6.826094e-07
I4306 n1_m1_206400_235200 0 1.172303e-06
I4307 n1_m1_206400_240000 0 1.009608e-06
I4308 n1_m1_206400_244800 0 7.635531e-07
I4309 n1_m1_206400_249600 0 6.285019e-07
I4310 n1_m1_206400_254400 0 9.558466e-07
I4311 n1_m1_206400_259200 0 9.698393e-07
I4312 n1_m1_206400_264000 0 1.608718e-06
I4313 n1_m1_206400_268800 0 6.669271e-07
I4314 n1_m1_206400_273600 0 8.619095e-07
I4315 n1_m1_206400_278400 0 1.211635e-06
I4316 n1_m1_206400_283200 0 9.000588e-07
I4317 n1_m1_206400_288000 0 9.664158e-07
I4318 n1_m1_206400_292800 0 3.247434e-07
I4319 n1_m1_206400_297600 0 1.020809e-06
I4320 n1_m1_206400_302400 0 3.497401e-07
I4321 n1_m1_206400_307200 0 2.162720e-07
I4322 n1_m1_206400_312000 0 4.350299e-07
I4323 n1_m1_206400_316800 0 2.604906e-07
I4324 n1_m1_206400_321600 0 8.208239e-07
I4325 n1_m1_206400_326400 0 3.168303e-07
I4326 n1_m1_206400_331200 0 2.002382e-07
I4327 n1_m1_206400_336000 0 2.788516e-07
I4328 n1_m1_206400_340800 0 1.581472e-07
I4329 n1_m1_206400_345600 0 2.445686e-07
I4330 n1_m1_206400_350400 0 1.463573e-07
I4331 n1_m1_206400_355200 0 1.531185e-07
I4332 n1_m1_206400_360000 0 2.120435e-07
I4333 n1_m1_206400_364800 0 1.590219e-07
I4334 n1_m1_206400_369600 0 2.416526e-07
I4335 n1_m1_206400_374400 0 1.711559e-07
I4336 n1_m1_206400_379200 0 1.566860e-07
I4337 n1_m1_206400_384000 0 2.399743e-07
I4338 n1_m1_206400_388800 0 1.523973e-07
I4339 n1_m1_206400_393600 0 2.173042e-07
I4340 n1_m1_206400_398400 0 1.458460e-07
I4341 n1_m1_206400_403200 0 1.464681e-07
I4342 n1_m1_206400_408000 0 2.194045e-07
I4343 n1_m1_206400_412800 0 1.483354e-07
I4344 n1_m1_206400_417600 0 2.196336e-07
I4345 n1_m1_206400_422400 0 1.424140e-07
I4346 n1_m1_206400_427200 0 1.399040e-07
I4347 n1_m1_206400_432000 0 2.169892e-07
I4348 n1_m1_206400_436800 0 1.465661e-07
I4349 n1_m1_206400_441600 0 2.203307e-07
I4350 n1_m1_206400_446400 0 1.468086e-07
I4351 n1_m1_206400_451200 0 1.479451e-07
I4352 n1_m1_206400_456000 0 2.339069e-07
I4353 n1_m1_206400_460800 0 1.802274e-07
I4354 n1_m1_206400_465600 0 2.691807e-07
I4355 n1_m1_206400_470400 0 8.569611e-08
I4356 n1_m1_211200_0 0 2.862533e-07
I4357 n1_m1_211200_4800 0 5.541597e-07
I4358 n1_m1_211200_9600 0 7.154504e-07
I4359 n1_m1_211200_14400 0 2.360116e-07
I4360 n1_m1_211200_19200 0 2.646288e-07
I4361 n1_m1_211200_24000 0 2.748821e-07
I4362 n1_m1_211200_28800 0 1.541238e-07
I4363 n1_m1_211200_33600 0 3.232409e-07
I4364 n1_m1_211200_38400 0 1.739879e-07
I4365 n1_m1_211200_43200 0 1.660593e-07
I4366 n1_m1_211200_48000 0 3.909203e-07
I4367 n1_m1_211200_52800 0 5.062284e-07
I4368 n1_m1_211200_57600 0 8.074955e-07
I4369 n1_m1_211200_62400 0 5.560416e-07
I4370 n1_m1_211200_67200 0 4.455650e-07
I4371 n1_m1_211200_72000 0 3.422518e-07
I4372 n1_m1_211200_76800 0 4.488708e-07
I4373 n1_m1_211200_81600 0 3.964878e-07
I4374 n1_m1_211200_86400 0 2.015872e-07
I4375 n1_m1_211200_91200 0 2.218005e-07
I4376 n1_m1_211200_96000 0 4.507185e-07
I4377 n1_m1_211200_100800 0 3.820321e-07
I4378 n1_m1_211200_105600 0 8.719208e-07
I4379 n1_m1_211200_110400 0 4.067277e-07
I4380 n1_m1_211200_115200 0 2.691987e-07
I4381 n1_m1_211200_120000 0 6.093921e-07
I4382 n1_m1_211200_124800 0 3.883581e-07
I4383 n1_m1_211200_129600 0 8.710912e-07
I4384 n1_m1_211200_134400 0 6.244259e-07
I4385 n1_m1_211200_139200 0 4.231104e-07
I4386 n1_m1_211200_144000 0 6.029144e-07
I4387 n1_m1_211200_148800 0 5.918501e-07
I4388 n1_m1_211200_153600 0 1.119001e-06
I4389 n1_m1_211200_158400 0 3.256738e-07
I4390 n1_m1_211200_163200 0 6.081608e-07
I4391 n1_m1_211200_168000 0 8.156790e-07
I4392 n1_m1_211200_172800 0 7.060226e-07
I4393 n1_m1_211200_177600 0 5.011624e-07
I4394 n1_m1_211200_182400 0 3.034045e-07
I4395 n1_m1_211200_187200 0 4.280848e-07
I4396 n1_m1_211200_192000 0 7.142153e-07
I4397 n1_m1_211200_196800 0 7.807780e-07
I4398 n1_m1_211200_201600 0 8.125658e-07
I4399 n1_m1_211200_206400 0 7.624916e-07
I4400 n1_m1_211200_211200 0 1.117974e-06
I4401 n1_m1_211200_216000 0 1.284114e-06
I4402 n1_m1_211200_220800 0 8.140092e-07
I4403 n1_m1_211200_225600 0 8.009441e-07
I4404 n1_m1_211200_230400 0 7.393168e-07
I4405 n1_m1_211200_235200 0 7.582084e-07
I4406 n1_m1_211200_240000 0 1.412464e-06
I4407 n1_m1_211200_244800 0 5.019708e-07
I4408 n1_m1_211200_249600 0 9.869661e-07
I4409 n1_m1_211200_254400 0 6.023523e-07
I4410 n1_m1_211200_259200 0 8.574783e-07
I4411 n1_m1_211200_264000 0 1.525875e-06
I4412 n1_m1_211200_268800 0 4.212076e-07
I4413 n1_m1_211200_273600 0 1.027281e-06
I4414 n1_m1_211200_278400 0 6.576177e-07
I4415 n1_m1_211200_283200 0 8.709126e-07
I4416 n1_m1_211200_288000 0 8.141038e-07
I4417 n1_m1_211200_292800 0 4.793497e-07
I4418 n1_m1_211200_297600 0 9.821297e-07
I4419 n1_m1_211200_302400 0 3.353171e-07
I4420 n1_m1_211200_307200 0 3.192932e-07
I4421 n1_m1_211200_312000 0 4.571829e-07
I4422 n1_m1_211200_316800 0 3.039679e-07
I4423 n1_m1_211200_321600 0 5.821194e-07
I4424 n1_m1_211200_326400 0 5.018400e-07
I4425 n1_m1_211200_331200 0 5.037283e-07
I4426 n1_m1_211200_336000 0 3.648401e-07
I4427 n1_m1_211200_340800 0 1.606438e-07
I4428 n1_m1_211200_345600 0 2.599858e-07
I4429 n1_m1_211200_350400 0 1.515368e-07
I4430 n1_m1_211200_355200 0 1.464095e-07
I4431 n1_m1_211200_360000 0 2.129063e-07
I4432 n1_m1_211200_364800 0 1.487562e-07
I4433 n1_m1_211200_369600 0 3.335842e-07
I4434 n1_m1_211200_374400 0 3.147658e-07
I4435 n1_m1_211200_379200 0 1.842820e-07
I4436 n1_m1_211200_384000 0 2.580162e-07
I4437 n1_m1_211200_388800 0 1.587457e-07
I4438 n1_m1_211200_393600 0 2.241163e-07
I4439 n1_m1_211200_398400 0 1.465577e-07
I4440 n1_m1_211200_403200 0 1.457637e-07
I4441 n1_m1_211200_408000 0 2.156068e-07
I4442 n1_m1_211200_412800 0 1.463473e-07
I4443 n1_m1_211200_417600 0 2.175666e-07
I4444 n1_m1_211200_422400 0 1.403855e-07
I4445 n1_m1_211200_427200 0 1.399040e-07
I4446 n1_m1_211200_432000 0 2.120612e-07
I4447 n1_m1_211200_436800 0 1.459357e-07
I4448 n1_m1_211200_441600 0 2.160841e-07
I4449 n1_m1_211200_446400 0 1.472777e-07
I4450 n1_m1_211200_451200 0 1.591070e-07
I4451 n1_m1_211200_456000 0 3.074091e-07
I4452 n1_m1_211200_460800 0 2.723644e-07
I4453 n1_m1_211200_465600 0 2.827378e-07
I4454 n1_m1_211200_470400 0 8.094715e-08
I4455 n1_m1_216000_0 0 4.041591e-07
I4456 n1_m1_216000_4800 0 7.450293e-07
I4457 n1_m1_216000_9600 0 1.005858e-06
I4458 n1_m1_216000_14400 0 3.703094e-07
I4459 n1_m1_216000_19200 0 3.842036e-07
I4460 n1_m1_216000_24000 0 3.994389e-07
I4461 n1_m1_216000_28800 0 2.638630e-07
I4462 n1_m1_216000_33600 0 4.223756e-07
I4463 n1_m1_216000_38400 0 2.650139e-07
I4464 n1_m1_216000_43200 0 2.804601e-07
I4465 n1_m1_216000_48000 0 5.623230e-07
I4466 n1_m1_216000_52800 0 8.072777e-07
I4467 n1_m1_216000_57600 0 1.679816e-06
I4468 n1_m1_216000_62400 0 1.069786e-06
I4469 n1_m1_216000_67200 0 6.260169e-07
I4470 n1_m1_216000_72000 0 1.243378e-06
I4471 n1_m1_216000_76800 0 1.177977e-06
I4472 n1_m1_216000_81600 0 8.485694e-07
I4473 n1_m1_216000_86400 0 3.129275e-07
I4474 n1_m1_216000_91200 0 3.907406e-07
I4475 n1_m1_216000_96000 0 9.840077e-07
I4476 n1_m1_216000_100800 0 9.158838e-07
I4477 n1_m1_216000_105600 0 1.149499e-06
I4478 n1_m1_216000_110400 0 4.943886e-07
I4479 n1_m1_216000_115200 0 6.221014e-07
I4480 n1_m1_216000_120000 0 1.418560e-06
I4481 n1_m1_216000_124800 0 1.039078e-06
I4482 n1_m1_216000_129600 0 1.700232e-06
I4483 n1_m1_216000_134400 0 8.530086e-07
I4484 n1_m1_216000_139200 0 1.120548e-06
I4485 n1_m1_216000_144000 0 1.731327e-06
I4486 n1_m1_216000_148800 0 1.405921e-06
I4487 n1_m1_216000_153600 0 1.523447e-06
I4488 n1_m1_216000_158400 0 7.659074e-07
I4489 n1_m1_216000_163200 0 1.276419e-06
I4490 n1_m1_216000_168000 0 1.538191e-06
I4491 n1_m1_216000_172800 0 1.197042e-06
I4492 n1_m1_216000_177600 0 8.798382e-07
I4493 n1_m1_216000_182400 0 5.524497e-07
I4494 n1_m1_216000_187200 0 9.205778e-07
I4495 n1_m1_216000_192000 0 1.739658e-06
I4496 n1_m1_216000_196800 0 1.358024e-06
I4497 n1_m1_216000_201600 0 1.158390e-06
I4498 n1_m1_216000_206400 0 1.336770e-06
I4499 n1_m1_216000_211200 0 1.872489e-06
I4500 n1_m1_216000_216000 0 2.385970e-06
I4501 n1_m1_216000_220800 0 1.214988e-06
I4502 n1_m1_216000_225600 0 1.216078e-06
I4503 n1_m1_216000_230400 0 1.122316e-06
I4504 n1_m1_216000_235200 0 1.116367e-06
I4505 n1_m1_216000_240000 0 2.224922e-06
I4506 n1_m1_216000_244800 0 7.918897e-07
I4507 n1_m1_216000_249600 0 1.164081e-06
I4508 n1_m1_216000_254400 0 7.415235e-07
I4509 n1_m1_216000_259200 0 1.442815e-06
I4510 n1_m1_216000_264000 0 1.922940e-06
I4511 n1_m1_216000_268800 0 6.349752e-07
I4512 n1_m1_216000_273600 0 1.210108e-06
I4513 n1_m1_216000_278400 0 1.006405e-06
I4514 n1_m1_216000_283200 0 1.158374e-06
I4515 n1_m1_216000_288000 0 1.486117e-06
I4516 n1_m1_216000_292800 0 6.974224e-07
I4517 n1_m1_216000_297600 0 1.175307e-06
I4518 n1_m1_216000_302400 0 6.361752e-07
I4519 n1_m1_216000_307200 0 8.488162e-07
I4520 n1_m1_216000_312000 0 8.742314e-07
I4521 n1_m1_216000_316800 0 4.296679e-07
I4522 n1_m1_216000_321600 0 8.304638e-07
I4523 n1_m1_216000_326400 0 8.670296e-07
I4524 n1_m1_216000_331200 0 6.016466e-07
I4525 n1_m1_216000_336000 0 4.549850e-07
I4526 n1_m1_216000_340800 0 3.290830e-07
I4527 n1_m1_216000_345600 0 3.895203e-07
I4528 n1_m1_216000_350400 0 2.389032e-07
I4529 n1_m1_216000_355200 0 2.162884e-07
I4530 n1_m1_216000_360000 0 3.415162e-07
I4531 n1_m1_216000_364800 0 2.263336e-07
I4532 n1_m1_216000_369600 0 6.392589e-07
I4533 n1_m1_216000_374400 0 6.889189e-07
I4534 n1_m1_216000_379200 0 3.089752e-07
I4535 n1_m1_216000_384000 0 3.912154e-07
I4536 n1_m1_216000_388800 0 2.534062e-07
I4537 n1_m1_216000_393600 0 3.495581e-07
I4538 n1_m1_216000_398400 0 2.212348e-07
I4539 n1_m1_216000_403200 0 2.197418e-07
I4540 n1_m1_216000_408000 0 3.257018e-07
I4541 n1_m1_216000_412800 0 2.154524e-07
I4542 n1_m1_216000_417600 0 3.228943e-07
I4543 n1_m1_216000_422400 0 2.119866e-07
I4544 n1_m1_216000_427200 0 2.098560e-07
I4545 n1_m1_216000_432000 0 3.149353e-07
I4546 n1_m1_216000_436800 0 2.119657e-07
I4547 n1_m1_216000_441600 0 3.302132e-07
I4548 n1_m1_216000_446400 0 2.252777e-07
I4549 n1_m1_216000_451200 0 2.387841e-07
I4550 n1_m1_216000_456000 0 4.980722e-07
I4551 n1_m1_216000_460800 0 4.541464e-07
I4552 n1_m1_216000_465600 0 4.337715e-07
I4553 n1_m1_216000_470400 0 1.200917e-07
I4554 n1_m1_220800_0 0 2.825036e-07
I4555 n1_m1_220800_4800 0 5.910884e-07
I4556 n1_m1_220800_9600 0 1.005969e-06
I4557 n1_m1_220800_14400 0 2.647300e-07
I4558 n1_m1_220800_19200 0 1.634471e-07
I4559 n1_m1_220800_24000 0 3.681400e-07
I4560 n1_m1_220800_28800 0 2.622647e-07
I4561 n1_m1_220800_33600 0 2.639010e-07
I4562 n1_m1_220800_38400 0 1.922974e-07
I4563 n1_m1_220800_43200 0 2.344924e-07
I4564 n1_m1_220800_48000 0 3.981632e-07
I4565 n1_m1_220800_52800 0 4.862831e-07
I4566 n1_m1_220800_57600 0 9.844409e-07
I4567 n1_m1_220800_62400 0 2.996232e-07
I4568 n1_m1_220800_67200 0 4.663633e-07
I4569 n1_m1_220800_72000 0 1.436514e-06
I4570 n1_m1_220800_76800 0 1.065419e-06
I4571 n1_m1_220800_81600 0 6.592473e-07
I4572 n1_m1_220800_86400 0 4.170402e-07
I4573 n1_m1_220800_91200 0 5.467319e-07
I4574 n1_m1_220800_96000 0 1.023436e-06
I4575 n1_m1_220800_100800 0 1.142086e-06
I4576 n1_m1_220800_105600 0 1.112110e-06
I4577 n1_m1_220800_110400 0 7.130888e-07
I4578 n1_m1_220800_115200 0 8.257516e-07
I4579 n1_m1_220800_120000 0 1.601799e-06
I4580 n1_m1_220800_124800 0 7.804640e-07
I4581 n1_m1_220800_129600 0 1.439209e-06
I4582 n1_m1_220800_134400 0 1.071254e-06
I4583 n1_m1_220800_139200 0 1.184753e-06
I4584 n1_m1_220800_144000 0 1.855239e-06
I4585 n1_m1_220800_148800 0 1.087276e-06
I4586 n1_m1_220800_153600 0 1.001273e-06
I4587 n1_m1_220800_158400 0 9.271992e-07
I4588 n1_m1_220800_163200 0 1.153629e-06
I4589 n1_m1_220800_168000 0 1.345016e-06
I4590 n1_m1_220800_172800 0 9.649596e-07
I4591 n1_m1_220800_177600 0 8.286829e-07
I4592 n1_m1_220800_182400 0 6.377831e-07
I4593 n1_m1_220800_187200 0 9.159140e-07
I4594 n1_m1_220800_192000 0 1.689458e-06
I4595 n1_m1_220800_196800 0 6.616090e-07
I4596 n1_m1_220800_201600 0 1.498249e-06
I4597 n1_m1_220800_206400 0 1.339678e-06
I4598 n1_m1_220800_211200 0 1.267753e-06
I4599 n1_m1_220800_216000 0 1.338984e-06
I4600 n1_m1_220800_220800 0 7.449081e-07
I4601 n1_m1_220800_225600 0 1.142676e-06
I4602 n1_m1_220800_230400 0 1.067949e-06
I4603 n1_m1_220800_235200 0 1.051256e-06
I4604 n1_m1_220800_240000 0 1.638062e-06
I4605 n1_m1_220800_244800 0 8.410535e-07
I4606 n1_m1_220800_249600 0 1.349235e-06
I4607 n1_m1_220800_254400 0 7.870316e-07
I4608 n1_m1_220800_259200 0 1.109421e-06
I4609 n1_m1_220800_264000 0 8.430740e-07
I4610 n1_m1_220800_268800 0 8.992430e-07
I4611 n1_m1_220800_273600 0 1.295814e-06
I4612 n1_m1_220800_278400 0 1.185492e-06
I4613 n1_m1_220800_283200 0 9.490824e-07
I4614 n1_m1_220800_288000 0 1.206649e-06
I4615 n1_m1_220800_292800 0 1.022294e-06
I4616 n1_m1_220800_297600 0 1.280219e-06
I4617 n1_m1_220800_302400 0 7.868649e-07
I4618 n1_m1_220800_307200 0 5.320324e-07
I4619 n1_m1_220800_312000 0 9.149018e-07
I4620 n1_m1_220800_316800 0 6.809235e-07
I4621 n1_m1_220800_321600 0 1.267829e-06
I4622 n1_m1_220800_326400 0 6.833039e-07
I4623 n1_m1_220800_331200 0 4.808124e-07
I4624 n1_m1_220800_336000 0 9.784939e-07
I4625 n1_m1_220800_340800 0 3.630992e-07
I4626 n1_m1_220800_345600 0 2.417923e-07
I4627 n1_m1_220800_350400 0 1.617787e-07
I4628 n1_m1_220800_355200 0 1.576580e-07
I4629 n1_m1_220800_360000 0 2.204039e-07
I4630 n1_m1_220800_364800 0 1.459410e-07
I4631 n1_m1_220800_369600 0 3.279873e-07
I4632 n1_m1_220800_374400 0 3.310736e-07
I4633 n1_m1_220800_379200 0 2.844677e-07
I4634 n1_m1_220800_384000 0 3.162011e-07
I4635 n1_m1_220800_388800 0 1.649997e-07
I4636 n1_m1_220800_393600 0 2.266241e-07
I4637 n1_m1_220800_398400 0 1.434439e-07
I4638 n1_m1_220800_403200 0 1.460697e-07
I4639 n1_m1_220800_408000 0 2.198491e-07
I4640 n1_m1_220800_412800 0 1.450840e-07
I4641 n1_m1_220800_417600 0 2.176721e-07
I4642 n1_m1_220800_422400 0 1.456115e-07
I4643 n1_m1_220800_427200 0 1.445900e-07
I4644 n1_m1_220800_432000 0 2.168850e-07
I4645 n1_m1_220800_436800 0 1.432795e-07
I4646 n1_m1_220800_441600 0 2.173228e-07
I4647 n1_m1_220800_446400 0 1.512638e-07
I4648 n1_m1_220800_451200 0 1.780421e-07
I4649 n1_m1_220800_456000 0 3.956145e-07
I4650 n1_m1_220800_460800 0 2.666701e-07
I4651 n1_m1_220800_465600 0 2.720277e-07
I4652 n1_m1_220800_470400 0 8.093363e-08
I4653 n1_m1_225600_0 0 3.047157e-07
I4654 n1_m1_225600_4800 0 6.475930e-07
I4655 n1_m1_225600_9600 0 8.549723e-07
I4656 n1_m1_225600_14400 0 2.146755e-07
I4657 n1_m1_225600_19200 0 1.761636e-07
I4658 n1_m1_225600_24000 0 3.067215e-07
I4659 n1_m1_225600_28800 0 1.912268e-07
I4660 n1_m1_225600_33600 0 3.202951e-07
I4661 n1_m1_225600_38400 0 1.786550e-07
I4662 n1_m1_225600_43200 0 1.820334e-07
I4663 n1_m1_225600_48000 0 3.385546e-07
I4664 n1_m1_225600_52800 0 2.744707e-07
I4665 n1_m1_225600_57600 0 6.945987e-07
I4666 n1_m1_225600_62400 0 2.500316e-07
I4667 n1_m1_225600_67200 0 3.217753e-07
I4668 n1_m1_225600_72000 0 7.146794e-07
I4669 n1_m1_225600_76800 0 8.277205e-07
I4670 n1_m1_225600_81600 0 7.940176e-07
I4671 n1_m1_225600_86400 0 5.206220e-07
I4672 n1_m1_225600_91200 0 6.245235e-07
I4673 n1_m1_225600_96000 0 8.162733e-07
I4674 n1_m1_225600_100800 0 1.154016e-06
I4675 n1_m1_225600_105600 0 1.711645e-06
I4676 n1_m1_225600_110400 0 9.039573e-07
I4677 n1_m1_225600_115200 0 6.703426e-07
I4678 n1_m1_225600_120000 0 1.436281e-06
I4679 n1_m1_225600_124800 0 1.144825e-06
I4680 n1_m1_225600_129600 0 1.858229e-06
I4681 n1_m1_225600_134400 0 1.194731e-06
I4682 n1_m1_225600_139200 0 1.027947e-06
I4683 n1_m1_225600_144000 0 1.674260e-06
I4684 n1_m1_225600_148800 0 1.109840e-06
I4685 n1_m1_225600_153600 0 1.488658e-06
I4686 n1_m1_225600_158400 0 7.896415e-07
I4687 n1_m1_225600_163200 0 1.031655e-06
I4688 n1_m1_225600_168000 0 1.743136e-06
I4689 n1_m1_225600_172800 0 1.230209e-06
I4690 n1_m1_225600_177600 0 9.304750e-07
I4691 n1_m1_225600_182400 0 5.516990e-07
I4692 n1_m1_225600_187200 0 8.988038e-07
I4693 n1_m1_225600_192000 0 1.252275e-06
I4694 n1_m1_225600_196800 0 9.348538e-07
I4695 n1_m1_225600_201600 0 1.769063e-06
I4696 n1_m1_225600_206400 0 1.272370e-06
I4697 n1_m1_225600_211200 0 1.379475e-06
I4698 n1_m1_225600_216000 0 1.572263e-06
I4699 n1_m1_225600_220800 0 1.027723e-06
I4700 n1_m1_225600_225600 0 1.211355e-06
I4701 n1_m1_225600_230400 0 9.600889e-07
I4702 n1_m1_225600_235200 0 1.144130e-06
I4703 n1_m1_225600_240000 0 1.807889e-06
I4704 n1_m1_225600_244800 0 9.477785e-07
I4705 n1_m1_225600_249600 0 1.044238e-06
I4706 n1_m1_225600_254400 0 7.068308e-07
I4707 n1_m1_225600_259200 0 8.159320e-07
I4708 n1_m1_225600_264000 0 1.029595e-06
I4709 n1_m1_225600_268800 0 5.533705e-07
I4710 n1_m1_225600_273600 0 9.795467e-07
I4711 n1_m1_225600_278400 0 1.236066e-06
I4712 n1_m1_225600_283200 0 1.092226e-06
I4713 n1_m1_225600_288000 0 1.420009e-06
I4714 n1_m1_225600_292800 0 8.710773e-07
I4715 n1_m1_225600_297600 0 1.621919e-06
I4716 n1_m1_225600_302400 0 9.994728e-07
I4717 n1_m1_225600_307200 0 5.654721e-07
I4718 n1_m1_225600_312000 0 1.081014e-06
I4719 n1_m1_225600_316800 0 7.210082e-07
I4720 n1_m1_225600_321600 0 1.544758e-06
I4721 n1_m1_225600_326400 0 8.319969e-07
I4722 n1_m1_225600_331200 0 5.802756e-07
I4723 n1_m1_225600_336000 0 8.971722e-07
I4724 n1_m1_225600_340800 0 2.251721e-07
I4725 n1_m1_225600_345600 0 2.473580e-07
I4726 n1_m1_225600_350400 0 1.525514e-07
I4727 n1_m1_225600_355200 0 1.531905e-07
I4728 n1_m1_225600_360000 0 2.157548e-07
I4729 n1_m1_225600_364800 0 1.576840e-07
I4730 n1_m1_225600_369600 0 2.464694e-07
I4731 n1_m1_225600_374400 0 1.894242e-07
I4732 n1_m1_225600_379200 0 2.061723e-07
I4733 n1_m1_225600_384000 0 2.816903e-07
I4734 n1_m1_225600_388800 0 1.632221e-07
I4735 n1_m1_225600_393600 0 2.237890e-07
I4736 n1_m1_225600_398400 0 1.417106e-07
I4737 n1_m1_225600_403200 0 1.458603e-07
I4738 n1_m1_225600_408000 0 2.198491e-07
I4739 n1_m1_225600_412800 0 1.465661e-07
I4740 n1_m1_225600_417600 0 2.199278e-07
I4741 n1_m1_225600_422400 0 1.492045e-07
I4742 n1_m1_225600_427200 0 1.518167e-07
I4743 n1_m1_225600_432000 0 2.218552e-07
I4744 n1_m1_225600_436800 0 1.461161e-07
I4745 n1_m1_225600_441600 0 2.230687e-07
I4746 n1_m1_225600_446400 0 1.490071e-07
I4747 n1_m1_225600_451200 0 1.622434e-07
I4748 n1_m1_225600_456000 0 2.938998e-07
I4749 n1_m1_225600_460800 0 1.935398e-07
I4750 n1_m1_225600_465600 0 2.619435e-07
I4751 n1_m1_225600_470400 0 8.538894e-08
I4752 n1_m1_230400_0 0 2.731210e-07
I4753 n1_m1_230400_4800 0 4.789897e-07
I4754 n1_m1_230400_9600 0 5.716104e-07
I4755 n1_m1_230400_14400 0 2.037288e-07
I4756 n1_m1_230400_19200 0 2.098332e-07
I4757 n1_m1_230400_24000 0 2.546744e-07
I4758 n1_m1_230400_28800 0 1.632692e-07
I4759 n1_m1_230400_33600 0 4.563566e-07
I4760 n1_m1_230400_38400 0 2.210620e-07
I4761 n1_m1_230400_43200 0 1.708633e-07
I4762 n1_m1_230400_48000 0 3.667585e-07
I4763 n1_m1_230400_52800 0 2.131753e-07
I4764 n1_m1_230400_57600 0 4.827470e-07
I4765 n1_m1_230400_62400 0 4.284797e-07
I4766 n1_m1_230400_67200 0 3.509736e-07
I4767 n1_m1_230400_72000 0 9.770681e-07
I4768 n1_m1_230400_76800 0 9.396232e-07
I4769 n1_m1_230400_81600 0 6.171375e-07
I4770 n1_m1_230400_86400 0 2.900241e-07
I4771 n1_m1_230400_91200 0 5.059244e-07
I4772 n1_m1_230400_96000 0 8.275630e-07
I4773 n1_m1_230400_100800 0 8.886037e-07
I4774 n1_m1_230400_105600 0 1.284994e-06
I4775 n1_m1_230400_110400 0 6.436425e-07
I4776 n1_m1_230400_115200 0 7.513906e-07
I4777 n1_m1_230400_120000 0 1.457513e-06
I4778 n1_m1_230400_124800 0 1.242445e-06
I4779 n1_m1_230400_129600 0 2.024994e-06
I4780 n1_m1_230400_134400 0 1.266741e-06
I4781 n1_m1_230400_139200 0 1.186025e-06
I4782 n1_m1_230400_144000 0 1.571628e-06
I4783 n1_m1_230400_148800 0 1.199350e-06
I4784 n1_m1_230400_153600 0 1.418552e-06
I4785 n1_m1_230400_158400 0 6.415132e-07
I4786 n1_m1_230400_163200 0 7.649739e-07
I4787 n1_m1_230400_168000 0 1.268781e-06
I4788 n1_m1_230400_172800 0 7.940150e-07
I4789 n1_m1_230400_177600 0 8.547927e-07
I4790 n1_m1_230400_182400 0 7.619854e-07
I4791 n1_m1_230400_187200 0 7.043868e-07
I4792 n1_m1_230400_192000 0 1.575946e-06
I4793 n1_m1_230400_196800 0 1.060147e-06
I4794 n1_m1_230400_201600 0 1.658349e-06
I4795 n1_m1_230400_206400 0 1.245814e-06
I4796 n1_m1_230400_211200 0 1.349016e-06
I4797 n1_m1_230400_216000 0 1.725771e-06
I4798 n1_m1_230400_220800 0 1.171055e-06
I4799 n1_m1_230400_225600 0 1.453849e-06
I4800 n1_m1_230400_230400 0 8.529404e-07
I4801 n1_m1_230400_235200 0 1.024128e-06
I4802 n1_m1_230400_240000 0 1.527766e-06
I4803 n1_m1_230400_244800 0 9.220455e-07
I4804 n1_m1_230400_249600 0 7.970040e-07
I4805 n1_m1_230400_254400 0 7.764799e-07
I4806 n1_m1_230400_259200 0 8.306061e-07
I4807 n1_m1_230400_264000 0 6.814649e-07
I4808 n1_m1_230400_268800 0 4.971222e-07
I4809 n1_m1_230400_273600 0 7.661021e-07
I4810 n1_m1_230400_278400 0 9.253100e-07
I4811 n1_m1_230400_283200 0 8.713932e-07
I4812 n1_m1_230400_288000 0 1.009773e-06
I4813 n1_m1_230400_292800 0 5.347807e-07
I4814 n1_m1_230400_297600 0 1.023675e-06
I4815 n1_m1_230400_302400 0 4.946547e-07
I4816 n1_m1_230400_307200 0 3.046669e-07
I4817 n1_m1_230400_312000 0 4.361985e-07
I4818 n1_m1_230400_316800 0 2.917843e-07
I4819 n1_m1_230400_321600 0 9.221469e-07
I4820 n1_m1_230400_326400 0 5.925235e-07
I4821 n1_m1_230400_331200 0 3.564948e-07
I4822 n1_m1_230400_336000 0 3.083585e-07
I4823 n1_m1_230400_340800 0 2.096976e-07
I4824 n1_m1_230400_345600 0 3.713921e-07
I4825 n1_m1_230400_350400 0 1.876441e-07
I4826 n1_m1_230400_355200 0 1.549219e-07
I4827 n1_m1_230400_360000 0 2.202651e-07
I4828 n1_m1_230400_364800 0 1.639426e-07
I4829 n1_m1_230400_369600 0 2.607339e-07
I4830 n1_m1_230400_374400 0 2.348891e-07
I4831 n1_m1_230400_379200 0 3.344343e-07
I4832 n1_m1_230400_384000 0 3.804748e-07
I4833 n1_m1_230400_388800 0 1.745788e-07
I4834 n1_m1_230400_393600 0 2.298126e-07
I4835 n1_m1_230400_398400 0 1.417106e-07
I4836 n1_m1_230400_403200 0 1.458603e-07
I4837 n1_m1_230400_408000 0 2.179501e-07
I4838 n1_m1_230400_412800 0 1.458745e-07
I4839 n1_m1_230400_417600 0 2.225027e-07
I4840 n1_m1_230400_422400 0 1.564463e-07
I4841 n1_m1_230400_427200 0 1.598903e-07
I4842 n1_m1_230400_432000 0 2.312492e-07
I4843 n1_m1_230400_436800 0 1.493325e-07
I4844 n1_m1_230400_441600 0 2.339001e-07
I4845 n1_m1_230400_446400 0 1.675832e-07
I4846 n1_m1_230400_451200 0 2.469176e-07
I4847 n1_m1_230400_456000 0 6.372991e-07
I4848 n1_m1_230400_460800 0 3.845565e-07
I4849 n1_m1_230400_465600 0 3.026394e-07
I4850 n1_m1_230400_470400 0 8.448573e-08
I4851 n1_m1_235200_0 0 2.629833e-07
I4852 n1_m1_235200_4800 0 5.020707e-07
I4853 n1_m1_235200_9600 0 8.056758e-07
I4854 n1_m1_235200_14400 0 2.252973e-07
I4855 n1_m1_235200_19200 0 1.637577e-07
I4856 n1_m1_235200_24000 0 2.516775e-07
I4857 n1_m1_235200_28800 0 1.623180e-07
I4858 n1_m1_235200_33600 0 2.606685e-07
I4859 n1_m1_235200_38400 0 2.209500e-07
I4860 n1_m1_235200_43200 0 2.540065e-07
I4861 n1_m1_235200_48000 0 3.104225e-07
I4862 n1_m1_235200_52800 0 3.183267e-07
I4863 n1_m1_235200_57600 0 5.565248e-07
I4864 n1_m1_235200_62400 0 8.951060e-07
I4865 n1_m1_235200_67200 0 5.681694e-07
I4866 n1_m1_235200_72000 0 1.060134e-06
I4867 n1_m1_235200_76800 0 7.308825e-07
I4868 n1_m1_235200_81600 0 5.580915e-07
I4869 n1_m1_235200_86400 0 5.450214e-07
I4870 n1_m1_235200_91200 0 3.975802e-07
I4871 n1_m1_235200_96000 0 4.935454e-07
I4872 n1_m1_235200_100800 0 4.329091e-07
I4873 n1_m1_235200_105600 0 1.154603e-06
I4874 n1_m1_235200_110400 0 5.286343e-07
I4875 n1_m1_235200_115200 0 5.338285e-07
I4876 n1_m1_235200_120000 0 1.031030e-06
I4877 n1_m1_235200_124800 0 9.630396e-07
I4878 n1_m1_235200_129600 0 1.993730e-06
I4879 n1_m1_235200_134400 0 1.035589e-06
I4880 n1_m1_235200_139200 0 8.031211e-07
I4881 n1_m1_235200_144000 0 9.158403e-07
I4882 n1_m1_235200_148800 0 8.939768e-07
I4883 n1_m1_235200_153600 0 1.141674e-06
I4884 n1_m1_235200_158400 0 5.054017e-07
I4885 n1_m1_235200_163200 0 4.721759e-07
I4886 n1_m1_235200_168000 0 4.984573e-07
I4887 n1_m1_235200_172800 0 1.026612e-06
I4888 n1_m1_235200_177600 0 6.921097e-07
I4889 n1_m1_235200_182400 0 3.352501e-07
I4890 n1_m1_235200_187200 0 3.603459e-07
I4891 n1_m1_235200_192000 0 8.432348e-07
I4892 n1_m1_235200_196800 0 1.120305e-06
I4893 n1_m1_235200_201600 0 9.647898e-07
I4894 n1_m1_235200_206400 0 9.132574e-07
I4895 n1_m1_235200_211200 0 1.078370e-06
I4896 n1_m1_235200_216000 0 1.830128e-06
I4897 n1_m1_235200_220800 0 1.157652e-06
I4898 n1_m1_235200_225600 0 9.992718e-07
I4899 n1_m1_235200_230400 0 7.827961e-07
I4900 n1_m1_235200_235200 0 4.446948e-07
I4901 n1_m1_235200_240000 0 1.471052e-06
I4902 n1_m1_235200_244800 0 4.770313e-07
I4903 n1_m1_235200_249600 0 5.032845e-07
I4904 n1_m1_235200_254400 0 2.439427e-07
I4905 n1_m1_235200_259200 0 4.052868e-07
I4906 n1_m1_235200_264000 0 9.157274e-07
I4907 n1_m1_235200_268800 0 3.176351e-07
I4908 n1_m1_235200_273600 0 3.467676e-07
I4909 n1_m1_235200_278400 0 3.466830e-07
I4910 n1_m1_235200_283200 0 7.704034e-07
I4911 n1_m1_235200_288000 0 8.383511e-07
I4912 n1_m1_235200_292800 0 3.823647e-07
I4913 n1_m1_235200_297600 0 4.277573e-07
I4914 n1_m1_235200_302400 0 3.130478e-07
I4915 n1_m1_235200_307200 0 3.902124e-07
I4916 n1_m1_235200_312000 0 3.422933e-07
I4917 n1_m1_235200_316800 0 2.062850e-07
I4918 n1_m1_235200_321600 0 2.644936e-07
I4919 n1_m1_235200_326400 0 2.217687e-07
I4920 n1_m1_235200_331200 0 2.197926e-07
I4921 n1_m1_235200_336000 0 2.693067e-07
I4922 n1_m1_235200_340800 0 1.916622e-07
I4923 n1_m1_235200_345600 0 2.423619e-07
I4924 n1_m1_235200_350400 0 1.607936e-07
I4925 n1_m1_235200_355200 0 1.602290e-07
I4926 n1_m1_235200_360000 0 2.188187e-07
I4927 n1_m1_235200_364800 0 1.555430e-07
I4928 n1_m1_235200_369600 0 4.769184e-07
I4929 n1_m1_235200_374400 0 5.969349e-07
I4930 n1_m1_235200_379200 0 4.424647e-07
I4931 n1_m1_235200_384000 0 4.132333e-07
I4932 n1_m1_235200_388800 0 1.727345e-07
I4933 n1_m1_235200_393600 0 2.413174e-07
I4934 n1_m1_235200_398400 0 1.437290e-07
I4935 n1_m1_235200_403200 0 1.437855e-07
I4936 n1_m1_235200_408000 0 2.150643e-07
I4937 n1_m1_235200_412800 0 1.501794e-07
I4938 n1_m1_235200_417600 0 2.483888e-07
I4939 n1_m1_235200_422400 0 1.634471e-07
I4940 n1_m1_235200_427200 0 1.527765e-07
I4941 n1_m1_235200_432000 0 2.294612e-07
I4942 n1_m1_235200_436800 0 1.556276e-07
I4943 n1_m1_235200_441600 0 2.391155e-07
I4944 n1_m1_235200_446400 0 2.708734e-07
I4945 n1_m1_235200_451200 0 3.336693e-07
I4946 n1_m1_235200_456000 0 9.058754e-07
I4947 n1_m1_235200_460800 0 5.757348e-07
I4948 n1_m1_235200_465600 0 3.323143e-07
I4949 n1_m1_235200_470400 0 8.042503e-08
I4950 n1_m1_240000_0 0 3.945894e-07
I4951 n1_m1_240000_4800 0 7.858863e-07
I4952 n1_m1_240000_9600 0 1.437561e-06
I4953 n1_m1_240000_14400 0 4.248287e-07
I4954 n1_m1_240000_19200 0 2.908545e-07
I4955 n1_m1_240000_24000 0 4.111977e-07
I4956 n1_m1_240000_28800 0 2.673273e-07
I4957 n1_m1_240000_33600 0 3.918066e-07
I4958 n1_m1_240000_38400 0 3.338207e-07
I4959 n1_m1_240000_43200 0 3.316327e-07
I4960 n1_m1_240000_48000 0 1.123254e-06
I4961 n1_m1_240000_52800 0 8.282598e-07
I4962 n1_m1_240000_57600 0 1.446552e-06
I4963 n1_m1_240000_62400 0 8.802030e-07
I4964 n1_m1_240000_67200 0 6.196188e-07
I4965 n1_m1_240000_72000 0 9.944111e-07
I4966 n1_m1_240000_76800 0 8.979717e-07
I4967 n1_m1_240000_81600 0 8.934851e-07
I4968 n1_m1_240000_86400 0 5.468111e-07
I4969 n1_m1_240000_91200 0 7.728321e-07
I4970 n1_m1_240000_96000 0 1.485989e-06
I4971 n1_m1_240000_100800 0 1.130420e-06
I4972 n1_m1_240000_105600 0 1.008013e-06
I4973 n1_m1_240000_110400 0 4.978967e-07
I4974 n1_m1_240000_115200 0 4.357057e-07
I4975 n1_m1_240000_120000 0 1.290252e-06
I4976 n1_m1_240000_124800 0 1.646590e-06
I4977 n1_m1_240000_129600 0 2.881616e-06
I4978 n1_m1_240000_134400 0 1.775578e-06
I4979 n1_m1_240000_139200 0 1.470113e-06
I4980 n1_m1_240000_144000 0 1.528357e-06
I4981 n1_m1_240000_148800 0 9.583565e-07
I4982 n1_m1_240000_153600 0 1.220497e-06
I4983 n1_m1_240000_158400 0 7.484386e-07
I4984 n1_m1_240000_163200 0 5.263138e-07
I4985 n1_m1_240000_168000 0 6.302515e-07
I4986 n1_m1_240000_172800 0 6.443538e-07
I4987 n1_m1_240000_177600 0 9.031247e-07
I4988 n1_m1_240000_182400 0 8.951246e-07
I4989 n1_m1_240000_187200 0 6.153674e-07
I4990 n1_m1_240000_192000 0 9.478093e-07
I4991 n1_m1_240000_196800 0 7.066305e-07
I4992 n1_m1_240000_201600 0 1.088870e-06
I4993 n1_m1_240000_206400 0 1.344206e-06
I4994 n1_m1_240000_211200 0 1.708593e-06
I4995 n1_m1_240000_216000 0 2.838226e-06
I4996 n1_m1_240000_220800 0 1.834098e-06
I4997 n1_m1_240000_225600 0 2.398391e-06
I4998 n1_m1_240000_230400 0 1.292911e-06
I4999 n1_m1_240000_235200 0 1.561993e-06
I5000 n1_m1_240000_240000 0 1.739662e-06
I5001 n1_m1_240000_244800 0 8.750834e-07
I5002 n1_m1_240000_249600 0 8.539065e-07
I5003 n1_m1_240000_254400 0 6.982858e-07
I5004 n1_m1_240000_259200 0 1.120931e-06
I5005 n1_m1_240000_264000 0 1.096579e-06
I5006 n1_m1_240000_268800 0 9.242012e-07
I5007 n1_m1_240000_273600 0 1.038804e-06
I5008 n1_m1_240000_278400 0 8.356876e-07
I5009 n1_m1_240000_283200 0 7.719295e-07
I5010 n1_m1_240000_288000 0 7.699146e-07
I5011 n1_m1_240000_292800 0 3.086399e-07
I5012 n1_m1_240000_297600 0 4.768420e-07
I5013 n1_m1_240000_302400 0 3.048041e-07
I5014 n1_m1_240000_307200 0 3.644769e-07
I5015 n1_m1_240000_312000 0 4.448933e-07
I5016 n1_m1_240000_316800 0 2.818041e-07
I5017 n1_m1_240000_321600 0 3.785304e-07
I5018 n1_m1_240000_326400 0 2.507005e-07
I5019 n1_m1_240000_331200 0 2.493704e-07
I5020 n1_m1_240000_336000 0 3.443044e-07
I5021 n1_m1_240000_340800 0 2.249818e-07
I5022 n1_m1_240000_345600 0 3.572428e-07
I5023 n1_m1_240000_350400 0 2.323804e-07
I5024 n1_m1_240000_355200 0 2.249396e-07
I5025 n1_m1_240000_360000 0 3.218345e-07
I5026 n1_m1_240000_364800 0 2.490367e-07
I5027 n1_m1_240000_369600 0 8.988749e-07
I5028 n1_m1_240000_374400 0 1.114938e-06
I5029 n1_m1_240000_379200 0 4.626993e-07
I5030 n1_m1_240000_384000 0 6.085076e-07
I5031 n1_m1_240000_388800 0 2.813089e-07
I5032 n1_m1_240000_393600 0 4.273570e-07
I5033 n1_m1_240000_398400 0 2.258478e-07
I5034 n1_m1_240000_403200 0 2.205484e-07
I5035 n1_m1_240000_408000 0 3.405986e-07
I5036 n1_m1_240000_412800 0 2.351115e-07
I5037 n1_m1_240000_417600 0 3.907208e-07
I5038 n1_m1_240000_422400 0 2.553371e-07
I5039 n1_m1_240000_427200 0 2.324776e-07
I5040 n1_m1_240000_432000 0 3.477760e-07
I5041 n1_m1_240000_436800 0 2.490515e-07
I5042 n1_m1_240000_441600 0 4.544837e-07
I5043 n1_m1_240000_446400 0 6.700176e-07
I5044 n1_m1_240000_451200 0 5.010326e-07
I5045 n1_m1_240000_456000 0 9.230261e-07
I5046 n1_m1_240000_460800 0 5.641223e-07
I5047 n1_m1_240000_465600 0 4.240442e-07
I5048 n1_m1_240000_470400 0 1.203107e-07
I5049 n1_m1_244800_0 0 2.553811e-07
I5050 n1_m1_244800_4800 0 4.961313e-07
I5051 n1_m1_244800_9600 0 1.457815e-06
I5052 n1_m1_244800_14400 0 6.106065e-07
I5053 n1_m1_244800_19200 0 2.417220e-07
I5054 n1_m1_244800_24000 0 2.836110e-07
I5055 n1_m1_244800_28800 0 1.969751e-07
I5056 n1_m1_244800_33600 0 2.980750e-07
I5057 n1_m1_244800_38400 0 2.229172e-07
I5058 n1_m1_244800_43200 0 2.249060e-07
I5059 n1_m1_244800_48000 0 1.076996e-06
I5060 n1_m1_244800_52800 0 7.993473e-07
I5061 n1_m1_244800_57600 0 7.713290e-07
I5062 n1_m1_244800_62400 0 3.548107e-07
I5063 n1_m1_244800_67200 0 3.127182e-07
I5064 n1_m1_244800_72000 0 4.806258e-07
I5065 n1_m1_244800_76800 0 5.342292e-07
I5066 n1_m1_244800_81600 0 4.828968e-07
I5067 n1_m1_244800_86400 0 3.585167e-07
I5068 n1_m1_244800_91200 0 8.073952e-07
I5069 n1_m1_244800_96000 0 1.206924e-06
I5070 n1_m1_244800_100800 0 8.056005e-07
I5071 n1_m1_244800_105600 0 6.391088e-07
I5072 n1_m1_244800_110400 0 4.125412e-07
I5073 n1_m1_244800_115200 0 3.750321e-07
I5074 n1_m1_244800_120000 0 1.204088e-06
I5075 n1_m1_244800_124800 0 1.181349e-06
I5076 n1_m1_244800_129600 0 1.610442e-06
I5077 n1_m1_244800_134400 0 1.185175e-06
I5078 n1_m1_244800_139200 0 1.166779e-06
I5079 n1_m1_244800_144000 0 1.662500e-06
I5080 n1_m1_244800_148800 0 8.867257e-07
I5081 n1_m1_244800_153600 0 5.644790e-07
I5082 n1_m1_244800_158400 0 3.867875e-07
I5083 n1_m1_244800_163200 0 5.350213e-07
I5084 n1_m1_244800_168000 0 4.989262e-07
I5085 n1_m1_244800_172800 0 3.928597e-07
I5086 n1_m1_244800_177600 0 6.512186e-07
I5087 n1_m1_244800_182400 0 9.037805e-07
I5088 n1_m1_244800_187200 0 8.297235e-07
I5089 n1_m1_244800_192000 0 9.476001e-07
I5090 n1_m1_244800_196800 0 2.550000e-07
I5091 n1_m1_244800_201600 0 8.481476e-07
I5092 n1_m1_244800_206400 0 1.047845e-06
I5093 n1_m1_244800_211200 0 1.268046e-06
I5094 n1_m1_244800_216000 0 1.724921e-06
I5095 n1_m1_244800_220800 0 1.203170e-06
I5096 n1_m1_244800_225600 0 1.858474e-06
I5097 n1_m1_244800_230400 0 1.240475e-06
I5098 n1_m1_244800_235200 0 1.369639e-06
I5099 n1_m1_244800_240000 0 1.361729e-06
I5100 n1_m1_244800_244800 0 7.543446e-07
I5101 n1_m1_244800_249600 0 1.097884e-06
I5102 n1_m1_244800_254400 0 5.797104e-07
I5103 n1_m1_244800_259200 0 8.441250e-07
I5104 n1_m1_244800_264000 0 7.608553e-07
I5105 n1_m1_244800_268800 0 9.326702e-07
I5106 n1_m1_244800_273600 0 9.803297e-07
I5107 n1_m1_244800_278400 0 9.521304e-07
I5108 n1_m1_244800_283200 0 4.240030e-07
I5109 n1_m1_244800_288000 0 3.123565e-07
I5110 n1_m1_244800_292800 0 1.728648e-07
I5111 n1_m1_244800_297600 0 2.632759e-07
I5112 n1_m1_244800_302400 0 1.669846e-07
I5113 n1_m1_244800_307200 0 1.608900e-07
I5114 n1_m1_244800_312000 0 2.578963e-07
I5115 n1_m1_244800_316800 0 2.141399e-07
I5116 n1_m1_244800_321600 0 2.509486e-07
I5117 n1_m1_244800_326400 0 1.535145e-07
I5118 n1_m1_244800_331200 0 1.535179e-07
I5119 n1_m1_244800_336000 0 2.232158e-07
I5120 n1_m1_244800_340800 0 1.459425e-07
I5121 n1_m1_244800_345600 0 2.296424e-07
I5122 n1_m1_244800_350400 0 1.480572e-07
I5123 n1_m1_244800_355200 0 1.404927e-07
I5124 n1_m1_244800_360000 0 2.123417e-07
I5125 n1_m1_244800_364800 0 1.622668e-07
I5126 n1_m1_244800_369600 0 4.137562e-07
I5127 n1_m1_244800_374400 0 4.687743e-07
I5128 n1_m1_244800_379200 0 3.391486e-07
I5129 n1_m1_244800_384000 0 4.437028e-07
I5130 n1_m1_244800_388800 0 1.816799e-07
I5131 n1_m1_244800_393600 0 2.680475e-07
I5132 n1_m1_244800_398400 0 1.533845e-07
I5133 n1_m1_244800_403200 0 1.460689e-07
I5134 n1_m1_244800_408000 0 2.178676e-07
I5135 n1_m1_244800_412800 0 1.513323e-07
I5136 n1_m1_244800_417600 0 2.325165e-07
I5137 n1_m1_244800_422400 0 1.665112e-07
I5138 n1_m1_244800_427200 0 1.683411e-07
I5139 n1_m1_244800_432000 0 2.370647e-07
I5140 n1_m1_244800_436800 0 1.708721e-07
I5141 n1_m1_244800_441600 0 4.103615e-07
I5142 n1_m1_244800_446400 0 5.786672e-07
I5143 n1_m1_244800_451200 0 5.135597e-07
I5144 n1_m1_244800_456000 0 9.584777e-07
I5145 n1_m1_244800_460800 0 4.914256e-07
I5146 n1_m1_244800_465600 0 3.070966e-07
I5147 n1_m1_244800_470400 0 8.456061e-08
I5148 n1_m1_249600_0 0 4.556721e-07
I5149 n1_m1_249600_4800 0 8.243465e-07
I5150 n1_m1_249600_9600 0 2.083302e-06
I5151 n1_m1_249600_14400 0 9.013636e-07
I5152 n1_m1_249600_19200 0 4.161966e-07
I5153 n1_m1_249600_24000 0 4.651177e-07
I5154 n1_m1_249600_28800 0 3.461777e-07
I5155 n1_m1_249600_33600 0 7.059045e-07
I5156 n1_m1_249600_38400 0 4.117080e-07
I5157 n1_m1_249600_43200 0 4.292551e-07
I5158 n1_m1_249600_48000 0 7.264462e-07
I5159 n1_m1_249600_52800 0 1.017857e-06
I5160 n1_m1_249600_57600 0 2.185901e-06
I5161 n1_m1_249600_62400 0 6.749973e-07
I5162 n1_m1_249600_67200 0 5.550515e-07
I5163 n1_m1_249600_72000 0 7.603616e-07
I5164 n1_m1_249600_76800 0 1.302704e-06
I5165 n1_m1_249600_81600 0 9.643112e-07
I5166 n1_m1_249600_86400 0 6.386840e-07
I5167 n1_m1_249600_91200 0 8.130970e-07
I5168 n1_m1_249600_96000 0 1.247792e-06
I5169 n1_m1_249600_100800 0 1.461492e-06
I5170 n1_m1_249600_105600 0 1.289940e-06
I5171 n1_m1_249600_110400 0 9.482662e-07
I5172 n1_m1_249600_115200 0 5.270720e-07
I5173 n1_m1_249600_120000 0 1.238022e-06
I5174 n1_m1_249600_124800 0 1.048141e-06
I5175 n1_m1_249600_129600 0 2.057565e-06
I5176 n1_m1_249600_134400 0 1.260243e-06
I5177 n1_m1_249600_139200 0 1.303694e-06
I5178 n1_m1_249600_144000 0 2.404692e-06
I5179 n1_m1_249600_148800 0 1.163730e-06
I5180 n1_m1_249600_153600 0 1.067278e-06
I5181 n1_m1_249600_158400 0 4.991227e-07
I5182 n1_m1_249600_163200 0 6.023167e-07
I5183 n1_m1_249600_168000 0 1.157150e-06
I5184 n1_m1_249600_172800 0 8.574606e-07
I5185 n1_m1_249600_177600 0 1.138571e-06
I5186 n1_m1_249600_182400 0 7.888184e-07
I5187 n1_m1_249600_187200 0 1.066822e-06
I5188 n1_m1_249600_192000 0 1.687277e-06
I5189 n1_m1_249600_196800 0 6.649889e-07
I5190 n1_m1_249600_201600 0 1.371227e-06
I5191 n1_m1_249600_206400 0 8.324563e-07
I5192 n1_m1_249600_211200 0 1.811405e-06
I5193 n1_m1_249600_216000 0 2.153165e-06
I5194 n1_m1_249600_220800 0 1.826471e-06
I5195 n1_m1_249600_225600 0 2.464841e-06
I5196 n1_m1_249600_230400 0 1.992458e-06
I5197 n1_m1_249600_235200 0 2.012376e-06
I5198 n1_m1_249600_240000 0 2.399381e-06
I5199 n1_m1_249600_244800 0 1.187901e-06
I5200 n1_m1_249600_249600 0 1.409630e-06
I5201 n1_m1_249600_254400 0 1.084133e-06
I5202 n1_m1_249600_259200 0 1.186263e-06
I5203 n1_m1_249600_264000 0 1.396497e-06
I5204 n1_m1_249600_268800 0 7.407683e-07
I5205 n1_m1_249600_273600 0 1.107014e-06
I5206 n1_m1_249600_278400 0 8.283149e-07
I5207 n1_m1_249600_283200 0 7.200631e-07
I5208 n1_m1_249600_288000 0 6.856547e-07
I5209 n1_m1_249600_292800 0 2.562117e-07
I5210 n1_m1_249600_297600 0 5.713753e-07
I5211 n1_m1_249600_302400 0 3.198163e-07
I5212 n1_m1_249600_307200 0 2.815827e-07
I5213 n1_m1_249600_312000 0 4.505289e-07
I5214 n1_m1_249600_316800 0 2.462543e-07
I5215 n1_m1_249600_321600 0 3.857224e-07
I5216 n1_m1_249600_326400 0 2.298796e-07
I5217 n1_m1_249600_331200 0 2.294753e-07
I5218 n1_m1_249600_336000 0 3.445441e-07
I5219 n1_m1_249600_340800 0 2.294799e-07
I5220 n1_m1_249600_345600 0 3.442393e-07
I5221 n1_m1_249600_350400 0 2.269620e-07
I5222 n1_m1_249600_355200 0 2.143568e-07
I5223 n1_m1_249600_360000 0 3.416814e-07
I5224 n1_m1_249600_364800 0 2.239530e-07
I5225 n1_m1_249600_369600 0 3.892337e-07
I5226 n1_m1_249600_374400 0 3.358121e-07
I5227 n1_m1_249600_379200 0 4.354657e-07
I5228 n1_m1_249600_384000 0 8.080357e-07
I5229 n1_m1_249600_388800 0 2.654599e-07
I5230 n1_m1_249600_393600 0 3.791952e-07
I5231 n1_m1_249600_398400 0 2.346871e-07
I5232 n1_m1_249600_403200 0 2.182478e-07
I5233 n1_m1_249600_408000 0 3.269302e-07
I5234 n1_m1_249600_412800 0 2.261364e-07
I5235 n1_m1_249600_417600 0 3.315204e-07
I5236 n1_m1_249600_422400 0 2.314126e-07
I5237 n1_m1_249600_427200 0 2.435791e-07
I5238 n1_m1_249600_432000 0 3.391539e-07
I5239 n1_m1_249600_436800 0 2.398277e-07
I5240 n1_m1_249600_441600 0 4.186968e-07
I5241 n1_m1_249600_446400 0 4.183743e-07
I5242 n1_m1_249600_451200 0 4.227639e-07
I5243 n1_m1_249600_456000 0 1.035393e-06
I5244 n1_m1_249600_460800 0 5.041204e-07
I5245 n1_m1_249600_465600 0 4.147069e-07
I5246 n1_m1_249600_470400 0 1.272413e-07
I5247 n1_m1_254400_0 0 1.282286e-07
I5248 n1_m1_254400_4800 0 2.330670e-07
I5249 n1_m1_254400_9600 0 5.425792e-07
I5250 n1_m1_254400_14400 0 2.415130e-07
I5251 n1_m1_254400_19200 0 1.925564e-07
I5252 n1_m1_254400_24000 0 3.897677e-07
I5253 n1_m1_254400_28800 0 3.469696e-07
I5254 n1_m1_254400_33600 0 4.883376e-07
I5255 n1_m1_254400_38400 0 1.923637e-07
I5256 n1_m1_254400_43200 0 1.569504e-07
I5257 n1_m1_254400_48000 0 4.313436e-07
I5258 n1_m1_254400_52800 0 4.842964e-07
I5259 n1_m1_254400_57600 0 7.418003e-07
I5260 n1_m1_254400_62400 0 3.661372e-07
I5261 n1_m1_254400_67200 0 2.404350e-07
I5262 n1_m1_254400_72000 0 6.422226e-07
I5263 n1_m1_254400_76800 0 5.801089e-07
I5264 n1_m1_254400_81600 0 4.188396e-07
I5265 n1_m1_254400_86400 0 2.137597e-07
I5266 n1_m1_254400_91200 0 2.851031e-07
I5267 n1_m1_254400_96000 0 6.101092e-07
I5268 n1_m1_254400_100800 0 4.843828e-07
I5269 n1_m1_254400_105600 0 4.276825e-07
I5270 n1_m1_254400_110400 0 3.120449e-07
I5271 n1_m1_254400_115200 0 3.047881e-07
I5272 n1_m1_254400_120000 0 4.391682e-07
I5273 n1_m1_254400_124800 0 2.179073e-07
I5274 n1_m1_254400_129600 0 3.969990e-07
I5275 n1_m1_254400_134400 0 5.069562e-07
I5276 n1_m1_254400_139200 0 5.541631e-07
I5277 n1_m1_254400_144000 0 7.594505e-07
I5278 n1_m1_254400_148800 0 3.882617e-07
I5279 n1_m1_254400_153600 0 4.018646e-07
I5280 n1_m1_254400_158400 0 3.282688e-07
I5281 n1_m1_254400_163200 0 4.058727e-07
I5282 n1_m1_254400_168000 0 4.228624e-07
I5283 n1_m1_254400_172800 0 1.664756e-07
I5284 n1_m1_254400_177600 0 3.214194e-07
I5285 n1_m1_254400_182400 0 3.546565e-07
I5286 n1_m1_254400_187200 0 3.942398e-07
I5287 n1_m1_254400_192000 0 5.698904e-07
I5288 n1_m1_254400_196800 0 3.727098e-07
I5289 n1_m1_254400_201600 0 4.855802e-07
I5290 n1_m1_254400_206400 0 3.799807e-07
I5291 n1_m1_254400_211200 0 4.616953e-07
I5292 n1_m1_254400_216000 0 5.911074e-07
I5293 n1_m1_254400_220800 0 5.855234e-07
I5294 n1_m1_254400_225600 0 9.601579e-07
I5295 n1_m1_254400_230400 0 6.154121e-07
I5296 n1_m1_254400_235200 0 6.050367e-07
I5297 n1_m1_254400_240000 0 8.843869e-07
I5298 n1_m1_254400_244800 0 6.330994e-07
I5299 n1_m1_254400_249600 0 7.687952e-07
I5300 n1_m1_254400_254400 0 4.362685e-07
I5301 n1_m1_254400_259200 0 3.883830e-07
I5302 n1_m1_254400_264000 0 4.601905e-07
I5303 n1_m1_254400_268800 0 2.644788e-07
I5304 n1_m1_254400_273600 0 3.132398e-07
I5305 n1_m1_254400_278400 0 2.599709e-07
I5306 n1_m1_254400_283200 0 2.780070e-07
I5307 n1_m1_254400_288000 0 2.460801e-07
I5308 n1_m1_254400_292800 0 1.225983e-07
I5309 n1_m1_254400_297600 0 2.903171e-07
I5310 n1_m1_254400_302400 0 1.056829e-07
I5311 n1_m1_254400_307200 0 9.189003e-08
I5312 n1_m1_254400_312000 0 1.506241e-07
I5313 n1_m1_254400_316800 0 7.729768e-08
I5314 n1_m1_254400_321600 0 1.278490e-07
I5315 n1_m1_254400_326400 0 7.683513e-08
I5316 n1_m1_254400_331200 0 7.444043e-08
I5317 n1_m1_254400_336000 0 1.136225e-07
I5318 n1_m1_254400_340800 0 7.446806e-08
I5319 n1_m1_254400_345600 0 1.118172e-07
I5320 n1_m1_254400_350400 0 7.551111e-08
I5321 n1_m1_254400_355200 0 7.332538e-08
I5322 n1_m1_254400_360000 0 1.175606e-07
I5323 n1_m1_254400_364800 0 7.086549e-08
I5324 n1_m1_254400_369600 0 1.558992e-07
I5325 n1_m1_254400_374400 0 1.589924e-07
I5326 n1_m1_254400_379200 0 2.083067e-07
I5327 n1_m1_254400_384000 0 4.780779e-07
I5328 n1_m1_254400_388800 0 1.229483e-07
I5329 n1_m1_254400_393600 0 1.318877e-07
I5330 n1_m1_254400_398400 0 7.487464e-08
I5331 n1_m1_254400_403200 0 7.213533e-08
I5332 n1_m1_254400_408000 0 1.136386e-07
I5333 n1_m1_254400_412800 0 7.675152e-08
I5334 n1_m1_254400_417600 0 1.086728e-07
I5335 n1_m1_254400_422400 0 7.440120e-08
I5336 n1_m1_254400_427200 0 7.436364e-08
I5337 n1_m1_254400_432000 0 1.044055e-07
I5338 n1_m1_254400_436800 0 7.361987e-08
I5339 n1_m1_254400_441600 0 1.242866e-07
I5340 n1_m1_254400_446400 0 8.799033e-08
I5341 n1_m1_254400_451200 0 8.778914e-08
I5342 n1_m1_254400_456000 0 2.394288e-07
I5343 n1_m1_254400_460800 0 1.246231e-07
I5344 n1_m1_254400_465600 0 1.353384e-07
I5345 n1_m1_254400_470400 0 4.250578e-08
I5346 n1_m1_259200_0 0 3.235173e-07
I5347 n1_m1_259200_4800 0 6.726714e-07
I5348 n1_m1_259200_9600 0 8.517747e-07
I5349 n1_m1_259200_14400 0 4.134419e-07
I5350 n1_m1_259200_19200 0 9.066472e-07
I5351 n1_m1_259200_24000 0 1.123719e-06
I5352 n1_m1_259200_28800 0 6.740466e-07
I5353 n1_m1_259200_33600 0 1.084019e-06
I5354 n1_m1_259200_38400 0 6.978149e-07
I5355 n1_m1_259200_43200 0 7.730055e-07
I5356 n1_m1_259200_48000 0 6.915316e-07
I5357 n1_m1_259200_52800 0 9.869759e-07
I5358 n1_m1_259200_57600 0 1.353970e-06
I5359 n1_m1_259200_62400 0 1.111122e-06
I5360 n1_m1_259200_67200 0 8.500297e-07
I5361 n1_m1_259200_72000 0 1.695408e-06
I5362 n1_m1_259200_76800 0 1.167241e-06
I5363 n1_m1_259200_81600 0 1.152114e-06
I5364 n1_m1_259200_86400 0 7.491440e-07
I5365 n1_m1_259200_91200 0 9.558318e-07
I5366 n1_m1_259200_96000 0 1.433097e-06
I5367 n1_m1_259200_100800 0 5.310654e-07
I5368 n1_m1_259200_105600 0 1.143092e-06
I5369 n1_m1_259200_110400 0 6.491643e-07
I5370 n1_m1_259200_115200 0 8.965203e-07
I5371 n1_m1_259200_120000 0 9.365297e-07
I5372 n1_m1_259200_124800 0 4.069913e-07
I5373 n1_m1_259200_129600 0 9.620935e-07
I5374 n1_m1_259200_134400 0 9.270064e-07
I5375 n1_m1_259200_139200 0 1.260184e-06
I5376 n1_m1_259200_144000 0 1.095427e-06
I5377 n1_m1_259200_148800 0 6.907045e-07
I5378 n1_m1_259200_153600 0 1.123346e-06
I5379 n1_m1_259200_158400 0 9.260759e-07
I5380 n1_m1_259200_163200 0 9.349704e-07
I5381 n1_m1_259200_168000 0 5.235042e-07
I5382 n1_m1_259200_172800 0 6.841828e-07
I5383 n1_m1_259200_177600 0 8.993666e-07
I5384 n1_m1_259200_182400 0 9.305966e-07
I5385 n1_m1_259200_187200 0 7.431618e-07
I5386 n1_m1_259200_192000 0 9.944894e-07
I5387 n1_m1_259200_196800 0 9.855661e-07
I5388 n1_m1_259200_201600 0 1.286976e-06
I5389 n1_m1_259200_206400 0 9.928463e-07
I5390 n1_m1_259200_211200 0 5.413128e-07
I5391 n1_m1_259200_216000 0 1.145177e-06
I5392 n1_m1_259200_220800 0 1.068257e-06
I5393 n1_m1_259200_225600 0 1.789749e-06
I5394 n1_m1_259200_230400 0 1.015384e-06
I5395 n1_m1_259200_235200 0 7.889924e-07
I5396 n1_m1_259200_240000 0 1.674707e-06
I5397 n1_m1_259200_244800 0 7.257363e-07
I5398 n1_m1_259200_249600 0 1.250735e-06
I5399 n1_m1_259200_254400 0 5.418204e-07
I5400 n1_m1_259200_259200 0 6.285202e-07
I5401 n1_m1_259200_264000 0 1.440266e-06
I5402 n1_m1_259200_268800 0 4.164852e-07
I5403 n1_m1_259200_273600 0 8.328850e-07
I5404 n1_m1_259200_278400 0 3.453131e-07
I5405 n1_m1_259200_283200 0 7.475684e-07
I5406 n1_m1_259200_288000 0 6.743741e-07
I5407 n1_m1_259200_292800 0 3.409194e-07
I5408 n1_m1_259200_297600 0 4.932176e-07
I5409 n1_m1_259200_302400 0 1.916673e-07
I5410 n1_m1_259200_307200 0 2.253448e-07
I5411 n1_m1_259200_312000 0 2.575614e-07
I5412 n1_m1_259200_316800 0 2.774341e-07
I5413 n1_m1_259200_321600 0 2.779085e-07
I5414 n1_m1_259200_326400 0 1.638120e-07
I5415 n1_m1_259200_331200 0 1.496976e-07
I5416 n1_m1_259200_336000 0 2.214797e-07
I5417 n1_m1_259200_340800 0 1.450932e-07
I5418 n1_m1_259200_345600 0 2.121325e-07
I5419 n1_m1_259200_350400 0 1.498755e-07
I5420 n1_m1_259200_355200 0 1.415501e-07
I5421 n1_m1_259200_360000 0 2.266994e-07
I5422 n1_m1_259200_364800 0 1.402704e-07
I5423 n1_m1_259200_369600 0 5.718565e-07
I5424 n1_m1_259200_374400 0 7.686654e-07
I5425 n1_m1_259200_379200 0 8.188132e-07
I5426 n1_m1_259200_384000 0 1.411884e-06
I5427 n1_m1_259200_388800 0 3.263568e-07
I5428 n1_m1_259200_393600 0 2.849427e-07
I5429 n1_m1_259200_398400 0 1.431081e-07
I5430 n1_m1_259200_403200 0 1.368986e-07
I5431 n1_m1_259200_408000 0 2.153388e-07
I5432 n1_m1_259200_412800 0 1.431723e-07
I5433 n1_m1_259200_417600 0 2.161129e-07
I5434 n1_m1_259200_422400 0 1.408107e-07
I5435 n1_m1_259200_427200 0 1.365937e-07
I5436 n1_m1_259200_432000 0 2.103195e-07
I5437 n1_m1_259200_436800 0 1.452331e-07
I5438 n1_m1_259200_441600 0 2.205603e-07
I5439 n1_m1_259200_446400 0 1.593695e-07
I5440 n1_m1_259200_451200 0 1.729424e-07
I5441 n1_m1_259200_456000 0 4.447555e-07
I5442 n1_m1_259200_460800 0 2.422428e-07
I5443 n1_m1_259200_465600 0 2.796624e-07
I5444 n1_m1_259200_470400 0 7.969286e-08
I5445 n1_m1_264000_0 0 4.780890e-07
I5446 n1_m1_264000_4800 0 8.536905e-07
I5447 n1_m1_264000_9600 0 1.574775e-06
I5448 n1_m1_264000_14400 0 7.450029e-07
I5449 n1_m1_264000_19200 0 5.035950e-07
I5450 n1_m1_264000_24000 0 9.099209e-07
I5451 n1_m1_264000_28800 0 6.168569e-07
I5452 n1_m1_264000_33600 0 9.087174e-07
I5453 n1_m1_264000_38400 0 6.215728e-07
I5454 n1_m1_264000_43200 0 5.797945e-07
I5455 n1_m1_264000_48000 0 1.336721e-06
I5456 n1_m1_264000_52800 0 9.223467e-07
I5457 n1_m1_264000_57600 0 2.681341e-06
I5458 n1_m1_264000_62400 0 1.167523e-06
I5459 n1_m1_264000_67200 0 1.538592e-06
I5460 n1_m1_264000_72000 0 2.028607e-06
I5461 n1_m1_264000_76800 0 1.889078e-06
I5462 n1_m1_264000_81600 0 2.060450e-06
I5463 n1_m1_264000_86400 0 1.085904e-06
I5464 n1_m1_264000_91200 0 1.452788e-06
I5465 n1_m1_264000_96000 0 1.595002e-06
I5466 n1_m1_264000_100800 0 1.567828e-06
I5467 n1_m1_264000_105600 0 1.453992e-06
I5468 n1_m1_264000_110400 0 1.207834e-06
I5469 n1_m1_264000_115200 0 7.193698e-07
I5470 n1_m1_264000_120000 0 1.547758e-06
I5471 n1_m1_264000_124800 0 1.001643e-06
I5472 n1_m1_264000_129600 0 9.248435e-07
I5473 n1_m1_264000_134400 0 7.664045e-07
I5474 n1_m1_264000_139200 0 7.917899e-07
I5475 n1_m1_264000_144000 0 2.092051e-06
I5476 n1_m1_264000_148800 0 9.930469e-07
I5477 n1_m1_264000_153600 0 8.360141e-07
I5478 n1_m1_264000_158400 0 5.236574e-07
I5479 n1_m1_264000_163200 0 6.113195e-07
I5480 n1_m1_264000_168000 0 1.532241e-06
I5481 n1_m1_264000_172800 0 5.238016e-07
I5482 n1_m1_264000_177600 0 6.805656e-07
I5483 n1_m1_264000_182400 0 5.413851e-07
I5484 n1_m1_264000_187200 0 1.065327e-06
I5485 n1_m1_264000_192000 0 2.358383e-06
I5486 n1_m1_264000_196800 0 7.601157e-07
I5487 n1_m1_264000_201600 0 2.020594e-06
I5488 n1_m1_264000_206400 0 1.164341e-06
I5489 n1_m1_264000_211200 0 1.739551e-06
I5490 n1_m1_264000_216000 0 1.341458e-06
I5491 n1_m1_264000_220800 0 9.467712e-07
I5492 n1_m1_264000_225600 0 1.856387e-06
I5493 n1_m1_264000_230400 0 1.544138e-06
I5494 n1_m1_264000_235200 0 2.025771e-06
I5495 n1_m1_264000_240000 0 1.943746e-06
I5496 n1_m1_264000_244800 0 1.367325e-06
I5497 n1_m1_264000_249600 0 1.305781e-06
I5498 n1_m1_264000_254400 0 1.193383e-06
I5499 n1_m1_264000_259200 0 1.706932e-06
I5500 n1_m1_264000_264000 0 1.861602e-06
I5501 n1_m1_264000_268800 0 1.387310e-06
I5502 n1_m1_264000_273600 0 1.192968e-06
I5503 n1_m1_264000_278400 0 1.548199e-06
I5504 n1_m1_264000_283200 0 9.683457e-07
I5505 n1_m1_264000_288000 0 7.579486e-07
I5506 n1_m1_264000_292800 0 2.838371e-07
I5507 n1_m1_264000_297600 0 5.766668e-07
I5508 n1_m1_264000_302400 0 3.423652e-07
I5509 n1_m1_264000_307200 0 2.927845e-07
I5510 n1_m1_264000_312000 0 4.042711e-07
I5511 n1_m1_264000_316800 0 3.211628e-07
I5512 n1_m1_264000_321600 0 7.208809e-07
I5513 n1_m1_264000_326400 0 2.468573e-07
I5514 n1_m1_264000_331200 0 2.269148e-07
I5515 n1_m1_264000_336000 0 3.420796e-07
I5516 n1_m1_264000_340800 0 2.185339e-07
I5517 n1_m1_264000_345600 0 3.252439e-07
I5518 n1_m1_264000_350400 0 2.232750e-07
I5519 n1_m1_264000_355200 0 2.175066e-07
I5520 n1_m1_264000_360000 0 3.474447e-07
I5521 n1_m1_264000_364800 0 2.114004e-07
I5522 n1_m1_264000_369600 0 7.865745e-07
I5523 n1_m1_264000_374400 0 9.979727e-07
I5524 n1_m1_264000_379200 0 1.157502e-06
I5525 n1_m1_264000_384000 0 2.142571e-06
I5526 n1_m1_264000_388800 0 5.391943e-07
I5527 n1_m1_264000_393600 0 4.525636e-07
I5528 n1_m1_264000_398400 0 2.226983e-07
I5529 n1_m1_264000_403200 0 2.124651e-07
I5530 n1_m1_264000_408000 0 3.185981e-07
I5531 n1_m1_264000_412800 0 2.090676e-07
I5532 n1_m1_264000_417600 0 3.219903e-07
I5533 n1_m1_264000_422400 0 2.100311e-07
I5534 n1_m1_264000_427200 0 2.043534e-07
I5535 n1_m1_264000_432000 0 3.248291e-07
I5536 n1_m1_264000_436800 0 2.177255e-07
I5537 n1_m1_264000_441600 0 3.326028e-07
I5538 n1_m1_264000_446400 0 2.396814e-07
I5539 n1_m1_264000_451200 0 2.450207e-07
I5540 n1_m1_264000_456000 0 5.197707e-07
I5541 n1_m1_264000_460800 0 4.026219e-07
I5542 n1_m1_264000_465600 0 5.514389e-07
I5543 n1_m1_264000_470400 0 1.389243e-07
I5544 n1_m1_268800_0 0 2.654407e-07
I5545 n1_m1_268800_4800 0 4.023390e-07
I5546 n1_m1_268800_9600 0 9.046018e-07
I5547 n1_m1_268800_14400 0 3.939973e-07
I5548 n1_m1_268800_19200 0 2.324704e-07
I5549 n1_m1_268800_24000 0 4.637753e-07
I5550 n1_m1_268800_28800 0 2.877877e-07
I5551 n1_m1_268800_33600 0 4.222805e-07
I5552 n1_m1_268800_38400 0 2.745707e-07
I5553 n1_m1_268800_43200 0 2.769539e-07
I5554 n1_m1_268800_48000 0 5.346682e-07
I5555 n1_m1_268800_52800 0 5.448913e-07
I5556 n1_m1_268800_57600 0 8.712212e-07
I5557 n1_m1_268800_62400 0 8.640476e-07
I5558 n1_m1_268800_67200 0 6.940948e-07
I5559 n1_m1_268800_72000 0 8.969445e-07
I5560 n1_m1_268800_76800 0 7.613084e-07
I5561 n1_m1_268800_81600 0 1.036803e-06
I5562 n1_m1_268800_86400 0 4.832033e-07
I5563 n1_m1_268800_91200 0 6.575512e-07
I5564 n1_m1_268800_96000 0 8.239267e-07
I5565 n1_m1_268800_100800 0 7.132582e-07
I5566 n1_m1_268800_105600 0 1.035004e-06
I5567 n1_m1_268800_110400 0 7.526717e-07
I5568 n1_m1_268800_115200 0 5.298908e-07
I5569 n1_m1_268800_120000 0 7.730015e-07
I5570 n1_m1_268800_124800 0 5.424535e-07
I5571 n1_m1_268800_129600 0 6.339130e-07
I5572 n1_m1_268800_134400 0 3.701931e-07
I5573 n1_m1_268800_139200 0 2.345302e-07
I5574 n1_m1_268800_144000 0 7.122967e-07
I5575 n1_m1_268800_148800 0 5.418758e-07
I5576 n1_m1_268800_153600 0 8.878303e-07
I5577 n1_m1_268800_158400 0 2.383646e-07
I5578 n1_m1_268800_163200 0 3.027578e-07
I5579 n1_m1_268800_168000 0 5.693014e-07
I5580 n1_m1_268800_172800 0 5.419325e-07
I5581 n1_m1_268800_177600 0 4.173502e-07
I5582 n1_m1_268800_182400 0 2.744411e-07
I5583 n1_m1_268800_187200 0 5.493792e-07
I5584 n1_m1_268800_192000 0 8.552346e-07
I5585 n1_m1_268800_196800 0 6.892188e-07
I5586 n1_m1_268800_201600 0 1.102566e-06
I5587 n1_m1_268800_206400 0 8.124829e-07
I5588 n1_m1_268800_211200 0 1.037243e-06
I5589 n1_m1_268800_216000 0 1.132956e-06
I5590 n1_m1_268800_220800 0 6.170925e-07
I5591 n1_m1_268800_225600 0 9.009573e-07
I5592 n1_m1_268800_230400 0 8.529260e-07
I5593 n1_m1_268800_235200 0 1.111243e-06
I5594 n1_m1_268800_240000 0 1.752059e-06
I5595 n1_m1_268800_244800 0 1.047561e-06
I5596 n1_m1_268800_249600 0 1.215343e-06
I5597 n1_m1_268800_254400 0 7.673657e-07
I5598 n1_m1_268800_259200 0 9.171937e-07
I5599 n1_m1_268800_264000 0 1.152899e-06
I5600 n1_m1_268800_268800 0 5.106449e-07
I5601 n1_m1_268800_273600 0 7.599065e-07
I5602 n1_m1_268800_278400 0 6.957802e-07
I5603 n1_m1_268800_283200 0 7.700431e-07
I5604 n1_m1_268800_288000 0 7.632294e-07
I5605 n1_m1_268800_292800 0 1.893706e-07
I5606 n1_m1_268800_297600 0 3.353408e-07
I5607 n1_m1_268800_302400 0 2.555143e-07
I5608 n1_m1_268800_307200 0 3.819790e-07
I5609 n1_m1_268800_312000 0 2.907159e-07
I5610 n1_m1_268800_316800 0 2.616259e-07
I5611 n1_m1_268800_321600 0 4.173907e-07
I5612 n1_m1_268800_326400 0 1.660079e-07
I5613 n1_m1_268800_331200 0 1.666303e-07
I5614 n1_m1_268800_336000 0 2.305327e-07
I5615 n1_m1_268800_340800 0 1.503347e-07
I5616 n1_m1_268800_345600 0 2.526060e-07
I5617 n1_m1_268800_350400 0 1.492524e-07
I5618 n1_m1_268800_355200 0 1.431262e-07
I5619 n1_m1_268800_360000 0 2.336742e-07
I5620 n1_m1_268800_364800 0 1.584357e-07
I5621 n1_m1_268800_369600 0 2.881145e-07
I5622 n1_m1_268800_374400 0 2.671172e-07
I5623 n1_m1_268800_379200 0 4.495416e-07
I5624 n1_m1_268800_384000 0 7.499198e-07
I5625 n1_m1_268800_388800 0 2.316166e-07
I5626 n1_m1_268800_393600 0 2.579844e-07
I5627 n1_m1_268800_398400 0 1.516980e-07
I5628 n1_m1_268800_403200 0 1.471285e-07
I5629 n1_m1_268800_408000 0 2.188752e-07
I5630 n1_m1_268800_412800 0 1.429357e-07
I5631 n1_m1_268800_417600 0 2.108524e-07
I5632 n1_m1_268800_422400 0 1.399040e-07
I5633 n1_m1_268800_427200 0 1.399040e-07
I5634 n1_m1_268800_432000 0 2.098560e-07
I5635 n1_m1_268800_436800 0 1.399040e-07
I5636 n1_m1_268800_441600 0 2.129112e-07
I5637 n1_m1_268800_446400 0 1.420276e-07
I5638 n1_m1_268800_451200 0 1.444056e-07
I5639 n1_m1_268800_456000 0 2.658883e-07
I5640 n1_m1_268800_460800 0 2.647216e-07
I5641 n1_m1_268800_465600 0 2.850567e-07
I5642 n1_m1_268800_470400 0 7.866501e-08
I5643 n1_m1_273600_0 0 4.712154e-07
I5644 n1_m1_273600_4800 0 8.480585e-07
I5645 n1_m1_273600_9600 0 1.712538e-06
I5646 n1_m1_273600_14400 0 8.378706e-07
I5647 n1_m1_273600_19200 0 4.691681e-07
I5648 n1_m1_273600_24000 0 4.313116e-07
I5649 n1_m1_273600_28800 0 2.628042e-07
I5650 n1_m1_273600_33600 0 7.730535e-07
I5651 n1_m1_273600_38400 0 3.110201e-07
I5652 n1_m1_273600_43200 0 3.325987e-07
I5653 n1_m1_273600_48000 0 4.010943e-07
I5654 n1_m1_273600_52800 0 4.025197e-07
I5655 n1_m1_273600_57600 0 5.509596e-07
I5656 n1_m1_273600_62400 0 9.923739e-07
I5657 n1_m1_273600_67200 0 5.229360e-07
I5658 n1_m1_273600_72000 0 6.890851e-07
I5659 n1_m1_273600_76800 0 5.182941e-07
I5660 n1_m1_273600_81600 0 7.893763e-07
I5661 n1_m1_273600_86400 0 5.831574e-07
I5662 n1_m1_273600_91200 0 5.076696e-07
I5663 n1_m1_273600_96000 0 5.708253e-07
I5664 n1_m1_273600_100800 0 4.305073e-07
I5665 n1_m1_273600_105600 0 1.427376e-06
I5666 n1_m1_273600_110400 0 6.924632e-07
I5667 n1_m1_273600_115200 0 4.669673e-07
I5668 n1_m1_273600_120000 0 7.199511e-07
I5669 n1_m1_273600_124800 0 4.617914e-07
I5670 n1_m1_273600_129600 0 1.005498e-06
I5671 n1_m1_273600_134400 0 4.279910e-07
I5672 n1_m1_273600_139200 0 3.782906e-07
I5673 n1_m1_273600_144000 0 4.809089e-07
I5674 n1_m1_273600_148800 0 6.547674e-07
I5675 n1_m1_273600_153600 0 1.462959e-06
I5676 n1_m1_273600_158400 0 3.826969e-07
I5677 n1_m1_273600_163200 0 5.262778e-07
I5678 n1_m1_273600_168000 0 6.794017e-07
I5679 n1_m1_273600_172800 0 6.927824e-07
I5680 n1_m1_273600_177600 0 5.495137e-07
I5681 n1_m1_273600_182400 0 3.012578e-07
I5682 n1_m1_273600_187200 0 4.572393e-07
I5683 n1_m1_273600_192000 0 1.215580e-06
I5684 n1_m1_273600_196800 0 1.267385e-06
I5685 n1_m1_273600_201600 0 1.153673e-06
I5686 n1_m1_273600_206400 0 1.397083e-06
I5687 n1_m1_273600_211200 0 1.782539e-06
I5688 n1_m1_273600_216000 0 2.199144e-06
I5689 n1_m1_273600_220800 0 9.996108e-07
I5690 n1_m1_273600_225600 0 1.082107e-06
I5691 n1_m1_273600_230400 0 1.116811e-06
I5692 n1_m1_273600_235200 0 1.466592e-06
I5693 n1_m1_273600_240000 0 2.252752e-06
I5694 n1_m1_273600_244800 0 1.064129e-06
I5695 n1_m1_273600_249600 0 1.741445e-06
I5696 n1_m1_273600_254400 0 1.074349e-06
I5697 n1_m1_273600_259200 0 1.381365e-06
I5698 n1_m1_273600_264000 0 1.737175e-06
I5699 n1_m1_273600_268800 0 5.215481e-07
I5700 n1_m1_273600_273600 0 1.546737e-06
I5701 n1_m1_273600_278400 0 8.113387e-07
I5702 n1_m1_273600_283200 0 1.151617e-06
I5703 n1_m1_273600_288000 0 1.058654e-06
I5704 n1_m1_273600_292800 0 3.953397e-07
I5705 n1_m1_273600_297600 0 7.574918e-07
I5706 n1_m1_273600_302400 0 3.774698e-07
I5707 n1_m1_273600_307200 0 4.692742e-07
I5708 n1_m1_273600_312000 0 4.529454e-07
I5709 n1_m1_273600_316800 0 2.979831e-07
I5710 n1_m1_273600_321600 0 4.615711e-07
I5711 n1_m1_273600_326400 0 2.461461e-07
I5712 n1_m1_273600_331200 0 2.476039e-07
I5713 n1_m1_273600_336000 0 4.401938e-07
I5714 n1_m1_273600_340800 0 2.604866e-07
I5715 n1_m1_273600_345600 0 3.687739e-07
I5716 n1_m1_273600_350400 0 2.394667e-07
I5717 n1_m1_273600_355200 0 2.374061e-07
I5718 n1_m1_273600_360000 0 4.180538e-07
I5719 n1_m1_273600_364800 0 3.292124e-07
I5720 n1_m1_273600_369600 0 5.611170e-07
I5721 n1_m1_273600_374400 0 6.583028e-07
I5722 n1_m1_273600_379200 0 7.282943e-07
I5723 n1_m1_273600_384000 0 1.242390e-06
I5724 n1_m1_273600_388800 0 4.837602e-07
I5725 n1_m1_273600_393600 0 4.535475e-07
I5726 n1_m1_273600_398400 0 2.126345e-07
I5727 n1_m1_273600_403200 0 2.082496e-07
I5728 n1_m1_273600_408000 0 3.344207e-07
I5729 n1_m1_273600_412800 0 2.151587e-07
I5730 n1_m1_273600_417600 0 3.155869e-07
I5731 n1_m1_273600_422400 0 2.098560e-07
I5732 n1_m1_273600_427200 0 2.098560e-07
I5733 n1_m1_273600_432000 0 3.147839e-07
I5734 n1_m1_273600_436800 0 2.098560e-07
I5735 n1_m1_273600_441600 0 3.215349e-07
I5736 n1_m1_273600_446400 0 2.130273e-07
I5737 n1_m1_273600_451200 0 2.156430e-07
I5738 n1_m1_273600_456000 0 3.806518e-07
I5739 n1_m1_273600_460800 0 3.669778e-07
I5740 n1_m1_273600_465600 0 4.128570e-07
I5741 n1_m1_273600_470400 0 1.167984e-07
I5742 n1_m1_278400_0 0 2.954422e-07
I5743 n1_m1_278400_4800 0 6.599648e-07
I5744 n1_m1_278400_9600 0 1.643679e-06
I5745 n1_m1_278400_14400 0 6.126847e-07
I5746 n1_m1_278400_19200 0 2.725380e-07
I5747 n1_m1_278400_24000 0 2.607329e-07
I5748 n1_m1_278400_28800 0 1.745694e-07
I5749 n1_m1_278400_33600 0 2.618829e-07
I5750 n1_m1_278400_38400 0 2.383034e-07
I5751 n1_m1_278400_43200 0 2.939785e-07
I5752 n1_m1_278400_48000 0 2.548761e-07
I5753 n1_m1_278400_52800 0 2.369878e-07
I5754 n1_m1_278400_57600 0 3.034619e-07
I5755 n1_m1_278400_62400 0 2.020396e-07
I5756 n1_m1_278400_67200 0 1.944115e-07
I5757 n1_m1_278400_72000 0 5.559626e-07
I5758 n1_m1_278400_76800 0 2.394962e-07
I5759 n1_m1_278400_81600 0 3.480131e-07
I5760 n1_m1_278400_86400 0 3.283100e-07
I5761 n1_m1_278400_91200 0 1.810464e-07
I5762 n1_m1_278400_96000 0 2.823180e-07
I5763 n1_m1_278400_100800 0 2.735777e-07
I5764 n1_m1_278400_105600 0 2.602207e-07
I5765 n1_m1_278400_110400 0 1.818861e-07
I5766 n1_m1_278400_115200 0 2.449083e-07
I5767 n1_m1_278400_120000 0 4.029258e-07
I5768 n1_m1_278400_124800 0 2.523936e-07
I5769 n1_m1_278400_129600 0 5.368258e-07
I5770 n1_m1_278400_134400 0 2.699488e-07
I5771 n1_m1_278400_139200 0 2.087029e-07
I5772 n1_m1_278400_144000 0 3.231238e-07
I5773 n1_m1_278400_148800 0 2.866856e-07
I5774 n1_m1_278400_153600 0 5.547253e-07
I5775 n1_m1_278400_158400 0 3.823530e-07
I5776 n1_m1_278400_163200 0 6.103256e-07
I5777 n1_m1_278400_168000 0 4.676042e-07
I5778 n1_m1_278400_172800 0 2.915886e-07
I5779 n1_m1_278400_177600 0 3.025404e-07
I5780 n1_m1_278400_182400 0 2.683455e-07
I5781 n1_m1_278400_187200 0 2.893576e-07
I5782 n1_m1_278400_192000 0 3.556486e-07
I5783 n1_m1_278400_196800 0 2.688005e-07
I5784 n1_m1_278400_201600 0 1.033472e-06
I5785 n1_m1_278400_206400 0 1.218281e-06
I5786 n1_m1_278400_211200 0 9.128576e-07
I5787 n1_m1_278400_216000 0 1.150471e-06
I5788 n1_m1_278400_220800 0 7.602280e-07
I5789 n1_m1_278400_225600 0 7.184246e-07
I5790 n1_m1_278400_230400 0 5.021068e-07
I5791 n1_m1_278400_235200 0 4.626486e-07
I5792 n1_m1_278400_240000 0 5.887281e-07
I5793 n1_m1_278400_244800 0 5.913113e-07
I5794 n1_m1_278400_249600 0 1.629785e-06
I5795 n1_m1_278400_254400 0 6.962706e-07
I5796 n1_m1_278400_259200 0 8.510105e-07
I5797 n1_m1_278400_264000 0 9.891121e-07
I5798 n1_m1_278400_268800 0 5.295676e-07
I5799 n1_m1_278400_273600 0 9.152707e-07
I5800 n1_m1_278400_278400 0 7.648509e-07
I5801 n1_m1_278400_283200 0 4.848755e-07
I5802 n1_m1_278400_288000 0 6.376596e-07
I5803 n1_m1_278400_292800 0 6.770418e-07
I5804 n1_m1_278400_297600 0 8.595120e-07
I5805 n1_m1_278400_302400 0 3.389355e-07
I5806 n1_m1_278400_307200 0 4.992731e-07
I5807 n1_m1_278400_312000 0 4.495588e-07
I5808 n1_m1_278400_316800 0 2.881899e-07
I5809 n1_m1_278400_321600 0 4.467464e-07
I5810 n1_m1_278400_326400 0 1.931969e-07
I5811 n1_m1_278400_331200 0 1.681203e-07
I5812 n1_m1_278400_336000 0 4.939765e-07
I5813 n1_m1_278400_340800 0 2.482369e-07
I5814 n1_m1_278400_345600 0 2.316956e-07
I5815 n1_m1_278400_350400 0 1.681047e-07
I5816 n1_m1_278400_355200 0 1.866460e-07
I5817 n1_m1_278400_360000 0 5.397796e-07
I5818 n1_m1_278400_364800 0 4.286821e-07
I5819 n1_m1_278400_369600 0 9.651871e-07
I5820 n1_m1_278400_374400 0 1.056451e-06
I5821 n1_m1_278400_379200 0 8.479008e-07
I5822 n1_m1_278400_384000 0 1.455700e-06
I5823 n1_m1_278400_388800 0 5.882681e-07
I5824 n1_m1_278400_393600 0 3.972903e-07
I5825 n1_m1_278400_398400 0 1.443439e-07
I5826 n1_m1_278400_403200 0 1.430551e-07
I5827 n1_m1_278400_408000 0 2.104050e-07
I5828 n1_m1_278400_412800 0 1.430939e-07
I5829 n1_m1_278400_417600 0 2.112392e-07
I5830 n1_m1_278400_422400 0 1.399040e-07
I5831 n1_m1_278400_427200 0 1.399040e-07
I5832 n1_m1_278400_432000 0 2.098560e-07
I5833 n1_m1_278400_436800 0 1.399040e-07
I5834 n1_m1_278400_441600 0 2.131258e-07
I5835 n1_m1_278400_446400 0 1.436867e-07
I5836 n1_m1_278400_451200 0 1.460015e-07
I5837 n1_m1_278400_456000 0 2.515012e-07
I5838 n1_m1_278400_460800 0 2.243553e-07
I5839 n1_m1_278400_465600 0 2.704404e-07
I5840 n1_m1_278400_470400 0 7.865592e-08
I5841 n1_m1_283200_0 0 1.298132e-07
I5842 n1_m1_283200_4800 0 3.007108e-07
I5843 n1_m1_283200_9600 0 8.624493e-07
I5844 n1_m1_283200_14400 0 2.346499e-07
I5845 n1_m1_283200_19200 0 9.203369e-08
I5846 n1_m1_283200_24000 0 1.280889e-07
I5847 n1_m1_283200_28800 0 8.561537e-08
I5848 n1_m1_283200_33600 0 1.252103e-07
I5849 n1_m1_283200_38400 0 1.509299e-07
I5850 n1_m1_283200_43200 0 1.935988e-07
I5851 n1_m1_283200_48000 0 1.530406e-07
I5852 n1_m1_283200_52800 0 1.390801e-07
I5853 n1_m1_283200_57600 0 1.283240e-07
I5854 n1_m1_283200_62400 0 8.748616e-08
I5855 n1_m1_283200_67200 0 9.716902e-08
I5856 n1_m1_283200_72000 0 2.560680e-07
I5857 n1_m1_283200_76800 0 1.043598e-07
I5858 n1_m1_283200_81600 0 1.928129e-07
I5859 n1_m1_283200_86400 0 1.424212e-07
I5860 n1_m1_283200_91200 0 1.102903e-07
I5861 n1_m1_283200_96000 0 1.562455e-07
I5862 n1_m1_283200_100800 0 1.108698e-07
I5863 n1_m1_283200_105600 0 1.414128e-07
I5864 n1_m1_283200_110400 0 8.773304e-08
I5865 n1_m1_283200_115200 0 1.291591e-07
I5866 n1_m1_283200_120000 0 2.147969e-07
I5867 n1_m1_283200_124800 0 1.427094e-07
I5868 n1_m1_283200_129600 0 3.053835e-07
I5869 n1_m1_283200_134400 0 1.031749e-07
I5870 n1_m1_283200_139200 0 1.039907e-07
I5871 n1_m1_283200_144000 0 1.784323e-07
I5872 n1_m1_283200_148800 0 1.377504e-07
I5873 n1_m1_283200_153600 0 2.109903e-07
I5874 n1_m1_283200_158400 0 2.134033e-07
I5875 n1_m1_283200_163200 0 3.203849e-07
I5876 n1_m1_283200_168000 0 1.618271e-07
I5877 n1_m1_283200_172800 0 1.697219e-07
I5878 n1_m1_283200_177600 0 1.799780e-07
I5879 n1_m1_283200_182400 0 1.717001e-07
I5880 n1_m1_283200_187200 0 1.582963e-07
I5881 n1_m1_283200_192000 0 1.768156e-07
I5882 n1_m1_283200_196800 0 1.275160e-07
I5883 n1_m1_283200_201600 0 5.199693e-07
I5884 n1_m1_283200_206400 0 5.205538e-07
I5885 n1_m1_283200_211200 0 3.269299e-07
I5886 n1_m1_283200_216000 0 5.691324e-07
I5887 n1_m1_283200_220800 0 3.598933e-07
I5888 n1_m1_283200_225600 0 2.883765e-07
I5889 n1_m1_283200_230400 0 1.706398e-07
I5890 n1_m1_283200_235200 0 1.585353e-07
I5891 n1_m1_283200_240000 0 2.856305e-07
I5892 n1_m1_283200_244800 0 2.312347e-07
I5893 n1_m1_283200_249600 0 6.724970e-07
I5894 n1_m1_283200_254400 0 2.081243e-07
I5895 n1_m1_283200_259200 0 3.193334e-07
I5896 n1_m1_283200_264000 0 4.754766e-07
I5897 n1_m1_283200_268800 0 2.179996e-07
I5898 n1_m1_283200_273600 0 4.174762e-07
I5899 n1_m1_283200_278400 0 4.778868e-07
I5900 n1_m1_283200_283200 0 3.260476e-07
I5901 n1_m1_283200_288000 0 3.800464e-07
I5902 n1_m1_283200_292800 0 3.953148e-07
I5903 n1_m1_283200_297600 0 3.674998e-07
I5904 n1_m1_283200_302400 0 2.238792e-07
I5905 n1_m1_283200_307200 0 3.317798e-07
I5906 n1_m1_283200_312000 0 3.237685e-07
I5907 n1_m1_283200_316800 0 2.521774e-07
I5908 n1_m1_283200_321600 0 2.461630e-07
I5909 n1_m1_283200_326400 0 1.351926e-07
I5910 n1_m1_283200_331200 0 1.099702e-07
I5911 n1_m1_283200_336000 0 2.296456e-07
I5912 n1_m1_283200_340800 0 1.118871e-07
I5913 n1_m1_283200_345600 0 1.199024e-07
I5914 n1_m1_283200_350400 0 8.096162e-08
I5915 n1_m1_283200_355200 0 9.416811e-08
I5916 n1_m1_283200_360000 0 3.092336e-07
I5917 n1_m1_283200_364800 0 1.994801e-07
I5918 n1_m1_283200_369600 0 5.224459e-07
I5919 n1_m1_283200_374400 0 4.833370e-07
I5920 n1_m1_283200_379200 0 2.957055e-07
I5921 n1_m1_283200_384000 0 4.840758e-07
I5922 n1_m1_283200_388800 0 1.596005e-07
I5923 n1_m1_283200_393600 0 1.528718e-07
I5924 n1_m1_283200_398400 0 7.507104e-08
I5925 n1_m1_283200_403200 0 7.478361e-08
I5926 n1_m1_283200_408000 0 1.065830e-07
I5927 n1_m1_283200_412800 0 7.197361e-08
I5928 n1_m1_283200_417600 0 1.063515e-07
I5929 n1_m1_283200_422400 0 6.995199e-08
I5930 n1_m1_283200_427200 0 6.995199e-08
I5931 n1_m1_283200_432000 0 1.049280e-07
I5932 n1_m1_283200_436800 0 6.995199e-08
I5933 n1_m1_283200_441600 0 1.056356e-07
I5934 n1_m1_283200_446400 0 7.077063e-08
I5935 n1_m1_283200_451200 0 7.192803e-08
I5936 n1_m1_283200_456000 0 1.222354e-07
I5937 n1_m1_283200_460800 0 9.877007e-08
I5938 n1_m1_283200_465600 0 1.287598e-07
I5939 n1_m1_283200_470400 0 3.857522e-08
I5940 n1_m1_288000_0 0 2.689488e-07
I5941 n1_m1_288000_4800 0 4.824726e-07
I5942 n1_m1_288000_9600 0 7.439167e-07
I5943 n1_m1_288000_14400 0 5.625860e-07
I5944 n1_m1_288000_19200 0 3.414585e-07
I5945 n1_m1_288000_24000 0 2.762700e-07
I5946 n1_m1_288000_28800 0 1.790940e-07
I5947 n1_m1_288000_33600 0 2.813707e-07
I5948 n1_m1_288000_38400 0 1.878470e-07
I5949 n1_m1_288000_43200 0 1.915493e-07
I5950 n1_m1_288000_48000 0 5.057811e-07
I5951 n1_m1_288000_52800 0 2.075651e-07
I5952 n1_m1_288000_57600 0 3.727288e-07
I5953 n1_m1_288000_62400 0 2.255682e-07
I5954 n1_m1_288000_67200 0 1.890362e-07
I5955 n1_m1_288000_72000 0 2.636709e-07
I5956 n1_m1_288000_76800 0 4.578797e-07
I5957 n1_m1_288000_81600 0 3.889592e-07
I5958 n1_m1_288000_86400 0 2.425904e-07
I5959 n1_m1_288000_91200 0 4.710128e-07
I5960 n1_m1_288000_96000 0 5.467010e-07
I5961 n1_m1_288000_100800 0 2.588366e-07
I5962 n1_m1_288000_105600 0 5.343169e-07
I5963 n1_m1_288000_110400 0 6.099933e-07
I5964 n1_m1_288000_115200 0 6.940657e-07
I5965 n1_m1_288000_120000 0 1.066125e-06
I5966 n1_m1_288000_124800 0 5.182962e-07
I5967 n1_m1_288000_129600 0 3.725952e-07
I5968 n1_m1_288000_134400 0 5.553598e-07
I5969 n1_m1_288000_139200 0 6.118139e-07
I5970 n1_m1_288000_144000 0 9.839274e-07
I5971 n1_m1_288000_148800 0 4.580412e-07
I5972 n1_m1_288000_153600 0 6.495928e-07
I5973 n1_m1_288000_158400 0 2.461647e-07
I5974 n1_m1_288000_163200 0 2.354730e-07
I5975 n1_m1_288000_168000 0 5.890909e-07
I5976 n1_m1_288000_172800 0 2.563679e-07
I5977 n1_m1_288000_177600 0 5.939442e-07
I5978 n1_m1_288000_182400 0 5.175771e-07
I5979 n1_m1_288000_187200 0 4.336340e-07
I5980 n1_m1_288000_192000 0 8.019905e-07
I5981 n1_m1_288000_196800 0 2.855159e-07
I5982 n1_m1_288000_201600 0 8.343209e-07
I5983 n1_m1_288000_206400 0 6.765018e-07
I5984 n1_m1_288000_211200 0 1.122331e-06
I5985 n1_m1_288000_216000 0 1.314716e-06
I5986 n1_m1_288000_220800 0 9.250828e-07
I5987 n1_m1_288000_225600 0 1.445632e-06
I5988 n1_m1_288000_230400 0 7.665080e-07
I5989 n1_m1_288000_235200 0 7.375446e-07
I5990 n1_m1_288000_240000 0 6.964894e-07
I5991 n1_m1_288000_244800 0 6.198433e-07
I5992 n1_m1_288000_249600 0 7.167222e-07
I5993 n1_m1_288000_254400 0 9.612376e-07
I5994 n1_m1_288000_259200 0 9.888454e-07
I5995 n1_m1_288000_264000 0 7.462786e-07
I5996 n1_m1_288000_268800 0 7.524552e-07
I5997 n1_m1_288000_273600 0 7.871522e-07
I5998 n1_m1_288000_278400 0 6.794965e-07
I5999 n1_m1_288000_283200 0 5.529605e-07
I6000 n1_m1_288000_288000 0 7.542125e-07
I6001 n1_m1_288000_292800 0 4.611415e-07
I6002 n1_m1_288000_297600 0 8.310749e-07
I6003 n1_m1_288000_302400 0 5.775210e-07
I6004 n1_m1_288000_307200 0 3.640016e-07
I6005 n1_m1_288000_312000 0 1.057409e-06
I6006 n1_m1_288000_316800 0 7.089130e-07
I6007 n1_m1_288000_321600 0 1.067168e-06
I6008 n1_m1_288000_326400 0 5.447092e-07
I6009 n1_m1_288000_331200 0 4.648366e-07
I6010 n1_m1_288000_336000 0 4.553629e-07
I6011 n1_m1_288000_340800 0 2.753469e-07
I6012 n1_m1_288000_345600 0 6.533852e-07
I6013 n1_m1_288000_350400 0 2.582467e-07
I6014 n1_m1_288000_355200 0 1.958390e-07
I6015 n1_m1_288000_360000 0 3.340847e-07
I6016 n1_m1_288000_364800 0 2.008993e-07
I6017 n1_m1_288000_369600 0 7.354590e-07
I6018 n1_m1_288000_374400 0 9.104878e-07
I6019 n1_m1_288000_379200 0 9.794089e-07
I6020 n1_m1_288000_384000 0 1.541855e-06
I6021 n1_m1_288000_388800 0 6.577970e-07
I6022 n1_m1_288000_393600 0 5.946969e-07
I6023 n1_m1_288000_398400 0 1.542249e-07
I6024 n1_m1_288000_403200 0 1.371636e-07
I6025 n1_m1_288000_408000 0 2.052559e-07
I6026 n1_m1_288000_412800 0 1.437632e-07
I6027 n1_m1_288000_417600 0 2.159589e-07
I6028 n1_m1_288000_422400 0 1.399040e-07
I6029 n1_m1_288000_427200 0 1.399040e-07
I6030 n1_m1_288000_432000 0 2.098560e-07
I6031 n1_m1_288000_436800 0 1.399040e-07
I6032 n1_m1_288000_441600 0 2.186161e-07
I6033 n1_m1_288000_446400 0 1.500383e-07
I6034 n1_m1_288000_451200 0 1.512692e-07
I6035 n1_m1_288000_456000 0 2.490557e-07
I6036 n1_m1_288000_460800 0 1.944543e-07
I6037 n1_m1_288000_465600 0 2.631710e-07
I6038 n1_m1_288000_470400 0 8.084344e-08
I6039 n1_m1_292800_0 0 2.386770e-07
I6040 n1_m1_292800_4800 0 4.123679e-07
I6041 n1_m1_292800_9600 0 1.326384e-06
I6042 n1_m1_292800_14400 0 7.430569e-07
I6043 n1_m1_292800_19200 0 3.701059e-07
I6044 n1_m1_292800_24000 0 3.075233e-07
I6045 n1_m1_292800_28800 0 2.352149e-07
I6046 n1_m1_292800_33600 0 3.990715e-07
I6047 n1_m1_292800_38400 0 3.046076e-07
I6048 n1_m1_292800_43200 0 3.550213e-07
I6049 n1_m1_292800_48000 0 3.017008e-07
I6050 n1_m1_292800_52800 0 2.301729e-07
I6051 n1_m1_292800_57600 0 2.874402e-07
I6052 n1_m1_292800_62400 0 5.444061e-07
I6053 n1_m1_292800_67200 0 2.663765e-07
I6054 n1_m1_292800_72000 0 3.329655e-07
I6055 n1_m1_292800_76800 0 2.366584e-07
I6056 n1_m1_292800_81600 0 4.839798e-07
I6057 n1_m1_292800_86400 0 6.068790e-07
I6058 n1_m1_292800_91200 0 4.015869e-07
I6059 n1_m1_292800_96000 0 4.286641e-07
I6060 n1_m1_292800_100800 0 4.411105e-07
I6061 n1_m1_292800_105600 0 1.343442e-06
I6062 n1_m1_292800_110400 0 1.035166e-06
I6063 n1_m1_292800_115200 0 9.055620e-07
I6064 n1_m1_292800_120000 0 6.327717e-07
I6065 n1_m1_292800_124800 0 3.004184e-07
I6066 n1_m1_292800_129600 0 7.797400e-07
I6067 n1_m1_292800_134400 0 6.536469e-07
I6068 n1_m1_292800_139200 0 3.156799e-07
I6069 n1_m1_292800_144000 0 6.962209e-07
I6070 n1_m1_292800_148800 0 6.967113e-07
I6071 n1_m1_292800_153600 0 1.040176e-06
I6072 n1_m1_292800_158400 0 1.901942e-07
I6073 n1_m1_292800_163200 0 2.079677e-07
I6074 n1_m1_292800_168000 0 2.825963e-07
I6075 n1_m1_292800_172800 0 3.971381e-07
I6076 n1_m1_292800_177600 0 3.834593e-07
I6077 n1_m1_292800_182400 0 2.959096e-07
I6078 n1_m1_292800_187200 0 2.934529e-07
I6079 n1_m1_292800_192000 0 3.714637e-07
I6080 n1_m1_292800_196800 0 3.468377e-07
I6081 n1_m1_292800_201600 0 5.553810e-07
I6082 n1_m1_292800_206400 0 6.061111e-07
I6083 n1_m1_292800_211200 0 7.185004e-07
I6084 n1_m1_292800_216000 0 1.492155e-06
I6085 n1_m1_292800_220800 0 8.860621e-07
I6086 n1_m1_292800_225600 0 8.055872e-07
I6087 n1_m1_292800_230400 0 5.309128e-07
I6088 n1_m1_292800_235200 0 2.981852e-07
I6089 n1_m1_292800_240000 0 6.987597e-07
I6090 n1_m1_292800_244800 0 3.662072e-07
I6091 n1_m1_292800_249600 0 5.719310e-07
I6092 n1_m1_292800_254400 0 4.162528e-07
I6093 n1_m1_292800_259200 0 7.603807e-07
I6094 n1_m1_292800_264000 0 7.636779e-07
I6095 n1_m1_292800_268800 0 2.658134e-07
I6096 n1_m1_292800_273600 0 3.208390e-07
I6097 n1_m1_292800_278400 0 2.334958e-07
I6098 n1_m1_292800_283200 0 3.765387e-07
I6099 n1_m1_292800_288000 0 3.908838e-07
I6100 n1_m1_292800_292800 0 2.058906e-07
I6101 n1_m1_292800_297600 0 3.226839e-07
I6102 n1_m1_292800_302400 0 2.351868e-07
I6103 n1_m1_292800_307200 0 1.936368e-07
I6104 n1_m1_292800_312000 0 4.746979e-07
I6105 n1_m1_292800_316800 0 3.179350e-07
I6106 n1_m1_292800_321600 0 4.426813e-07
I6107 n1_m1_292800_326400 0 2.414217e-07
I6108 n1_m1_292800_331200 0 1.826983e-07
I6109 n1_m1_292800_336000 0 2.732432e-07
I6110 n1_m1_292800_340800 0 1.958039e-07
I6111 n1_m1_292800_345600 0 3.615026e-07
I6112 n1_m1_292800_350400 0 1.944701e-07
I6113 n1_m1_292800_355200 0 1.932066e-07
I6114 n1_m1_292800_360000 0 2.541204e-07
I6115 n1_m1_292800_364800 0 1.661713e-07
I6116 n1_m1_292800_369600 0 2.885552e-07
I6117 n1_m1_292800_374400 0 3.477351e-07
I6118 n1_m1_292800_379200 0 6.031958e-07
I6119 n1_m1_292800_384000 0 1.133947e-06
I6120 n1_m1_292800_388800 0 4.037537e-07
I6121 n1_m1_292800_393600 0 3.495791e-07
I6122 n1_m1_292800_398400 0 1.446422e-07
I6123 n1_m1_292800_403200 0 1.429792e-07
I6124 n1_m1_292800_408000 0 2.170332e-07
I6125 n1_m1_292800_412800 0 1.435132e-07
I6126 n1_m1_292800_417600 0 2.110196e-07
I6127 n1_m1_292800_422400 0 1.399040e-07
I6128 n1_m1_292800_427200 0 1.399040e-07
I6129 n1_m1_292800_432000 0 2.098560e-07
I6130 n1_m1_292800_436800 0 1.399040e-07
I6131 n1_m1_292800_441600 0 2.101000e-07
I6132 n1_m1_292800_446400 0 1.401863e-07
I6133 n1_m1_292800_451200 0 1.413437e-07
I6134 n1_m1_292800_456000 0 2.327922e-07
I6135 n1_m1_292800_460800 0 1.752791e-07
I6136 n1_m1_292800_465600 0 2.486306e-07
I6137 n1_m1_292800_470400 0 7.626624e-08
I6138 n1_m1_297600_0 0 4.373026e-07
I6139 n1_m1_297600_4800 0 8.836800e-07
I6140 n1_m1_297600_9600 0 1.709506e-06
I6141 n1_m1_297600_14400 0 7.561551e-07
I6142 n1_m1_297600_19200 0 6.802839e-07
I6143 n1_m1_297600_24000 0 1.011453e-06
I6144 n1_m1_297600_28800 0 1.175569e-06
I6145 n1_m1_297600_33600 0 1.778063e-06
I6146 n1_m1_297600_38400 0 8.290173e-07
I6147 n1_m1_297600_43200 0 6.554680e-07
I6148 n1_m1_297600_48000 0 9.518133e-07
I6149 n1_m1_297600_52800 0 1.221973e-06
I6150 n1_m1_297600_57600 0 1.746618e-06
I6151 n1_m1_297600_62400 0 1.493684e-06
I6152 n1_m1_297600_67200 0 1.285709e-06
I6153 n1_m1_297600_72000 0 1.807138e-06
I6154 n1_m1_297600_76800 0 1.242868e-06
I6155 n1_m1_297600_81600 0 1.409780e-06
I6156 n1_m1_297600_86400 0 8.159733e-07
I6157 n1_m1_297600_91200 0 6.442971e-07
I6158 n1_m1_297600_96000 0 1.584366e-06
I6159 n1_m1_297600_100800 0 1.320681e-06
I6160 n1_m1_297600_105600 0 1.633457e-06
I6161 n1_m1_297600_110400 0 7.188699e-07
I6162 n1_m1_297600_115200 0 6.414913e-07
I6163 n1_m1_297600_120000 0 8.651122e-07
I6164 n1_m1_297600_124800 0 5.003984e-07
I6165 n1_m1_297600_129600 0 1.090397e-06
I6166 n1_m1_297600_134400 0 5.518010e-07
I6167 n1_m1_297600_139200 0 8.145422e-07
I6168 n1_m1_297600_144000 0 9.642943e-07
I6169 n1_m1_297600_148800 0 5.286741e-07
I6170 n1_m1_297600_153600 0 7.962328e-07
I6171 n1_m1_297600_158400 0 2.627502e-07
I6172 n1_m1_297600_163200 0 2.315877e-07
I6173 n1_m1_297600_168000 0 3.712745e-07
I6174 n1_m1_297600_172800 0 2.585320e-07
I6175 n1_m1_297600_177600 0 3.911356e-07
I6176 n1_m1_297600_182400 0 2.845921e-07
I6177 n1_m1_297600_187200 0 3.165322e-07
I6178 n1_m1_297600_192000 0 4.553744e-07
I6179 n1_m1_297600_196800 0 3.330133e-07
I6180 n1_m1_297600_201600 0 4.866015e-07
I6181 n1_m1_297600_206400 0 4.693959e-07
I6182 n1_m1_297600_211200 0 5.313241e-07
I6183 n1_m1_297600_216000 0 8.253348e-07
I6184 n1_m1_297600_220800 0 4.790557e-07
I6185 n1_m1_297600_225600 0 5.126494e-07
I6186 n1_m1_297600_230400 0 2.567564e-07
I6187 n1_m1_297600_235200 0 2.566882e-07
I6188 n1_m1_297600_240000 0 4.101566e-07
I6189 n1_m1_297600_244800 0 2.912910e-07
I6190 n1_m1_297600_249600 0 4.512218e-07
I6191 n1_m1_297600_254400 0 3.528507e-07
I6192 n1_m1_297600_259200 0 4.495392e-07
I6193 n1_m1_297600_264000 0 6.607896e-07
I6194 n1_m1_297600_268800 0 2.784329e-07
I6195 n1_m1_297600_273600 0 5.162397e-07
I6196 n1_m1_297600_278400 0 2.617401e-07
I6197 n1_m1_297600_283200 0 3.544615e-07
I6198 n1_m1_297600_288000 0 4.659176e-07
I6199 n1_m1_297600_292800 0 2.548319e-07
I6200 n1_m1_297600_297600 0 3.856718e-07
I6201 n1_m1_297600_302400 0 2.562906e-07
I6202 n1_m1_297600_307200 0 2.291655e-07
I6203 n1_m1_297600_312000 0 3.768908e-07
I6204 n1_m1_297600_316800 0 2.532634e-07
I6205 n1_m1_297600_321600 0 3.866005e-07
I6206 n1_m1_297600_326400 0 2.431382e-07
I6207 n1_m1_297600_331200 0 2.406966e-07
I6208 n1_m1_297600_336000 0 3.522582e-07
I6209 n1_m1_297600_340800 0 2.359326e-07
I6210 n1_m1_297600_345600 0 3.650827e-07
I6211 n1_m1_297600_350400 0 2.481376e-07
I6212 n1_m1_297600_355200 0 2.312848e-07
I6213 n1_m1_297600_360000 0 3.395127e-07
I6214 n1_m1_297600_364800 0 2.202424e-07
I6215 n1_m1_297600_369600 0 3.380242e-07
I6216 n1_m1_297600_374400 0 2.469212e-07
I6217 n1_m1_297600_379200 0 2.785154e-07
I6218 n1_m1_297600_384000 0 4.574654e-07
I6219 n1_m1_297600_388800 0 2.821989e-07
I6220 n1_m1_297600_393600 0 3.688394e-07
I6221 n1_m1_297600_398400 0 2.242543e-07
I6222 n1_m1_297600_403200 0 2.099112e-07
I6223 n1_m1_297600_408000 0 3.075528e-07
I6224 n1_m1_297600_412800 0 2.086068e-07
I6225 n1_m1_297600_417600 0 3.147839e-07
I6226 n1_m1_297600_422400 0 2.096514e-07
I6227 n1_m1_297600_427200 0 2.096730e-07
I6228 n1_m1_297600_432000 0 3.147839e-07
I6229 n1_m1_297600_436800 0 2.098560e-07
I6230 n1_m1_297600_441600 0 3.151123e-07
I6231 n1_m1_297600_446400 0 2.099152e-07
I6232 n1_m1_297600_451200 0 2.106504e-07
I6233 n1_m1_297600_456000 0 3.392623e-07
I6234 n1_m1_297600_460800 0 2.547106e-07
I6235 n1_m1_297600_465600 0 3.669095e-07
I6236 n1_m1_297600_470400 0 1.154928e-07
I6237 n1_m1_302400_0 0 2.469544e-07
I6238 n1_m1_302400_4800 0 4.224283e-07
I6239 n1_m1_302400_9600 0 6.737043e-07
I6240 n1_m1_302400_14400 0 5.424138e-07
I6241 n1_m1_302400_19200 0 9.712988e-07
I6242 n1_m1_302400_24000 0 9.982220e-07
I6243 n1_m1_302400_28800 0 8.184555e-07
I6244 n1_m1_302400_33600 0 1.385565e-06
I6245 n1_m1_302400_38400 0 7.955542e-07
I6246 n1_m1_302400_43200 0 6.700055e-07
I6247 n1_m1_302400_48000 0 1.052277e-06
I6248 n1_m1_302400_52800 0 9.834425e-07
I6249 n1_m1_302400_57600 0 1.830832e-06
I6250 n1_m1_302400_62400 0 1.288849e-06
I6251 n1_m1_302400_67200 0 1.048381e-06
I6252 n1_m1_302400_72000 0 1.817736e-06
I6253 n1_m1_302400_76800 0 1.175533e-06
I6254 n1_m1_302400_81600 0 1.384822e-06
I6255 n1_m1_302400_86400 0 4.557185e-07
I6256 n1_m1_302400_91200 0 8.464235e-07
I6257 n1_m1_302400_96000 0 1.508427e-06
I6258 n1_m1_302400_100800 0 1.105335e-06
I6259 n1_m1_302400_105600 0 1.204005e-06
I6260 n1_m1_302400_110400 0 7.051614e-07
I6261 n1_m1_302400_115200 0 6.318863e-07
I6262 n1_m1_302400_120000 0 9.097028e-07
I6263 n1_m1_302400_124800 0 3.683455e-07
I6264 n1_m1_302400_129600 0 5.114621e-07
I6265 n1_m1_302400_134400 0 4.850709e-07
I6266 n1_m1_302400_139200 0 8.246437e-07
I6267 n1_m1_302400_144000 0 5.811530e-07
I6268 n1_m1_302400_148800 0 2.058357e-07
I6269 n1_m1_302400_153600 0 2.630441e-07
I6270 n1_m1_302400_158400 0 1.609607e-07
I6271 n1_m1_302400_163200 0 1.501611e-07
I6272 n1_m1_302400_168000 0 2.351792e-07
I6273 n1_m1_302400_172800 0 1.543334e-07
I6274 n1_m1_302400_177600 0 2.498693e-07
I6275 n1_m1_302400_182400 0 1.785486e-07
I6276 n1_m1_302400_187200 0 2.345142e-07
I6277 n1_m1_302400_192000 0 3.871772e-07
I6278 n1_m1_302400_196800 0 3.188250e-07
I6279 n1_m1_302400_201600 0 3.551692e-07
I6280 n1_m1_302400_206400 0 2.251081e-07
I6281 n1_m1_302400_211200 0 2.014498e-07
I6282 n1_m1_302400_216000 0 2.646755e-07
I6283 n1_m1_302400_220800 0 1.606402e-07
I6284 n1_m1_302400_225600 0 2.343716e-07
I6285 n1_m1_302400_230400 0 1.573441e-07
I6286 n1_m1_302400_235200 0 1.665524e-07
I6287 n1_m1_302400_240000 0 2.596692e-07
I6288 n1_m1_302400_244800 0 1.738992e-07
I6289 n1_m1_302400_249600 0 2.615420e-07
I6290 n1_m1_302400_254400 0 1.781133e-07
I6291 n1_m1_302400_259200 0 1.998787e-07
I6292 n1_m1_302400_264000 0 3.368293e-07
I6293 n1_m1_302400_268800 0 3.415065e-07
I6294 n1_m1_302400_273600 0 4.898048e-07
I6295 n1_m1_302400_278400 0 3.531833e-07
I6296 n1_m1_302400_283200 0 4.918605e-07
I6297 n1_m1_302400_288000 0 5.788886e-07
I6298 n1_m1_302400_292800 0 1.953215e-07
I6299 n1_m1_302400_297600 0 2.971948e-07
I6300 n1_m1_302400_302400 0 1.606283e-07
I6301 n1_m1_302400_307200 0 1.438685e-07
I6302 n1_m1_302400_312000 0 2.259914e-07
I6303 n1_m1_302400_316800 0 1.476671e-07
I6304 n1_m1_302400_321600 0 2.232605e-07
I6305 n1_m1_302400_326400 0 1.476670e-07
I6306 n1_m1_302400_331200 0 1.476670e-07
I6307 n1_m1_302400_336000 0 2.194576e-07
I6308 n1_m1_302400_340800 0 1.426769e-07
I6309 n1_m1_302400_345600 0 2.169208e-07
I6310 n1_m1_302400_350400 0 1.435435e-07
I6311 n1_m1_302400_355200 0 1.412568e-07
I6312 n1_m1_302400_360000 0 2.107703e-07
I6313 n1_m1_302400_364800 0 1.399040e-07
I6314 n1_m1_302400_369600 0 2.102758e-07
I6315 n1_m1_302400_374400 0 1.477285e-07
I6316 n1_m1_302400_379200 0 1.621632e-07
I6317 n1_m1_302400_384000 0 2.450062e-07
I6318 n1_m1_302400_388800 0 1.583148e-07
I6319 n1_m1_302400_393600 0 2.181359e-07
I6320 n1_m1_302400_398400 0 1.403877e-07
I6321 n1_m1_302400_403200 0 1.361286e-07
I6322 n1_m1_302400_408000 0 2.089545e-07
I6323 n1_m1_302400_412800 0 1.398052e-07
I6324 n1_m1_302400_417600 0 2.098560e-07
I6325 n1_m1_302400_422400 0 1.372177e-07
I6326 n1_m1_302400_427200 0 1.375004e-07
I6327 n1_m1_302400_432000 0 2.098560e-07
I6328 n1_m1_302400_436800 0 1.399040e-07
I6329 n1_m1_302400_441600 0 2.142310e-07
I6330 n1_m1_302400_446400 0 1.411959e-07
I6331 n1_m1_302400_451200 0 1.399728e-07
I6332 n1_m1_302400_456000 0 2.234177e-07
I6333 n1_m1_302400_460800 0 1.697723e-07
I6334 n1_m1_302400_465600 0 2.499223e-07
I6335 n1_m1_302400_470400 0 7.869395e-08
I6336 n1_m1_307200_0 0 2.066120e-07
I6337 n1_m1_307200_4800 0 3.410491e-07
I6338 n1_m1_307200_9600 0 8.941702e-07
I6339 n1_m1_307200_14400 0 5.000617e-07
I6340 n1_m1_307200_19200 0 7.106006e-07
I6341 n1_m1_307200_24000 0 7.588147e-07
I6342 n1_m1_307200_28800 0 4.533250e-07
I6343 n1_m1_307200_33600 0 8.883830e-07
I6344 n1_m1_307200_38400 0 7.173648e-07
I6345 n1_m1_307200_43200 0 5.491187e-07
I6346 n1_m1_307200_48000 0 6.748173e-07
I6347 n1_m1_307200_52800 0 6.453064e-07
I6348 n1_m1_307200_57600 0 1.731015e-06
I6349 n1_m1_307200_62400 0 9.117323e-07
I6350 n1_m1_307200_67200 0 8.437676e-07
I6351 n1_m1_307200_72000 0 1.108313e-06
I6352 n1_m1_307200_76800 0 1.109482e-06
I6353 n1_m1_307200_81600 0 1.112946e-06
I6354 n1_m1_307200_86400 0 7.806226e-07
I6355 n1_m1_307200_91200 0 8.749855e-07
I6356 n1_m1_307200_96000 0 1.220994e-06
I6357 n1_m1_307200_100800 0 1.068141e-06
I6358 n1_m1_307200_105600 0 1.312033e-06
I6359 n1_m1_307200_110400 0 9.127594e-07
I6360 n1_m1_307200_115200 0 5.145756e-07
I6361 n1_m1_307200_120000 0 8.005895e-07
I6362 n1_m1_307200_124800 0 4.229147e-07
I6363 n1_m1_307200_129600 0 5.337301e-07
I6364 n1_m1_307200_134400 0 3.128517e-07
I6365 n1_m1_307200_139200 0 2.802768e-07
I6366 n1_m1_307200_144000 0 4.542077e-07
I6367 n1_m1_307200_148800 0 2.484488e-07
I6368 n1_m1_307200_153600 0 2.362767e-07
I6369 n1_m1_307200_158400 0 1.703239e-07
I6370 n1_m1_307200_163200 0 1.550848e-07
I6371 n1_m1_307200_168000 0 2.369870e-07
I6372 n1_m1_307200_172800 0 1.535643e-07
I6373 n1_m1_307200_177600 0 2.498154e-07
I6374 n1_m1_307200_182400 0 1.753907e-07
I6375 n1_m1_307200_187200 0 2.604870e-07
I6376 n1_m1_307200_192000 0 5.217957e-07
I6377 n1_m1_307200_196800 0 4.301817e-07
I6378 n1_m1_307200_201600 0 3.797382e-07
I6379 n1_m1_307200_206400 0 3.052572e-07
I6380 n1_m1_307200_211200 0 2.521117e-07
I6381 n1_m1_307200_216000 0 2.658471e-07
I6382 n1_m1_307200_220800 0 1.600596e-07
I6383 n1_m1_307200_225600 0 2.383688e-07
I6384 n1_m1_307200_230400 0 1.614278e-07
I6385 n1_m1_307200_235200 0 1.650703e-07
I6386 n1_m1_307200_240000 0 2.555948e-07
I6387 n1_m1_307200_244800 0 1.771472e-07
I6388 n1_m1_307200_249600 0 2.712946e-07
I6389 n1_m1_307200_254400 0 1.923645e-07
I6390 n1_m1_307200_259200 0 2.371016e-07
I6391 n1_m1_307200_264000 0 3.573018e-07
I6392 n1_m1_307200_268800 0 3.065530e-07
I6393 n1_m1_307200_273600 0 5.081380e-07
I6394 n1_m1_307200_278400 0 4.426735e-07
I6395 n1_m1_307200_283200 0 5.060768e-07
I6396 n1_m1_307200_288000 0 6.297332e-07
I6397 n1_m1_307200_292800 0 2.802551e-07
I6398 n1_m1_307200_297600 0 3.789808e-07
I6399 n1_m1_307200_302400 0 1.644995e-07
I6400 n1_m1_307200_307200 0 1.536950e-07
I6401 n1_m1_307200_312000 0 2.354052e-07
I6402 n1_m1_307200_316800 0 1.463083e-07
I6403 n1_m1_307200_321600 0 2.201532e-07
I6404 n1_m1_307200_326400 0 1.465661e-07
I6405 n1_m1_307200_331200 0 1.470936e-07
I6406 n1_m1_307200_336000 0 2.211542e-07
I6407 n1_m1_307200_340800 0 1.452355e-07
I6408 n1_m1_307200_345600 0 2.119589e-07
I6409 n1_m1_307200_350400 0 1.409073e-07
I6410 n1_m1_307200_355200 0 1.401719e-07
I6411 n1_m1_307200_360000 0 2.106054e-07
I6412 n1_m1_307200_364800 0 1.399040e-07
I6413 n1_m1_307200_369600 0 2.102328e-07
I6414 n1_m1_307200_374400 0 1.466419e-07
I6415 n1_m1_307200_379200 0 1.605678e-07
I6416 n1_m1_307200_384000 0 2.420728e-07
I6417 n1_m1_307200_388800 0 1.530626e-07
I6418 n1_m1_307200_393600 0 2.156058e-07
I6419 n1_m1_307200_398400 0 1.406680e-07
I6420 n1_m1_307200_403200 0 1.445318e-07
I6421 n1_m1_307200_408000 0 2.185691e-07
I6422 n1_m1_307200_412800 0 1.413648e-07
I6423 n1_m1_307200_417600 0 2.098560e-07
I6424 n1_m1_307200_422400 0 1.371631e-07
I6425 n1_m1_307200_427200 0 1.374516e-07
I6426 n1_m1_307200_432000 0 2.098560e-07
I6427 n1_m1_307200_436800 0 1.399040e-07
I6428 n1_m1_307200_441600 0 2.146878e-07
I6429 n1_m1_307200_446400 0 1.442361e-07
I6430 n1_m1_307200_451200 0 1.403772e-07
I6431 n1_m1_307200_456000 0 2.198039e-07
I6432 n1_m1_307200_460800 0 1.684117e-07
I6433 n1_m1_307200_465600 0 2.463474e-07
I6434 n1_m1_307200_470400 0 7.823212e-08
I6435 n1_m1_312000_0 0 3.802724e-07
I6436 n1_m1_312000_4800 0 6.215819e-07
I6437 n1_m1_312000_9600 0 7.769646e-07
I6438 n1_m1_312000_14400 0 4.851227e-07
I6439 n1_m1_312000_19200 0 6.600477e-07
I6440 n1_m1_312000_24000 0 7.701153e-07
I6441 n1_m1_312000_28800 0 6.017224e-07
I6442 n1_m1_312000_33600 0 7.768332e-07
I6443 n1_m1_312000_38400 0 4.226274e-07
I6444 n1_m1_312000_43200 0 3.392431e-07
I6445 n1_m1_312000_48000 0 5.467480e-07
I6446 n1_m1_312000_52800 0 5.054737e-07
I6447 n1_m1_312000_57600 0 1.367845e-06
I6448 n1_m1_312000_62400 0 5.288231e-07
I6449 n1_m1_312000_67200 0 5.707239e-07
I6450 n1_m1_312000_72000 0 8.961306e-07
I6451 n1_m1_312000_76800 0 1.026632e-06
I6452 n1_m1_312000_81600 0 9.479471e-07
I6453 n1_m1_312000_86400 0 5.132009e-07
I6454 n1_m1_312000_91200 0 1.012890e-06
I6455 n1_m1_312000_96000 0 1.498325e-06
I6456 n1_m1_312000_100800 0 1.425857e-06
I6457 n1_m1_312000_105600 0 1.764517e-06
I6458 n1_m1_312000_110400 0 1.031343e-06
I6459 n1_m1_312000_115200 0 7.205915e-07
I6460 n1_m1_312000_120000 0 9.831449e-07
I6461 n1_m1_312000_124800 0 6.849641e-07
I6462 n1_m1_312000_129600 0 5.253968e-07
I6463 n1_m1_312000_134400 0 4.081841e-07
I6464 n1_m1_312000_139200 0 3.052092e-07
I6465 n1_m1_312000_144000 0 8.611812e-07
I6466 n1_m1_312000_148800 0 3.109949e-07
I6467 n1_m1_312000_153600 0 3.353370e-07
I6468 n1_m1_312000_158400 0 2.363913e-07
I6469 n1_m1_312000_163200 0 2.230874e-07
I6470 n1_m1_312000_168000 0 3.400764e-07
I6471 n1_m1_312000_172800 0 2.302695e-07
I6472 n1_m1_312000_177600 0 3.474350e-07
I6473 n1_m1_312000_182400 0 2.773869e-07
I6474 n1_m1_312000_187200 0 4.331586e-07
I6475 n1_m1_312000_192000 0 6.320590e-07
I6476 n1_m1_312000_196800 0 4.167133e-07
I6477 n1_m1_312000_201600 0 4.307156e-07
I6478 n1_m1_312000_206400 0 3.664542e-07
I6479 n1_m1_312000_211200 0 3.092170e-07
I6480 n1_m1_312000_216000 0 3.701433e-07
I6481 n1_m1_312000_220800 0 2.277059e-07
I6482 n1_m1_312000_225600 0 3.495113e-07
I6483 n1_m1_312000_230400 0 2.313635e-07
I6484 n1_m1_312000_235200 0 2.312961e-07
I6485 n1_m1_312000_240000 0 3.544869e-07
I6486 n1_m1_312000_244800 0 2.485416e-07
I6487 n1_m1_312000_249600 0 3.847544e-07
I6488 n1_m1_312000_254400 0 2.626784e-07
I6489 n1_m1_312000_259200 0 2.781876e-07
I6490 n1_m1_312000_264000 0 4.177609e-07
I6491 n1_m1_312000_268800 0 2.547122e-07
I6492 n1_m1_312000_273600 0 4.118292e-07
I6493 n1_m1_312000_278400 0 2.877160e-07
I6494 n1_m1_312000_283200 0 3.833202e-07
I6495 n1_m1_312000_288000 0 7.308395e-07
I6496 n1_m1_312000_292800 0 8.832682e-07
I6497 n1_m1_312000_297600 0 1.365234e-06
I6498 n1_m1_312000_302400 0 3.524769e-07
I6499 n1_m1_312000_307200 0 2.460354e-07
I6500 n1_m1_312000_312000 0 3.338828e-07
I6501 n1_m1_312000_316800 0 2.135002e-07
I6502 n1_m1_312000_321600 0 3.938698e-07
I6503 n1_m1_312000_326400 0 2.241964e-07
I6504 n1_m1_312000_331200 0 2.269243e-07
I6505 n1_m1_312000_336000 0 3.439588e-07
I6506 n1_m1_312000_340800 0 2.267229e-07
I6507 n1_m1_312000_345600 0 3.289691e-07
I6508 n1_m1_312000_350400 0 2.182308e-07
I6509 n1_m1_312000_355200 0 2.117389e-07
I6510 n1_m1_312000_360000 0 3.186594e-07
I6511 n1_m1_312000_364800 0 2.098560e-07
I6512 n1_m1_312000_369600 0 3.167325e-07
I6513 n1_m1_312000_374400 0 2.198733e-07
I6514 n1_m1_312000_379200 0 2.341096e-07
I6515 n1_m1_312000_384000 0 3.687211e-07
I6516 n1_m1_312000_388800 0 2.366737e-07
I6517 n1_m1_312000_393600 0 3.347287e-07
I6518 n1_m1_312000_398400 0 2.119522e-07
I6519 n1_m1_312000_403200 0 2.149037e-07
I6520 n1_m1_312000_408000 0 3.232527e-07
I6521 n1_m1_312000_412800 0 2.112674e-07
I6522 n1_m1_312000_417600 0 3.147839e-07
I6523 n1_m1_312000_422400 0 2.095969e-07
I6524 n1_m1_312000_427200 0 2.096241e-07
I6525 n1_m1_312000_432000 0 3.147839e-07
I6526 n1_m1_312000_436800 0 2.098560e-07
I6527 n1_m1_312000_441600 0 3.152476e-07
I6528 n1_m1_312000_446400 0 2.103219e-07
I6529 n1_m1_312000_451200 0 2.099082e-07
I6530 n1_m1_312000_456000 0 3.318999e-07
I6531 n1_m1_312000_460800 0 2.533345e-07
I6532 n1_m1_312000_465600 0 3.684336e-07
I6533 n1_m1_312000_470400 0 1.172077e-07
I6534 n1_m1_316800_0 0 2.355445e-07
I6535 n1_m1_316800_4800 0 4.288283e-07
I6536 n1_m1_316800_9600 0 9.698627e-07
I6537 n1_m1_316800_14400 0 2.849270e-07
I6538 n1_m1_316800_19200 0 2.555020e-07
I6539 n1_m1_316800_24000 0 3.214531e-07
I6540 n1_m1_316800_28800 0 1.822016e-07
I6541 n1_m1_316800_33600 0 3.824465e-07
I6542 n1_m1_316800_38400 0 2.278550e-07
I6543 n1_m1_316800_43200 0 2.264921e-07
I6544 n1_m1_316800_48000 0 2.408186e-07
I6545 n1_m1_316800_52800 0 1.626865e-07
I6546 n1_m1_316800_57600 0 2.671732e-07
I6547 n1_m1_316800_62400 0 6.210028e-07
I6548 n1_m1_316800_67200 0 2.661758e-07
I6549 n1_m1_316800_72000 0 2.988923e-07
I6550 n1_m1_316800_76800 0 2.148399e-07
I6551 n1_m1_316800_81600 0 3.245919e-07
I6552 n1_m1_316800_86400 0 2.686230e-07
I6553 n1_m1_316800_91200 0 2.539428e-07
I6554 n1_m1_316800_96000 0 5.619587e-07
I6555 n1_m1_316800_100800 0 3.089614e-07
I6556 n1_m1_316800_105600 0 1.121390e-06
I6557 n1_m1_316800_110400 0 3.949148e-07
I6558 n1_m1_316800_115200 0 1.930664e-07
I6559 n1_m1_316800_120000 0 3.788584e-07
I6560 n1_m1_316800_124800 0 1.642445e-07
I6561 n1_m1_316800_129600 0 4.800428e-07
I6562 n1_m1_316800_134400 0 1.627287e-07
I6563 n1_m1_316800_139200 0 2.003042e-07
I6564 n1_m1_316800_144000 0 2.670729e-07
I6565 n1_m1_316800_148800 0 1.863940e-07
I6566 n1_m1_316800_153600 0 2.533544e-07
I6567 n1_m1_316800_158400 0 1.510177e-07
I6568 n1_m1_316800_163200 0 1.495697e-07
I6569 n1_m1_316800_168000 0 2.092330e-07
I6570 n1_m1_316800_172800 0 1.401899e-07
I6571 n1_m1_316800_177600 0 2.263935e-07
I6572 n1_m1_316800_182400 0 1.575893e-07
I6573 n1_m1_316800_187200 0 2.378615e-07
I6574 n1_m1_316800_192000 0 5.902326e-07
I6575 n1_m1_316800_196800 0 5.201180e-07
I6576 n1_m1_316800_201600 0 4.012621e-07
I6577 n1_m1_316800_206400 0 2.093599e-07
I6578 n1_m1_316800_211200 0 1.764815e-07
I6579 n1_m1_316800_216000 0 2.290756e-07
I6580 n1_m1_316800_220800 0 1.465378e-07
I6581 n1_m1_316800_225600 0 2.259890e-07
I6582 n1_m1_316800_230400 0 1.465378e-07
I6583 n1_m1_316800_235200 0 1.523107e-07
I6584 n1_m1_316800_240000 0 2.375102e-07
I6585 n1_m1_316800_244800 0 1.614398e-07
I6586 n1_m1_316800_249600 0 2.495187e-07
I6587 n1_m1_316800_254400 0 1.620335e-07
I6588 n1_m1_316800_259200 0 1.564744e-07
I6589 n1_m1_316800_264000 0 2.373116e-07
I6590 n1_m1_316800_268800 0 1.478381e-07
I6591 n1_m1_316800_273600 0 2.384162e-07
I6592 n1_m1_316800_278400 0 1.585826e-07
I6593 n1_m1_316800_283200 0 5.908008e-07
I6594 n1_m1_316800_288000 0 1.051491e-06
I6595 n1_m1_316800_292800 0 9.149487e-07
I6596 n1_m1_316800_297600 0 1.219825e-06
I6597 n1_m1_316800_302400 0 2.734726e-07
I6598 n1_m1_316800_307200 0 1.653948e-07
I6599 n1_m1_316800_312000 0 2.115290e-07
I6600 n1_m1_316800_316800 0 1.443924e-07
I6601 n1_m1_316800_321600 0 4.149126e-07
I6602 n1_m1_316800_326400 0 1.657703e-07
I6603 n1_m1_316800_331200 0 1.604577e-07
I6604 n1_m1_316800_336000 0 2.307024e-07
I6605 n1_m1_316800_340800 0 1.479678e-07
I6606 n1_m1_316800_345600 0 2.198491e-07
I6607 n1_m1_316800_350400 0 1.452452e-07
I6608 n1_m1_316800_355200 0 1.363457e-07
I6609 n1_m1_316800_360000 0 2.058215e-07
I6610 n1_m1_316800_364800 0 1.363036e-07
I6611 n1_m1_316800_369600 0 2.044245e-07
I6612 n1_m1_316800_374400 0 1.430092e-07
I6613 n1_m1_316800_379200 0 1.502514e-07
I6614 n1_m1_316800_384000 0 2.435256e-07
I6615 n1_m1_316800_388800 0 1.581964e-07
I6616 n1_m1_316800_393600 0 2.278857e-07
I6617 n1_m1_316800_398400 0 1.458562e-07
I6618 n1_m1_316800_403200 0 1.448723e-07
I6619 n1_m1_316800_408000 0 2.173085e-07
I6620 n1_m1_316800_412800 0 1.448294e-07
I6621 n1_m1_316800_417600 0 2.171873e-07
I6622 n1_m1_316800_422400 0 1.424286e-07
I6623 n1_m1_316800_427200 0 1.399040e-07
I6624 n1_m1_316800_432000 0 2.098560e-07
I6625 n1_m1_316800_436800 0 1.399040e-07
I6626 n1_m1_316800_441600 0 2.102905e-07
I6627 n1_m1_316800_446400 0 1.441085e-07
I6628 n1_m1_316800_451200 0 1.456615e-07
I6629 n1_m1_316800_456000 0 2.383384e-07
I6630 n1_m1_316800_460800 0 1.793045e-07
I6631 n1_m1_316800_465600 0 2.455702e-07
I6632 n1_m1_316800_470400 0 7.625859e-08
I6633 n1_m1_321600_0 0 4.650734e-07
I6634 n1_m1_321600_4800 0 9.763584e-07
I6635 n1_m1_321600_9600 0 1.873352e-06
I6636 n1_m1_321600_14400 0 7.943603e-07
I6637 n1_m1_321600_19200 0 4.554423e-07
I6638 n1_m1_321600_24000 0 4.061666e-07
I6639 n1_m1_321600_28800 0 2.746336e-07
I6640 n1_m1_321600_33600 0 6.103549e-07
I6641 n1_m1_321600_38400 0 2.926030e-07
I6642 n1_m1_321600_43200 0 3.044202e-07
I6643 n1_m1_321600_48000 0 3.547163e-07
I6644 n1_m1_321600_52800 0 2.590220e-07
I6645 n1_m1_321600_57600 0 3.899479e-07
I6646 n1_m1_321600_62400 0 4.077750e-07
I6647 n1_m1_321600_67200 0 2.930772e-07
I6648 n1_m1_321600_72000 0 4.138557e-07
I6649 n1_m1_321600_76800 0 4.543980e-07
I6650 n1_m1_321600_81600 0 4.616083e-07
I6651 n1_m1_321600_86400 0 2.952249e-07
I6652 n1_m1_321600_91200 0 2.930582e-07
I6653 n1_m1_321600_96000 0 6.418208e-07
I6654 n1_m1_321600_100800 0 6.158518e-07
I6655 n1_m1_321600_105600 0 7.567681e-07
I6656 n1_m1_321600_110400 0 4.011888e-07
I6657 n1_m1_321600_115200 0 2.685895e-07
I6658 n1_m1_321600_120000 0 4.357014e-07
I6659 n1_m1_321600_124800 0 2.784857e-07
I6660 n1_m1_321600_129600 0 4.327898e-07
I6661 n1_m1_321600_134400 0 2.555997e-07
I6662 n1_m1_321600_139200 0 2.449040e-07
I6663 n1_m1_321600_144000 0 4.436176e-07
I6664 n1_m1_321600_148800 0 2.415360e-07
I6665 n1_m1_321600_153600 0 3.650598e-07
I6666 n1_m1_321600_158400 0 2.183154e-07
I6667 n1_m1_321600_163200 0 2.222113e-07
I6668 n1_m1_321600_168000 0 3.181046e-07
I6669 n1_m1_321600_172800 0 2.199103e-07
I6670 n1_m1_321600_177600 0 3.338107e-07
I6671 n1_m1_321600_182400 0 2.553024e-07
I6672 n1_m1_321600_187200 0 4.155328e-07
I6673 n1_m1_321600_192000 0 8.808587e-07
I6674 n1_m1_321600_196800 0 6.963636e-07
I6675 n1_m1_321600_201600 0 8.144439e-07
I6676 n1_m1_321600_206400 0 4.605194e-07
I6677 n1_m1_321600_211200 0 3.000028e-07
I6678 n1_m1_321600_216000 0 3.430151e-07
I6679 n1_m1_321600_220800 0 2.113521e-07
I6680 n1_m1_321600_225600 0 3.271038e-07
I6681 n1_m1_321600_230400 0 2.127717e-07
I6682 n1_m1_321600_235200 0 2.213453e-07
I6683 n1_m1_321600_240000 0 3.540747e-07
I6684 n1_m1_321600_244800 0 2.407111e-07
I6685 n1_m1_321600_249600 0 3.654227e-07
I6686 n1_m1_321600_254400 0 2.389517e-07
I6687 n1_m1_321600_259200 0 2.253342e-07
I6688 n1_m1_321600_264000 0 3.368332e-07
I6689 n1_m1_321600_268800 0 2.156032e-07
I6690 n1_m1_321600_273600 0 3.655036e-07
I6691 n1_m1_321600_278400 0 2.503501e-07
I6692 n1_m1_321600_283200 0 1.074513e-06
I6693 n1_m1_321600_288000 0 1.630312e-06
I6694 n1_m1_321600_292800 0 1.006423e-06
I6695 n1_m1_321600_297600 0 1.208185e-06
I6696 n1_m1_321600_302400 0 3.105420e-07
I6697 n1_m1_321600_307200 0 2.446305e-07
I6698 n1_m1_321600_312000 0 3.307608e-07
I6699 n1_m1_321600_316800 0 2.283716e-07
I6700 n1_m1_321600_321600 0 7.000049e-07
I6701 n1_m1_321600_326400 0 2.759688e-07
I6702 n1_m1_321600_331200 0 2.618884e-07
I6703 n1_m1_321600_336000 0 3.587591e-07
I6704 n1_m1_321600_340800 0 2.238492e-07
I6705 n1_m1_321600_345600 0 3.281483e-07
I6706 n1_m1_321600_350400 0 2.178403e-07
I6707 n1_m1_321600_355200 0 2.048703e-07
I6708 n1_m1_321600_360000 0 3.112628e-07
I6709 n1_m1_321600_364800 0 2.105159e-07
I6710 n1_m1_321600_369600 0 3.136349e-07
I6711 n1_m1_321600_374400 0 2.133822e-07
I6712 n1_m1_321600_379200 0 2.289439e-07
I6713 n1_m1_321600_384000 0 3.798691e-07
I6714 n1_m1_321600_388800 0 2.593527e-07
I6715 n1_m1_321600_393600 0 3.850602e-07
I6716 n1_m1_321600_398400 0 2.494607e-07
I6717 n1_m1_321600_403200 0 2.510699e-07
I6718 n1_m1_321600_408000 0 3.933468e-07
I6719 n1_m1_321600_412800 0 2.507664e-07
I6720 n1_m1_321600_417600 0 3.387490e-07
I6721 n1_m1_321600_422400 0 2.173673e-07
I6722 n1_m1_321600_427200 0 2.133329e-07
I6723 n1_m1_321600_432000 0 3.150617e-07
I6724 n1_m1_321600_436800 0 2.081072e-07
I6725 n1_m1_321600_441600 0 3.173396e-07
I6726 n1_m1_321600_446400 0 2.175002e-07
I6727 n1_m1_321600_451200 0 2.250570e-07
I6728 n1_m1_321600_456000 0 3.759779e-07
I6729 n1_m1_321600_460800 0 2.861272e-07
I6730 n1_m1_321600_465600 0 3.784482e-07
I6731 n1_m1_321600_470400 0 1.143265e-07
I6732 n1_m1_326400_0 0 2.708512e-07
I6733 n1_m1_326400_4800 0 5.754078e-07
I6734 n1_m1_326400_9600 0 1.176254e-06
I6735 n1_m1_326400_14400 0 3.818288e-07
I6736 n1_m1_326400_19200 0 1.892288e-07
I6737 n1_m1_326400_24000 0 2.515802e-07
I6738 n1_m1_326400_28800 0 1.728015e-07
I6739 n1_m1_326400_33600 0 2.457772e-07
I6740 n1_m1_326400_38400 0 1.655883e-07
I6741 n1_m1_326400_43200 0 1.759756e-07
I6742 n1_m1_326400_48000 0 2.428669e-07
I6743 n1_m1_326400_52800 0 1.606515e-07
I6744 n1_m1_326400_57600 0 2.669139e-07
I6745 n1_m1_326400_62400 0 1.716353e-07
I6746 n1_m1_326400_67200 0 1.719137e-07
I6747 n1_m1_326400_72000 0 2.682763e-07
I6748 n1_m1_326400_76800 0 1.700155e-07
I6749 n1_m1_326400_81600 0 2.481829e-07
I6750 n1_m1_326400_86400 0 1.707159e-07
I6751 n1_m1_326400_91200 0 1.857525e-07
I6752 n1_m1_326400_96000 0 3.912976e-07
I6753 n1_m1_326400_100800 0 3.345937e-07
I6754 n1_m1_326400_105600 0 3.976484e-07
I6755 n1_m1_326400_110400 0 1.853714e-07
I6756 n1_m1_326400_115200 0 1.695262e-07
I6757 n1_m1_326400_120000 0 2.426121e-07
I6758 n1_m1_326400_124800 0 1.705336e-07
I6759 n1_m1_326400_129600 0 2.407928e-07
I6760 n1_m1_326400_134400 0 1.628381e-07
I6761 n1_m1_326400_139200 0 1.571468e-07
I6762 n1_m1_326400_144000 0 2.414162e-07
I6763 n1_m1_326400_148800 0 1.538492e-07
I6764 n1_m1_326400_153600 0 2.274074e-07
I6765 n1_m1_326400_158400 0 1.467295e-07
I6766 n1_m1_326400_163200 0 1.408920e-07
I6767 n1_m1_326400_168000 0 2.138645e-07
I6768 n1_m1_326400_172800 0 1.490852e-07
I6769 n1_m1_326400_177600 0 2.240976e-07
I6770 n1_m1_326400_182400 0 1.677131e-07
I6771 n1_m1_326400_187200 0 1.997265e-07
I6772 n1_m1_326400_192000 0 3.977879e-07
I6773 n1_m1_326400_196800 0 2.973620e-07
I6774 n1_m1_326400_201600 0 4.878204e-07
I6775 n1_m1_326400_206400 0 2.794230e-07
I6776 n1_m1_326400_211200 0 1.906084e-07
I6777 n1_m1_326400_216000 0 2.283932e-07
I6778 n1_m1_326400_220800 0 1.407915e-07
I6779 n1_m1_326400_225600 0 2.144743e-07
I6780 n1_m1_326400_230400 0 1.420499e-07
I6781 n1_m1_326400_235200 0 1.450699e-07
I6782 n1_m1_326400_240000 0 2.266806e-07
I6783 n1_m1_326400_244800 0 1.575867e-07
I6784 n1_m1_326400_249600 0 2.406495e-07
I6785 n1_m1_326400_254400 0 1.568862e-07
I6786 n1_m1_326400_259200 0 1.501794e-07
I6787 n1_m1_326400_264000 0 2.216591e-07
I6788 n1_m1_326400_268800 0 1.434408e-07
I6789 n1_m1_326400_273600 0 2.237844e-07
I6790 n1_m1_326400_278400 0 1.615682e-07
I6791 n1_m1_326400_283200 0 4.055945e-07
I6792 n1_m1_326400_288000 0 6.732114e-07
I6793 n1_m1_326400_292800 0 4.976542e-07
I6794 n1_m1_326400_297600 0 5.183127e-07
I6795 n1_m1_326400_302400 0 1.835760e-07
I6796 n1_m1_326400_307200 0 1.486943e-07
I6797 n1_m1_326400_312000 0 2.104469e-07
I6798 n1_m1_326400_316800 0 1.502682e-07
I6799 n1_m1_326400_321600 0 2.596927e-07
I6800 n1_m1_326400_326400 0 1.708997e-07
I6801 n1_m1_326400_331200 0 1.636730e-07
I6802 n1_m1_326400_336000 0 2.285009e-07
I6803 n1_m1_326400_340800 0 1.448907e-07
I6804 n1_m1_326400_345600 0 2.131193e-07
I6805 n1_m1_326400_350400 0 1.453347e-07
I6806 n1_m1_326400_355200 0 1.400908e-07
I6807 n1_m1_326400_360000 0 2.070725e-07
I6808 n1_m1_326400_364800 0 1.425786e-07
I6809 n1_m1_326400_369600 0 2.106490e-07
I6810 n1_m1_326400_374400 0 1.440881e-07
I6811 n1_m1_326400_379200 0 1.598903e-07
I6812 n1_m1_326400_384000 0 3.091572e-07
I6813 n1_m1_326400_388800 0 5.124578e-07
I6814 n1_m1_326400_393600 0 1.043555e-06
I6815 n1_m1_326400_398400 0 7.034263e-07
I6816 n1_m1_326400_403200 0 6.872514e-07
I6817 n1_m1_326400_408000 0 9.958950e-07
I6818 n1_m1_326400_412800 0 6.118928e-07
I6819 n1_m1_326400_417600 0 4.551224e-07
I6820 n1_m1_326400_422400 0 1.484402e-07
I6821 n1_m1_326400_427200 0 1.468589e-07
I6822 n1_m1_326400_432000 0 2.154616e-07
I6823 n1_m1_326400_436800 0 1.415714e-07
I6824 n1_m1_326400_441600 0 2.150219e-07
I6825 n1_m1_326400_446400 0 1.404425e-07
I6826 n1_m1_326400_451200 0 1.389982e-07
I6827 n1_m1_326400_456000 0 2.390404e-07
I6828 n1_m1_326400_460800 0 1.911127e-07
I6829 n1_m1_326400_465600 0 2.536019e-07
I6830 n1_m1_326400_470400 0 7.633179e-08
I6831 n1_m1_331200_0 0 2.660024e-07
I6832 n1_m1_331200_4800 0 5.234076e-07
I6833 n1_m1_331200_9600 0 8.672791e-07
I6834 n1_m1_331200_14400 0 2.433801e-07
I6835 n1_m1_331200_19200 0 1.751826e-07
I6836 n1_m1_331200_24000 0 2.456547e-07
I6837 n1_m1_331200_28800 0 1.570109e-07
I6838 n1_m1_331200_33600 0 2.604303e-07
I6839 n1_m1_331200_38400 0 1.698078e-07
I6840 n1_m1_331200_43200 0 1.574190e-07
I6841 n1_m1_331200_48000 0 2.468515e-07
I6842 n1_m1_331200_52800 0 1.646947e-07
I6843 n1_m1_331200_57600 0 2.411394e-07
I6844 n1_m1_331200_62400 0 1.683368e-07
I6845 n1_m1_331200_67200 0 1.641445e-07
I6846 n1_m1_331200_72000 0 2.489728e-07
I6847 n1_m1_331200_76800 0 1.742747e-07
I6848 n1_m1_331200_81600 0 2.435071e-07
I6849 n1_m1_331200_86400 0 1.597678e-07
I6850 n1_m1_331200_91200 0 2.216079e-07
I6851 n1_m1_331200_96000 0 3.620449e-07
I6852 n1_m1_331200_100800 0 3.743930e-07
I6853 n1_m1_331200_105600 0 3.271725e-07
I6854 n1_m1_331200_110400 0 1.725444e-07
I6855 n1_m1_331200_115200 0 1.607675e-07
I6856 n1_m1_331200_120000 0 2.518840e-07
I6857 n1_m1_331200_124800 0 1.742407e-07
I6858 n1_m1_331200_129600 0 2.427851e-07
I6859 n1_m1_331200_134400 0 1.554286e-07
I6860 n1_m1_331200_139200 0 1.565439e-07
I6861 n1_m1_331200_144000 0 2.545285e-07
I6862 n1_m1_331200_148800 0 1.569389e-07
I6863 n1_m1_331200_153600 0 2.246122e-07
I6864 n1_m1_331200_158400 0 1.434374e-07
I6865 n1_m1_331200_163200 0 1.399274e-07
I6866 n1_m1_331200_168000 0 2.089060e-07
I6867 n1_m1_331200_172800 0 1.454508e-07
I6868 n1_m1_331200_177600 0 2.279085e-07
I6869 n1_m1_331200_182400 0 1.642323e-07
I6870 n1_m1_331200_187200 0 1.710370e-07
I6871 n1_m1_331200_192000 0 2.640833e-07
I6872 n1_m1_331200_196800 0 1.763024e-07
I6873 n1_m1_331200_201600 0 2.664031e-07
I6874 n1_m1_331200_206400 0 2.063986e-07
I6875 n1_m1_331200_211200 0 1.799325e-07
I6876 n1_m1_331200_216000 0 2.331936e-07
I6877 n1_m1_331200_220800 0 1.418800e-07
I6878 n1_m1_331200_225600 0 2.098560e-07
I6879 n1_m1_331200_230400 0 1.399040e-07
I6880 n1_m1_331200_235200 0 1.414566e-07
I6881 n1_m1_331200_240000 0 2.158406e-07
I6882 n1_m1_331200_244800 0 1.494737e-07
I6883 n1_m1_331200_249600 0 2.245069e-07
I6884 n1_m1_331200_254400 0 1.490220e-07
I6885 n1_m1_331200_259200 0 1.429527e-07
I6886 n1_m1_331200_264000 0 2.110344e-07
I6887 n1_m1_331200_268800 0 1.492010e-07
I6888 n1_m1_331200_273600 0 2.235134e-07
I6889 n1_m1_331200_278400 0 1.559123e-07
I6890 n1_m1_331200_283200 0 1.929151e-07
I6891 n1_m1_331200_288000 0 3.376235e-07
I6892 n1_m1_331200_292800 0 2.305664e-07
I6893 n1_m1_331200_297600 0 2.743054e-07
I6894 n1_m1_331200_302400 0 1.517284e-07
I6895 n1_m1_331200_307200 0 1.442240e-07
I6896 n1_m1_331200_312000 0 2.151913e-07
I6897 n1_m1_331200_316800 0 1.457917e-07
I6898 n1_m1_331200_321600 0 2.349709e-07
I6899 n1_m1_331200_326400 0 1.544870e-07
I6900 n1_m1_331200_331200 0 1.511186e-07
I6901 n1_m1_331200_336000 0 2.170544e-07
I6902 n1_m1_331200_340800 0 1.422066e-07
I6903 n1_m1_331200_345600 0 2.103359e-07
I6904 n1_m1_331200_350400 0 1.451663e-07
I6905 n1_m1_331200_355200 0 1.432585e-07
I6906 n1_m1_331200_360000 0 2.101122e-07
I6907 n1_m1_331200_364800 0 1.399040e-07
I6908 n1_m1_331200_369600 0 2.098560e-07
I6909 n1_m1_331200_374400 0 1.508775e-07
I6910 n1_m1_331200_379200 0 1.842530e-07
I6911 n1_m1_331200_384000 0 5.081569e-07
I6912 n1_m1_331200_388800 0 1.087169e-06
I6913 n1_m1_331200_393600 0 1.837896e-06
I6914 n1_m1_331200_398400 0 1.164395e-06
I6915 n1_m1_331200_403200 0 1.137383e-06
I6916 n1_m1_331200_408000 0 1.610209e-06
I6917 n1_m1_331200_412800 0 1.000035e-06
I6918 n1_m1_331200_417600 0 6.576093e-07
I6919 n1_m1_331200_422400 0 1.520669e-07
I6920 n1_m1_331200_427200 0 1.528200e-07
I6921 n1_m1_331200_432000 0 2.398493e-07
I6922 n1_m1_331200_436800 0 1.536315e-07
I6923 n1_m1_331200_441600 0 2.127612e-07
I6924 n1_m1_331200_446400 0 1.399604e-07
I6925 n1_m1_331200_451200 0 1.350486e-07
I6926 n1_m1_331200_456000 0 2.232294e-07
I6927 n1_m1_331200_460800 0 1.743080e-07
I6928 n1_m1_331200_465600 0 2.468427e-07
I6929 n1_m1_331200_470400 0 7.592486e-08
I6930 n1_m1_336000_0 0 3.276694e-07
I6931 n1_m1_336000_4800 0 5.258769e-07
I6932 n1_m1_336000_9600 0 1.269634e-06
I6933 n1_m1_336000_14400 0 5.859347e-07
I6934 n1_m1_336000_19200 0 2.899540e-07
I6935 n1_m1_336000_24000 0 3.465278e-07
I6936 n1_m1_336000_28800 0 2.263708e-07
I6937 n1_m1_336000_33600 0 3.777722e-07
I6938 n1_m1_336000_38400 0 2.443411e-07
I6939 n1_m1_336000_43200 0 2.175331e-07
I6940 n1_m1_336000_48000 0 3.596799e-07
I6941 n1_m1_336000_52800 0 2.409464e-07
I6942 n1_m1_336000_57600 0 3.309758e-07
I6943 n1_m1_336000_62400 0 2.423821e-07
I6944 n1_m1_336000_67200 0 2.313853e-07
I6945 n1_m1_336000_72000 0 3.587910e-07
I6946 n1_m1_336000_76800 0 2.459293e-07
I6947 n1_m1_336000_81600 0 3.778142e-07
I6948 n1_m1_336000_86400 0 3.134354e-07
I6949 n1_m1_336000_91200 0 3.241649e-07
I6950 n1_m1_336000_96000 0 4.632188e-07
I6951 n1_m1_336000_100800 0 4.878514e-07
I6952 n1_m1_336000_105600 0 5.594114e-07
I6953 n1_m1_336000_110400 0 2.673226e-07
I6954 n1_m1_336000_115200 0 2.525471e-07
I6955 n1_m1_336000_120000 0 3.688380e-07
I6956 n1_m1_336000_124800 0 2.637403e-07
I6957 n1_m1_336000_129600 0 4.667272e-07
I6958 n1_m1_336000_134400 0 2.721193e-07
I6959 n1_m1_336000_139200 0 2.948206e-07
I6960 n1_m1_336000_144000 0 5.267198e-07
I6961 n1_m1_336000_148800 0 2.551183e-07
I6962 n1_m1_336000_153600 0 3.454445e-07
I6963 n1_m1_336000_158400 0 2.130852e-07
I6964 n1_m1_336000_163200 0 2.097573e-07
I6965 n1_m1_336000_168000 0 3.127708e-07
I6966 n1_m1_336000_172800 0 2.116000e-07
I6967 n1_m1_336000_177600 0 3.307978e-07
I6968 n1_m1_336000_182400 0 2.391730e-07
I6969 n1_m1_336000_187200 0 2.506768e-07
I6970 n1_m1_336000_192000 0 3.861153e-07
I6971 n1_m1_336000_196800 0 2.685283e-07
I6972 n1_m1_336000_201600 0 3.966435e-07
I6973 n1_m1_336000_206400 0 2.640037e-07
I6974 n1_m1_336000_211200 0 2.520850e-07
I6975 n1_m1_336000_216000 0 3.512014e-07
I6976 n1_m1_336000_220800 0 2.146035e-07
I6977 n1_m1_336000_225600 0 3.078683e-07
I6978 n1_m1_336000_230400 0 2.104538e-07
I6979 n1_m1_336000_235200 0 2.075694e-07
I6980 n1_m1_336000_240000 0 3.130798e-07
I6981 n1_m1_336000_244800 0 2.151705e-07
I6982 n1_m1_336000_249600 0 3.294424e-07
I6983 n1_m1_336000_254400 0 2.144930e-07
I6984 n1_m1_336000_259200 0 2.091828e-07
I6985 n1_m1_336000_264000 0 3.045450e-07
I6986 n1_m1_336000_268800 0 2.180908e-07
I6987 n1_m1_336000_273600 0 3.401353e-07
I6988 n1_m1_336000_278400 0 2.315138e-07
I6989 n1_m1_336000_283200 0 3.784963e-07
I6990 n1_m1_336000_288000 0 8.776496e-07
I6991 n1_m1_336000_292800 0 5.634351e-07
I6992 n1_m1_336000_297600 0 4.019006e-07
I6993 n1_m1_336000_302400 0 2.304817e-07
I6994 n1_m1_336000_307200 0 2.243856e-07
I6995 n1_m1_336000_312000 0 3.306661e-07
I6996 n1_m1_336000_316800 0 2.126105e-07
I6997 n1_m1_336000_321600 0 3.306159e-07
I6998 n1_m1_336000_326400 0 2.212888e-07
I6999 n1_m1_336000_331200 0 2.205201e-07
I7000 n1_m1_336000_336000 0 3.198943e-07
I7001 n1_m1_336000_340800 0 2.098743e-07
I7002 n1_m1_336000_345600 0 3.154001e-07
I7003 n1_m1_336000_350400 0 2.163805e-07
I7004 n1_m1_336000_355200 0 2.126862e-07
I7005 n1_m1_336000_360000 0 3.149670e-07
I7006 n1_m1_336000_364800 0 2.108869e-07
I7007 n1_m1_336000_369600 0 3.132466e-07
I7008 n1_m1_336000_374400 0 2.257055e-07
I7009 n1_m1_336000_379200 0 2.863748e-07
I7010 n1_m1_336000_384000 0 8.576030e-07
I7011 n1_m1_336000_388800 0 1.597136e-06
I7012 n1_m1_336000_393600 0 1.854065e-06
I7013 n1_m1_336000_398400 0 1.341564e-06
I7014 n1_m1_336000_403200 0 1.211505e-06
I7015 n1_m1_336000_408000 0 1.289616e-06
I7016 n1_m1_336000_412800 0 5.547532e-07
I7017 n1_m1_336000_417600 0 5.003913e-07
I7018 n1_m1_336000_422400 0 2.504300e-07
I7019 n1_m1_336000_427200 0 2.489379e-07
I7020 n1_m1_336000_432000 0 3.549162e-07
I7021 n1_m1_336000_436800 0 2.252892e-07
I7022 n1_m1_336000_441600 0 3.138108e-07
I7023 n1_m1_336000_446400 0 2.156872e-07
I7024 n1_m1_336000_451200 0 2.126241e-07
I7025 n1_m1_336000_456000 0 3.437895e-07
I7026 n1_m1_336000_460800 0 2.569211e-07
I7027 n1_m1_336000_465600 0 3.661323e-07
I7028 n1_m1_336000_470400 0 1.135191e-07
I7029 n1_m1_340800_0 0 1.088853e-07
I7030 n1_m1_340800_4800 0 1.986328e-07
I7031 n1_m1_340800_9600 0 4.271945e-07
I7032 n1_m1_340800_14400 0 1.600257e-07
I7033 n1_m1_340800_19200 0 8.685913e-08
I7034 n1_m1_340800_24000 0 1.126567e-07
I7035 n1_m1_340800_28800 0 7.496387e-08
I7036 n1_m1_340800_33600 0 1.102683e-07
I7037 n1_m1_340800_38400 0 7.380767e-08
I7038 n1_m1_340800_43200 0 7.500502e-08
I7039 n1_m1_340800_48000 0 1.090052e-07
I7040 n1_m1_340800_52800 0 7.263364e-08
I7041 n1_m1_340800_57600 0 1.132324e-07
I7042 n1_m1_340800_62400 0 1.065803e-07
I7043 n1_m1_340800_67200 0 1.454163e-07
I7044 n1_m1_340800_72000 0 3.138970e-07
I7045 n1_m1_340800_76800 0 1.591752e-07
I7046 n1_m1_340800_81600 0 1.428993e-07
I7047 n1_m1_340800_86400 0 1.166230e-07
I7048 n1_m1_340800_91200 0 1.950007e-07
I7049 n1_m1_340800_96000 0 4.117368e-07
I7050 n1_m1_340800_100800 0 3.874162e-07
I7051 n1_m1_340800_105600 0 3.577435e-07
I7052 n1_m1_340800_110400 0 1.906325e-07
I7053 n1_m1_340800_115200 0 1.119584e-07
I7054 n1_m1_340800_120000 0 1.479525e-07
I7055 n1_m1_340800_124800 0 1.024584e-07
I7056 n1_m1_340800_129600 0 2.594944e-07
I7057 n1_m1_340800_134400 0 1.117030e-07
I7058 n1_m1_340800_139200 0 9.840632e-08
I7059 n1_m1_340800_144000 0 1.421396e-07
I7060 n1_m1_340800_148800 0 1.109703e-07
I7061 n1_m1_340800_153600 0 1.273429e-07
I7062 n1_m1_340800_158400 0 7.570034e-08
I7063 n1_m1_340800_163200 0 7.216798e-08
I7064 n1_m1_340800_168000 0 1.064748e-07
I7065 n1_m1_340800_172800 0 6.995199e-08
I7066 n1_m1_340800_177600 0 1.153165e-07
I7067 n1_m1_340800_182400 0 8.498978e-08
I7068 n1_m1_340800_187200 0 1.021857e-07
I7069 n1_m1_340800_192000 0 1.490118e-07
I7070 n1_m1_340800_196800 0 1.044773e-07
I7071 n1_m1_340800_201600 0 1.302028e-07
I7072 n1_m1_340800_206400 0 8.842884e-08
I7073 n1_m1_340800_211200 0 8.460462e-08
I7074 n1_m1_340800_216000 0 1.139620e-07
I7075 n1_m1_340800_220800 0 6.921803e-08
I7076 n1_m1_340800_225600 0 1.030189e-07
I7077 n1_m1_340800_230400 0 7.133522e-08
I7078 n1_m1_340800_235200 0 7.247850e-08
I7079 n1_m1_340800_240000 0 1.078314e-07
I7080 n1_m1_340800_244800 0 7.323531e-08
I7081 n1_m1_340800_249600 0 1.099246e-07
I7082 n1_m1_340800_254400 0 7.312622e-08
I7083 n1_m1_340800_259200 0 7.188533e-08
I7084 n1_m1_340800_264000 0 1.106509e-07
I7085 n1_m1_340800_268800 0 7.181512e-08
I7086 n1_m1_340800_273600 0 1.094637e-07
I7087 n1_m1_340800_278400 0 8.267044e-08
I7088 n1_m1_340800_283200 0 3.508477e-07
I7089 n1_m1_340800_288000 0 4.470830e-07
I7090 n1_m1_340800_292800 0 1.339261e-07
I7091 n1_m1_340800_297600 0 1.446185e-07
I7092 n1_m1_340800_302400 0 7.341007e-08
I7093 n1_m1_340800_307200 0 6.840070e-08
I7094 n1_m1_340800_312000 0 1.000610e-07
I7095 n1_m1_340800_316800 0 6.791877e-08
I7096 n1_m1_340800_321600 0 1.131665e-07
I7097 n1_m1_340800_326400 0 7.661408e-08
I7098 n1_m1_340800_331200 0 7.483564e-08
I7099 n1_m1_340800_336000 0 1.095768e-07
I7100 n1_m1_340800_340800 0 7.169442e-08
I7101 n1_m1_340800_345600 0 1.075110e-07
I7102 n1_m1_340800_350400 0 7.147696e-08
I7103 n1_m1_340800_355200 0 7.014899e-08
I7104 n1_m1_340800_360000 0 1.049280e-07
I7105 n1_m1_340800_364800 0 7.238114e-08
I7106 n1_m1_340800_369600 0 1.044794e-07
I7107 n1_m1_340800_374400 0 6.892354e-08
I7108 n1_m1_340800_379200 0 7.605500e-08
I7109 n1_m1_340800_384000 0 1.710664e-07
I7110 n1_m1_340800_388800 0 2.744726e-07
I7111 n1_m1_340800_393600 0 4.186448e-07
I7112 n1_m1_340800_398400 0 3.976934e-07
I7113 n1_m1_340800_403200 0 2.740979e-07
I7114 n1_m1_340800_408000 0 2.155200e-07
I7115 n1_m1_340800_412800 0 8.546155e-08
I7116 n1_m1_340800_417600 0 1.131860e-07
I7117 n1_m1_340800_422400 0 7.477918e-08
I7118 n1_m1_340800_427200 0 7.203832e-08
I7119 n1_m1_340800_432000 0 1.057043e-07
I7120 n1_m1_340800_436800 0 7.276989e-08
I7121 n1_m1_340800_441600 0 1.063286e-07
I7122 n1_m1_340800_446400 0 7.496219e-08
I7123 n1_m1_340800_451200 0 8.014429e-08
I7124 n1_m1_340800_456000 0 1.295862e-07
I7125 n1_m1_340800_460800 0 9.229445e-08
I7126 n1_m1_340800_465600 0 1.264197e-07
I7127 n1_m1_340800_470400 0 3.882988e-08
I7128 n1_m1_345600_0 0 3.708883e-07
I7129 n1_m1_345600_4800 0 7.438930e-07
I7130 n1_m1_345600_9600 0 1.126727e-06
I7131 n1_m1_345600_14400 0 2.985399e-07
I7132 n1_m1_345600_19200 0 2.370378e-07
I7133 n1_m1_345600_24000 0 3.447469e-07
I7134 n1_m1_345600_28800 0 2.203627e-07
I7135 n1_m1_345600_33600 0 3.198631e-07
I7136 n1_m1_345600_38400 0 2.172599e-07
I7137 n1_m1_345600_43200 0 2.293623e-07
I7138 n1_m1_345600_48000 0 3.304006e-07
I7139 n1_m1_345600_52800 0 2.223434e-07
I7140 n1_m1_345600_57600 0 4.655876e-07
I7141 n1_m1_345600_62400 0 7.217475e-07
I7142 n1_m1_345600_67200 0 7.426932e-07
I7143 n1_m1_345600_72000 0 1.188483e-06
I7144 n1_m1_345600_76800 0 7.336875e-07
I7145 n1_m1_345600_81600 0 7.332266e-07
I7146 n1_m1_345600_86400 0 5.859483e-07
I7147 n1_m1_345600_91200 0 1.005982e-06
I7148 n1_m1_345600_96000 0 2.019087e-06
I7149 n1_m1_345600_100800 0 1.670591e-06
I7150 n1_m1_345600_105600 0 1.414829e-06
I7151 n1_m1_345600_110400 0 7.772234e-07
I7152 n1_m1_345600_115200 0 3.921449e-07
I7153 n1_m1_345600_120000 0 6.191585e-07
I7154 n1_m1_345600_124800 0 2.961311e-07
I7155 n1_m1_345600_129600 0 7.566450e-07
I7156 n1_m1_345600_134400 0 3.051374e-07
I7157 n1_m1_345600_139200 0 2.876466e-07
I7158 n1_m1_345600_144000 0 4.366695e-07
I7159 n1_m1_345600_148800 0 4.834634e-07
I7160 n1_m1_345600_153600 0 4.656348e-07
I7161 n1_m1_345600_158400 0 2.389530e-07
I7162 n1_m1_345600_163200 0 2.273440e-07
I7163 n1_m1_345600_168000 0 3.324913e-07
I7164 n1_m1_345600_172800 0 2.115909e-07
I7165 n1_m1_345600_177600 0 3.379118e-07
I7166 n1_m1_345600_182400 0 2.627613e-07
I7167 n1_m1_345600_187200 0 4.572187e-07
I7168 n1_m1_345600_192000 0 7.408399e-07
I7169 n1_m1_345600_196800 0 6.071465e-07
I7170 n1_m1_345600_201600 0 6.803719e-07
I7171 n1_m1_345600_206400 0 4.518303e-07
I7172 n1_m1_345600_211200 0 3.317166e-07
I7173 n1_m1_345600_216000 0 3.543987e-07
I7174 n1_m1_345600_220800 0 2.029692e-07
I7175 n1_m1_345600_225600 0 3.072360e-07
I7176 n1_m1_345600_230400 0 2.115088e-07
I7177 n1_m1_345600_235200 0 2.168427e-07
I7178 n1_m1_345600_240000 0 3.292531e-07
I7179 n1_m1_345600_244800 0 2.181488e-07
I7180 n1_m1_345600_249600 0 3.217526e-07
I7181 n1_m1_345600_254400 0 2.184914e-07
I7182 n1_m1_345600_259200 0 2.194363e-07
I7183 n1_m1_345600_264000 0 3.261425e-07
I7184 n1_m1_345600_268800 0 2.147116e-07
I7185 n1_m1_345600_273600 0 3.618417e-07
I7186 n1_m1_345600_278400 0 2.557232e-07
I7187 n1_m1_345600_283200 0 6.717158e-07
I7188 n1_m1_345600_288000 0 7.433270e-07
I7189 n1_m1_345600_292800 0 2.657577e-07
I7190 n1_m1_345600_297600 0 3.843627e-07
I7191 n1_m1_345600_302400 0 2.134666e-07
I7192 n1_m1_345600_307200 0 2.023323e-07
I7193 n1_m1_345600_312000 0 3.113522e-07
I7194 n1_m1_345600_316800 0 2.175240e-07
I7195 n1_m1_345600_321600 0 3.533612e-07
I7196 n1_m1_345600_326400 0 2.243093e-07
I7197 n1_m1_345600_331200 0 2.216718e-07
I7198 n1_m1_345600_336000 0 3.295906e-07
I7199 n1_m1_345600_340800 0 2.199731e-07
I7200 n1_m1_345600_345600 0 3.308921e-07
I7201 n1_m1_345600_350400 0 2.238512e-07
I7202 n1_m1_345600_355200 0 2.152019e-07
I7203 n1_m1_345600_360000 0 3.073162e-07
I7204 n1_m1_345600_364800 0 2.114538e-07
I7205 n1_m1_345600_369600 0 3.231454e-07
I7206 n1_m1_345600_374400 0 2.077309e-07
I7207 n1_m1_345600_379200 0 2.123129e-07
I7208 n1_m1_345600_384000 0 3.605448e-07
I7209 n1_m1_345600_388800 0 3.461223e-07
I7210 n1_m1_345600_393600 0 5.249374e-07
I7211 n1_m1_345600_398400 0 4.387550e-07
I7212 n1_m1_345600_403200 0 2.729640e-07
I7213 n1_m1_345600_408000 0 3.763354e-07
I7214 n1_m1_345600_412800 0 2.338367e-07
I7215 n1_m1_345600_417600 0 3.132743e-07
I7216 n1_m1_345600_422400 0 2.099328e-07
I7217 n1_m1_345600_427200 0 2.117674e-07
I7218 n1_m1_345600_432000 0 3.262385e-07
I7219 n1_m1_345600_436800 0 2.143939e-07
I7220 n1_m1_345600_441600 0 3.156707e-07
I7221 n1_m1_345600_446400 0 2.345461e-07
I7222 n1_m1_345600_451200 0 2.500727e-07
I7223 n1_m1_345600_456000 0 3.986550e-07
I7224 n1_m1_345600_460800 0 2.774131e-07
I7225 n1_m1_345600_465600 0 3.834657e-07
I7226 n1_m1_345600_470400 0 1.204844e-07
I7227 n1_m1_350400_0 0 2.454468e-07
I7228 n1_m1_350400_4800 0 4.359546e-07
I7229 n1_m1_350400_9600 0 6.535631e-07
I7230 n1_m1_350400_14400 0 2.005726e-07
I7231 n1_m1_350400_19200 0 1.558111e-07
I7232 n1_m1_350400_24000 0 2.207101e-07
I7233 n1_m1_350400_28800 0 1.421633e-07
I7234 n1_m1_350400_33600 0 2.315421e-07
I7235 n1_m1_350400_38400 0 1.506753e-07
I7236 n1_m1_350400_43200 0 1.480433e-07
I7237 n1_m1_350400_48000 0 2.264716e-07
I7238 n1_m1_350400_52800 0 1.594517e-07
I7239 n1_m1_350400_57600 0 2.812522e-07
I7240 n1_m1_350400_62400 0 5.366144e-07
I7241 n1_m1_350400_67200 0 4.213641e-07
I7242 n1_m1_350400_72000 0 4.319345e-07
I7243 n1_m1_350400_76800 0 4.515751e-07
I7244 n1_m1_350400_81600 0 5.510434e-07
I7245 n1_m1_350400_86400 0 4.269128e-07
I7246 n1_m1_350400_91200 0 6.852467e-07
I7247 n1_m1_350400_96000 0 1.157342e-06
I7248 n1_m1_350400_100800 0 8.803931e-07
I7249 n1_m1_350400_105600 0 1.039745e-06
I7250 n1_m1_350400_110400 0 5.185123e-07
I7251 n1_m1_350400_115200 0 2.560203e-07
I7252 n1_m1_350400_120000 0 4.637064e-07
I7253 n1_m1_350400_124800 0 1.703829e-07
I7254 n1_m1_350400_129600 0 3.818514e-07
I7255 n1_m1_350400_134400 0 2.037053e-07
I7256 n1_m1_350400_139200 0 2.861071e-07
I7257 n1_m1_350400_144000 0 3.924192e-07
I7258 n1_m1_350400_148800 0 3.986989e-07
I7259 n1_m1_350400_153600 0 3.715341e-07
I7260 n1_m1_350400_158400 0 1.674691e-07
I7261 n1_m1_350400_163200 0 1.583288e-07
I7262 n1_m1_350400_168000 0 2.279895e-07
I7263 n1_m1_350400_172800 0 1.409918e-07
I7264 n1_m1_350400_177600 0 2.234794e-07
I7265 n1_m1_350400_182400 0 1.802440e-07
I7266 n1_m1_350400_187200 0 3.814939e-07
I7267 n1_m1_350400_192000 0 7.009621e-07
I7268 n1_m1_350400_196800 0 5.876303e-07
I7269 n1_m1_350400_201600 0 6.786104e-07
I7270 n1_m1_350400_206400 0 4.927032e-07
I7271 n1_m1_350400_211200 0 3.324707e-07
I7272 n1_m1_350400_216000 0 2.568812e-07
I7273 n1_m1_350400_220800 0 1.374203e-07
I7274 n1_m1_350400_225600 0 2.029561e-07
I7275 n1_m1_350400_230400 0 1.378877e-07
I7276 n1_m1_350400_235200 0 1.400451e-07
I7277 n1_m1_350400_240000 0 2.122956e-07
I7278 n1_m1_350400_244800 0 1.401181e-07
I7279 n1_m1_350400_249600 0 2.099135e-07
I7280 n1_m1_350400_254400 0 1.407670e-07
I7281 n1_m1_350400_259200 0 1.417340e-07
I7282 n1_m1_350400_264000 0 2.180215e-07
I7283 n1_m1_350400_268800 0 1.441314e-07
I7284 n1_m1_350400_273600 0 2.187489e-07
I7285 n1_m1_350400_278400 0 1.619524e-07
I7286 n1_m1_350400_283200 0 1.674011e-07
I7287 n1_m1_350400_288000 0 2.529254e-07
I7288 n1_m1_350400_292800 0 1.675526e-07
I7289 n1_m1_350400_297600 0 2.234368e-07
I7290 n1_m1_350400_302400 0 1.415822e-07
I7291 n1_m1_350400_307200 0 1.406056e-07
I7292 n1_m1_350400_312000 0 2.152334e-07
I7293 n1_m1_350400_316800 0 1.427060e-07
I7294 n1_m1_350400_321600 0 2.211535e-07
I7295 n1_m1_350400_326400 0 1.465661e-07
I7296 n1_m1_350400_331200 0 1.439738e-07
I7297 n1_m1_350400_336000 0 2.195380e-07
I7298 n1_m1_350400_340800 0 1.543061e-07
I7299 n1_m1_350400_345600 0 2.436084e-07
I7300 n1_m1_350400_350400 0 1.574202e-07
I7301 n1_m1_350400_355200 0 1.490719e-07
I7302 n1_m1_350400_360000 0 2.016956e-07
I7303 n1_m1_350400_364800 0 1.341628e-07
I7304 n1_m1_350400_369600 0 2.158185e-07
I7305 n1_m1_350400_374400 0 1.424963e-07
I7306 n1_m1_350400_379200 0 1.399040e-07
I7307 n1_m1_350400_384000 0 2.189373e-07
I7308 n1_m1_350400_388800 0 1.451525e-07
I7309 n1_m1_350400_393600 0 2.301306e-07
I7310 n1_m1_350400_398400 0 1.567104e-07
I7311 n1_m1_350400_403200 0 1.459697e-07
I7312 n1_m1_350400_408000 0 2.261314e-07
I7313 n1_m1_350400_412800 0 1.477426e-07
I7314 n1_m1_350400_417600 0 2.121527e-07
I7315 n1_m1_350400_422400 0 1.419846e-07
I7316 n1_m1_350400_427200 0 1.371657e-07
I7317 n1_m1_350400_432000 0 2.113775e-07
I7318 n1_m1_350400_436800 0 1.446240e-07
I7319 n1_m1_350400_441600 0 2.209091e-07
I7320 n1_m1_350400_446400 0 1.588319e-07
I7321 n1_m1_350400_451200 0 1.642114e-07
I7322 n1_m1_350400_456000 0 2.553326e-07
I7323 n1_m1_350400_460800 0 1.813280e-07
I7324 n1_m1_350400_465600 0 2.574222e-07
I7325 n1_m1_350400_470400 0 8.185060e-08
I7326 n1_m1_355200_0 0 2.251337e-07
I7327 n1_m1_355200_4800 0 3.251459e-07
I7328 n1_m1_355200_9600 0 4.201526e-07
I7329 n1_m1_355200_14400 0 1.849513e-07
I7330 n1_m1_355200_19200 0 1.539883e-07
I7331 n1_m1_355200_24000 0 2.245694e-07
I7332 n1_m1_355200_28800 0 1.521564e-07
I7333 n1_m1_355200_33600 0 2.931315e-07
I7334 n1_m1_355200_38400 0 1.574948e-07
I7335 n1_m1_355200_43200 0 1.499160e-07
I7336 n1_m1_355200_48000 0 2.224403e-07
I7337 n1_m1_355200_52800 0 1.605193e-07
I7338 n1_m1_355200_57600 0 2.399910e-07
I7339 n1_m1_355200_62400 0 2.131188e-07
I7340 n1_m1_355200_67200 0 1.996895e-07
I7341 n1_m1_355200_72000 0 2.812588e-07
I7342 n1_m1_355200_76800 0 2.148590e-07
I7343 n1_m1_355200_81600 0 3.055752e-07
I7344 n1_m1_355200_86400 0 2.106347e-07
I7345 n1_m1_355200_91200 0 3.095974e-07
I7346 n1_m1_355200_96000 0 8.905985e-07
I7347 n1_m1_355200_100800 0 8.566242e-07
I7348 n1_m1_355200_105600 0 1.169935e-06
I7349 n1_m1_355200_110400 0 4.718308e-07
I7350 n1_m1_355200_115200 0 2.532049e-07
I7351 n1_m1_355200_120000 0 2.917256e-07
I7352 n1_m1_355200_124800 0 1.613321e-07
I7353 n1_m1_355200_129600 0 2.520110e-07
I7354 n1_m1_355200_134400 0 1.694193e-07
I7355 n1_m1_355200_139200 0 1.853092e-07
I7356 n1_m1_355200_144000 0 2.720114e-07
I7357 n1_m1_355200_148800 0 1.985271e-07
I7358 n1_m1_355200_153600 0 2.609825e-07
I7359 n1_m1_355200_158400 0 1.580377e-07
I7360 n1_m1_355200_163200 0 1.478742e-07
I7361 n1_m1_355200_168000 0 2.085054e-07
I7362 n1_m1_355200_172800 0 1.342431e-07
I7363 n1_m1_355200_177600 0 2.176457e-07
I7364 n1_m1_355200_182400 0 1.612804e-07
I7365 n1_m1_355200_187200 0 2.061335e-07
I7366 n1_m1_355200_192000 0 3.838363e-07
I7367 n1_m1_355200_196800 0 2.854434e-07
I7368 n1_m1_355200_201600 0 4.944708e-07
I7369 n1_m1_355200_206400 0 3.327292e-07
I7370 n1_m1_355200_211200 0 2.457110e-07
I7371 n1_m1_355200_216000 0 2.469434e-07
I7372 n1_m1_355200_220800 0 1.410341e-07
I7373 n1_m1_355200_225600 0 2.089646e-07
I7374 n1_m1_355200_230400 0 1.400212e-07
I7375 n1_m1_355200_235200 0 1.379985e-07
I7376 n1_m1_355200_240000 0 2.026813e-07
I7377 n1_m1_355200_244800 0 1.354600e-07
I7378 n1_m1_355200_249600 0 2.098560e-07
I7379 n1_m1_355200_254400 0 1.399040e-07
I7380 n1_m1_355200_259200 0 1.406895e-07
I7381 n1_m1_355200_264000 0 2.171186e-07
I7382 n1_m1_355200_268800 0 1.559255e-07
I7383 n1_m1_355200_273600 0 2.288508e-07
I7384 n1_m1_355200_278400 0 1.697745e-07
I7385 n1_m1_355200_283200 0 1.631689e-07
I7386 n1_m1_355200_288000 0 2.849097e-07
I7387 n1_m1_355200_292800 0 1.649691e-07
I7388 n1_m1_355200_297600 0 2.266367e-07
I7389 n1_m1_355200_302400 0 1.502069e-07
I7390 n1_m1_355200_307200 0 1.448773e-07
I7391 n1_m1_355200_312000 0 2.171682e-07
I7392 n1_m1_355200_316800 0 1.468083e-07
I7393 n1_m1_355200_321600 0 2.162061e-07
I7394 n1_m1_355200_326400 0 1.484426e-07
I7395 n1_m1_355200_331200 0 1.508947e-07
I7396 n1_m1_355200_336000 0 2.388654e-07
I7397 n1_m1_355200_340800 0 2.006622e-07
I7398 n1_m1_355200_345600 0 3.510178e-07
I7399 n1_m1_355200_350400 0 1.600023e-07
I7400 n1_m1_355200_355200 0 1.434543e-07
I7401 n1_m1_355200_360000 0 2.041352e-07
I7402 n1_m1_355200_364800 0 1.333230e-07
I7403 n1_m1_355200_369600 0 2.080538e-07
I7404 n1_m1_355200_374400 0 1.392664e-07
I7405 n1_m1_355200_379200 0 1.388595e-07
I7406 n1_m1_355200_384000 0 2.108641e-07
I7407 n1_m1_355200_388800 0 1.405208e-07
I7408 n1_m1_355200_393600 0 2.130018e-07
I7409 n1_m1_355200_398400 0 1.427280e-07
I7410 n1_m1_355200_403200 0 1.413959e-07
I7411 n1_m1_355200_408000 0 2.116373e-07
I7412 n1_m1_355200_412800 0 1.410150e-07
I7413 n1_m1_355200_417600 0 2.081261e-07
I7414 n1_m1_355200_422400 0 1.372480e-07
I7415 n1_m1_355200_427200 0 1.361213e-07
I7416 n1_m1_355200_432000 0 2.088504e-07
I7417 n1_m1_355200_436800 0 1.456005e-07
I7418 n1_m1_355200_441600 0 2.233855e-07
I7419 n1_m1_355200_446400 0 1.512571e-07
I7420 n1_m1_355200_451200 0 1.500756e-07
I7421 n1_m1_355200_456000 0 2.468234e-07
I7422 n1_m1_355200_460800 0 1.928776e-07
I7423 n1_m1_355200_465600 0 2.660076e-07
I7424 n1_m1_355200_470400 0 8.389722e-08
I7425 n1_m1_360000_0 0 3.634143e-07
I7426 n1_m1_360000_4800 0 6.145955e-07
I7427 n1_m1_360000_9600 0 8.205182e-07
I7428 n1_m1_360000_14400 0 3.115474e-07
I7429 n1_m1_360000_19200 0 2.500176e-07
I7430 n1_m1_360000_24000 0 3.471389e-07
I7431 n1_m1_360000_28800 0 2.359725e-07
I7432 n1_m1_360000_33600 0 5.644460e-07
I7433 n1_m1_360000_38400 0 2.544019e-07
I7434 n1_m1_360000_43200 0 2.325159e-07
I7435 n1_m1_360000_48000 0 3.241617e-07
I7436 n1_m1_360000_52800 0 2.198993e-07
I7437 n1_m1_360000_57600 0 3.313509e-07
I7438 n1_m1_360000_62400 0 2.261669e-07
I7439 n1_m1_360000_67200 0 2.263021e-07
I7440 n1_m1_360000_72000 0 3.350237e-07
I7441 n1_m1_360000_76800 0 2.233213e-07
I7442 n1_m1_360000_81600 0 3.349819e-07
I7443 n1_m1_360000_86400 0 2.233213e-07
I7444 n1_m1_360000_91200 0 2.383842e-07
I7445 n1_m1_360000_96000 0 4.985163e-07
I7446 n1_m1_360000_100800 0 4.622603e-07
I7447 n1_m1_360000_105600 0 6.540647e-07
I7448 n1_m1_360000_110400 0 3.065139e-07
I7449 n1_m1_360000_115200 0 2.552989e-07
I7450 n1_m1_360000_120000 0 3.454663e-07
I7451 n1_m1_360000_124800 0 2.102969e-07
I7452 n1_m1_360000_129600 0 3.056208e-07
I7453 n1_m1_360000_134400 0 2.074983e-07
I7454 n1_m1_360000_139200 0 2.077952e-07
I7455 n1_m1_360000_144000 0 3.134262e-07
I7456 n1_m1_360000_148800 0 2.167573e-07
I7457 n1_m1_360000_153600 0 3.213512e-07
I7458 n1_m1_360000_158400 0 2.109508e-07
I7459 n1_m1_360000_163200 0 2.059996e-07
I7460 n1_m1_360000_168000 0 3.008114e-07
I7461 n1_m1_360000_172800 0 2.029245e-07
I7462 n1_m1_360000_177600 0 3.197263e-07
I7463 n1_m1_360000_182400 0 2.216512e-07
I7464 n1_m1_360000_187200 0 2.390136e-07
I7465 n1_m1_360000_192000 0 3.687842e-07
I7466 n1_m1_360000_196800 0 2.402967e-07
I7467 n1_m1_360000_201600 0 3.879529e-07
I7468 n1_m1_360000_206400 0 2.685199e-07
I7469 n1_m1_360000_211200 0 2.472432e-07
I7470 n1_m1_360000_216000 0 3.319210e-07
I7471 n1_m1_360000_220800 0 2.099983e-07
I7472 n1_m1_360000_225600 0 3.147839e-07
I7473 n1_m1_360000_230400 0 2.138064e-07
I7474 n1_m1_360000_235200 0 2.143726e-07
I7475 n1_m1_360000_240000 0 3.130578e-07
I7476 n1_m1_360000_244800 0 2.058093e-07
I7477 n1_m1_360000_249600 0 3.147839e-07
I7478 n1_m1_360000_254400 0 2.098560e-07
I7479 n1_m1_360000_259200 0 2.099231e-07
I7480 n1_m1_360000_264000 0 3.122494e-07
I7481 n1_m1_360000_268800 0 2.135997e-07
I7482 n1_m1_360000_273600 0 5.623517e-07
I7483 n1_m1_360000_278400 0 6.857467e-07
I7484 n1_m1_360000_283200 0 5.368555e-07
I7485 n1_m1_360000_288000 0 8.299388e-07
I7486 n1_m1_360000_292800 0 2.885860e-07
I7487 n1_m1_360000_297600 0 3.691365e-07
I7488 n1_m1_360000_302400 0 2.183289e-07
I7489 n1_m1_360000_307200 0 2.109446e-07
I7490 n1_m1_360000_312000 0 3.125384e-07
I7491 n1_m1_360000_316800 0 2.130913e-07
I7492 n1_m1_360000_321600 0 3.508169e-07
I7493 n1_m1_360000_326400 0 2.954905e-07
I7494 n1_m1_360000_331200 0 3.592916e-07
I7495 n1_m1_360000_336000 0 5.920649e-07
I7496 n1_m1_360000_340800 0 3.552441e-07
I7497 n1_m1_360000_345600 0 5.745029e-07
I7498 n1_m1_360000_350400 0 2.301782e-07
I7499 n1_m1_360000_355200 0 2.102506e-07
I7500 n1_m1_360000_360000 0 3.008781e-07
I7501 n1_m1_360000_364800 0 1.998689e-07
I7502 n1_m1_360000_369600 0 3.004104e-07
I7503 n1_m1_360000_374400 0 2.024216e-07
I7504 n1_m1_360000_379200 0 2.048029e-07
I7505 n1_m1_360000_384000 0 3.129426e-07
I7506 n1_m1_360000_388800 0 2.110466e-07
I7507 n1_m1_360000_393600 0 3.257565e-07
I7508 n1_m1_360000_398400 0 2.193692e-07
I7509 n1_m1_360000_403200 0 2.177971e-07
I7510 n1_m1_360000_408000 0 3.153886e-07
I7511 n1_m1_360000_412800 0 2.098560e-07
I7512 n1_m1_360000_417600 0 3.108036e-07
I7513 n1_m1_360000_422400 0 2.046900e-07
I7514 n1_m1_360000_427200 0 2.041819e-07
I7515 n1_m1_360000_432000 0 3.114236e-07
I7516 n1_m1_360000_436800 0 2.129963e-07
I7517 n1_m1_360000_441600 0 3.185066e-07
I7518 n1_m1_360000_446400 0 2.101290e-07
I7519 n1_m1_360000_451200 0 2.122021e-07
I7520 n1_m1_360000_456000 0 3.513861e-07
I7521 n1_m1_360000_460800 0 2.699031e-07
I7522 n1_m1_360000_465600 0 3.835840e-07
I7523 n1_m1_360000_470400 0 1.207244e-07
I7524 n1_m1_364800_0 0 2.656536e-07
I7525 n1_m1_364800_4800 0 4.664770e-07
I7526 n1_m1_364800_9600 0 4.804047e-07
I7527 n1_m1_364800_14400 0 1.576802e-07
I7528 n1_m1_364800_19200 0 1.548787e-07
I7529 n1_m1_364800_24000 0 2.439823e-07
I7530 n1_m1_364800_28800 0 1.671117e-07
I7531 n1_m1_364800_33600 0 4.711805e-07
I7532 n1_m1_364800_38400 0 2.165932e-07
I7533 n1_m1_364800_43200 0 1.735154e-07
I7534 n1_m1_364800_48000 0 2.219362e-07
I7535 n1_m1_364800_52800 0 1.456351e-07
I7536 n1_m1_364800_57600 0 2.343349e-07
I7537 n1_m1_364800_62400 0 1.585836e-07
I7538 n1_m1_364800_67200 0 1.512177e-07
I7539 n1_m1_364800_72000 0 2.111442e-07
I7540 n1_m1_364800_76800 0 1.366509e-07
I7541 n1_m1_364800_81600 0 2.084565e-07
I7542 n1_m1_364800_86400 0 1.398731e-07
I7543 n1_m1_364800_91200 0 1.428116e-07
I7544 n1_m1_364800_96000 0 2.277821e-07
I7545 n1_m1_364800_100800 0 1.609400e-07
I7546 n1_m1_364800_105600 0 2.458173e-07
I7547 n1_m1_364800_110400 0 1.596069e-07
I7548 n1_m1_364800_115200 0 1.547399e-07
I7549 n1_m1_364800_120000 0 2.317072e-07
I7550 n1_m1_364800_124800 0 1.453240e-07
I7551 n1_m1_364800_129600 0 2.086299e-07
I7552 n1_m1_364800_134400 0 1.381497e-07
I7553 n1_m1_364800_139200 0 1.380973e-07
I7554 n1_m1_364800_144000 0 2.065905e-07
I7555 n1_m1_364800_148800 0 1.362811e-07
I7556 n1_m1_364800_153600 0 2.098354e-07
I7557 n1_m1_364800_158400 0 1.397653e-07
I7558 n1_m1_364800_163200 0 1.384374e-07
I7559 n1_m1_364800_168000 0 2.072730e-07
I7560 n1_m1_364800_172800 0 1.393640e-07
I7561 n1_m1_364800_177600 0 2.180777e-07
I7562 n1_m1_364800_182400 0 1.491012e-07
I7563 n1_m1_364800_187200 0 1.563178e-07
I7564 n1_m1_364800_192000 0 2.366155e-07
I7565 n1_m1_364800_196800 0 1.533294e-07
I7566 n1_m1_364800_201600 0 2.464434e-07
I7567 n1_m1_364800_206400 0 1.700699e-07
I7568 n1_m1_364800_211200 0 1.593027e-07
I7569 n1_m1_364800_216000 0 2.208662e-07
I7570 n1_m1_364800_220800 0 1.399887e-07
I7571 n1_m1_364800_225600 0 2.098484e-07
I7572 n1_m1_364800_230400 0 1.405695e-07
I7573 n1_m1_364800_235200 0 1.382949e-07
I7574 n1_m1_364800_240000 0 2.077877e-07
I7575 n1_m1_364800_244800 0 1.398423e-07
I7576 n1_m1_364800_249600 0 2.098560e-07
I7577 n1_m1_364800_254400 0 1.399040e-07
I7578 n1_m1_364800_259200 0 1.405948e-07
I7579 n1_m1_364800_264000 0 2.168804e-07
I7580 n1_m1_364800_268800 0 1.413092e-07
I7581 n1_m1_364800_273600 0 5.259066e-07
I7582 n1_m1_364800_278400 0 7.427582e-07
I7583 n1_m1_364800_283200 0 4.770024e-07
I7584 n1_m1_364800_288000 0 5.632379e-07
I7585 n1_m1_364800_292800 0 1.723433e-07
I7586 n1_m1_364800_297600 0 2.563800e-07
I7587 n1_m1_364800_302400 0 1.441197e-07
I7588 n1_m1_364800_307200 0 1.524885e-07
I7589 n1_m1_364800_312000 0 2.178454e-07
I7590 n1_m1_364800_316800 0 1.359860e-07
I7591 n1_m1_364800_321600 0 2.374933e-07
I7592 n1_m1_364800_326400 0 2.532213e-07
I7593 n1_m1_364800_331200 0 2.937144e-07
I7594 n1_m1_364800_336000 0 5.865907e-07
I7595 n1_m1_364800_340800 0 2.598605e-07
I7596 n1_m1_364800_345600 0 2.967170e-07
I7597 n1_m1_364800_350400 0 1.475360e-07
I7598 n1_m1_364800_355200 0 1.390759e-07
I7599 n1_m1_364800_360000 0 2.003427e-07
I7600 n1_m1_364800_364800 0 1.332419e-07
I7601 n1_m1_364800_369600 0 1.998628e-07
I7602 n1_m1_364800_374400 0 1.363471e-07
I7603 n1_m1_364800_379200 0 1.399040e-07
I7604 n1_m1_364800_384000 0 2.098560e-07
I7605 n1_m1_364800_388800 0 1.403637e-07
I7606 n1_m1_364800_393600 0 2.128298e-07
I7607 n1_m1_364800_398400 0 1.457613e-07
I7608 n1_m1_364800_403200 0 1.454084e-07
I7609 n1_m1_364800_408000 0 2.103957e-07
I7610 n1_m1_364800_412800 0 1.435256e-07
I7611 n1_m1_364800_417600 0 2.082619e-07
I7612 n1_m1_364800_422400 0 1.365038e-07
I7613 n1_m1_364800_427200 0 1.361213e-07
I7614 n1_m1_364800_432000 0 2.074633e-07
I7615 n1_m1_364800_436800 0 1.403855e-07
I7616 n1_m1_364800_441600 0 2.096152e-07
I7617 n1_m1_364800_446400 0 1.396632e-07
I7618 n1_m1_364800_451200 0 1.410614e-07
I7619 n1_m1_364800_456000 0 2.335403e-07
I7620 n1_m1_364800_460800 0 1.764608e-07
I7621 n1_m1_364800_465600 0 2.548653e-07
I7622 n1_m1_364800_470400 0 8.077287e-08
I7623 n1_m1_369600_0 0 2.265983e-07
I7624 n1_m1_369600_4800 0 3.918533e-07
I7625 n1_m1_369600_9600 0 4.881180e-07
I7626 n1_m1_369600_14400 0 1.750989e-07
I7627 n1_m1_369600_19200 0 1.615776e-07
I7628 n1_m1_369600_24000 0 2.288473e-07
I7629 n1_m1_369600_28800 0 1.558477e-07
I7630 n1_m1_369600_33600 0 3.499910e-07
I7631 n1_m1_369600_38400 0 1.878678e-07
I7632 n1_m1_369600_43200 0 1.767967e-07
I7633 n1_m1_369600_48000 0 2.265014e-07
I7634 n1_m1_369600_52800 0 1.513854e-07
I7635 n1_m1_369600_57600 0 2.258902e-07
I7636 n1_m1_369600_62400 0 1.437635e-07
I7637 n1_m1_369600_67200 0 1.398793e-07
I7638 n1_m1_369600_72000 0 2.006815e-07
I7639 n1_m1_369600_76800 0 1.348997e-07
I7640 n1_m1_369600_81600 0 2.048264e-07
I7641 n1_m1_369600_86400 0 1.393279e-07
I7642 n1_m1_369600_91200 0 1.390332e-07
I7643 n1_m1_369600_96000 0 2.155492e-07
I7644 n1_m1_369600_100800 0 1.518143e-07
I7645 n1_m1_369600_105600 0 2.252296e-07
I7646 n1_m1_369600_110400 0 1.470639e-07
I7647 n1_m1_369600_115200 0 1.491799e-07
I7648 n1_m1_369600_120000 0 2.308563e-07
I7649 n1_m1_369600_124800 0 1.513086e-07
I7650 n1_m1_369600_129600 0 2.185297e-07
I7651 n1_m1_369600_134400 0 1.373633e-07
I7652 n1_m1_369600_139200 0 1.332419e-07
I7653 n1_m1_369600_144000 0 2.010767e-07
I7654 n1_m1_369600_148800 0 1.395935e-07
I7655 n1_m1_369600_153600 0 2.097591e-07
I7656 n1_m1_369600_158400 0 1.378478e-07
I7657 n1_m1_369600_163200 0 1.373633e-07
I7658 n1_m1_369600_168000 0 2.060450e-07
I7659 n1_m1_369600_172800 0 1.373633e-07
I7660 n1_m1_369600_177600 0 2.092208e-07
I7661 n1_m1_369600_182400 0 1.409159e-07
I7662 n1_m1_369600_187200 0 1.488809e-07
I7663 n1_m1_369600_192000 0 2.331687e-07
I7664 n1_m1_369600_196800 0 1.564303e-07
I7665 n1_m1_369600_201600 0 2.552148e-07
I7666 n1_m1_369600_206400 0 1.759922e-07
I7667 n1_m1_369600_211200 0 1.695214e-07
I7668 n1_m1_369600_216000 0 2.270885e-07
I7669 n1_m1_369600_220800 0 1.440254e-07
I7670 n1_m1_369600_225600 0 2.094892e-07
I7671 n1_m1_369600_230400 0 1.374940e-07
I7672 n1_m1_369600_235200 0 1.365729e-07
I7673 n1_m1_369600_240000 0 2.035128e-07
I7674 n1_m1_369600_244800 0 1.349732e-07
I7675 n1_m1_369600_249600 0 2.098560e-07
I7676 n1_m1_369600_254400 0 1.401516e-07
I7677 n1_m1_369600_259200 0 1.426872e-07
I7678 n1_m1_369600_264000 0 2.237167e-07
I7679 n1_m1_369600_268800 0 1.436302e-07
I7680 n1_m1_369600_273600 0 4.423841e-07
I7681 n1_m1_369600_278400 0 5.565882e-07
I7682 n1_m1_369600_283200 0 3.347750e-07
I7683 n1_m1_369600_288000 0 5.108327e-07
I7684 n1_m1_369600_292800 0 1.732539e-07
I7685 n1_m1_369600_297600 0 2.365857e-07
I7686 n1_m1_369600_302400 0 1.581886e-07
I7687 n1_m1_369600_307200 0 1.817696e-07
I7688 n1_m1_369600_312000 0 2.502725e-07
I7689 n1_m1_369600_316800 0 1.375401e-07
I7690 n1_m1_369600_321600 0 2.182970e-07
I7691 n1_m1_369600_326400 0 1.606654e-07
I7692 n1_m1_369600_331200 0 1.598410e-07
I7693 n1_m1_369600_336000 0 3.902528e-07
I7694 n1_m1_369600_340800 0 1.993042e-07
I7695 n1_m1_369600_345600 0 2.619669e-07
I7696 n1_m1_369600_350400 0 1.566889e-07
I7697 n1_m1_369600_355200 0 1.406745e-07
I7698 n1_m1_369600_360000 0 2.003427e-07
I7699 n1_m1_369600_364800 0 1.332419e-07
I7700 n1_m1_369600_369600 0 1.998628e-07
I7701 n1_m1_369600_374400 0 1.363471e-07
I7702 n1_m1_369600_379200 0 1.399040e-07
I7703 n1_m1_369600_384000 0 2.098560e-07
I7704 n1_m1_369600_388800 0 1.399040e-07
I7705 n1_m1_369600_393600 0 2.100605e-07
I7706 n1_m1_369600_398400 0 1.420678e-07
I7707 n1_m1_369600_403200 0 1.431257e-07
I7708 n1_m1_369600_408000 0 2.213311e-07
I7709 n1_m1_369600_412800 0 1.470601e-07
I7710 n1_m1_369600_417600 0 2.112392e-07
I7711 n1_m1_369600_422400 0 1.399040e-07
I7712 n1_m1_369600_427200 0 1.361213e-07
I7713 n1_m1_369600_432000 0 2.014154e-07
I7714 n1_m1_369600_436800 0 1.399040e-07
I7715 n1_m1_369600_441600 0 2.076598e-07
I7716 n1_m1_369600_446400 0 1.376971e-07
I7717 n1_m1_369600_451200 0 1.403724e-07
I7718 n1_m1_369600_456000 0 2.298693e-07
I7719 n1_m1_369600_460800 0 1.739202e-07
I7720 n1_m1_369600_465600 0 2.490381e-07
I7721 n1_m1_369600_470400 0 7.763033e-08
I7722 n1_m1_374400_0 0 2.044561e-07
I7723 n1_m1_374400_4800 0 2.750291e-07
I7724 n1_m1_374400_9600 0 3.161497e-07
I7725 n1_m1_374400_14400 0 1.525870e-07
I7726 n1_m1_374400_19200 0 1.475917e-07
I7727 n1_m1_374400_24000 0 2.287097e-07
I7728 n1_m1_374400_28800 0 1.546492e-07
I7729 n1_m1_374400_33600 0 2.601009e-07
I7730 n1_m1_374400_38400 0 1.626567e-07
I7731 n1_m1_374400_43200 0 1.654667e-07
I7732 n1_m1_374400_48000 0 2.191716e-07
I7733 n1_m1_374400_52800 0 1.444206e-07
I7734 n1_m1_374400_57600 0 2.173790e-07
I7735 n1_m1_374400_62400 0 1.399040e-07
I7736 n1_m1_374400_67200 0 1.398561e-07
I7737 n1_m1_374400_72000 0 2.092340e-07
I7738 n1_m1_374400_76800 0 1.397470e-07
I7739 n1_m1_374400_81600 0 2.098560e-07
I7740 n1_m1_374400_86400 0 1.423317e-07
I7741 n1_m1_374400_91200 0 1.449685e-07
I7742 n1_m1_374400_96000 0 2.107638e-07
I7743 n1_m1_374400_100800 0 1.376409e-07
I7744 n1_m1_374400_105600 0 2.100141e-07
I7745 n1_m1_374400_110400 0 1.457192e-07
I7746 n1_m1_374400_115200 0 1.525389e-07
I7747 n1_m1_374400_120000 0 2.380404e-07
I7748 n1_m1_374400_124800 0 1.606142e-07
I7749 n1_m1_374400_129600 0 2.279896e-07
I7750 n1_m1_374400_134400 0 1.404686e-07
I7751 n1_m1_374400_139200 0 1.348997e-07
I7752 n1_m1_374400_144000 0 2.037740e-07
I7753 n1_m1_374400_148800 0 1.390408e-07
I7754 n1_m1_374400_153600 0 2.050757e-07
I7755 n1_m1_374400_158400 0 1.339201e-07
I7756 n1_m1_374400_163200 0 1.332419e-07
I7757 n1_m1_374400_168000 0 1.998628e-07
I7758 n1_m1_374400_172800 0 1.332419e-07
I7759 n1_m1_374400_177600 0 2.149798e-07
I7760 n1_m1_374400_182400 0 1.456627e-07
I7761 n1_m1_374400_187200 0 1.546076e-07
I7762 n1_m1_374400_192000 0 2.418808e-07
I7763 n1_m1_374400_196800 0 1.596927e-07
I7764 n1_m1_374400_201600 0 2.618121e-07
I7765 n1_m1_374400_206400 0 1.734769e-07
I7766 n1_m1_374400_211200 0 1.625955e-07
I7767 n1_m1_374400_216000 0 2.154518e-07
I7768 n1_m1_374400_220800 0 1.367988e-07
I7769 n1_m1_374400_225600 0 2.091060e-07
I7770 n1_m1_374400_230400 0 1.411934e-07
I7771 n1_m1_374400_235200 0 1.396781e-07
I7772 n1_m1_374400_240000 0 2.045206e-07
I7773 n1_m1_374400_244800 0 1.372062e-07
I7774 n1_m1_374400_249600 0 2.100270e-07
I7775 n1_m1_374400_254400 0 1.428164e-07
I7776 n1_m1_374400_259200 0 1.460989e-07
I7777 n1_m1_374400_264000 0 2.240835e-07
I7778 n1_m1_374400_268800 0 1.503407e-07
I7779 n1_m1_374400_273600 0 3.130505e-07
I7780 n1_m1_374400_278400 0 3.049071e-07
I7781 n1_m1_374400_283200 0 1.959643e-07
I7782 n1_m1_374400_288000 0 3.279263e-07
I7783 n1_m1_374400_292800 0 1.570779e-07
I7784 n1_m1_374400_297600 0 2.229402e-07
I7785 n1_m1_374400_302400 0 1.569324e-07
I7786 n1_m1_374400_307200 0 1.714604e-07
I7787 n1_m1_374400_312000 0 2.427911e-07
I7788 n1_m1_374400_316800 0 1.400265e-07
I7789 n1_m1_374400_321600 0 2.086560e-07
I7790 n1_m1_374400_326400 0 1.481637e-07
I7791 n1_m1_374400_331200 0 1.446671e-07
I7792 n1_m1_374400_336000 0 2.452288e-07
I7793 n1_m1_374400_340800 0 2.170905e-07
I7794 n1_m1_374400_345600 0 3.762148e-07
I7795 n1_m1_374400_350400 0 1.584032e-07
I7796 n1_m1_374400_355200 0 1.407908e-07
I7797 n1_m1_374400_360000 0 2.003427e-07
I7798 n1_m1_374400_364800 0 1.332419e-07
I7799 n1_m1_374400_369600 0 1.998628e-07
I7800 n1_m1_374400_374400 0 1.363471e-07
I7801 n1_m1_374400_379200 0 1.399040e-07
I7802 n1_m1_374400_384000 0 2.105533e-07
I7803 n1_m1_374400_388800 0 1.438250e-07
I7804 n1_m1_374400_393600 0 2.247210e-07
I7805 n1_m1_374400_398400 0 1.553542e-07
I7806 n1_m1_374400_403200 0 1.553686e-07
I7807 n1_m1_374400_408000 0 2.296722e-07
I7808 n1_m1_374400_412800 0 1.480904e-07
I7809 n1_m1_374400_417600 0 2.112392e-07
I7810 n1_m1_374400_422400 0 1.399040e-07
I7811 n1_m1_374400_427200 0 1.361213e-07
I7812 n1_m1_374400_432000 0 2.014154e-07
I7813 n1_m1_374400_436800 0 1.399040e-07
I7814 n1_m1_374400_441600 0 2.043735e-07
I7815 n1_m1_374400_446400 0 1.363801e-07
I7816 n1_m1_374400_451200 0 1.395573e-07
I7817 n1_m1_374400_456000 0 2.239141e-07
I7818 n1_m1_374400_460800 0 1.721539e-07
I7819 n1_m1_374400_465600 0 2.475137e-07
I7820 n1_m1_374400_470400 0 7.712221e-08
I7821 n1_m1_379200_0 0 1.855004e-07
I7822 n1_m1_379200_4800 0 2.013183e-07
I7823 n1_m1_379200_9600 0 2.547347e-07
I7824 n1_m1_379200_14400 0 1.611699e-07
I7825 n1_m1_379200_19200 0 1.520447e-07
I7826 n1_m1_379200_24000 0 2.260337e-07
I7827 n1_m1_379200_28800 0 1.522650e-07
I7828 n1_m1_379200_33600 0 2.470338e-07
I7829 n1_m1_379200_38400 0 1.542679e-07
I7830 n1_m1_379200_43200 0 1.578066e-07
I7831 n1_m1_379200_48000 0 2.138363e-07
I7832 n1_m1_379200_52800 0 1.408638e-07
I7833 n1_m1_379200_57600 0 2.119590e-07
I7834 n1_m1_379200_62400 0 1.362342e-07
I7835 n1_m1_379200_67200 0 1.369399e-07
I7836 n1_m1_379200_72000 0 2.114421e-07
I7837 n1_m1_379200_76800 0 1.372739e-07
I7838 n1_m1_379200_81600 0 2.043513e-07
I7839 n1_m1_379200_86400 0 1.373246e-07
I7840 n1_m1_379200_91200 0 1.392265e-07
I7841 n1_m1_379200_96000 0 2.096579e-07
I7842 n1_m1_379200_100800 0 1.411908e-07
I7843 n1_m1_379200_105600 0 2.153025e-07
I7844 n1_m1_379200_110400 0 1.432467e-07
I7845 n1_m1_379200_115200 0 1.466015e-07
I7846 n1_m1_379200_120000 0 2.370443e-07
I7847 n1_m1_379200_124800 0 1.628826e-07
I7848 n1_m1_379200_129600 0 2.321006e-07
I7849 n1_m1_379200_134400 0 1.403556e-07
I7850 n1_m1_379200_139200 0 1.348395e-07
I7851 n1_m1_379200_144000 0 2.036759e-07
I7852 n1_m1_379200_148800 0 1.390609e-07
I7853 n1_m1_379200_153600 0 2.053802e-07
I7854 n1_m1_379200_158400 0 1.369117e-07
I7855 n1_m1_379200_163200 0 1.369117e-07
I7856 n1_m1_379200_168000 0 2.053675e-07
I7857 n1_m1_379200_172800 0 1.369117e-07
I7858 n1_m1_379200_177600 0 2.156504e-07
I7859 n1_m1_379200_182400 0 1.440881e-07
I7860 n1_m1_379200_187200 0 1.508794e-07
I7861 n1_m1_379200_192000 0 2.415736e-07
I7862 n1_m1_379200_196800 0 1.657842e-07
I7863 n1_m1_379200_201600 0 2.780015e-07
I7864 n1_m1_379200_206400 0 1.824648e-07
I7865 n1_m1_379200_211200 0 1.668607e-07
I7866 n1_m1_379200_216000 0 2.187671e-07
I7867 n1_m1_379200_220800 0 1.343304e-07
I7868 n1_m1_379200_225600 0 2.048415e-07
I7869 n1_m1_379200_230400 0 1.426704e-07
I7870 n1_m1_379200_235200 0 1.432350e-07
I7871 n1_m1_379200_240000 0 2.091251e-07
I7872 n1_m1_379200_244800 0 1.372294e-07
I7873 n1_m1_379200_249600 0 2.102229e-07
I7874 n1_m1_379200_254400 0 1.454087e-07
I7875 n1_m1_379200_259200 0 1.465661e-07
I7876 n1_m1_379200_264000 0 2.170860e-07
I7877 n1_m1_379200_268800 0 1.575917e-07
I7878 n1_m1_379200_273600 0 2.485716e-07
I7879 n1_m1_379200_278400 0 1.817306e-07
I7880 n1_m1_379200_283200 0 1.629840e-07
I7881 n1_m1_379200_288000 0 2.475200e-07
I7882 n1_m1_379200_292800 0 1.462132e-07
I7883 n1_m1_379200_297600 0 2.175202e-07
I7884 n1_m1_379200_302400 0 1.486034e-07
I7885 n1_m1_379200_307200 0 1.462895e-07
I7886 n1_m1_379200_312000 0 2.191206e-07
I7887 n1_m1_379200_316800 0 1.433491e-07
I7888 n1_m1_379200_321600 0 2.057012e-07
I7889 n1_m1_379200_326400 0 1.461929e-07
I7890 n1_m1_379200_331200 0 1.505976e-07
I7891 n1_m1_379200_336000 0 2.236285e-07
I7892 n1_m1_379200_340800 0 2.967873e-07
I7893 n1_m1_379200_345600 0 6.629477e-07
I7894 n1_m1_379200_350400 0 1.640325e-07
I7895 n1_m1_379200_355200 0 1.399640e-07
I7896 n1_m1_379200_360000 0 2.003427e-07
I7897 n1_m1_379200_364800 0 1.332419e-07
I7898 n1_m1_379200_369600 0 1.998628e-07
I7899 n1_m1_379200_374400 0 1.363471e-07
I7900 n1_m1_379200_379200 0 1.399040e-07
I7901 n1_m1_379200_384000 0 2.113521e-07
I7902 n1_m1_379200_388800 0 1.512552e-07
I7903 n1_m1_379200_393600 0 2.576480e-07
I7904 n1_m1_379200_398400 0 1.771108e-07
I7905 n1_m1_379200_403200 0 1.725733e-07
I7906 n1_m1_379200_408000 0 2.389045e-07
I7907 n1_m1_379200_412800 0 1.481682e-07
I7908 n1_m1_379200_417600 0 2.145202e-07
I7909 n1_m1_379200_422400 0 1.399040e-07
I7910 n1_m1_379200_427200 0 1.361213e-07
I7911 n1_m1_379200_432000 0 2.014154e-07
I7912 n1_m1_379200_436800 0 1.399040e-07
I7913 n1_m1_379200_441600 0 2.078622e-07
I7914 n1_m1_379200_446400 0 1.421602e-07
I7915 n1_m1_379200_451200 0 1.415367e-07
I7916 n1_m1_379200_456000 0 2.345192e-07
I7917 n1_m1_379200_460800 0 1.792990e-07
I7918 n1_m1_379200_465600 0 2.551038e-07
I7919 n1_m1_379200_470400 0 8.031570e-08
I7920 n1_m1_384000_0 0 2.469673e-07
I7921 n1_m1_384000_4800 0 2.786968e-07
I7922 n1_m1_384000_9600 0 3.808456e-07
I7923 n1_m1_384000_14400 0 2.337872e-07
I7924 n1_m1_384000_19200 0 2.247826e-07
I7925 n1_m1_384000_24000 0 3.269196e-07
I7926 n1_m1_384000_28800 0 2.277540e-07
I7927 n1_m1_384000_33600 0 4.231540e-07
I7928 n1_m1_384000_38400 0 2.438406e-07
I7929 n1_m1_384000_43200 0 2.366833e-07
I7930 n1_m1_384000_48000 0 3.255163e-07
I7931 n1_m1_384000_52800 0 2.141487e-07
I7932 n1_m1_384000_57600 0 3.094107e-07
I7933 n1_m1_384000_62400 0 2.085187e-07
I7934 n1_m1_384000_67200 0 2.079327e-07
I7935 n1_m1_384000_72000 0 3.131072e-07
I7936 n1_m1_384000_76800 0 2.024915e-07
I7937 n1_m1_384000_81600 0 3.012206e-07
I7938 n1_m1_384000_86400 0 2.004080e-07
I7939 n1_m1_384000_91200 0 2.040850e-07
I7940 n1_m1_384000_96000 0 3.088535e-07
I7941 n1_m1_384000_100800 0 2.118156e-07
I7942 n1_m1_384000_105600 0 3.183535e-07
I7943 n1_m1_384000_110400 0 2.103394e-07
I7944 n1_m1_384000_115200 0 2.121425e-07
I7945 n1_m1_384000_120000 0 3.527441e-07
I7946 n1_m1_384000_124800 0 2.524658e-07
I7947 n1_m1_384000_129600 0 3.453291e-07
I7948 n1_m1_384000_134400 0 2.089301e-07
I7949 n1_m1_384000_139200 0 2.074283e-07
I7950 n1_m1_384000_144000 0 3.050130e-07
I7951 n1_m1_384000_148800 0 2.080272e-07
I7952 n1_m1_384000_153600 0 3.059372e-07
I7953 n1_m1_384000_158400 0 2.086987e-07
I7954 n1_m1_384000_163200 0 2.098560e-07
I7955 n1_m1_384000_168000 0 3.111321e-07
I7956 n1_m1_384000_172800 0 2.027597e-07
I7957 n1_m1_384000_177600 0 3.128926e-07
I7958 n1_m1_384000_182400 0 2.098560e-07
I7959 n1_m1_384000_187200 0 2.187876e-07
I7960 n1_m1_384000_192000 0 3.480181e-07
I7961 n1_m1_384000_196800 0 2.645260e-07
I7962 n1_m1_384000_201600 0 4.947775e-07
I7963 n1_m1_384000_206400 0 3.352202e-07
I7964 n1_m1_384000_211200 0 2.490478e-07
I7965 n1_m1_384000_216000 0 3.273925e-07
I7966 n1_m1_384000_220800 0 2.093399e-07
I7967 n1_m1_384000_225600 0 3.126955e-07
I7968 n1_m1_384000_230400 0 2.127676e-07
I7969 n1_m1_384000_235200 0 2.080352e-07
I7970 n1_m1_384000_240000 0 3.155092e-07
I7971 n1_m1_384000_244800 0 2.139759e-07
I7972 n1_m1_384000_249600 0 3.191867e-07
I7973 n1_m1_384000_254400 0 2.127450e-07
I7974 n1_m1_384000_259200 0 2.235378e-07
I7975 n1_m1_384000_264000 0 3.554064e-07
I7976 n1_m1_384000_268800 0 2.340781e-07
I7977 n1_m1_384000_273600 0 3.574829e-07
I7978 n1_m1_384000_278400 0 2.591435e-07
I7979 n1_m1_384000_283200 0 2.353228e-07
I7980 n1_m1_384000_288000 0 3.587399e-07
I7981 n1_m1_384000_292800 0 2.125236e-07
I7982 n1_m1_384000_297600 0 3.167590e-07
I7983 n1_m1_384000_302400 0 2.117693e-07
I7984 n1_m1_384000_307200 0 2.083849e-07
I7985 n1_m1_384000_312000 0 3.145885e-07
I7986 n1_m1_384000_316800 0 2.116150e-07
I7987 n1_m1_384000_321600 0 3.158744e-07
I7988 n1_m1_384000_326400 0 2.162042e-07
I7989 n1_m1_384000_331200 0 2.152087e-07
I7990 n1_m1_384000_336000 0 3.297729e-07
I7991 n1_m1_384000_340800 0 3.285354e-07
I7992 n1_m1_384000_345600 0 7.129300e-07
I7993 n1_m1_384000_350400 0 2.519515e-07
I7994 n1_m1_384000_355200 0 2.102981e-07
I7995 n1_m1_384000_360000 0 3.005141e-07
I7996 n1_m1_384000_364800 0 1.998628e-07
I7997 n1_m1_384000_369600 0 2.997942e-07
I7998 n1_m1_384000_374400 0 2.038233e-07
I7999 n1_m1_384000_379200 0 2.091840e-07
I8000 n1_m1_384000_384000 0 3.166922e-07
I8001 n1_m1_384000_388800 0 2.209093e-07
I8002 n1_m1_384000_393600 0 3.513539e-07
I8003 n1_m1_384000_398400 0 2.386902e-07
I8004 n1_m1_384000_403200 0 2.352599e-07
I8005 n1_m1_384000_408000 0 3.369377e-07
I8006 n1_m1_384000_412800 0 2.144079e-07
I8007 n1_m1_384000_417600 0 3.174585e-07
I8008 n1_m1_384000_422400 0 2.098560e-07
I8009 n1_m1_384000_427200 0 2.084775e-07
I8010 n1_m1_384000_432000 0 3.117082e-07
I8011 n1_m1_384000_436800 0 2.098560e-07
I8012 n1_m1_384000_441600 0 3.150000e-07
I8013 n1_m1_384000_446400 0 2.116253e-07
I8014 n1_m1_384000_451200 0 2.146192e-07
I8015 n1_m1_384000_456000 0 3.927003e-07
I8016 n1_m1_384000_460800 0 3.409283e-07
I8017 n1_m1_384000_465600 0 3.937997e-07
I8018 n1_m1_384000_470400 0 1.161987e-07
I8019 n1_m1_388800_0 0 1.846856e-07
I8020 n1_m1_388800_4800 0 2.332465e-07
I8021 n1_m1_388800_9600 0 2.752432e-07
I8022 n1_m1_388800_14400 0 1.532249e-07
I8023 n1_m1_388800_19200 0 1.470693e-07
I8024 n1_m1_388800_24000 0 2.134368e-07
I8025 n1_m1_388800_28800 0 1.490323e-07
I8026 n1_m1_388800_33600 0 3.483411e-07
I8027 n1_m1_388800_38400 0 1.802308e-07
I8028 n1_m1_388800_43200 0 1.664330e-07
I8029 n1_m1_388800_48000 0 2.196482e-07
I8030 n1_m1_388800_52800 0 1.419670e-07
I8031 n1_m1_388800_57600 0 2.052446e-07
I8032 n1_m1_388800_62400 0 1.448519e-07
I8033 n1_m1_388800_67200 0 1.422964e-07
I8034 n1_m1_388800_72000 0 2.100745e-07
I8035 n1_m1_388800_76800 0 1.367172e-07
I8036 n1_m1_388800_81600 0 2.071596e-07
I8037 n1_m1_388800_86400 0 1.367897e-07
I8038 n1_m1_388800_91200 0 1.398884e-07
I8039 n1_m1_388800_96000 0 2.098317e-07
I8040 n1_m1_388800_100800 0 1.399024e-07
I8041 n1_m1_388800_105600 0 2.098560e-07
I8042 n1_m1_388800_110400 0 1.399040e-07
I8043 n1_m1_388800_115200 0 1.412249e-07
I8044 n1_m1_388800_120000 0 2.346849e-07
I8045 n1_m1_388800_124800 0 1.710126e-07
I8046 n1_m1_388800_129600 0 2.310561e-07
I8047 n1_m1_388800_134400 0 1.399040e-07
I8048 n1_m1_388800_139200 0 1.399040e-07
I8049 n1_m1_388800_144000 0 2.040690e-07
I8050 n1_m1_388800_148800 0 1.395871e-07
I8051 n1_m1_388800_153600 0 2.098148e-07
I8052 n1_m1_388800_158400 0 1.398986e-07
I8053 n1_m1_388800_163200 0 1.399040e-07
I8054 n1_m1_388800_168000 0 2.098390e-07
I8055 n1_m1_388800_172800 0 1.377636e-07
I8056 n1_m1_388800_177600 0 2.090797e-07
I8057 n1_m1_388800_182400 0 1.391956e-07
I8058 n1_m1_388800_187200 0 1.430755e-07
I8059 n1_m1_388800_192000 0 2.395221e-07
I8060 n1_m1_388800_196800 0 2.199013e-07
I8061 n1_m1_388800_201600 0 4.918372e-07
I8062 n1_m1_388800_206400 0 3.425964e-07
I8063 n1_m1_388800_211200 0 1.883300e-07
I8064 n1_m1_388800_216000 0 2.233367e-07
I8065 n1_m1_388800_220800 0 1.372138e-07
I8066 n1_m1_388800_225600 0 2.042996e-07
I8067 n1_m1_388800_230400 0 1.437879e-07
I8068 n1_m1_388800_235200 0 1.407791e-07
I8069 n1_m1_388800_240000 0 2.102459e-07
I8070 n1_m1_388800_244800 0 1.386352e-07
I8071 n1_m1_388800_249600 0 2.098758e-07
I8072 n1_m1_388800_254400 0 1.413731e-07
I8073 n1_m1_388800_259200 0 1.569693e-07
I8074 n1_m1_388800_264000 0 2.533940e-07
I8075 n1_m1_388800_268800 0 1.592958e-07
I8076 n1_m1_388800_273600 0 2.772030e-07
I8077 n1_m1_388800_278400 0 2.315236e-07
I8078 n1_m1_388800_283200 0 1.767065e-07
I8079 n1_m1_388800_288000 0 2.419840e-07
I8080 n1_m1_388800_292800 0 1.405062e-07
I8081 n1_m1_388800_297600 0 2.098560e-07
I8082 n1_m1_388800_302400 0 1.399040e-07
I8083 n1_m1_388800_307200 0 1.399040e-07
I8084 n1_m1_388800_312000 0 2.098560e-07
I8085 n1_m1_388800_316800 0 1.399040e-07
I8086 n1_m1_388800_321600 0 2.122837e-07
I8087 n1_m1_388800_326400 0 1.427750e-07
I8088 n1_m1_388800_331200 0 1.364827e-07
I8089 n1_m1_388800_336000 0 2.183362e-07
I8090 n1_m1_388800_340800 0 1.815302e-07
I8091 n1_m1_388800_345600 0 3.638899e-07
I8092 n1_m1_388800_350400 0 1.668134e-07
I8093 n1_m1_388800_355200 0 1.403839e-07
I8094 n1_m1_388800_360000 0 2.003427e-07
I8095 n1_m1_388800_364800 0 1.332419e-07
I8096 n1_m1_388800_369600 0 1.998628e-07
I8097 n1_m1_388800_374400 0 1.332550e-07
I8098 n1_m1_388800_379200 0 1.369244e-07
I8099 n1_m1_388800_384000 0 2.098623e-07
I8100 n1_m1_388800_388800 0 1.399321e-07
I8101 n1_m1_388800_393600 0 2.099222e-07
I8102 n1_m1_388800_398400 0 1.399604e-07
I8103 n1_m1_388800_403200 0 1.407581e-07
I8104 n1_m1_388800_408000 0 2.135417e-07
I8105 n1_m1_388800_412800 0 1.399110e-07
I8106 n1_m1_388800_417600 0 2.098560e-07
I8107 n1_m1_388800_422400 0 1.399040e-07
I8108 n1_m1_388800_427200 0 1.399040e-07
I8109 n1_m1_388800_432000 0 2.098560e-07
I8110 n1_m1_388800_436800 0 1.399040e-07
I8111 n1_m1_388800_441600 0 2.084769e-07
I8112 n1_m1_388800_446400 0 1.396553e-07
I8113 n1_m1_388800_451200 0 1.422237e-07
I8114 n1_m1_388800_456000 0 2.488662e-07
I8115 n1_m1_388800_460800 0 2.013227e-07
I8116 n1_m1_388800_465600 0 2.500826e-07
I8117 n1_m1_388800_470400 0 7.557283e-08
I8118 n1_m1_393600_0 0 1.846286e-07
I8119 n1_m1_393600_4800 0 2.321759e-07
I8120 n1_m1_393600_9600 0 2.758415e-07
I8121 n1_m1_393600_14400 0 1.521136e-07
I8122 n1_m1_393600_19200 0 1.466720e-07
I8123 n1_m1_393600_24000 0 2.120062e-07
I8124 n1_m1_393600_28800 0 1.449819e-07
I8125 n1_m1_393600_33600 0 4.198289e-07
I8126 n1_m1_393600_38400 0 2.226739e-07
I8127 n1_m1_393600_43200 0 1.767464e-07
I8128 n1_m1_393600_48000 0 2.170544e-07
I8129 n1_m1_393600_52800 0 1.380973e-07
I8130 n1_m1_393600_57600 0 2.051417e-07
I8131 n1_m1_393600_62400 0 1.451828e-07
I8132 n1_m1_393600_67200 0 1.458603e-07
I8133 n1_m1_393600_72000 0 2.106746e-07
I8134 n1_m1_393600_76800 0 1.399040e-07
I8135 n1_m1_393600_81600 0 2.076491e-07
I8136 n1_m1_393600_86400 0 1.399040e-07
I8137 n1_m1_393600_91200 0 1.399040e-07
I8138 n1_m1_393600_96000 0 2.098560e-07
I8139 n1_m1_393600_100800 0 1.399040e-07
I8140 n1_m1_393600_105600 0 2.116117e-07
I8141 n1_m1_393600_110400 0 1.422188e-07
I8142 n1_m1_393600_115200 0 1.427161e-07
I8143 n1_m1_393600_120000 0 2.310386e-07
I8144 n1_m1_393600_124800 0 1.694628e-07
I8145 n1_m1_393600_129600 0 2.304578e-07
I8146 n1_m1_393600_134400 0 1.399040e-07
I8147 n1_m1_393600_139200 0 1.399040e-07
I8148 n1_m1_393600_144000 0 2.040690e-07
I8149 n1_m1_393600_148800 0 1.395935e-07
I8150 n1_m1_393600_153600 0 2.098560e-07
I8151 n1_m1_393600_158400 0 1.397176e-07
I8152 n1_m1_393600_163200 0 1.379325e-07
I8153 n1_m1_393600_168000 0 2.077766e-07
I8154 n1_m1_393600_172800 0 1.444771e-07
I8155 n1_m1_393600_177600 0 2.115215e-07
I8156 n1_m1_393600_182400 0 1.372504e-07
I8157 n1_m1_393600_187200 0 1.428963e-07
I8158 n1_m1_393600_192000 0 2.539244e-07
I8159 n1_m1_393600_196800 0 2.524991e-07
I8160 n1_m1_393600_201600 0 5.594700e-07
I8161 n1_m1_393600_206400 0 3.855467e-07
I8162 n1_m1_393600_211200 0 1.978492e-07
I8163 n1_m1_393600_216000 0 2.276686e-07
I8164 n1_m1_393600_220800 0 1.371940e-07
I8165 n1_m1_393600_225600 0 2.042666e-07
I8166 n1_m1_393600_230400 0 1.437996e-07
I8167 n1_m1_393600_235200 0 1.432350e-07
I8168 n1_m1_393600_240000 0 2.092457e-07
I8169 n1_m1_393600_244800 0 1.349799e-07
I8170 n1_m1_393600_249600 0 2.099835e-07
I8171 n1_m1_393600_254400 0 1.433133e-07
I8172 n1_m1_393600_259200 0 1.595687e-07
I8173 n1_m1_393600_264000 0 2.573112e-07
I8174 n1_m1_393600_268800 0 1.651409e-07
I8175 n1_m1_393600_273600 0 3.359226e-07
I8176 n1_m1_393600_278400 0 3.395883e-07
I8177 n1_m1_393600_283200 0 2.238481e-07
I8178 n1_m1_393600_288000 0 2.557937e-07
I8179 n1_m1_393600_292800 0 1.423948e-07
I8180 n1_m1_393600_297600 0 2.098560e-07
I8181 n1_m1_393600_302400 0 1.399040e-07
I8182 n1_m1_393600_307200 0 1.399040e-07
I8183 n1_m1_393600_312000 0 2.098560e-07
I8184 n1_m1_393600_316800 0 1.398942e-07
I8185 n1_m1_393600_321600 0 2.101749e-07
I8186 n1_m1_393600_326400 0 1.405815e-07
I8187 n1_m1_393600_331200 0 1.367988e-07
I8188 n1_m1_393600_336000 0 2.196876e-07
I8189 n1_m1_393600_340800 0 1.723350e-07
I8190 n1_m1_393600_345600 0 3.317672e-07
I8191 n1_m1_393600_350400 0 1.641933e-07
I8192 n1_m1_393600_355200 0 1.403839e-07
I8193 n1_m1_393600_360000 0 2.003427e-07
I8194 n1_m1_393600_364800 0 1.332419e-07
I8195 n1_m1_393600_369600 0 1.998628e-07
I8196 n1_m1_393600_374400 0 1.332419e-07
I8197 n1_m1_393600_379200 0 1.356366e-07
I8198 n1_m1_393600_384000 0 2.090124e-07
I8199 n1_m1_393600_388800 0 1.399040e-07
I8200 n1_m1_393600_393600 0 2.098560e-07
I8201 n1_m1_393600_398400 0 1.399040e-07
I8202 n1_m1_393600_403200 0 1.402865e-07
I8203 n1_m1_393600_408000 0 2.131810e-07
I8204 n1_m1_393600_412800 0 1.404827e-07
I8205 n1_m1_393600_417600 0 2.098560e-07
I8206 n1_m1_393600_422400 0 1.399040e-07
I8207 n1_m1_393600_427200 0 1.399040e-07
I8208 n1_m1_393600_432000 0 2.098560e-07
I8209 n1_m1_393600_436800 0 1.399040e-07
I8210 n1_m1_393600_441600 0 2.046900e-07
I8211 n1_m1_393600_446400 0 1.389724e-07
I8212 n1_m1_393600_451200 0 1.418166e-07
I8213 n1_m1_393600_456000 0 2.335075e-07
I8214 n1_m1_393600_460800 0 1.717709e-07
I8215 n1_m1_393600_465600 0 2.442219e-07
I8216 n1_m1_393600_470400 0 7.646217e-08
I8217 n1_m1_398400_0 0 1.702762e-07
I8218 n1_m1_398400_4800 0 2.049493e-07
I8219 n1_m1_398400_9600 0 2.594243e-07
I8220 n1_m1_398400_14400 0 1.487793e-07
I8221 n1_m1_398400_19200 0 1.460590e-07
I8222 n1_m1_398400_24000 0 2.139499e-07
I8223 n1_m1_398400_28800 0 1.462677e-07
I8224 n1_m1_398400_33600 0 4.722746e-07
I8225 n1_m1_398400_38400 0 2.560913e-07
I8226 n1_m1_398400_43200 0 1.807536e-07
I8227 n1_m1_398400_48000 0 2.227195e-07
I8228 n1_m1_398400_52800 0 1.392766e-07
I8229 n1_m1_398400_57600 0 2.056355e-07
I8230 n1_m1_398400_62400 0 1.406869e-07
I8231 n1_m1_398400_67200 0 1.407006e-07
I8232 n1_m1_398400_72000 0 2.088500e-07
I8233 n1_m1_398400_76800 0 1.359170e-07
I8234 n1_m1_398400_81600 0 2.004029e-07
I8235 n1_m1_398400_86400 0 1.359993e-07
I8236 n1_m1_398400_91200 0 1.390853e-07
I8237 n1_m1_398400_96000 0 2.094744e-07
I8238 n1_m1_398400_100800 0 1.399040e-07
I8239 n1_m1_398400_105600 0 2.141441e-07
I8240 n1_m1_398400_110400 0 1.422087e-07
I8241 n1_m1_398400_115200 0 1.449862e-07
I8242 n1_m1_398400_120000 0 2.274688e-07
I8243 n1_m1_398400_124800 0 1.646770e-07
I8244 n1_m1_398400_129600 0 2.237298e-07
I8245 n1_m1_398400_134400 0 1.393975e-07
I8246 n1_m1_398400_139200 0 1.399040e-07
I8247 n1_m1_398400_144000 0 2.047801e-07
I8248 n1_m1_398400_148800 0 1.398155e-07
I8249 n1_m1_398400_153600 0 2.116771e-07
I8250 n1_m1_398400_158400 0 1.407333e-07
I8251 n1_m1_398400_163200 0 1.384867e-07
I8252 n1_m1_398400_168000 0 2.039799e-07
I8253 n1_m1_398400_172800 0 1.436585e-07
I8254 n1_m1_398400_177600 0 2.115735e-07
I8255 n1_m1_398400_182400 0 1.380691e-07
I8256 n1_m1_398400_187200 0 1.433195e-07
I8257 n1_m1_398400_192000 0 2.342474e-07
I8258 n1_m1_398400_196800 0 1.911154e-07
I8259 n1_m1_398400_201600 0 3.926670e-07
I8260 n1_m1_398400_206400 0 2.707336e-07
I8261 n1_m1_398400_211200 0 1.788730e-07
I8262 n1_m1_398400_216000 0 2.317740e-07
I8263 n1_m1_398400_220800 0 1.391198e-07
I8264 n1_m1_398400_225600 0 2.042666e-07
I8265 n1_m1_398400_230400 0 1.437996e-07
I8266 n1_m1_398400_235200 0 1.403980e-07
I8267 n1_m1_398400_240000 0 2.030396e-07
I8268 n1_m1_398400_244800 0 1.362214e-07
I8269 n1_m1_398400_249600 0 2.145085e-07
I8270 n1_m1_398400_254400 0 1.414321e-07
I8271 n1_m1_398400_259200 0 1.470613e-07
I8272 n1_m1_398400_264000 0 2.340074e-07
I8273 n1_m1_398400_268800 0 1.639926e-07
I8274 n1_m1_398400_273600 0 3.019698e-07
I8275 n1_m1_398400_278400 0 2.719983e-07
I8276 n1_m1_398400_283200 0 1.907890e-07
I8277 n1_m1_398400_288000 0 2.565825e-07
I8278 n1_m1_398400_292800 0 1.449959e-07
I8279 n1_m1_398400_297600 0 2.098560e-07
I8280 n1_m1_398400_302400 0 1.399040e-07
I8281 n1_m1_398400_307200 0 1.399040e-07
I8282 n1_m1_398400_312000 0 2.098560e-07
I8283 n1_m1_398400_316800 0 1.398998e-07
I8284 n1_m1_398400_321600 0 2.093159e-07
I8285 n1_m1_398400_326400 0 1.378236e-07
I8286 n1_m1_398400_331200 0 1.371803e-07
I8287 n1_m1_398400_336000 0 2.185713e-07
I8288 n1_m1_398400_340800 0 1.619229e-07
I8289 n1_m1_398400_345600 0 2.944592e-07
I8290 n1_m1_398400_350400 0 1.565740e-07
I8291 n1_m1_398400_355200 0 1.398284e-07
I8292 n1_m1_398400_360000 0 2.003427e-07
I8293 n1_m1_398400_364800 0 1.332419e-07
I8294 n1_m1_398400_369600 0 1.998628e-07
I8295 n1_m1_398400_374400 0 1.358866e-07
I8296 n1_m1_398400_379200 0 1.362414e-07
I8297 n1_m1_398400_384000 0 2.077266e-07
I8298 n1_m1_398400_388800 0 1.399040e-07
I8299 n1_m1_398400_393600 0 2.098560e-07
I8300 n1_m1_398400_398400 0 1.405006e-07
I8301 n1_m1_398400_403200 0 1.445436e-07
I8302 n1_m1_398400_408000 0 2.197343e-07
I8303 n1_m1_398400_412800 0 1.415695e-07
I8304 n1_m1_398400_417600 0 2.098560e-07
I8305 n1_m1_398400_422400 0 1.399040e-07
I8306 n1_m1_398400_427200 0 1.399040e-07
I8307 n1_m1_398400_432000 0 2.098560e-07
I8308 n1_m1_398400_436800 0 1.399040e-07
I8309 n1_m1_398400_441600 0 2.046900e-07
I8310 n1_m1_398400_446400 0 1.389724e-07
I8311 n1_m1_398400_451200 0 1.400756e-07
I8312 n1_m1_398400_456000 0 2.199607e-07
I8313 n1_m1_398400_460800 0 1.633342e-07
I8314 n1_m1_398400_465600 0 2.466518e-07
I8315 n1_m1_398400_470400 0 8.032634e-08
I8316 n1_m1_403200_0 0 1.853659e-07
I8317 n1_m1_403200_4800 0 2.404873e-07
I8318 n1_m1_403200_9600 0 2.815924e-07
I8319 n1_m1_403200_14400 0 1.536340e-07
I8320 n1_m1_403200_19200 0 1.469516e-07
I8321 n1_m1_403200_24000 0 2.111198e-07
I8322 n1_m1_403200_28800 0 1.443955e-07
I8323 n1_m1_403200_33600 0 4.190043e-07
I8324 n1_m1_403200_38400 0 2.164066e-07
I8325 n1_m1_403200_43200 0 1.736690e-07
I8326 n1_m1_403200_48000 0 2.289677e-07
I8327 n1_m1_403200_52800 0 1.452795e-07
I8328 n1_m1_403200_57600 0 2.094911e-07
I8329 n1_m1_403200_62400 0 1.399040e-07
I8330 n1_m1_403200_67200 0 1.393896e-07
I8331 n1_m1_403200_72000 0 2.025444e-07
I8332 n1_m1_403200_76800 0 1.334871e-07
I8333 n1_m1_403200_81600 0 1.998628e-07
I8334 n1_m1_403200_86400 0 1.334991e-07
I8335 n1_m1_403200_91200 0 1.344421e-07
I8336 n1_m1_403200_96000 0 2.075928e-07
I8337 n1_m1_403200_100800 0 1.399040e-07
I8338 n1_m1_403200_105600 0 2.103703e-07
I8339 n1_m1_403200_110400 0 1.400954e-07
I8340 n1_m1_403200_115200 0 1.404991e-07
I8341 n1_m1_403200_120000 0 2.215450e-07
I8342 n1_m1_403200_124800 0 1.632495e-07
I8343 n1_m1_403200_129600 0 2.213143e-07
I8344 n1_m1_403200_134400 0 1.369002e-07
I8345 n1_m1_403200_139200 0 1.399040e-07
I8346 n1_m1_403200_144000 0 2.092429e-07
I8347 n1_m1_403200_148800 0 1.414560e-07
I8348 n1_m1_403200_153600 0 2.256394e-07
I8349 n1_m1_403200_158400 0 1.494322e-07
I8350 n1_m1_403200_163200 0 1.413962e-07
I8351 n1_m1_403200_168000 0 2.019822e-07
I8352 n1_m1_403200_172800 0 1.385207e-07
I8353 n1_m1_403200_177600 0 2.119001e-07
I8354 n1_m1_403200_182400 0 1.427683e-07
I8355 n1_m1_403200_187200 0 1.448745e-07
I8356 n1_m1_403200_192000 0 2.288734e-07
I8357 n1_m1_403200_196800 0 1.749771e-07
I8358 n1_m1_403200_201600 0 3.186138e-07
I8359 n1_m1_403200_206400 0 2.266282e-07
I8360 n1_m1_403200_211200 0 1.745144e-07
I8361 n1_m1_403200_216000 0 2.389210e-07
I8362 n1_m1_403200_220800 0 1.406102e-07
I8363 n1_m1_403200_225600 0 2.042666e-07
I8364 n1_m1_403200_230400 0 1.442568e-07
I8365 n1_m1_403200_235200 0 1.404544e-07
I8366 n1_m1_403200_240000 0 2.026293e-07
I8367 n1_m1_403200_244800 0 1.361941e-07
I8368 n1_m1_403200_249600 0 2.181844e-07
I8369 n1_m1_403200_254400 0 1.410075e-07
I8370 n1_m1_403200_259200 0 1.407696e-07
I8371 n1_m1_403200_264000 0 2.200845e-07
I8372 n1_m1_403200_268800 0 1.533413e-07
I8373 n1_m1_403200_273600 0 2.439810e-07
I8374 n1_m1_403200_278400 0 1.823854e-07
I8375 n1_m1_403200_283200 0 1.608068e-07
I8376 n1_m1_403200_288000 0 2.393078e-07
I8377 n1_m1_403200_292800 0 1.401871e-07
I8378 n1_m1_403200_297600 0 2.098560e-07
I8379 n1_m1_403200_302400 0 1.399040e-07
I8380 n1_m1_403200_307200 0 1.400673e-07
I8381 n1_m1_403200_312000 0 2.114187e-07
I8382 n1_m1_403200_316800 0 1.401932e-07
I8383 n1_m1_403200_321600 0 2.088530e-07
I8384 n1_m1_403200_326400 0 1.395870e-07
I8385 n1_m1_403200_331200 0 1.395750e-07
I8386 n1_m1_403200_336000 0 2.174610e-07
I8387 n1_m1_403200_340800 0 1.571277e-07
I8388 n1_m1_403200_345600 0 2.819091e-07
I8389 n1_m1_403200_350400 0 1.575050e-07
I8390 n1_m1_403200_355200 0 1.403031e-07
I8391 n1_m1_403200_360000 0 2.003427e-07
I8392 n1_m1_403200_364800 0 1.332419e-07
I8393 n1_m1_403200_369600 0 1.998628e-07
I8394 n1_m1_403200_374400 0 1.358339e-07
I8395 n1_m1_403200_379200 0 1.390207e-07
I8396 n1_m1_403200_384000 0 2.083486e-07
I8397 n1_m1_403200_388800 0 1.390969e-07
I8398 n1_m1_403200_393600 0 2.098560e-07
I8399 n1_m1_403200_398400 0 1.399907e-07
I8400 n1_m1_403200_403200 0 1.413373e-07
I8401 n1_m1_403200_408000 0 2.178891e-07
I8402 n1_m1_403200_412800 0 1.412943e-07
I8403 n1_m1_403200_417600 0 2.098560e-07
I8404 n1_m1_403200_422400 0 1.399040e-07
I8405 n1_m1_403200_427200 0 1.399040e-07
I8406 n1_m1_403200_432000 0 2.098560e-07
I8407 n1_m1_403200_436800 0 1.399040e-07
I8408 n1_m1_403200_441600 0 2.055437e-07
I8409 n1_m1_403200_446400 0 1.391264e-07
I8410 n1_m1_403200_451200 0 1.399040e-07
I8411 n1_m1_403200_456000 0 2.192281e-07
I8412 n1_m1_403200_460800 0 1.641366e-07
I8413 n1_m1_403200_465600 0 2.468242e-07
I8414 n1_m1_403200_470400 0 8.028280e-08
I8415 n1_m1_408000_0 0 2.549873e-07
I8416 n1_m1_408000_4800 0 3.073580e-07
I8417 n1_m1_408000_9600 0 3.935556e-07
I8418 n1_m1_408000_14400 0 2.271301e-07
I8419 n1_m1_408000_19200 0 2.198168e-07
I8420 n1_m1_408000_24000 0 3.186157e-07
I8421 n1_m1_408000_28800 0 2.178740e-07
I8422 n1_m1_408000_33600 0 5.152891e-07
I8423 n1_m1_408000_38400 0 2.610783e-07
I8424 n1_m1_408000_43200 0 2.457362e-07
I8425 n1_m1_408000_48000 0 3.436276e-07
I8426 n1_m1_408000_52800 0 2.247488e-07
I8427 n1_m1_408000_57600 0 3.151984e-07
I8428 n1_m1_408000_62400 0 2.098560e-07
I8429 n1_m1_408000_67200 0 2.098111e-07
I8430 n1_m1_408000_72000 0 3.087672e-07
I8431 n1_m1_408000_76800 0 1.998628e-07
I8432 n1_m1_408000_81600 0 2.997942e-07
I8433 n1_m1_408000_86400 0 1.998628e-07
I8434 n1_m1_408000_91200 0 2.041611e-07
I8435 n1_m1_408000_96000 0 3.145866e-07
I8436 n1_m1_408000_100800 0 2.098560e-07
I8437 n1_m1_408000_105600 0 3.147839e-07
I8438 n1_m1_408000_110400 0 2.098560e-07
I8439 n1_m1_408000_115200 0 2.098560e-07
I8440 n1_m1_408000_120000 0 3.267184e-07
I8441 n1_m1_408000_124800 0 2.369560e-07
I8442 n1_m1_408000_129600 0 3.319594e-07
I8443 n1_m1_408000_134400 0 2.095940e-07
I8444 n1_m1_408000_139200 0 2.098560e-07
I8445 n1_m1_408000_144000 0 3.156172e-07
I8446 n1_m1_408000_148800 0 2.196363e-07
I8447 n1_m1_408000_153600 0 3.725585e-07
I8448 n1_m1_408000_158400 0 2.521068e-07
I8449 n1_m1_408000_163200 0 2.298623e-07
I8450 n1_m1_408000_168000 0 3.104182e-07
I8451 n1_m1_408000_172800 0 2.067225e-07
I8452 n1_m1_408000_177600 0 3.207659e-07
I8453 n1_m1_408000_182400 0 2.093055e-07
I8454 n1_m1_408000_187200 0 2.099407e-07
I8455 n1_m1_408000_192000 0 3.412280e-07
I8456 n1_m1_408000_196800 0 2.697201e-07
I8457 n1_m1_408000_201600 0 6.000001e-07
I8458 n1_m1_408000_206400 0 4.785153e-07
I8459 n1_m1_408000_211200 0 2.928183e-07
I8460 n1_m1_408000_216000 0 3.597699e-07
I8461 n1_m1_408000_220800 0 2.088806e-07
I8462 n1_m1_408000_225600 0 3.063999e-07
I8463 n1_m1_408000_230400 0 2.177743e-07
I8464 n1_m1_408000_235200 0 2.146408e-07
I8465 n1_m1_408000_240000 0 3.058429e-07
I8466 n1_m1_408000_244800 0 2.023787e-07
I8467 n1_m1_408000_249600 0 3.193528e-07
I8468 n1_m1_408000_254400 0 2.150219e-07
I8469 n1_m1_408000_259200 0 2.197397e-07
I8470 n1_m1_408000_264000 0 3.396380e-07
I8471 n1_m1_408000_268800 0 2.215515e-07
I8472 n1_m1_408000_273600 0 3.442976e-07
I8473 n1_m1_408000_278400 0 2.494474e-07
I8474 n1_m1_408000_283200 0 2.251493e-07
I8475 n1_m1_408000_288000 0 3.473449e-07
I8476 n1_m1_408000_292800 0 2.069554e-07
I8477 n1_m1_408000_297600 0 3.147839e-07
I8478 n1_m1_408000_302400 0 2.098560e-07
I8479 n1_m1_408000_307200 0 2.112752e-07
I8480 n1_m1_408000_312000 0 3.283681e-07
I8481 n1_m1_408000_316800 0 2.123700e-07
I8482 n1_m1_408000_321600 0 3.060658e-07
I8483 n1_m1_408000_326400 0 2.098560e-07
I8484 n1_m1_408000_331200 0 2.098560e-07
I8485 n1_m1_408000_336000 0 3.259627e-07
I8486 n1_m1_408000_340800 0 2.328734e-07
I8487 n1_m1_408000_345600 0 4.096976e-07
I8488 n1_m1_408000_350400 0 2.321227e-07
I8489 n1_m1_408000_355200 0 2.100526e-07
I8490 n1_m1_408000_360000 0 3.005141e-07
I8491 n1_m1_408000_364800 0 1.998628e-07
I8492 n1_m1_408000_369600 0 3.015382e-07
I8493 n1_m1_408000_374400 0 2.025018e-07
I8494 n1_m1_408000_379200 0 2.055577e-07
I8495 n1_m1_408000_384000 0 3.091099e-07
I8496 n1_m1_408000_388800 0 2.061932e-07
I8497 n1_m1_408000_393600 0 3.186595e-07
I8498 n1_m1_408000_398400 0 2.149910e-07
I8499 n1_m1_408000_403200 0 2.170763e-07
I8500 n1_m1_408000_408000 0 3.191127e-07
I8501 n1_m1_408000_412800 0 2.111051e-07
I8502 n1_m1_408000_417600 0 3.147839e-07
I8503 n1_m1_408000_422400 0 2.098560e-07
I8504 n1_m1_408000_427200 0 2.098560e-07
I8505 n1_m1_408000_432000 0 3.147839e-07
I8506 n1_m1_408000_436800 0 2.098560e-07
I8507 n1_m1_408000_441600 0 3.144556e-07
I8508 n1_m1_408000_446400 0 2.097968e-07
I8509 n1_m1_408000_451200 0 2.098560e-07
I8510 n1_m1_408000_456000 0 3.320588e-07
I8511 n1_m1_408000_460800 0 2.565490e-07
I8512 n1_m1_408000_465600 0 3.734858e-07
I8513 n1_m1_408000_470400 0 1.178942e-07
I8514 n1_m1_412800_0 0 1.640581e-07
I8515 n1_m1_412800_4800 0 1.792445e-07
I8516 n1_m1_412800_9600 0 2.377241e-07
I8517 n1_m1_412800_14400 0 1.507094e-07
I8518 n1_m1_412800_19200 0 1.504019e-07
I8519 n1_m1_412800_24000 0 2.150572e-07
I8520 n1_m1_412800_28800 0 1.465661e-07
I8521 n1_m1_412800_33600 0 2.691825e-07
I8522 n1_m1_412800_38400 0 1.606316e-07
I8523 n1_m1_412800_43200 0 1.648868e-07
I8524 n1_m1_412800_48000 0 2.288307e-07
I8525 n1_m1_412800_52800 0 1.472930e-07
I8526 n1_m1_412800_57600 0 2.135681e-07
I8527 n1_m1_412800_62400 0 1.399040e-07
I8528 n1_m1_412800_67200 0 1.399040e-07
I8529 n1_m1_412800_72000 0 2.061534e-07
I8530 n1_m1_412800_76800 0 1.333830e-07
I8531 n1_m1_412800_81600 0 2.074589e-07
I8532 n1_m1_412800_86400 0 1.414142e-07
I8533 n1_m1_412800_91200 0 1.389865e-07
I8534 n1_m1_412800_96000 0 2.098560e-07
I8535 n1_m1_412800_100800 0 1.399040e-07
I8536 n1_m1_412800_105600 0 2.098560e-07
I8537 n1_m1_412800_110400 0 1.399040e-07
I8538 n1_m1_412800_115200 0 1.404756e-07
I8539 n1_m1_412800_120000 0 2.187270e-07
I8540 n1_m1_412800_124800 0 1.493466e-07
I8541 n1_m1_412800_129600 0 2.140127e-07
I8542 n1_m1_412800_134400 0 1.399040e-07
I8543 n1_m1_412800_139200 0 1.399040e-07
I8544 n1_m1_412800_144000 0 2.110698e-07
I8545 n1_m1_412800_148800 0 1.473777e-07
I8546 n1_m1_412800_153600 0 2.298140e-07
I8547 n1_m1_412800_158400 0 1.532776e-07
I8548 n1_m1_412800_163200 0 1.497771e-07
I8549 n1_m1_412800_168000 0 2.168780e-07
I8550 n1_m1_412800_172800 0 1.443783e-07
I8551 n1_m1_412800_177600 0 2.173438e-07
I8552 n1_m1_412800_182400 0 1.392406e-07
I8553 n1_m1_412800_187200 0 1.446747e-07
I8554 n1_m1_412800_192000 0 2.304928e-07
I8555 n1_m1_412800_196800 0 1.686443e-07
I8556 n1_m1_412800_201600 0 3.199735e-07
I8557 n1_m1_412800_206400 0 2.325124e-07
I8558 n1_m1_412800_211200 0 1.815138e-07
I8559 n1_m1_412800_216000 0 2.353893e-07
I8560 n1_m1_412800_220800 0 1.377873e-07
I8561 n1_m1_412800_225600 0 2.009979e-07
I8562 n1_m1_412800_230400 0 1.359399e-07
I8563 n1_m1_412800_235200 0 1.358813e-07
I8564 n1_m1_412800_240000 0 2.013047e-07
I8565 n1_m1_412800_244800 0 1.336441e-07
I8566 n1_m1_412800_249600 0 2.064332e-07
I8567 n1_m1_412800_254400 0 1.419294e-07
I8568 n1_m1_412800_259200 0 1.475894e-07
I8569 n1_m1_412800_264000 0 2.204631e-07
I8570 n1_m1_412800_268800 0 1.456345e-07
I8571 n1_m1_412800_273600 0 2.285924e-07
I8572 n1_m1_412800_278400 0 1.570673e-07
I8573 n1_m1_412800_283200 0 1.525930e-07
I8574 n1_m1_412800_288000 0 2.308852e-07
I8575 n1_m1_412800_292800 0 1.486863e-07
I8576 n1_m1_412800_297600 0 2.132858e-07
I8577 n1_m1_412800_302400 0 1.399040e-07
I8578 n1_m1_412800_307200 0 1.401510e-07
I8579 n1_m1_412800_312000 0 2.122202e-07
I8580 n1_m1_412800_316800 0 1.404650e-07
I8581 n1_m1_412800_321600 0 2.127937e-07
I8582 n1_m1_412800_326400 0 1.399040e-07
I8583 n1_m1_412800_331200 0 1.425716e-07
I8584 n1_m1_412800_336000 0 2.192139e-07
I8585 n1_m1_412800_340800 0 1.500100e-07
I8586 n1_m1_412800_345600 0 2.404988e-07
I8587 n1_m1_412800_350400 0 1.517955e-07
I8588 n1_m1_412800_355200 0 1.409767e-07
I8589 n1_m1_412800_360000 0 2.074777e-07
I8590 n1_m1_412800_364800 0 1.382385e-07
I8591 n1_m1_412800_369600 0 2.079928e-07
I8592 n1_m1_412800_374400 0 1.391277e-07
I8593 n1_m1_412800_379200 0 1.392337e-07
I8594 n1_m1_412800_384000 0 2.111898e-07
I8595 n1_m1_412800_388800 0 1.489843e-07
I8596 n1_m1_412800_393600 0 2.404310e-07
I8597 n1_m1_412800_398400 0 1.525151e-07
I8598 n1_m1_412800_403200 0 1.478928e-07
I8599 n1_m1_412800_408000 0 2.218271e-07
I8600 n1_m1_412800_412800 0 1.427481e-07
I8601 n1_m1_412800_417600 0 2.098560e-07
I8602 n1_m1_412800_422400 0 1.399040e-07
I8603 n1_m1_412800_427200 0 1.399040e-07
I8604 n1_m1_412800_432000 0 2.098560e-07
I8605 n1_m1_412800_436800 0 1.399040e-07
I8606 n1_m1_412800_441600 0 2.061035e-07
I8607 n1_m1_412800_446400 0 1.399842e-07
I8608 n1_m1_412800_451200 0 1.444273e-07
I8609 n1_m1_412800_456000 0 2.243799e-07
I8610 n1_m1_412800_460800 0 1.660654e-07
I8611 n1_m1_412800_465600 0 2.399342e-07
I8612 n1_m1_412800_470400 0 7.583072e-08
I8613 n1_m1_417600_0 0 2.363575e-07
I8614 n1_m1_417600_4800 0 2.497710e-07
I8615 n1_m1_417600_9600 0 3.300580e-07
I8616 n1_m1_417600_14400 0 2.188275e-07
I8617 n1_m1_417600_19200 0 2.244647e-07
I8618 n1_m1_417600_24000 0 3.225654e-07
I8619 n1_m1_417600_28800 0 2.198491e-07
I8620 n1_m1_417600_33600 0 3.988831e-07
I8621 n1_m1_417600_38400 0 2.450585e-07
I8622 n1_m1_417600_43200 0 2.524821e-07
I8623 n1_m1_417600_48000 0 3.367812e-07
I8624 n1_m1_417600_52800 0 2.112392e-07
I8625 n1_m1_417600_57600 0 3.158214e-07
I8626 n1_m1_417600_62400 0 2.098560e-07
I8627 n1_m1_417600_67200 0 2.098560e-07
I8628 n1_m1_417600_72000 0 3.139986e-07
I8629 n1_m1_417600_76800 0 2.084727e-07
I8630 n1_m1_417600_81600 0 3.172094e-07
I8631 n1_m1_417600_86400 0 2.162075e-07
I8632 n1_m1_417600_91200 0 2.098560e-07
I8633 n1_m1_417600_96000 0 3.147839e-07
I8634 n1_m1_417600_100800 0 2.098560e-07
I8635 n1_m1_417600_105600 0 3.147839e-07
I8636 n1_m1_417600_110400 0 2.098560e-07
I8637 n1_m1_417600_115200 0 2.109992e-07
I8638 n1_m1_417600_120000 0 3.286304e-07
I8639 n1_m1_417600_124800 0 2.198491e-07
I8640 n1_m1_417600_129600 0 3.173669e-07
I8641 n1_m1_417600_134400 0 2.098560e-07
I8642 n1_m1_417600_139200 0 2.098560e-07
I8643 n1_m1_417600_144000 0 3.166047e-07
I8644 n1_m1_417600_148800 0 2.193833e-07
I8645 n1_m1_417600_153600 0 3.297737e-07
I8646 n1_m1_417600_158400 0 2.198491e-07
I8647 n1_m1_417600_163200 0 2.198491e-07
I8648 n1_m1_417600_168000 0 3.297737e-07
I8649 n1_m1_417600_172800 0 2.198491e-07
I8650 n1_m1_417600_177600 0 3.266402e-07
I8651 n1_m1_417600_182400 0 2.098560e-07
I8652 n1_m1_417600_187200 0 2.182286e-07
I8653 n1_m1_417600_192000 0 3.438802e-07
I8654 n1_m1_417600_196800 0 2.372187e-07
I8655 n1_m1_417600_201600 0 4.042939e-07
I8656 n1_m1_417600_206400 0 2.763476e-07
I8657 n1_m1_417600_211200 0 2.596200e-07
I8658 n1_m1_417600_216000 0 3.493365e-07
I8659 n1_m1_417600_220800 0 2.118471e-07
I8660 n1_m1_417600_225600 0 3.052132e-07
I8661 n1_m1_417600_230400 0 2.049898e-07
I8662 n1_m1_417600_235200 0 2.071460e-07
I8663 n1_m1_417600_240000 0 3.051461e-07
I8664 n1_m1_417600_244800 0 2.025164e-07
I8665 n1_m1_417600_249600 0 3.097675e-07
I8666 n1_m1_417600_254400 0 2.127638e-07
I8667 n1_m1_417600_259200 0 2.192561e-07
I8668 n1_m1_417600_264000 0 3.271663e-07
I8669 n1_m1_417600_268800 0 2.177965e-07
I8670 n1_m1_417600_273600 0 3.560634e-07
I8671 n1_m1_417600_278400 0 2.584633e-07
I8672 n1_m1_417600_283200 0 2.574963e-07
I8673 n1_m1_417600_288000 0 3.543208e-07
I8674 n1_m1_417600_292800 0 2.204618e-07
I8675 n1_m1_417600_297600 0 3.198221e-07
I8676 n1_m1_417600_302400 0 2.098560e-07
I8677 n1_m1_417600_307200 0 2.098560e-07
I8678 n1_m1_417600_312000 0 3.147839e-07
I8679 n1_m1_417600_316800 0 2.142141e-07
I8680 n1_m1_417600_321600 0 3.197992e-07
I8681 n1_m1_417600_326400 0 2.098560e-07
I8682 n1_m1_417600_331200 0 2.151913e-07
I8683 n1_m1_417600_336000 0 3.297737e-07
I8684 n1_m1_417600_340800 0 2.217462e-07
I8685 n1_m1_417600_345600 0 3.429868e-07
I8686 n1_m1_417600_350400 0 2.275557e-07
I8687 n1_m1_417600_355200 0 2.121425e-07
I8688 n1_m1_417600_360000 0 3.147839e-07
I8689 n1_m1_417600_364800 0 2.098560e-07
I8690 n1_m1_417600_369600 0 3.147839e-07
I8691 n1_m1_417600_374400 0 2.098560e-07
I8692 n1_m1_417600_379200 0 2.131370e-07
I8693 n1_m1_417600_384000 0 3.319894e-07
I8694 n1_m1_417600_388800 0 2.367748e-07
I8695 n1_m1_417600_393600 0 3.743857e-07
I8696 n1_m1_417600_398400 0 2.261793e-07
I8697 n1_m1_417600_403200 0 2.125789e-07
I8698 n1_m1_417600_408000 0 3.178083e-07
I8699 n1_m1_417600_412800 0 2.105476e-07
I8700 n1_m1_417600_417600 0 3.147839e-07
I8701 n1_m1_417600_422400 0 2.098560e-07
I8702 n1_m1_417600_427200 0 2.098560e-07
I8703 n1_m1_417600_432000 0 3.147839e-07
I8704 n1_m1_417600_436800 0 2.098560e-07
I8705 n1_m1_417600_441600 0 3.165351e-07
I8706 n1_m1_417600_446400 0 2.172727e-07
I8707 n1_m1_417600_451200 0 2.173194e-07
I8708 n1_m1_417600_456000 0 3.346889e-07
I8709 n1_m1_417600_460800 0 2.467176e-07
I8710 n1_m1_417600_465600 0 3.563223e-07
I8711 n1_m1_417600_470400 0 1.125147e-07
I8712 n1_m1_422400_0 0 7.528109e-08
I8713 n1_m1_422400_4800 0 7.865281e-08
I8714 n1_m1_422400_9600 0 1.052787e-07
I8715 n1_m1_422400_14400 0 7.132900e-08
I8716 n1_m1_422400_19200 0 7.276701e-08
I8717 n1_m1_422400_24000 0 1.062345e-07
I8718 n1_m1_422400_28800 0 7.302586e-08
I8719 n1_m1_422400_33600 0 1.427084e-07
I8720 n1_m1_422400_38400 0 8.513930e-08
I8721 n1_m1_422400_43200 0 8.761797e-08
I8722 n1_m1_422400_48000 0 1.143728e-07
I8723 n1_m1_422400_52800 0 7.051119e-08
I8724 n1_m1_422400_57600 0 1.049429e-07
I8725 n1_m1_422400_62400 0 6.999684e-08
I8726 n1_m1_422400_67200 0 7.054109e-08
I8727 n1_m1_422400_72000 0 1.055859e-07
I8728 n1_m1_422400_76800 0 6.995199e-08
I8729 n1_m1_422400_81600 0 1.058595e-07
I8730 n1_m1_422400_86400 0 7.206918e-08
I8731 n1_m1_422400_91200 0 6.995199e-08
I8732 n1_m1_422400_96000 0 1.049280e-07
I8733 n1_m1_422400_100800 0 6.995199e-08
I8734 n1_m1_422400_105600 0 1.049280e-07
I8735 n1_m1_422400_110400 0 6.995199e-08
I8736 n1_m1_422400_115200 0 7.033308e-08
I8737 n1_m1_422400_120000 0 1.095435e-07
I8738 n1_m1_422400_124800 0 7.328303e-08
I8739 n1_m1_422400_129600 0 1.057890e-07
I8740 n1_m1_422400_134400 0 6.995199e-08
I8741 n1_m1_422400_139200 0 6.995199e-08
I8742 n1_m1_422400_144000 0 1.055349e-07
I8743 n1_m1_422400_148800 0 7.312777e-08
I8744 n1_m1_422400_153600 0 1.099246e-07
I8745 n1_m1_422400_158400 0 7.328303e-08
I8746 n1_m1_422400_163200 0 7.328303e-08
I8747 n1_m1_422400_168000 0 1.099246e-07
I8748 n1_m1_422400_172800 0 7.328303e-08
I8749 n1_m1_422400_177600 0 1.088801e-07
I8750 n1_m1_422400_182400 0 6.995199e-08
I8751 n1_m1_422400_187200 0 7.190196e-08
I8752 n1_m1_422400_192000 0 1.137865e-07
I8753 n1_m1_422400_196800 0 7.800222e-08
I8754 n1_m1_422400_201600 0 1.315246e-07
I8755 n1_m1_422400_206400 0 9.012020e-08
I8756 n1_m1_422400_211200 0 8.619790e-08
I8757 n1_m1_422400_216000 0 1.168821e-07
I8758 n1_m1_422400_220800 0 7.114934e-08
I8759 n1_m1_422400_225600 0 1.049280e-07
I8760 n1_m1_422400_230400 0 6.995199e-08
I8761 n1_m1_422400_235200 0 6.863933e-08
I8762 n1_m1_422400_240000 0 1.038378e-07
I8763 n1_m1_422400_244800 0 6.995199e-08
I8764 n1_m1_422400_249600 0 1.056348e-07
I8765 n1_m1_422400_254400 0 7.289572e-08
I8766 n1_m1_422400_259200 0 7.426316e-08
I8767 n1_m1_422400_264000 0 1.130189e-07
I8768 n1_m1_422400_268800 0 7.449713e-08
I8769 n1_m1_422400_273600 0 1.277710e-07
I8770 n1_m1_422400_278400 0 1.024507e-07
I8771 n1_m1_422400_283200 0 1.037488e-07
I8772 n1_m1_422400_288000 0 1.256756e-07
I8773 n1_m1_422400_292800 0 7.260637e-08
I8774 n1_m1_422400_297600 0 1.049280e-07
I8775 n1_m1_422400_302400 0 6.995199e-08
I8776 n1_m1_422400_307200 0 6.995199e-08
I8777 n1_m1_422400_312000 0 1.049280e-07
I8778 n1_m1_422400_316800 0 6.996311e-08
I8779 n1_m1_422400_321600 0 1.073197e-07
I8780 n1_m1_422400_326400 0 7.026897e-08
I8781 n1_m1_422400_331200 0 7.168258e-08
I8782 n1_m1_422400_336000 0 1.096554e-07
I8783 n1_m1_422400_340800 0 7.328303e-08
I8784 n1_m1_422400_345600 0 1.121049e-07
I8785 n1_m1_422400_350400 0 7.522690e-08
I8786 n1_m1_422400_355200 0 7.063344e-08
I8787 n1_m1_422400_360000 0 1.049280e-07
I8788 n1_m1_422400_364800 0 6.995199e-08
I8789 n1_m1_422400_369600 0 1.049280e-07
I8790 n1_m1_422400_374400 0 6.995199e-08
I8791 n1_m1_422400_379200 0 6.995199e-08
I8792 n1_m1_422400_384000 0 1.140429e-07
I8793 n1_m1_422400_388800 0 8.222679e-08
I8794 n1_m1_422400_393600 0 1.265516e-07
I8795 n1_m1_422400_398400 0 7.687018e-08
I8796 n1_m1_422400_403200 0 7.128869e-08
I8797 n1_m1_422400_408000 0 1.059866e-07
I8798 n1_m1_422400_412800 0 7.012842e-08
I8799 n1_m1_422400_417600 0 1.049280e-07
I8800 n1_m1_422400_422400 0 6.995199e-08
I8801 n1_m1_422400_427200 0 6.995199e-08
I8802 n1_m1_422400_432000 0 1.049280e-07
I8803 n1_m1_422400_436800 0 6.995199e-08
I8804 n1_m1_422400_441600 0 1.072601e-07
I8805 n1_m1_422400_446400 0 7.283950e-08
I8806 n1_m1_422400_451200 0 7.091358e-08
I8807 n1_m1_422400_456000 0 1.106726e-07
I8808 n1_m1_422400_460800 0 8.426527e-08
I8809 n1_m1_422400_465600 0 1.214280e-07
I8810 n1_m1_422400_470400 0 3.778480e-08
I8811 n1_m1_427200_0 0 1.557688e-07
I8812 n1_m1_427200_4800 0 1.649151e-07
I8813 n1_m1_427200_9600 0 2.163205e-07
I8814 n1_m1_427200_14400 0 1.424056e-07
I8815 n1_m1_427200_19200 0 1.447673e-07
I8816 n1_m1_427200_24000 0 2.052828e-07
I8817 n1_m1_427200_28800 0 1.417341e-07
I8818 n1_m1_427200_33600 0 2.711045e-07
I8819 n1_m1_427200_38400 0 1.654954e-07
I8820 n1_m1_427200_43200 0 1.768254e-07
I8821 n1_m1_427200_48000 0 2.373306e-07
I8822 n1_m1_427200_52800 0 1.451828e-07
I8823 n1_m1_427200_57600 0 2.100773e-07
I8824 n1_m1_427200_62400 0 1.430843e-07
I8825 n1_m1_427200_67200 0 1.460902e-07
I8826 n1_m1_427200_72000 0 2.160664e-07
I8827 n1_m1_427200_76800 0 1.399040e-07
I8828 n1_m1_427200_81600 0 2.117191e-07
I8829 n1_m1_427200_86400 0 1.441384e-07
I8830 n1_m1_427200_91200 0 1.399040e-07
I8831 n1_m1_427200_96000 0 2.098560e-07
I8832 n1_m1_427200_100800 0 1.399040e-07
I8833 n1_m1_427200_105600 0 2.098560e-07
I8834 n1_m1_427200_110400 0 1.399040e-07
I8835 n1_m1_427200_115200 0 1.406662e-07
I8836 n1_m1_427200_120000 0 2.190869e-07
I8837 n1_m1_427200_124800 0 1.440336e-07
I8838 n1_m1_427200_129600 0 2.106002e-07
I8839 n1_m1_427200_134400 0 1.399040e-07
I8840 n1_m1_427200_139200 0 1.399040e-07
I8841 n1_m1_427200_144000 0 2.110698e-07
I8842 n1_m1_427200_148800 0 1.462555e-07
I8843 n1_m1_427200_153600 0 2.198491e-07
I8844 n1_m1_427200_158400 0 1.465661e-07
I8845 n1_m1_427200_163200 0 1.465661e-07
I8846 n1_m1_427200_168000 0 2.198491e-07
I8847 n1_m1_427200_172800 0 1.465661e-07
I8848 n1_m1_427200_177600 0 2.189462e-07
I8849 n1_m1_427200_182400 0 1.436867e-07
I8850 n1_m1_427200_187200 0 1.482957e-07
I8851 n1_m1_427200_192000 0 2.291210e-07
I8852 n1_m1_427200_196800 0 1.520239e-07
I8853 n1_m1_427200_201600 0 2.524687e-07
I8854 n1_m1_427200_206400 0 1.755010e-07
I8855 n1_m1_427200_211200 0 1.691100e-07
I8856 n1_m1_427200_216000 0 2.343037e-07
I8857 n1_m1_427200_220800 0 1.427341e-07
I8858 n1_m1_427200_225600 0 2.098560e-07
I8859 n1_m1_427200_230400 0 1.399040e-07
I8860 n1_m1_427200_235200 0 1.417953e-07
I8861 n1_m1_427200_240000 0 2.147767e-07
I8862 n1_m1_427200_244800 0 1.409298e-07
I8863 n1_m1_427200_249600 0 2.178238e-07
I8864 n1_m1_427200_254400 0 1.468467e-07
I8865 n1_m1_427200_259200 0 1.495962e-07
I8866 n1_m1_427200_264000 0 2.319099e-07
I8867 n1_m1_427200_268800 0 1.590850e-07
I8868 n1_m1_427200_273600 0 2.560768e-07
I8869 n1_m1_427200_278400 0 2.128674e-07
I8870 n1_m1_427200_283200 0 2.267471e-07
I8871 n1_m1_427200_288000 0 2.643211e-07
I8872 n1_m1_427200_292800 0 1.453240e-07
I8873 n1_m1_427200_297600 0 2.098560e-07
I8874 n1_m1_427200_302400 0 1.399040e-07
I8875 n1_m1_427200_307200 0 1.399040e-07
I8876 n1_m1_427200_312000 0 2.098560e-07
I8877 n1_m1_427200_316800 0 1.399040e-07
I8878 n1_m1_427200_321600 0 2.098560e-07
I8879 n1_m1_427200_326400 0 1.411973e-07
I8880 n1_m1_427200_331200 0 1.432656e-07
I8881 n1_m1_427200_336000 0 2.187510e-07
I8882 n1_m1_427200_340800 0 1.465661e-07
I8883 n1_m1_427200_345600 0 2.198491e-07
I8884 n1_m1_427200_350400 0 1.458039e-07
I8885 n1_m1_427200_355200 0 1.406662e-07
I8886 n1_m1_427200_360000 0 2.098560e-07
I8887 n1_m1_427200_364800 0 1.399040e-07
I8888 n1_m1_427200_369600 0 2.098560e-07
I8889 n1_m1_427200_374400 0 1.399040e-07
I8890 n1_m1_427200_379200 0 1.399040e-07
I8891 n1_m1_427200_384000 0 2.254571e-07
I8892 n1_m1_427200_388800 0 1.597273e-07
I8893 n1_m1_427200_393600 0 2.398957e-07
I8894 n1_m1_427200_398400 0 1.532636e-07
I8895 n1_m1_427200_403200 0 1.466467e-07
I8896 n1_m1_427200_408000 0 2.144155e-07
I8897 n1_m1_427200_412800 0 1.406238e-07
I8898 n1_m1_427200_417600 0 2.098560e-07
I8899 n1_m1_427200_422400 0 1.399040e-07
I8900 n1_m1_427200_427200 0 1.399040e-07
I8901 n1_m1_427200_432000 0 2.098560e-07
I8902 n1_m1_427200_436800 0 1.399040e-07
I8903 n1_m1_427200_441600 0 2.104488e-07
I8904 n1_m1_427200_446400 0 1.456345e-07
I8905 n1_m1_427200_451200 0 1.472232e-07
I8906 n1_m1_427200_456000 0 2.373476e-07
I8907 n1_m1_427200_460800 0 1.715138e-07
I8908 n1_m1_427200_465600 0 2.379352e-07
I8909 n1_m1_427200_470400 0 7.367824e-08
I8910 n1_m1_432000_0 0 2.440980e-07
I8911 n1_m1_432000_4800 0 2.581266e-07
I8912 n1_m1_432000_9600 0 3.367568e-07
I8913 n1_m1_432000_14400 0 2.189067e-07
I8914 n1_m1_432000_19200 0 2.200509e-07
I8915 n1_m1_432000_24000 0 3.152628e-07
I8916 n1_m1_432000_28800 0 2.104217e-07
I8917 n1_m1_432000_33600 0 3.497424e-07
I8918 n1_m1_432000_38400 0 2.182226e-07
I8919 n1_m1_432000_43200 0 2.338790e-07
I8920 n1_m1_432000_48000 0 3.329017e-07
I8921 n1_m1_432000_52800 0 2.112691e-07
I8922 n1_m1_432000_57600 0 3.150447e-07
I8923 n1_m1_432000_62400 0 2.181953e-07
I8924 n1_m1_432000_67200 0 2.209807e-07
I8925 n1_m1_432000_72000 0 3.242904e-07
I8926 n1_m1_432000_76800 0 2.098560e-07
I8927 n1_m1_432000_81600 0 3.190589e-07
I8928 n1_m1_432000_86400 0 2.162075e-07
I8929 n1_m1_432000_91200 0 2.098560e-07
I8930 n1_m1_432000_96000 0 3.147839e-07
I8931 n1_m1_432000_100800 0 2.098560e-07
I8932 n1_m1_432000_105600 0 3.147839e-07
I8933 n1_m1_432000_110400 0 2.098560e-07
I8934 n1_m1_432000_115200 0 2.101208e-07
I8935 n1_m1_432000_120000 0 3.179913e-07
I8936 n1_m1_432000_124800 0 2.106210e-07
I8937 n1_m1_432000_129600 0 3.147839e-07
I8938 n1_m1_432000_134400 0 2.098560e-07
I8939 n1_m1_432000_139200 0 2.098560e-07
I8940 n1_m1_432000_144000 0 3.166047e-07
I8941 n1_m1_432000_148800 0 2.193833e-07
I8942 n1_m1_432000_153600 0 3.297737e-07
I8943 n1_m1_432000_158400 0 2.198491e-07
I8944 n1_m1_432000_163200 0 2.198491e-07
I8945 n1_m1_432000_168000 0 3.297737e-07
I8946 n1_m1_432000_172800 0 2.198491e-07
I8947 n1_m1_432000_177600 0 3.297737e-07
I8948 n1_m1_432000_182400 0 2.198491e-07
I8949 n1_m1_432000_187200 0 2.246763e-07
I8950 n1_m1_432000_192000 0 3.425618e-07
I8951 n1_m1_432000_196800 0 2.201776e-07
I8952 n1_m1_432000_201600 0 3.570766e-07
I8953 n1_m1_432000_206400 0 2.497015e-07
I8954 n1_m1_432000_211200 0 2.406823e-07
I8955 n1_m1_432000_216000 0 3.392663e-07
I8956 n1_m1_432000_220800 0 2.123595e-07
I8957 n1_m1_432000_225600 0 3.147839e-07
I8958 n1_m1_432000_230400 0 2.098560e-07
I8959 n1_m1_432000_235200 0 2.140762e-07
I8960 n1_m1_432000_240000 0 3.257638e-07
I8961 n1_m1_432000_244800 0 2.106654e-07
I8962 n1_m1_432000_249600 0 3.231360e-07
I8963 n1_m1_432000_254400 0 2.182965e-07
I8964 n1_m1_432000_259200 0 2.186202e-07
I8965 n1_m1_432000_264000 0 3.321822e-07
I8966 n1_m1_432000_268800 0 2.229261e-07
I8967 n1_m1_432000_273600 0 3.389304e-07
I8968 n1_m1_432000_278400 0 2.459642e-07
I8969 n1_m1_432000_283200 0 2.566662e-07
I8970 n1_m1_432000_288000 0 3.535224e-07
I8971 n1_m1_432000_292800 0 2.164633e-07
I8972 n1_m1_432000_297600 0 3.147839e-07
I8973 n1_m1_432000_302400 0 2.098560e-07
I8974 n1_m1_432000_307200 0 2.098560e-07
I8975 n1_m1_432000_312000 0 3.147839e-07
I8976 n1_m1_432000_316800 0 2.098560e-07
I8977 n1_m1_432000_321600 0 3.175820e-07
I8978 n1_m1_432000_326400 0 2.175343e-07
I8979 n1_m1_432000_331200 0 2.187702e-07
I8980 n1_m1_432000_336000 0 3.297737e-07
I8981 n1_m1_432000_340800 0 2.198491e-07
I8982 n1_m1_432000_345600 0 3.297737e-07
I8983 n1_m1_432000_350400 0 2.188835e-07
I8984 n1_m1_432000_355200 0 2.121308e-07
I8985 n1_m1_432000_360000 0 3.148958e-07
I8986 n1_m1_432000_364800 0 2.098560e-07
I8987 n1_m1_432000_369600 0 3.147839e-07
I8988 n1_m1_432000_374400 0 2.098560e-07
I8989 n1_m1_432000_379200 0 2.098560e-07
I8990 n1_m1_432000_384000 0 3.105887e-07
I8991 n1_m1_432000_388800 0 2.133116e-07
I8992 n1_m1_432000_393600 0 3.217283e-07
I8993 n1_m1_432000_398400 0 2.142011e-07
I8994 n1_m1_432000_403200 0 2.117769e-07
I8995 n1_m1_432000_408000 0 3.137666e-07
I8996 n1_m1_432000_412800 0 2.098560e-07
I8997 n1_m1_432000_417600 0 3.147839e-07
I8998 n1_m1_432000_422400 0 2.098560e-07
I8999 n1_m1_432000_427200 0 2.098560e-07
I9000 n1_m1_432000_432000 0 3.147839e-07
I9001 n1_m1_432000_436800 0 2.098560e-07
I9002 n1_m1_432000_441600 0 3.178366e-07
I9003 n1_m1_432000_446400 0 2.289531e-07
I9004 n1_m1_432000_451200 0 2.374254e-07
I9005 n1_m1_432000_456000 0 3.633336e-07
I9006 n1_m1_432000_460800 0 2.481624e-07
I9007 n1_m1_432000_465600 0 3.429816e-07
I9008 n1_m1_432000_470400 0 1.080781e-07
I9009 n1_m1_436800_0 0 1.572903e-07
I9010 n1_m1_436800_4800 0 1.686160e-07
I9011 n1_m1_436800_9600 0 2.241981e-07
I9012 n1_m1_436800_14400 0 1.489909e-07
I9013 n1_m1_436800_19200 0 1.516059e-07
I9014 n1_m1_436800_24000 0 2.152760e-07
I9015 n1_m1_436800_28800 0 1.423317e-07
I9016 n1_m1_436800_33600 0 2.243354e-07
I9017 n1_m1_436800_38400 0 1.399040e-07
I9018 n1_m1_436800_43200 0 1.456627e-07
I9019 n1_m1_436800_48000 0 2.125129e-07
I9020 n1_m1_436800_52800 0 1.399604e-07
I9021 n1_m1_436800_57600 0 2.114339e-07
I9022 n1_m1_436800_62400 0 1.483474e-07
I9023 n1_m1_436800_67200 0 1.517294e-07
I9024 n1_m1_436800_72000 0 2.179429e-07
I9025 n1_m1_436800_76800 0 1.405513e-07
I9026 n1_m1_436800_81600 0 2.162944e-07
I9027 n1_m1_436800_86400 0 1.441384e-07
I9028 n1_m1_436800_91200 0 1.399040e-07
I9029 n1_m1_436800_96000 0 2.098560e-07
I9030 n1_m1_436800_100800 0 1.399040e-07
I9031 n1_m1_436800_105600 0 2.099112e-07
I9032 n1_m1_436800_110400 0 1.413961e-07
I9033 n1_m1_436800_115200 0 1.415539e-07
I9034 n1_m1_436800_120000 0 2.100691e-07
I9035 n1_m1_436800_124800 0 1.399040e-07
I9036 n1_m1_436800_129600 0 2.098560e-07
I9037 n1_m1_436800_134400 0 1.399040e-07
I9038 n1_m1_436800_139200 0 1.399040e-07
I9039 n1_m1_436800_144000 0 2.110698e-07
I9040 n1_m1_436800_148800 0 1.462555e-07
I9041 n1_m1_436800_153600 0 2.198491e-07
I9042 n1_m1_436800_158400 0 1.465661e-07
I9043 n1_m1_436800_163200 0 1.465661e-07
I9044 n1_m1_436800_168000 0 2.198491e-07
I9045 n1_m1_436800_172800 0 1.465661e-07
I9046 n1_m1_436800_177600 0 2.198491e-07
I9047 n1_m1_436800_182400 0 1.465661e-07
I9048 n1_m1_436800_187200 0 1.497842e-07
I9049 n1_m1_436800_192000 0 2.273016e-07
I9050 n1_m1_436800_196800 0 1.419647e-07
I9051 n1_m1_436800_201600 0 2.301506e-07
I9052 n1_m1_436800_206400 0 1.577738e-07
I9053 n1_m1_436800_211200 0 1.516662e-07
I9054 n1_m1_436800_216000 0 2.161953e-07
I9055 n1_m1_436800_220800 0 1.399040e-07
I9056 n1_m1_436800_225600 0 2.098560e-07
I9057 n1_m1_436800_230400 0 1.399040e-07
I9058 n1_m1_436800_235200 0 1.408355e-07
I9059 n1_m1_436800_240000 0 2.106296e-07
I9060 n1_m1_436800_244800 0 1.394540e-07
I9061 n1_m1_436800_249600 0 2.070613e-07
I9062 n1_m1_436800_254400 0 1.380408e-07
I9063 n1_m1_436800_259200 0 1.380408e-07
I9064 n1_m1_436800_264000 0 2.070613e-07
I9065 n1_m1_436800_268800 0 1.393829e-07
I9066 n1_m1_436800_273600 0 2.122165e-07
I9067 n1_m1_436800_278400 0 1.438412e-07
I9068 n1_m1_436800_283200 0 1.456029e-07
I9069 n1_m1_436800_288000 0 2.138200e-07
I9070 n1_m1_436800_292800 0 1.413013e-07
I9071 n1_m1_436800_297600 0 2.098560e-07
I9072 n1_m1_436800_302400 0 1.399040e-07
I9073 n1_m1_436800_307200 0 1.399040e-07
I9074 n1_m1_436800_312000 0 2.098560e-07
I9075 n1_m1_436800_316800 0 1.399040e-07
I9076 n1_m1_436800_321600 0 2.122837e-07
I9077 n1_m1_436800_326400 0 1.465661e-07
I9078 n1_m1_436800_331200 0 1.465661e-07
I9079 n1_m1_436800_336000 0 2.198491e-07
I9080 n1_m1_436800_340800 0 1.465661e-07
I9081 n1_m1_436800_345600 0 2.198491e-07
I9082 n1_m1_436800_350400 0 1.465661e-07
I9083 n1_m1_436800_355200 0 1.458137e-07
I9084 n1_m1_436800_360000 0 2.117490e-07
I9085 n1_m1_436800_364800 0 1.399040e-07
I9086 n1_m1_436800_369600 0 2.098560e-07
I9087 n1_m1_436800_374400 0 1.399040e-07
I9088 n1_m1_436800_379200 0 1.399040e-07
I9089 n1_m1_436800_384000 0 2.061036e-07
I9090 n1_m1_436800_388800 0 1.363940e-07
I9091 n1_m1_436800_393600 0 2.100060e-07
I9092 n1_m1_436800_398400 0 1.414908e-07
I9093 n1_m1_436800_403200 0 1.406662e-07
I9094 n1_m1_436800_408000 0 2.063752e-07
I9095 n1_m1_436800_412800 0 1.399040e-07
I9096 n1_m1_436800_417600 0 2.098560e-07
I9097 n1_m1_436800_422400 0 1.399040e-07
I9098 n1_m1_436800_427200 0 1.399040e-07
I9099 n1_m1_436800_432000 0 2.098560e-07
I9100 n1_m1_436800_436800 0 1.399040e-07
I9101 n1_m1_436800_441600 0 2.204484e-07
I9102 n1_m1_436800_446400 0 1.665117e-07
I9103 n1_m1_436800_451200 0 1.701083e-07
I9104 n1_m1_436800_456000 0 2.298157e-07
I9105 n1_m1_436800_460800 0 1.502612e-07
I9106 n1_m1_436800_465600 0 2.274784e-07
I9107 n1_m1_436800_470400 0 7.476363e-08
I9108 n1_m1_441600_0 0 2.407382e-07
I9109 n1_m1_441600_4800 0 2.361716e-07
I9110 n1_m1_441600_9600 0 3.317839e-07
I9111 n1_m1_441600_14400 0 2.273515e-07
I9112 n1_m1_441600_19200 0 2.251227e-07
I9113 n1_m1_441600_24000 0 3.235190e-07
I9114 n1_m1_441600_28800 0 2.136583e-07
I9115 n1_m1_441600_33600 0 3.395788e-07
I9116 n1_m1_441600_38400 0 2.136138e-07
I9117 n1_m1_441600_43200 0 2.184941e-07
I9118 n1_m1_441600_48000 0 3.256430e-07
I9119 n1_m1_441600_52800 0 2.164437e-07
I9120 n1_m1_441600_57600 0 3.437435e-07
I9121 n1_m1_441600_62400 0 2.522421e-07
I9122 n1_m1_441600_67200 0 2.468060e-07
I9123 n1_m1_441600_72000 0 3.418714e-07
I9124 n1_m1_441600_76800 0 2.159219e-07
I9125 n1_m1_441600_81600 0 3.180685e-07
I9126 n1_m1_441600_86400 0 2.171771e-07
I9127 n1_m1_441600_91200 0 2.101825e-07
I9128 n1_m1_441600_96000 0 3.156814e-07
I9129 n1_m1_441600_100800 0 2.148655e-07
I9130 n1_m1_441600_105600 0 3.235226e-07
I9131 n1_m1_441600_110400 0 2.181589e-07
I9132 n1_m1_441600_115200 0 2.151425e-07
I9133 n1_m1_441600_120000 0 3.237224e-07
I9134 n1_m1_441600_124800 0 2.152178e-07
I9135 n1_m1_441600_129600 0 3.225329e-07
I9136 n1_m1_441600_134400 0 2.130518e-07
I9137 n1_m1_441600_139200 0 2.125401e-07
I9138 n1_m1_441600_144000 0 3.247085e-07
I9139 n1_m1_441600_148800 0 2.183861e-07
I9140 n1_m1_441600_153600 0 3.217735e-07
I9141 n1_m1_441600_158400 0 2.266970e-07
I9142 n1_m1_441600_163200 0 2.244387e-07
I9143 n1_m1_441600_168000 0 3.222928e-07
I9144 n1_m1_441600_172800 0 2.219964e-07
I9145 n1_m1_441600_177600 0 3.299628e-07
I9146 n1_m1_441600_182400 0 2.161480e-07
I9147 n1_m1_441600_187200 0 2.243698e-07
I9148 n1_m1_441600_192000 0 3.365343e-07
I9149 n1_m1_441600_196800 0 2.119782e-07
I9150 n1_m1_441600_201600 0 3.409008e-07
I9151 n1_m1_441600_206400 0 2.270892e-07
I9152 n1_m1_441600_211200 0 2.254726e-07
I9153 n1_m1_441600_216000 0 3.294984e-07
I9154 n1_m1_441600_220800 0 2.063981e-07
I9155 n1_m1_441600_225600 0 3.159897e-07
I9156 n1_m1_441600_230400 0 2.129772e-07
I9157 n1_m1_441600_235200 0 2.087974e-07
I9158 n1_m1_441600_240000 0 3.152978e-07
I9159 n1_m1_441600_244800 0 2.144212e-07
I9160 n1_m1_441600_249600 0 3.083678e-07
I9161 n1_m1_441600_254400 0 2.009591e-07
I9162 n1_m1_441600_259200 0 2.064706e-07
I9163 n1_m1_441600_264000 0 3.169036e-07
I9164 n1_m1_441600_268800 0 2.090988e-07
I9165 n1_m1_441600_273600 0 3.228329e-07
I9166 n1_m1_441600_278400 0 2.220818e-07
I9167 n1_m1_441600_283200 0 2.201556e-07
I9168 n1_m1_441600_288000 0 3.213232e-07
I9169 n1_m1_441600_292800 0 2.097113e-07
I9170 n1_m1_441600_297600 0 3.144556e-07
I9171 n1_m1_441600_302400 0 2.055437e-07
I9172 n1_m1_441600_307200 0 2.046900e-07
I9173 n1_m1_441600_312000 0 3.070350e-07
I9174 n1_m1_441600_316800 0 2.085232e-07
I9175 n1_m1_441600_321600 0 3.262796e-07
I9176 n1_m1_441600_326400 0 2.148891e-07
I9177 n1_m1_441600_331200 0 2.158688e-07
I9178 n1_m1_441600_336000 0 3.219418e-07
I9179 n1_m1_441600_340800 0 2.164706e-07
I9180 n1_m1_441600_345600 0 3.326853e-07
I9181 n1_m1_441600_350400 0 2.238929e-07
I9182 n1_m1_441600_355200 0 2.204401e-07
I9183 n1_m1_441600_360000 0 3.230833e-07
I9184 n1_m1_441600_364800 0 2.099216e-07
I9185 n1_m1_441600_369600 0 3.233866e-07
I9186 n1_m1_441600_374400 0 2.153721e-07
I9187 n1_m1_441600_379200 0 2.066838e-07
I9188 n1_m1_441600_384000 0 3.106766e-07
I9189 n1_m1_441600_388800 0 2.060870e-07
I9190 n1_m1_441600_393600 0 3.151248e-07
I9191 n1_m1_441600_398400 0 2.140972e-07
I9192 n1_m1_441600_403200 0 2.180093e-07
I9193 n1_m1_441600_408000 0 3.228020e-07
I9194 n1_m1_441600_412800 0 2.112695e-07
I9195 n1_m1_441600_417600 0 3.222264e-07
I9196 n1_m1_441600_422400 0 2.131193e-07
I9197 n1_m1_441600_427200 0 2.104488e-07
I9198 n1_m1_441600_432000 0 3.156732e-07
I9199 n1_m1_441600_436800 0 2.104488e-07
I9200 n1_m1_441600_441600 0 3.318729e-07
I9201 n1_m1_441600_446400 0 2.392846e-07
I9202 n1_m1_441600_451200 0 2.350832e-07
I9203 n1_m1_441600_456000 0 3.374802e-07
I9204 n1_m1_441600_460800 0 2.332735e-07
I9205 n1_m1_441600_465600 0 3.479151e-07
I9206 n1_m1_441600_470400 0 1.130630e-07
I9207 n1_m1_446400_0 0 1.623409e-07
I9208 n1_m1_446400_4800 0 1.740221e-07
I9209 n1_m1_446400_9600 0 2.338690e-07
I9210 n1_m1_446400_14400 0 1.436092e-07
I9211 n1_m1_446400_19200 0 1.588973e-07
I9212 n1_m1_446400_24000 0 2.286444e-07
I9213 n1_m1_446400_28800 0 1.442046e-07
I9214 n1_m1_446400_33600 0 2.270081e-07
I9215 n1_m1_446400_38400 0 1.448223e-07
I9216 n1_m1_446400_43200 0 1.456627e-07
I9217 n1_m1_446400_48000 0 2.211729e-07
I9218 n1_m1_446400_52800 0 1.434098e-07
I9219 n1_m1_446400_57600 0 2.357630e-07
I9220 n1_m1_446400_62400 0 1.786459e-07
I9221 n1_m1_446400_67200 0 1.727938e-07
I9222 n1_m1_446400_72000 0 2.381689e-07
I9223 n1_m1_446400_76800 0 1.499600e-07
I9224 n1_m1_446400_81600 0 2.162093e-07
I9225 n1_m1_446400_86400 0 1.532739e-07
I9226 n1_m1_446400_91200 0 1.439357e-07
I9227 n1_m1_446400_96000 0 2.104257e-07
I9228 n1_m1_446400_100800 0 1.420226e-07
I9229 n1_m1_446400_105600 0 2.196322e-07
I9230 n1_m1_446400_110400 0 1.426105e-07
I9231 n1_m1_446400_115200 0 1.421427e-07
I9232 n1_m1_446400_120000 0 2.230755e-07
I9233 n1_m1_446400_124800 0 1.427295e-07
I9234 n1_m1_446400_129600 0 2.115129e-07
I9235 n1_m1_446400_134400 0 1.416891e-07
I9236 n1_m1_446400_139200 0 1.443515e-07
I9237 n1_m1_446400_144000 0 2.253794e-07
I9238 n1_m1_446400_148800 0 1.461713e-07
I9239 n1_m1_446400_153600 0 2.114886e-07
I9240 n1_m1_446400_158400 0 1.468955e-07
I9241 n1_m1_446400_163200 0 1.468102e-07
I9242 n1_m1_446400_168000 0 2.118803e-07
I9243 n1_m1_446400_172800 0 1.493246e-07
I9244 n1_m1_446400_177600 0 2.250664e-07
I9245 n1_m1_446400_182400 0 1.411501e-07
I9246 n1_m1_446400_187200 0 1.472742e-07
I9247 n1_m1_446400_192000 0 2.285116e-07
I9248 n1_m1_446400_196800 0 1.467637e-07
I9249 n1_m1_446400_201600 0 2.295350e-07
I9250 n1_m1_446400_206400 0 1.489488e-07
I9251 n1_m1_446400_211200 0 1.529270e-07
I9252 n1_m1_446400_216000 0 2.301780e-07
I9253 n1_m1_446400_220800 0 1.418236e-07
I9254 n1_m1_446400_225600 0 2.173619e-07
I9255 n1_m1_446400_230400 0 1.417834e-07
I9256 n1_m1_446400_235200 0 1.345828e-07
I9257 n1_m1_446400_240000 0 2.095547e-07
I9258 n1_m1_446400_244800 0 1.463944e-07
I9259 n1_m1_446400_249600 0 2.144488e-07
I9260 n1_m1_446400_254400 0 1.392152e-07
I9261 n1_m1_446400_259200 0 1.407211e-07
I9262 n1_m1_446400_264000 0 2.156219e-07
I9263 n1_m1_446400_268800 0 1.442766e-07
I9264 n1_m1_446400_273600 0 2.198842e-07
I9265 n1_m1_446400_278400 0 1.474656e-07
I9266 n1_m1_446400_283200 0 1.470161e-07
I9267 n1_m1_446400_288000 0 2.197752e-07
I9268 n1_m1_446400_292800 0 1.450358e-07
I9269 n1_m1_446400_297600 0 2.111094e-07
I9270 n1_m1_446400_302400 0 1.400015e-07
I9271 n1_m1_446400_307200 0 1.398475e-07
I9272 n1_m1_446400_312000 0 2.103423e-07
I9273 n1_m1_446400_316800 0 1.407888e-07
I9274 n1_m1_446400_321600 0 2.161732e-07
I9275 n1_m1_446400_326400 0 1.472326e-07
I9276 n1_m1_446400_331200 0 1.562205e-07
I9277 n1_m1_446400_336000 0 2.182957e-07
I9278 n1_m1_446400_340800 0 1.508949e-07
I9279 n1_m1_446400_345600 0 2.438015e-07
I9280 n1_m1_446400_350400 0 1.498031e-07
I9281 n1_m1_446400_355200 0 1.466726e-07
I9282 n1_m1_446400_360000 0 2.159748e-07
I9283 n1_m1_446400_364800 0 1.407798e-07
I9284 n1_m1_446400_369600 0 2.115964e-07
I9285 n1_m1_446400_374400 0 1.408987e-07
I9286 n1_m1_446400_379200 0 1.376803e-07
I9287 n1_m1_446400_384000 0 2.073271e-07
I9288 n1_m1_446400_388800 0 1.394547e-07
I9289 n1_m1_446400_393600 0 2.111686e-07
I9290 n1_m1_446400_398400 0 1.408936e-07
I9291 n1_m1_446400_403200 0 1.416120e-07
I9292 n1_m1_446400_408000 0 2.125660e-07
I9293 n1_m1_446400_412800 0 1.404782e-07
I9294 n1_m1_446400_417600 0 2.173349e-07
I9295 n1_m1_446400_422400 0 1.452410e-07
I9296 n1_m1_446400_427200 0 1.452563e-07
I9297 n1_m1_446400_432000 0 2.184518e-07
I9298 n1_m1_446400_436800 0 1.456345e-07
I9299 n1_m1_446400_441600 0 2.148963e-07
I9300 n1_m1_446400_446400 0 1.464437e-07
I9301 n1_m1_446400_451200 0 1.466569e-07
I9302 n1_m1_446400_456000 0 2.205044e-07
I9303 n1_m1_446400_460800 0 1.532296e-07
I9304 n1_m1_446400_465600 0 2.258922e-07
I9305 n1_m1_446400_470400 0 7.194215e-08
I9306 n1_m1_451200_0 0 8.363646e-08
I9307 n1_m1_451200_4800 0 9.295138e-08
I9308 n1_m1_451200_9600 0 1.197730e-07
I9309 n1_m1_451200_14400 0 7.053822e-08
I9310 n1_m1_451200_19200 0 7.894359e-08
I9311 n1_m1_451200_24000 0 1.181687e-07
I9312 n1_m1_451200_28800 0 7.304644e-08
I9313 n1_m1_451200_33600 0 1.163730e-07
I9314 n1_m1_451200_38400 0 7.387561e-08
I9315 n1_m1_451200_43200 0 7.283137e-08
I9316 n1_m1_451200_48000 0 1.109831e-07
I9317 n1_m1_451200_52800 0 7.210375e-08
I9318 n1_m1_451200_57600 0 1.174469e-07
I9319 n1_m1_451200_62400 0 8.544313e-08
I9320 n1_m1_451200_67200 0 8.359340e-08
I9321 n1_m1_451200_72000 0 1.145433e-07
I9322 n1_m1_451200_76800 0 7.466603e-08
I9323 n1_m1_451200_81600 0 1.078619e-07
I9324 n1_m1_451200_86400 0 7.679016e-08
I9325 n1_m1_451200_91200 0 7.446866e-08
I9326 n1_m1_451200_96000 0 1.061780e-07
I9327 n1_m1_451200_100800 0 7.067183e-08
I9328 n1_m1_451200_105600 0 1.098630e-07
I9329 n1_m1_451200_110400 0 7.276307e-08
I9330 n1_m1_451200_115200 0 7.278233e-08
I9331 n1_m1_451200_120000 0 1.103702e-07
I9332 n1_m1_451200_124800 0 7.105293e-08
I9333 n1_m1_451200_129600 0 1.057234e-07
I9334 n1_m1_451200_134400 0 7.365647e-08
I9335 n1_m1_451200_139200 0 7.561816e-08
I9336 n1_m1_451200_144000 0 1.145112e-07
I9337 n1_m1_451200_148800 0 7.524700e-08
I9338 n1_m1_451200_153600 0 1.089895e-07
I9339 n1_m1_451200_158400 0 7.315923e-08
I9340 n1_m1_451200_163200 0 7.320325e-08
I9341 n1_m1_451200_168000 0 1.090194e-07
I9342 n1_m1_451200_172800 0 7.536602e-08
I9343 n1_m1_451200_177600 0 1.136731e-07
I9344 n1_m1_451200_182400 0 7.263376e-08
I9345 n1_m1_451200_187200 0 7.455646e-08
I9346 n1_m1_451200_192000 0 1.171496e-07
I9347 n1_m1_451200_196800 0 7.609184e-08
I9348 n1_m1_451200_201600 0 1.166150e-07
I9349 n1_m1_451200_206400 0 7.283878e-08
I9350 n1_m1_451200_211200 0 7.621086e-08
I9351 n1_m1_451200_216000 0 1.171307e-07
I9352 n1_m1_451200_220800 0 7.362179e-08
I9353 n1_m1_451200_225600 0 1.097677e-07
I9354 n1_m1_451200_230400 0 7.163019e-08
I9355 n1_m1_451200_235200 0 6.930272e-08
I9356 n1_m1_451200_240000 0 1.076967e-07
I9357 n1_m1_451200_244800 0 7.326378e-08
I9358 n1_m1_451200_249600 0 1.092596e-07
I9359 n1_m1_451200_254400 0 7.041789e-08
I9360 n1_m1_451200_259200 0 7.004278e-08
I9361 n1_m1_451200_264000 0 1.071360e-07
I9362 n1_m1_451200_268800 0 7.310146e-08
I9363 n1_m1_451200_273600 0 1.133222e-07
I9364 n1_m1_451200_278400 0 7.480574e-08
I9365 n1_m1_451200_283200 0 7.328303e-08
I9366 n1_m1_451200_288000 0 1.134359e-07
I9367 n1_m1_451200_292800 0 7.708656e-08
I9368 n1_m1_451200_297600 0 1.089506e-07
I9369 n1_m1_451200_302400 0 7.263376e-08
I9370 n1_m1_451200_307200 0 7.263376e-08
I9371 n1_m1_451200_312000 0 1.107006e-07
I9372 n1_m1_451200_316800 0 7.334105e-08
I9373 n1_m1_451200_321600 0 1.061217e-07
I9374 n1_m1_451200_326400 0 7.323591e-08
I9375 n1_m1_451200_331200 0 7.726335e-08
I9376 n1_m1_451200_336000 0 1.114360e-07
I9377 n1_m1_451200_340800 0 7.781227e-08
I9378 n1_m1_451200_345600 0 1.221604e-07
I9379 n1_m1_451200_350400 0 7.442931e-08
I9380 n1_m1_451200_355200 0 7.328303e-08
I9381 n1_m1_451200_360000 0 1.094899e-07
I9382 n1_m1_451200_364800 0 7.259967e-08
I9383 n1_m1_451200_369600 0 1.055075e-07
I9384 n1_m1_451200_374400 0 6.995199e-08
I9385 n1_m1_451200_379200 0 7.254884e-08
I9386 n1_m1_451200_384000 0 1.066459e-07
I9387 n1_m1_451200_388800 0 7.066789e-08
I9388 n1_m1_451200_393600 0 1.089506e-07
I9389 n1_m1_451200_398400 0 7.263376e-08
I9390 n1_m1_451200_403200 0 7.263376e-08
I9391 n1_m1_451200_408000 0 1.089506e-07
I9392 n1_m1_451200_412800 0 7.063619e-08
I9393 n1_m1_451200_417600 0 1.057671e-07
I9394 n1_m1_451200_422400 0 7.060126e-08
I9395 n1_m1_451200_427200 0 7.212396e-08
I9396 n1_m1_451200_432000 0 1.099246e-07
I9397 n1_m1_451200_436800 0 7.328303e-08
I9398 n1_m1_451200_441600 0 1.073416e-07
I9399 n1_m1_451200_446400 0 7.281725e-08
I9400 n1_m1_451200_451200 0 7.328303e-08
I9401 n1_m1_451200_456000 0 1.099246e-07
I9402 n1_m1_451200_460800 0 7.580955e-08
I9403 n1_m1_451200_465600 0 1.121547e-07
I9404 n1_m1_451200_470400 0 3.573818e-08
I9405 n1_m1_456000_0 0 1.620357e-07
I9406 n1_m1_456000_4800 0 1.595266e-07
I9407 n1_m1_456000_9600 0 2.578557e-07
I9408 n1_m1_456000_14400 0 1.697700e-07
I9409 n1_m1_456000_19200 0 1.490689e-07
I9410 n1_m1_456000_24000 0 2.331802e-07
I9411 n1_m1_456000_28800 0 1.525784e-07
I9412 n1_m1_456000_33600 0 2.312417e-07
I9413 n1_m1_456000_38400 0 1.442513e-07
I9414 n1_m1_456000_43200 0 1.407580e-07
I9415 n1_m1_456000_48000 0 2.108105e-07
I9416 n1_m1_456000_52800 0 1.426704e-07
I9417 n1_m1_456000_57600 0 2.283602e-07
I9418 n1_m1_456000_62400 0 1.610886e-07
I9419 n1_m1_456000_67200 0 1.543978e-07
I9420 n1_m1_456000_72000 0 2.259892e-07
I9421 n1_m1_456000_76800 0 1.528803e-07
I9422 n1_m1_456000_81600 0 2.218371e-07
I9423 n1_m1_456000_86400 0 1.508153e-07
I9424 n1_m1_456000_91200 0 1.409925e-07
I9425 n1_m1_456000_96000 0 2.106701e-07
I9426 n1_m1_456000_100800 0 1.447589e-07
I9427 n1_m1_456000_105600 0 2.269911e-07
I9428 n1_m1_456000_110400 0 1.575207e-07
I9429 n1_m1_456000_115200 0 1.576881e-07
I9430 n1_m1_456000_120000 0 2.329778e-07
I9431 n1_m1_456000_124800 0 1.552851e-07
I9432 n1_m1_456000_129600 0 2.286755e-07
I9433 n1_m1_456000_134400 0 1.550152e-07
I9434 n1_m1_456000_139200 0 1.600984e-07
I9435 n1_m1_456000_144000 0 2.454006e-07
I9436 n1_m1_456000_148800 0 1.588675e-07
I9437 n1_m1_456000_153600 0 2.411789e-07
I9438 n1_m1_456000_158400 0 1.663933e-07
I9439 n1_m1_456000_163200 0 1.707016e-07
I9440 n1_m1_456000_168000 0 2.445978e-07
I9441 n1_m1_456000_172800 0 1.495048e-07
I9442 n1_m1_456000_177600 0 2.322037e-07
I9443 n1_m1_456000_182400 0 1.895577e-07
I9444 n1_m1_456000_187200 0 2.002776e-07
I9445 n1_m1_456000_192000 0 2.556957e-07
I9446 n1_m1_456000_196800 0 1.563709e-07
I9447 n1_m1_456000_201600 0 2.395383e-07
I9448 n1_m1_456000_206400 0 1.708575e-07
I9449 n1_m1_456000_211200 0 1.764718e-07
I9450 n1_m1_456000_216000 0 2.465640e-07
I9451 n1_m1_456000_220800 0 1.512521e-07
I9452 n1_m1_456000_225600 0 2.338470e-07
I9453 n1_m1_456000_230400 0 1.598037e-07
I9454 n1_m1_456000_235200 0 1.563051e-07
I9455 n1_m1_456000_240000 0 2.340199e-07
I9456 n1_m1_456000_244800 0 1.604852e-07
I9457 n1_m1_456000_249600 0 2.409363e-07
I9458 n1_m1_456000_254400 0 1.601675e-07
I9459 n1_m1_456000_259200 0 1.558985e-07
I9460 n1_m1_456000_264000 0 2.272952e-07
I9461 n1_m1_456000_268800 0 1.594266e-07
I9462 n1_m1_456000_273600 0 2.523409e-07
I9463 n1_m1_456000_278400 0 1.663830e-07
I9464 n1_m1_456000_283200 0 1.601778e-07
I9465 n1_m1_456000_288000 0 2.511670e-07
I9466 n1_m1_456000_292800 0 1.745699e-07
I9467 n1_m1_456000_297600 0 2.434317e-07
I9468 n1_m1_456000_302400 0 1.506550e-07
I9469 n1_m1_456000_307200 0 1.454589e-07
I9470 n1_m1_456000_312000 0 2.240373e-07
I9471 n1_m1_456000_316800 0 1.586300e-07
I9472 n1_m1_456000_321600 0 2.415227e-07
I9473 n1_m1_456000_326400 0 1.616496e-07
I9474 n1_m1_456000_331200 0 1.540717e-07
I9475 n1_m1_456000_336000 0 4.362576e-07
I9476 n1_m1_456000_340800 0 3.258273e-07
I9477 n1_m1_456000_345600 0 2.415677e-07
I9478 n1_m1_456000_350400 0 1.597489e-07
I9479 n1_m1_456000_355200 0 1.539906e-07
I9480 n1_m1_456000_360000 0 2.238833e-07
I9481 n1_m1_456000_364800 0 1.499562e-07
I9482 n1_m1_456000_369600 0 2.165377e-07
I9483 n1_m1_456000_374400 0 1.430092e-07
I9484 n1_m1_456000_379200 0 1.564870e-07
I9485 n1_m1_456000_384000 0 2.294896e-07
I9486 n1_m1_456000_388800 0 1.480251e-07
I9487 n1_m1_456000_393600 0 2.170441e-07
I9488 n1_m1_456000_398400 0 1.462730e-07
I9489 n1_m1_456000_403200 0 1.457917e-07
I9490 n1_m1_456000_408000 0 2.131179e-07
I9491 n1_m1_456000_412800 0 1.474271e-07
I9492 n1_m1_456000_417600 0 2.239141e-07
I9493 n1_m1_456000_422400 0 1.470125e-07
I9494 n1_m1_456000_427200 0 1.445900e-07
I9495 n1_m1_456000_432000 0 2.157929e-07
I9496 n1_m1_456000_436800 0 1.399040e-07
I9497 n1_m1_456000_441600 0 2.110416e-07
I9498 n1_m1_456000_446400 0 1.513650e-07
I9499 n1_m1_456000_451200 0 1.520708e-07
I9500 n1_m1_456000_456000 0 2.202161e-07
I9501 n1_m1_456000_460800 0 1.516191e-07
I9502 n1_m1_456000_465600 0 2.262552e-07
I9503 n1_m1_456000_470400 0 7.328327e-08
I9504 n1_m1_460800_0 0 1.479493e-07
I9505 n1_m1_460800_4800 0 1.690808e-07
I9506 n1_m1_460800_9600 0 2.552278e-07
I9507 n1_m1_460800_14400 0 1.587885e-07
I9508 n1_m1_460800_19200 0 1.693693e-07
I9509 n1_m1_460800_24000 0 2.445915e-07
I9510 n1_m1_460800_28800 0 1.590197e-07
I9511 n1_m1_460800_33600 0 2.621215e-07
I9512 n1_m1_460800_38400 0 1.578523e-07
I9513 n1_m1_460800_43200 0 1.545755e-07
I9514 n1_m1_460800_48000 0 2.344968e-07
I9515 n1_m1_460800_52800 0 1.543854e-07
I9516 n1_m1_460800_57600 0 2.492273e-07
I9517 n1_m1_460800_62400 0 1.770900e-07
I9518 n1_m1_460800_67200 0 1.698834e-07
I9519 n1_m1_460800_72000 0 2.509718e-07
I9520 n1_m1_460800_76800 0 1.707020e-07
I9521 n1_m1_460800_81600 0 2.478488e-07
I9522 n1_m1_460800_86400 0 1.659433e-07
I9523 n1_m1_460800_91200 0 1.504052e-07
I9524 n1_m1_460800_96000 0 2.328331e-07
I9525 n1_m1_460800_100800 0 1.674760e-07
I9526 n1_m1_460800_105600 0 2.643848e-07
I9527 n1_m1_460800_110400 0 1.796195e-07
I9528 n1_m1_460800_115200 0 1.859593e-07
I9529 n1_m1_460800_120000 0 3.823388e-07
I9530 n1_m1_460800_124800 0 2.171511e-07
I9531 n1_m1_460800_129600 0 2.573292e-07
I9532 n1_m1_460800_134400 0 1.626735e-07
I9533 n1_m1_460800_139200 0 2.149296e-07
I9534 n1_m1_460800_144000 0 5.105321e-07
I9535 n1_m1_460800_148800 0 2.466475e-07
I9536 n1_m1_460800_153600 0 3.875586e-07
I9537 n1_m1_460800_158400 0 2.680641e-07
I9538 n1_m1_460800_163200 0 2.922781e-07
I9539 n1_m1_460800_168000 0 4.125288e-07
I9540 n1_m1_460800_172800 0 1.908383e-07
I9541 n1_m1_460800_177600 0 3.272962e-07
I9542 n1_m1_460800_182400 0 3.729488e-07
I9543 n1_m1_460800_187200 0 4.095114e-07
I9544 n1_m1_460800_192000 0 4.543355e-07
I9545 n1_m1_460800_196800 0 2.375243e-07
I9546 n1_m1_460800_201600 0 3.788254e-07
I9547 n1_m1_460800_206400 0 3.467363e-07
I9548 n1_m1_460800_211200 0 3.601750e-07
I9549 n1_m1_460800_216000 0 3.960683e-07
I9550 n1_m1_460800_220800 0 1.835841e-07
I9551 n1_m1_460800_225600 0 3.395404e-07
I9552 n1_m1_460800_230400 0 2.880463e-07
I9553 n1_m1_460800_235200 0 2.666108e-07
I9554 n1_m1_460800_240000 0 3.513011e-07
I9555 n1_m1_460800_244800 0 2.617347e-07
I9556 n1_m1_460800_249600 0 4.382238e-07
I9557 n1_m1_460800_254400 0 3.007634e-07
I9558 n1_m1_460800_259200 0 2.670184e-07
I9559 n1_m1_460800_264000 0 3.155985e-07
I9560 n1_m1_460800_268800 0 1.987262e-07
I9561 n1_m1_460800_273600 0 3.760229e-07
I9562 n1_m1_460800_278400 0 2.483230e-07
I9563 n1_m1_460800_283200 0 2.272624e-07
I9564 n1_m1_460800_288000 0 3.468816e-07
I9565 n1_m1_460800_292800 0 2.431127e-07
I9566 n1_m1_460800_297600 0 3.890762e-07
I9567 n1_m1_460800_302400 0 2.137285e-07
I9568 n1_m1_460800_307200 0 1.666248e-07
I9569 n1_m1_460800_312000 0 2.463728e-07
I9570 n1_m1_460800_316800 0 2.168301e-07
I9571 n1_m1_460800_321600 0 3.288753e-07
I9572 n1_m1_460800_326400 0 2.017810e-07
I9573 n1_m1_460800_331200 0 2.537830e-07
I9574 n1_m1_460800_336000 0 4.849699e-07
I9575 n1_m1_460800_340800 0 3.892421e-07
I9576 n1_m1_460800_345600 0 4.311104e-07
I9577 n1_m1_460800_350400 0 1.771455e-07
I9578 n1_m1_460800_355200 0 1.710452e-07
I9579 n1_m1_460800_360000 0 2.480350e-07
I9580 n1_m1_460800_364800 0 1.765603e-07
I9581 n1_m1_460800_369600 0 2.552460e-07
I9582 n1_m1_460800_374400 0 1.583793e-07
I9583 n1_m1_460800_379200 0 1.725168e-07
I9584 n1_m1_460800_384000 0 2.958188e-07
I9585 n1_m1_460800_388800 0 1.895623e-07
I9586 n1_m1_460800_393600 0 2.566515e-07
I9587 n1_m1_460800_398400 0 1.620512e-07
I9588 n1_m1_460800_403200 0 1.554690e-07
I9589 n1_m1_460800_408000 0 2.184765e-07
I9590 n1_m1_460800_412800 0 1.623238e-07
I9591 n1_m1_460800_417600 0 2.457541e-07
I9592 n1_m1_460800_422400 0 1.600139e-07
I9593 n1_m1_460800_427200 0 1.538030e-07
I9594 n1_m1_460800_432000 0 2.258760e-07
I9595 n1_m1_460800_436800 0 1.449570e-07
I9596 n1_m1_460800_441600 0 2.273569e-07
I9597 n1_m1_460800_446400 0 1.665501e-07
I9598 n1_m1_460800_451200 0 1.673739e-07
I9599 n1_m1_460800_456000 0 2.394114e-07
I9600 n1_m1_460800_460800 0 1.617310e-07
I9601 n1_m1_460800_465600 0 2.424919e-07
I9602 n1_m1_460800_470400 0 7.919705e-08
I9603 n1_m1_465600_0 0 2.560835e-07
I9604 n1_m1_465600_4800 0 2.594256e-07
I9605 n1_m1_465600_9600 0 3.507330e-07
I9606 n1_m1_465600_14400 0 2.223010e-07
I9607 n1_m1_465600_19200 0 2.521577e-07
I9608 n1_m1_465600_24000 0 3.688104e-07
I9609 n1_m1_465600_28800 0 2.468877e-07
I9610 n1_m1_465600_33600 0 4.291697e-07
I9611 n1_m1_465600_38400 0 2.432511e-07
I9612 n1_m1_465600_43200 0 2.376517e-07
I9613 n1_m1_465600_48000 0 3.597868e-07
I9614 n1_m1_465600_52800 0 2.386925e-07
I9615 n1_m1_465600_57600 0 3.889207e-07
I9616 n1_m1_465600_62400 0 2.658131e-07
I9617 n1_m1_465600_67200 0 2.537665e-07
I9618 n1_m1_465600_72000 0 3.764406e-07
I9619 n1_m1_465600_76800 0 2.577609e-07
I9620 n1_m1_465600_81600 0 3.632407e-07
I9621 n1_m1_465600_86400 0 2.477570e-07
I9622 n1_m1_465600_91200 0 2.388756e-07
I9623 n1_m1_465600_96000 0 3.682323e-07
I9624 n1_m1_465600_100800 0 2.628472e-07
I9625 n1_m1_465600_105600 0 4.123965e-07
I9626 n1_m1_465600_110400 0 2.624561e-07
I9627 n1_m1_465600_115200 0 2.661642e-07
I9628 n1_m1_465600_120000 0 5.526457e-07
I9629 n1_m1_465600_124800 0 3.826058e-07
I9630 n1_m1_465600_129600 0 4.176281e-07
I9631 n1_m1_465600_134400 0 2.403308e-07
I9632 n1_m1_465600_139200 0 2.999110e-07
I9633 n1_m1_465600_144000 0 7.629174e-07
I9634 n1_m1_465600_148800 0 4.327291e-07
I9635 n1_m1_465600_153600 0 6.050641e-07
I9636 n1_m1_465600_158400 0 3.600245e-07
I9637 n1_m1_465600_163200 0 4.010078e-07
I9638 n1_m1_465600_168000 0 6.438044e-07
I9639 n1_m1_465600_172800 0 3.079424e-07
I9640 n1_m1_465600_177600 0 4.582162e-07
I9641 n1_m1_465600_182400 0 4.603235e-07
I9642 n1_m1_465600_187200 0 5.073182e-07
I9643 n1_m1_465600_192000 0 7.006542e-07
I9644 n1_m1_465600_196800 0 4.425759e-07
I9645 n1_m1_465600_201600 0 5.480426e-07
I9646 n1_m1_465600_206400 0 4.985848e-07
I9647 n1_m1_465600_211200 0 5.379768e-07
I9648 n1_m1_465600_216000 0 6.031236e-07
I9649 n1_m1_465600_220800 0 2.767267e-07
I9650 n1_m1_465600_225600 0 5.049565e-07
I9651 n1_m1_465600_230400 0 4.189201e-07
I9652 n1_m1_465600_235200 0 3.884622e-07
I9653 n1_m1_465600_240000 0 5.234100e-07
I9654 n1_m1_465600_244800 0 3.934462e-07
I9655 n1_m1_465600_249600 0 6.980122e-07
I9656 n1_m1_465600_254400 0 4.913641e-07
I9657 n1_m1_465600_259200 0 4.394556e-07
I9658 n1_m1_465600_264000 0 5.016609e-07
I9659 n1_m1_465600_268800 0 2.882633e-07
I9660 n1_m1_465600_273600 0 5.390577e-07
I9661 n1_m1_465600_278400 0 3.928035e-07
I9662 n1_m1_465600_283200 0 3.725560e-07
I9663 n1_m1_465600_288000 0 4.799373e-07
I9664 n1_m1_465600_292800 0 2.993157e-07
I9665 n1_m1_465600_297600 0 5.880957e-07
I9666 n1_m1_465600_302400 0 3.907700e-07
I9667 n1_m1_465600_307200 0 2.660673e-07
I9668 n1_m1_465600_312000 0 3.686856e-07
I9669 n1_m1_465600_316800 0 3.298142e-07
I9670 n1_m1_465600_321600 0 5.269386e-07
I9671 n1_m1_465600_326400 0 3.268723e-07
I9672 n1_m1_465600_331200 0 3.622358e-07
I9673 n1_m1_465600_336000 0 4.655071e-07
I9674 n1_m1_465600_340800 0 3.738960e-07
I9675 n1_m1_465600_345600 0 6.329394e-07
I9676 n1_m1_465600_350400 0 2.666533e-07
I9677 n1_m1_465600_355200 0 2.563699e-07
I9678 n1_m1_465600_360000 0 3.685716e-07
I9679 n1_m1_465600_364800 0 3.028819e-07
I9680 n1_m1_465600_369600 0 4.700239e-07
I9681 n1_m1_465600_374400 0 2.469247e-07
I9682 n1_m1_465600_379200 0 2.469716e-07
I9683 n1_m1_465600_384000 0 4.502171e-07
I9684 n1_m1_465600_388800 0 2.921793e-07
I9685 n1_m1_465600_393600 0 3.926384e-07
I9686 n1_m1_465600_398400 0 2.476128e-07
I9687 n1_m1_465600_403200 0 2.381223e-07
I9688 n1_m1_465600_408000 0 3.355683e-07
I9689 n1_m1_465600_412800 0 2.397507e-07
I9690 n1_m1_465600_417600 0 3.555187e-07
I9691 n1_m1_465600_422400 0 2.349883e-07
I9692 n1_m1_465600_427200 0 2.301992e-07
I9693 n1_m1_465600_432000 0 3.389295e-07
I9694 n1_m1_465600_436800 0 2.190754e-07
I9695 n1_m1_465600_441600 0 3.398960e-07
I9696 n1_m1_465600_446400 0 2.498660e-07
I9697 n1_m1_465600_451200 0 2.561024e-07
I9698 n1_m1_465600_456000 0 3.562925e-07
I9699 n1_m1_465600_460800 0 2.372743e-07
I9700 n1_m1_465600_465600 0 3.652679e-07
I9701 n1_m1_465600_470400 0 1.198612e-07
I9702 n1_m1_470400_0 0 9.755633e-08
I9703 n1_m1_470400_4800 0 8.386313e-08
I9704 n1_m1_470400_9600 0 1.119883e-07
I9705 n1_m1_470400_14400 0 7.721383e-08
I9706 n1_m1_470400_19200 0 7.931464e-08
I9707 n1_m1_470400_24000 0 1.212203e-07
I9708 n1_m1_470400_28800 0 8.243743e-08
I9709 n1_m1_470400_33600 0 1.317165e-07
I9710 n1_m1_470400_38400 0 7.658585e-08
I9711 n1_m1_470400_43200 0 7.400766e-08
I9712 n1_m1_470400_48000 0 1.109842e-07
I9713 n1_m1_470400_52800 0 7.505346e-08
I9714 n1_m1_470400_57600 0 1.232064e-07
I9715 n1_m1_470400_62400 0 8.375607e-08
I9716 n1_m1_470400_67200 0 7.964872e-08
I9717 n1_m1_470400_72000 0 1.190050e-07
I9718 n1_m1_470400_76800 0 8.262690e-08
I9719 n1_m1_470400_81600 0 1.151343e-07
I9720 n1_m1_470400_86400 0 7.768679e-08
I9721 n1_m1_470400_91200 0 7.556960e-08
I9722 n1_m1_470400_96000 0 1.151674e-07
I9723 n1_m1_470400_100800 0 8.279126e-08
I9724 n1_m1_470400_105600 0 1.273655e-07
I9725 n1_m1_470400_110400 0 8.042311e-08
I9726 n1_m1_470400_115200 0 8.024094e-08
I9727 n1_m1_470400_120000 0 1.392602e-07
I9728 n1_m1_470400_124800 0 1.031627e-07
I9729 n1_m1_470400_129600 0 1.325701e-07
I9730 n1_m1_470400_134400 0 7.766694e-08
I9731 n1_m1_470400_139200 0 8.466467e-08
I9732 n1_m1_470400_144000 0 1.722452e-07
I9733 n1_m1_470400_148800 0 1.108546e-07
I9734 n1_m1_470400_153600 0 1.548104e-07
I9735 n1_m1_470400_158400 0 9.246861e-08
I9736 n1_m1_470400_163200 0 9.882198e-08
I9737 n1_m1_470400_168000 0 1.603777e-07
I9738 n1_m1_470400_172800 0 9.123657e-08
I9739 n1_m1_470400_177600 0 1.287875e-07
I9740 n1_m1_470400_182400 0 1.036873e-07
I9741 n1_m1_470400_187200 0 1.096951e-07
I9742 n1_m1_470400_192000 0 1.676133e-07
I9743 n1_m1_470400_196800 0 1.161642e-07
I9744 n1_m1_470400_201600 0 1.430551e-07
I9745 n1_m1_470400_206400 0 1.127942e-07
I9746 n1_m1_470400_211200 0 1.201213e-07
I9747 n1_m1_470400_216000 0 1.522482e-07
I9748 n1_m1_470400_220800 0 8.231734e-08
I9749 n1_m1_470400_225600 0 1.375478e-07
I9750 n1_m1_470400_230400 0 1.009938e-07
I9751 n1_m1_470400_235200 0 9.775776e-08
I9752 n1_m1_470400_240000 0 1.410475e-07
I9753 n1_m1_470400_244800 0 1.012843e-07
I9754 n1_m1_470400_249600 0 1.688553e-07
I9755 n1_m1_470400_254400 0 1.179991e-07
I9756 n1_m1_470400_259200 0 1.090503e-07
I9757 n1_m1_470400_264000 0 1.396535e-07
I9758 n1_m1_470400_268800 0 8.649144e-08
I9759 n1_m1_470400_273600 0 1.426816e-07
I9760 n1_m1_470400_278400 0 1.021991e-07
I9761 n1_m1_470400_283200 0 1.003596e-07
I9762 n1_m1_470400_288000 0 1.332123e-07
I9763 n1_m1_470400_292800 0 8.328228e-08
I9764 n1_m1_470400_297600 0 1.516759e-07
I9765 n1_m1_470400_302400 0 1.053245e-07
I9766 n1_m1_470400_307200 0 8.183876e-08
I9767 n1_m1_470400_312000 0 1.157090e-07
I9768 n1_m1_470400_316800 0 9.071302e-08
I9769 n1_m1_470400_321600 0 1.487706e-07
I9770 n1_m1_470400_326400 0 1.003419e-07
I9771 n1_m1_470400_331200 0 9.341525e-08
I9772 n1_m1_470400_336000 0 1.273343e-07
I9773 n1_m1_470400_340800 0 9.543627e-08
I9774 n1_m1_470400_345600 0 1.552623e-07
I9775 n1_m1_470400_350400 0 8.515485e-08
I9776 n1_m1_470400_355200 0 8.121951e-08
I9777 n1_m1_470400_360000 0 1.143446e-07
I9778 n1_m1_470400_364800 0 8.968780e-08
I9779 n1_m1_470400_369600 0 1.424905e-07
I9780 n1_m1_470400_374400 0 7.871955e-08
I9781 n1_m1_470400_379200 0 7.598945e-08
I9782 n1_m1_470400_384000 0 1.255567e-07
I9783 n1_m1_470400_388800 0 8.343180e-08
I9784 n1_m1_470400_393600 0 1.182506e-07
I9785 n1_m1_470400_398400 0 7.635117e-08
I9786 n1_m1_470400_403200 0 7.497392e-08
I9787 n1_m1_470400_408000 0 1.074747e-07
I9788 n1_m1_470400_412800 0 7.640236e-08
I9789 n1_m1_470400_417600 0 1.129027e-07
I9790 n1_m1_470400_422400 0 7.480741e-08
I9791 n1_m1_470400_427200 0 7.437464e-08
I9792 n1_m1_470400_432000 0 1.108902e-07
I9793 n1_m1_470400_436800 0 7.256463e-08
I9794 n1_m1_470400_441600 0 1.079818e-07
I9795 n1_m1_470400_446400 0 7.840664e-08
I9796 n1_m1_470400_451200 0 8.074966e-08
I9797 n1_m1_470400_456000 0 1.113784e-07
I9798 n1_m1_470400_460800 0 7.291546e-08
I9799 n1_m1_470400_465600 0 1.124511e-07
I9800 n1_m1_470400_470400 0 3.688147e-08
I9801 n1_m1_4000_0 0 8.660722e-08
I9802 n1_m1_4000_4800 0 8.528045e-08
I9803 n1_m1_4000_9600 0 1.123493e-07
I9804 n1_m1_4000_14400 0 6.983907e-08
I9805 n1_m1_4000_19200 0 7.465215e-08
I9806 n1_m1_4000_24000 0 1.062368e-07
I9807 n1_m1_4000_28800 0 6.662094e-08
I9808 n1_m1_4000_33600 0 1.051892e-07
I9809 n1_m1_4000_38400 0 7.729158e-08
I9810 n1_m1_4000_43200 0 7.967265e-08
I9811 n1_m1_4000_48000 0 1.164509e-07
I9812 n1_m1_4000_52800 0 7.547307e-08
I9813 n1_m1_4000_57600 0 1.142617e-07
I9814 n1_m1_4000_62400 0 7.887326e-08
I9815 n1_m1_4000_67200 0 7.585189e-08
I9816 n1_m1_4000_72000 0 1.088942e-07
I9817 n1_m1_4000_76800 0 7.232324e-08
I9818 n1_m1_4000_81600 0 1.127264e-07
I9819 n1_m1_4000_86400 0 7.405623e-08
I9820 n1_m1_4000_91200 0 7.043188e-08
I9821 n1_m1_4000_96000 0 1.061432e-07
I9822 n1_m1_4000_100800 0 7.250984e-08
I9823 n1_m1_4000_105600 0 1.057686e-07
I9824 n1_m1_4000_110400 0 7.271522e-08
I9825 n1_m1_4000_115200 0 7.295684e-08
I9826 n1_m1_4000_120000 0 1.059740e-07
I9827 n1_m1_4000_124800 0 7.043188e-08
I9828 n1_m1_4000_129600 0 1.064935e-07
I9829 n1_m1_4000_134400 0 7.346605e-08
I9830 n1_m1_4000_139200 0 7.376293e-08
I9831 n1_m1_4000_144000 0 1.122903e-07
I9832 n1_m1_4000_148800 0 8.237523e-08
I9833 n1_m1_4000_153600 0 1.261401e-07
I9834 n1_m1_4000_158400 0 8.786342e-08
I9835 n1_m1_4000_163200 0 8.808926e-08
I9836 n1_m1_4000_168000 0 1.243844e-07
I9837 n1_m1_4000_172800 0 7.702819e-08
I9838 n1_m1_4000_177600 0 1.112372e-07
I9839 n1_m1_4000_182400 0 7.376293e-08
I9840 n1_m1_4000_187200 0 7.376293e-08
I9841 n1_m1_4000_192000 0 1.112796e-07
I9842 n1_m1_4000_196800 0 7.696695e-08
I9843 n1_m1_4000_201600 0 1.156633e-07
I9844 n1_m1_4000_206400 0 7.744373e-08
I9845 n1_m1_4000_211200 0 7.716108e-08
I9846 n1_m1_4000_216000 0 1.156410e-07
I9847 n1_m1_4000_220800 0 7.675642e-08
I9848 n1_m1_4000_225600 0 1.138202e-07
I9849 n1_m1_4000_230400 0 7.328303e-08
I9850 n1_m1_4000_235200 0 7.185746e-08
I9851 n1_m1_4000_240000 0 1.062156e-07
I9852 n1_m1_4000_244800 0 7.400300e-08
I9853 n1_m1_4000_249600 0 1.177317e-07
I9854 n1_m1_4000_254400 0 8.234772e-08
I9855 n1_m1_4000_259200 0 8.361182e-08
I9856 n1_m1_4000_264000 0 1.268201e-07
I9857 n1_m1_4000_268800 0 9.922664e-08
I9858 n1_m1_4000_273600 0 1.564269e-07
I9859 n1_m1_4000_278400 0 1.091514e-07
I9860 n1_m1_4000_283200 0 1.077877e-07
I9861 n1_m1_4000_288000 0 1.384246e-07
I9862 n1_m1_4000_292800 0 1.017920e-07
I9863 n1_m1_4000_297600 0 1.491374e-07
I9864 n1_m1_4000_302400 0 9.910977e-08
I9865 n1_m1_4000_307200 0 9.193309e-08
I9866 n1_m1_4000_312000 0 1.372991e-07
I9867 n1_m1_4000_316800 0 8.689155e-08
I9868 n1_m1_4000_321600 0 1.115443e-07
I9869 n1_m1_4000_326400 0 7.280314e-08
I9870 n1_m1_4000_331200 0 7.636002e-08
I9871 n1_m1_4000_336000 0 1.224910e-07
I9872 n1_m1_4000_340800 0 8.266614e-08
I9873 n1_m1_4000_345600 0 1.211067e-07
I9874 n1_m1_4000_350400 0 7.913904e-08
I9875 n1_m1_4000_355200 0 7.694027e-08
I9876 n1_m1_4000_360000 0 1.126910e-07
I9877 n1_m1_4000_364800 0 7.543958e-08
I9878 n1_m1_4000_369600 0 1.186610e-07
I9879 n1_m1_4000_374400 0 7.972145e-08
I9880 n1_m1_4000_379200 0 7.946523e-08
I9881 n1_m1_4000_384000 0 1.180126e-07
I9882 n1_m1_4000_388800 0 7.538515e-08
I9883 n1_m1_4000_393600 0 1.098859e-07
I9884 n1_m1_4000_398400 0 7.287431e-08
I9885 n1_m1_4000_403200 0 7.280314e-08
I9886 n1_m1_4000_408000 0 1.111619e-07
I9887 n1_m1_4000_412800 0 7.138773e-08
I9888 n1_m1_4000_417600 0 1.066838e-07
I9889 n1_m1_4000_422400 0 7.351485e-08
I9890 n1_m1_4000_427200 0 7.376293e-08
I9891 n1_m1_4000_432000 0 1.106444e-07
I9892 n1_m1_4000_436800 0 7.362872e-08
I9893 n1_m1_4000_441600 0 1.123891e-07
I9894 n1_m1_4000_446400 0 7.657174e-08
I9895 n1_m1_4000_451200 0 7.914060e-08
I9896 n1_m1_4000_456000 0 1.188603e-07
I9897 n1_m1_4000_460800 0 7.636002e-08
I9898 n1_m1_4000_465600 0 1.079643e-07
I9899 n1_m1_4000_470400 0 3.506224e-08
I9900 n1_m1_32000_0 0 6.662094e-08
I9901 n1_m1_32000_4800 0 6.728433e-08
I9902 n1_m1_32000_9600 0 1.061898e-07
I9903 n1_m1_32000_14400 0 7.168581e-08
I9904 n1_m1_32000_19200 0 7.027076e-08
I9905 n1_m1_32000_24000 0 1.041038e-07
I9906 n1_m1_32000_28800 0 6.845584e-08
I9907 n1_m1_32000_33600 0 1.058595e-07
I9908 n1_m1_32000_38400 0 6.897569e-08
I9909 n1_m1_32000_43200 0 7.312419e-08
I9910 n1_m1_32000_48000 0 1.129618e-07
I9911 n1_m1_32000_52800 0 8.401133e-08
I9912 n1_m1_32000_57600 0 1.407479e-07
I9913 n1_m1_32000_62400 0 8.052000e-08
I9914 n1_m1_32000_67200 0 8.106700e-08
I9915 n1_m1_32000_72000 0 1.113898e-07
I9916 n1_m1_32000_76800 0 7.410168e-08
I9917 n1_m1_32000_81600 0 1.022420e-07
I9918 n1_m1_32000_86400 0 6.995199e-08
I9919 n1_m1_32000_91200 0 7.212013e-08
I9920 n1_m1_32000_96000 0 1.081461e-07
I9921 n1_m1_32000_100800 0 6.902042e-08
I9922 n1_m1_32000_105600 0 1.059951e-07
I9923 n1_m1_32000_110400 0 7.032411e-08
I9924 n1_m1_32000_115200 0 7.388817e-08
I9925 n1_m1_32000_120000 0 1.095399e-07
I9926 n1_m1_32000_124800 0 7.154742e-08
I9927 n1_m1_32000_129600 0 1.093888e-07
I9928 n1_m1_32000_134400 0 6.974242e-08
I9929 n1_m1_32000_139200 0 7.685977e-08
I9930 n1_m1_32000_144000 0 1.109560e-07
I9931 n1_m1_32000_148800 0 6.893490e-08
I9932 n1_m1_32000_153600 0 1.105171e-07
I9933 n1_m1_32000_158400 0 1.141674e-07
I9934 n1_m1_32000_163200 0 1.354043e-07
I9935 n1_m1_32000_168000 0 2.958354e-07
I9936 n1_m1_32000_172800 0 9.806422e-08
I9937 n1_m1_32000_177600 0 1.122639e-07
I9938 n1_m1_32000_182400 0 6.935606e-08
I9939 n1_m1_32000_187200 0 6.845584e-08
I9940 n1_m1_32000_192000 0 1.042813e-07
I9941 n1_m1_32000_196800 0 6.995199e-08
I9942 n1_m1_32000_201600 0 1.023309e-07
I9943 n1_m1_32000_206400 0 6.662094e-08
I9944 n1_m1_32000_211200 0 6.662094e-08
I9945 n1_m1_32000_216000 0 1.010666e-07
I9946 n1_m1_32000_220800 0 6.716519e-08
I9947 n1_m1_32000_225600 0 1.022406e-07
I9948 n1_m1_32000_230400 0 6.831517e-08
I9949 n1_m1_32000_235200 0 6.811709e-08
I9950 n1_m1_32000_240000 0 1.025411e-07
I9951 n1_m1_32000_244800 0 6.909303e-08
I9952 n1_m1_32000_249600 0 1.011419e-07
I9953 n1_m1_32000_254400 0 6.854280e-08
I9954 n1_m1_32000_259200 0 6.975546e-08
I9955 n1_m1_32000_264000 0 1.070452e-07
I9956 n1_m1_32000_268800 0 7.088355e-08
I9957 n1_m1_32000_273600 0 1.060854e-07
I9958 n1_m1_32000_278400 0 7.328303e-08
I9959 n1_m1_32000_283200 0 7.423158e-08
I9960 n1_m1_32000_288000 0 1.180406e-07
I9961 n1_m1_32000_292800 0 8.726714e-08
I9962 n1_m1_32000_297600 0 1.949086e-07
I9963 n1_m1_32000_302400 0 9.991359e-08
I9964 n1_m1_32000_307200 0 8.160706e-08
I9965 n1_m1_32000_312000 0 1.088161e-07
I9966 n1_m1_32000_316800 0 6.907054e-08
I9967 n1_m1_32000_321600 0 1.078135e-07
I9968 n1_m1_32000_326400 0 7.261104e-08
I9969 n1_m1_32000_331200 0 7.080724e-08
I9970 n1_m1_32000_336000 0 1.012017e-07
I9971 n1_m1_32000_340800 0 6.662094e-08
I9972 n1_m1_32000_345600 0 1.026979e-07
I9973 n1_m1_32000_350400 0 7.079169e-08
I9974 n1_m1_32000_355200 0 7.571721e-08
I9975 n1_m1_32000_360000 0 1.094726e-07
I9976 n1_m1_32000_364800 0 1.243816e-07
I9977 n1_m1_32000_369600 0 1.291163e-07
I9978 n1_m1_32000_374400 0 7.771813e-08
I9979 n1_m1_32000_379200 0 7.642748e-08
I9980 n1_m1_32000_384000 0 1.121751e-07
I9981 n1_m1_32000_388800 0 6.948262e-08
I9982 n1_m1_32000_393600 0 1.038784e-07
I9983 n1_m1_32000_398400 0 7.128929e-08
I9984 n1_m1_32000_403200 0 7.039361e-08
I9985 n1_m1_32000_408000 0 1.093637e-07
I9986 n1_m1_32000_412800 0 7.115879e-08
I9987 n1_m1_32000_417600 0 1.049280e-07
I9988 n1_m1_32000_422400 0 6.995199e-08
I9989 n1_m1_32000_427200 0 6.995199e-08
I9990 n1_m1_32000_432000 0 1.049280e-07
I9991 n1_m1_32000_436800 0 6.995199e-08
I9992 n1_m1_32000_441600 0 1.075110e-07
I9993 n1_m1_32000_446400 0 7.041777e-08
I9994 n1_m1_32000_451200 0 6.995199e-08
I9995 n1_m1_32000_456000 0 1.049280e-07
I9996 n1_m1_32000_460800 0 7.247850e-08
I9997 n1_m1_32000_465600 0 1.099246e-07
I9998 n1_m1_32000_470400 0 3.664152e-08
I9999 n1_m1_60000_0 0 7.227683e-08
I10000 n1_m1_60000_4800 0 7.018177e-08
I10001 n1_m1_60000_9600 0 1.049280e-07
I10002 n1_m1_60000_14400 0 6.995199e-08
I10003 n1_m1_60000_19200 0 6.995199e-08
I10004 n1_m1_60000_24000 0 1.049280e-07
I10005 n1_m1_60000_28800 0 6.783480e-08
I10006 n1_m1_60000_33600 0 1.039587e-07
I10007 n1_m1_60000_38400 0 7.096824e-08
I10008 n1_m1_60000_43200 0 8.015733e-08
I10009 n1_m1_60000_48000 0 1.684979e-07
I10010 n1_m1_60000_52800 0 2.234914e-07
I10011 n1_m1_60000_57600 0 3.890817e-07
I10012 n1_m1_60000_62400 0 1.288955e-07
I10013 n1_m1_60000_67200 0 9.060776e-08
I10014 n1_m1_60000_72000 0 1.120231e-07
I10015 n1_m1_60000_76800 0 6.981084e-08
I10016 n1_m1_60000_81600 0 1.016750e-07
I10017 n1_m1_60000_86400 0 7.340098e-08
I10018 n1_m1_60000_91200 0 7.966284e-08
I10019 n1_m1_60000_96000 0 1.163176e-07
I10020 n1_m1_60000_100800 0 7.579137e-08
I10021 n1_m1_60000_105600 0 1.098580e-07
I10022 n1_m1_60000_110400 0 7.314189e-08
I10023 n1_m1_60000_115200 0 7.463397e-08
I10024 n1_m1_60000_120000 0 1.298139e-07
I10025 n1_m1_60000_124800 0 8.519576e-08
I10026 n1_m1_60000_129600 0 1.213851e-07
I10027 n1_m1_60000_134400 0 7.810760e-08
I10028 n1_m1_60000_139200 0 6.839938e-08
I10029 n1_m1_60000_144000 0 1.028506e-07
I10030 n1_m1_60000_148800 0 6.762714e-08
I10031 n1_m1_60000_153600 0 1.099211e-07
I10032 n1_m1_60000_158400 0 7.658717e-08
I10033 n1_m1_60000_163200 0 7.780736e-08
I10034 n1_m1_60000_168000 0 1.304630e-07
I10035 n1_m1_60000_172800 0 8.050971e-08
I10036 n1_m1_60000_177600 0 1.065229e-07
I10037 n1_m1_60000_182400 0 6.868143e-08
I10038 n1_m1_60000_187200 0 6.830297e-08
I10039 n1_m1_60000_192000 0 1.042928e-07
I10040 n1_m1_60000_196800 0 6.749138e-08
I10041 n1_m1_60000_201600 0 1.072616e-07
I10042 n1_m1_60000_206400 0 7.017220e-08
I10043 n1_m1_60000_211200 0 6.716986e-08
I10044 n1_m1_60000_216000 0 9.994517e-08
I10045 n1_m1_60000_220800 0 6.672022e-08
I10046 n1_m1_60000_225600 0 9.996550e-08
I10047 n1_m1_60000_230400 0 6.794556e-08
I10048 n1_m1_60000_235200 0 6.988141e-08
I10049 n1_m1_60000_240000 0 1.049280e-07
I10050 n1_m1_60000_244800 0 6.998608e-08
I10051 n1_m1_60000_249600 0 1.051397e-07
I10052 n1_m1_60000_254400 0 7.007938e-08
I10053 n1_m1_60000_259200 0 6.997053e-08
I10054 n1_m1_60000_264000 0 1.028108e-07
I10055 n1_m1_60000_268800 0 7.381939e-08
I10056 n1_m1_60000_273600 0 1.054530e-07
I10057 n1_m1_60000_278400 0 6.950032e-08
I10058 n1_m1_60000_283200 0 7.328303e-08
I10059 n1_m1_60000_288000 0 1.071605e-07
I10060 n1_m1_60000_292800 0 7.518958e-08
I10061 n1_m1_60000_297600 0 1.797452e-07
I10062 n1_m1_60000_302400 0 1.897558e-07
I10063 n1_m1_60000_307200 0 1.178523e-07
I10064 n1_m1_60000_312000 0 1.226556e-07
I10065 n1_m1_60000_316800 0 6.941970e-08
I10066 n1_m1_60000_321600 0 1.084087e-07
I10067 n1_m1_60000_326400 0 7.170914e-08
I10068 n1_m1_60000_331200 0 6.824891e-08
I10069 n1_m1_60000_336000 0 1.044313e-07
I10070 n1_m1_60000_340800 0 7.324069e-08
I10071 n1_m1_60000_345600 0 1.071581e-07
I10072 n1_m1_60000_350400 0 7.031693e-08
I10073 n1_m1_60000_355200 0 7.229896e-08
I10074 n1_m1_60000_360000 0 1.118606e-07
I10075 n1_m1_60000_364800 0 1.351730e-07
I10076 n1_m1_60000_369600 0 1.749263e-07
I10077 n1_m1_60000_374400 0 1.541774e-07
I10078 n1_m1_60000_379200 0 1.294154e-07
I10079 n1_m1_60000_384000 0 1.835036e-07
I10080 n1_m1_60000_388800 0 7.343853e-08
I10081 n1_m1_60000_393600 0 1.191876e-07
I10082 n1_m1_60000_398400 0 7.368566e-08
I10083 n1_m1_60000_403200 0 6.838850e-08
I10084 n1_m1_60000_408000 0 1.159212e-07
I10085 n1_m1_60000_412800 0 7.157923e-08
I10086 n1_m1_60000_417600 0 1.042657e-07
I10087 n1_m1_60000_422400 0 6.841110e-08
I10088 n1_m1_60000_427200 0 6.676209e-08
I10089 n1_m1_60000_432000 0 1.076259e-07
I10090 n1_m1_60000_436800 0 7.135771e-08
I10091 n1_m1_60000_441600 0 1.078476e-07
I10092 n1_m1_60000_446400 0 7.044361e-08
I10093 n1_m1_60000_451200 0 6.780358e-08
I10094 n1_m1_60000_456000 0 1.099586e-07
I10095 n1_m1_60000_460800 0 7.911823e-08
I10096 n1_m1_60000_465600 0 1.114044e-07
I10097 n1_m1_60000_470400 0 3.665767e-08
I10098 n1_m1_88000_0 0 7.858151e-08
I10099 n1_m1_88000_4800 0 8.444912e-08
I10100 n1_m1_88000_9600 0 1.142390e-07
I10101 n1_m1_88000_14400 0 7.021430e-08
I10102 n1_m1_88000_19200 0 6.962735e-08
I10103 n1_m1_88000_24000 0 1.015352e-07
I10104 n1_m1_88000_28800 0 6.739246e-08
I10105 n1_m1_88000_33600 0 9.993141e-08
I10106 n1_m1_88000_38400 0 6.662094e-08
I10107 n1_m1_88000_43200 0 6.714557e-08
I10108 n1_m1_88000_48000 0 1.039053e-07
I10109 n1_m1_88000_52800 0 7.121214e-08
I10110 n1_m1_88000_57600 0 1.135741e-07
I10111 n1_m1_88000_62400 0 7.203234e-08
I10112 n1_m1_88000_67200 0 6.979972e-08
I10113 n1_m1_88000_72000 0 1.003407e-07
I10114 n1_m1_88000_76800 0 6.741303e-08
I10115 n1_m1_88000_81600 0 1.046154e-07
I10116 n1_m1_88000_86400 0 6.931229e-08
I10117 n1_m1_88000_91200 0 6.662094e-08
I10118 n1_m1_88000_96000 0 1.033754e-07
I10119 n1_m1_88000_100800 0 6.995199e-08
I10120 n1_m1_88000_105600 0 1.049280e-07
I10121 n1_m1_88000_110400 0 6.995199e-08
I10122 n1_m1_88000_115200 0 7.033308e-08
I10123 n1_m1_88000_120000 0 1.173512e-07
I10124 n1_m1_88000_124800 0 8.642756e-08
I10125 n1_m1_88000_129600 0 1.154551e-07
I10126 n1_m1_88000_134400 0 6.914458e-08
I10127 n1_m1_88000_139200 0 6.726902e-08
I10128 n1_m1_88000_144000 0 1.028249e-07
I10129 n1_m1_88000_148800 0 6.806948e-08
I10130 n1_m1_88000_153600 0 1.099842e-07
I10131 n1_m1_88000_158400 0 1.088550e-07
I10132 n1_m1_88000_163200 0 1.541620e-07
I10133 n1_m1_88000_168000 0 4.448073e-07
I10134 n1_m1_88000_172800 0 1.789522e-07
I10135 n1_m1_88000_177600 0 1.390293e-07
I10136 n1_m1_88000_182400 0 7.274668e-08
I10137 n1_m1_88000_187200 0 6.830178e-08
I10138 n1_m1_88000_192000 0 1.048203e-07
I10139 n1_m1_88000_196800 0 7.324859e-08
I10140 n1_m1_88000_201600 0 1.046323e-07
I10141 n1_m1_88000_206400 0 6.884614e-08
I10142 n1_m1_88000_211200 0 6.978225e-08
I10143 n1_m1_88000_216000 0 1.088573e-07
I10144 n1_m1_88000_220800 0 7.396054e-08
I10145 n1_m1_88000_225600 0 1.038313e-07
I10146 n1_m1_88000_230400 0 6.908908e-08
I10147 n1_m1_88000_235200 0 7.040366e-08
I10148 n1_m1_88000_240000 0 1.049280e-07
I10149 n1_m1_88000_244800 0 6.944063e-08
I10150 n1_m1_88000_249600 0 1.018688e-07
I10151 n1_m1_88000_254400 0 6.958417e-08
I10152 n1_m1_88000_259200 0 6.995199e-08
I10153 n1_m1_88000_264000 0 1.028108e-07
I10154 n1_m1_88000_268800 0 6.989481e-08
I10155 n1_m1_88000_273600 0 1.060131e-07
I10156 n1_m1_88000_278400 0 7.179382e-08
I10157 n1_m1_88000_283200 0 7.258376e-08
I10158 n1_m1_88000_288000 0 1.945256e-07
I10159 n1_m1_88000_292800 0 3.605673e-07
I10160 n1_m1_88000_297600 0 3.470693e-07
I10161 n1_m1_88000_302400 0 3.764712e-07
I10162 n1_m1_88000_307200 0 4.398257e-07
I10163 n1_m1_88000_312000 0 2.257543e-07
I10164 n1_m1_88000_316800 0 7.876919e-08
I10165 n1_m1_88000_321600 0 1.078174e-07
I10166 n1_m1_88000_326400 0 7.680116e-08
I10167 n1_m1_88000_331200 0 7.943461e-08
I10168 n1_m1_88000_336000 0 1.194243e-07
I10169 n1_m1_88000_340800 0 7.841824e-08
I10170 n1_m1_88000_345600 0 1.122421e-07
I10171 n1_m1_88000_350400 0 7.402884e-08
I10172 n1_m1_88000_355200 0 7.353746e-08
I10173 n1_m1_88000_360000 0 1.219711e-07
I10174 n1_m1_88000_364800 0 4.741267e-07
I10175 n1_m1_88000_369600 0 4.579434e-07
I10176 n1_m1_88000_374400 0 3.923490e-07
I10177 n1_m1_88000_379200 0 4.284003e-07
I10178 n1_m1_88000_384000 0 8.272635e-07
I10179 n1_m1_88000_388800 0 2.721430e-07
I10180 n1_m1_88000_393600 0 2.516002e-07
I10181 n1_m1_88000_398400 0 7.159514e-08
I10182 n1_m1_88000_403200 0 6.747069e-08
I10183 n1_m1_88000_408000 0 1.017522e-07
I10184 n1_m1_88000_412800 0 7.190040e-08
I10185 n1_m1_88000_417600 0 1.305652e-07
I10186 n1_m1_88000_422400 0 8.516442e-08
I10187 n1_m1_88000_427200 0 7.311844e-08
I10188 n1_m1_88000_432000 0 1.136999e-07
I10189 n1_m1_88000_436800 0 7.556673e-08
I10190 n1_m1_88000_441600 0 1.083722e-07
I10191 n1_m1_88000_446400 0 7.253915e-08
I10192 n1_m1_88000_451200 0 7.426484e-08
I10193 n1_m1_88000_456000 0 1.224972e-07
I10194 n1_m1_88000_460800 0 8.813459e-08
I10195 n1_m1_88000_465600 0 1.224155e-07
I10196 n1_m1_88000_470400 0 3.825286e-08
I10197 n1_m1_116000_0 0 1.885147e-07
I10198 n1_m1_116000_4800 0 2.444650e-07
I10199 n1_m1_116000_9600 0 2.886578e-07
I10200 n1_m1_116000_14400 0 1.476388e-07
I10201 n1_m1_116000_19200 0 1.407367e-07
I10202 n1_m1_116000_24000 0 2.089667e-07
I10203 n1_m1_116000_28800 0 1.368834e-07
I10204 n1_m1_116000_33600 0 2.048170e-07
I10205 n1_m1_116000_38400 0 1.399040e-07
I10206 n1_m1_116000_43200 0 1.399040e-07
I10207 n1_m1_116000_48000 0 2.098560e-07
I10208 n1_m1_116000_52800 0 1.399040e-07
I10209 n1_m1_116000_57600 0 2.072871e-07
I10210 n1_m1_116000_62400 0 1.343569e-07
I10211 n1_m1_116000_67200 0 1.405674e-07
I10212 n1_m1_116000_72000 0 2.346836e-07
I10213 n1_m1_116000_76800 0 1.533693e-07
I10214 n1_m1_116000_81600 0 2.166310e-07
I10215 n1_m1_116000_86400 0 1.456627e-07
I10216 n1_m1_116000_91200 0 1.469048e-07
I10217 n1_m1_116000_96000 0 2.160099e-07
I10218 n1_m1_116000_100800 0 1.509698e-07
I10219 n1_m1_116000_105600 0 2.297011e-07
I10220 n1_m1_116000_110400 0 1.501371e-07
I10221 n1_m1_116000_115200 0 1.515626e-07
I10222 n1_m1_116000_120000 0 2.237871e-07
I10223 n1_m1_116000_124800 0 1.587893e-07
I10224 n1_m1_116000_129600 0 2.274286e-07
I10225 n1_m1_116000_134400 0 1.473565e-07
I10226 n1_m1_116000_139200 0 1.401298e-07
I10227 n1_m1_116000_144000 0 2.100395e-07
I10228 n1_m1_116000_148800 0 1.359519e-07
I10229 n1_m1_116000_153600 0 2.146832e-07
I10230 n1_m1_116000_158400 0 1.413437e-07
I10231 n1_m1_116000_163200 0 1.508710e-07
I10232 n1_m1_116000_168000 0 2.527079e-07
I10233 n1_m1_116000_172800 0 1.561640e-07
I10234 n1_m1_116000_177600 0 2.165181e-07
I10235 n1_m1_116000_182400 0 1.432350e-07
I10236 n1_m1_116000_187200 0 1.464532e-07
I10237 n1_m1_116000_192000 0 2.242105e-07
I10238 n1_m1_116000_196800 0 1.466931e-07
I10239 n1_m1_116000_201600 0 2.226015e-07
I10240 n1_m1_116000_206400 0 1.535105e-07
I10241 n1_m1_116000_211200 0 1.605113e-07
I10242 n1_m1_116000_216000 0 2.225732e-07
I10243 n1_m1_116000_220800 0 1.375610e-07
I10244 n1_m1_116000_225600 0 2.101524e-07
I10245 n1_m1_116000_230400 0 1.404686e-07
I10246 n1_m1_116000_235200 0 1.365729e-07
I10247 n1_m1_116000_240000 0 2.048594e-07
I10248 n1_m1_116000_244800 0 1.365729e-07
I10249 n1_m1_116000_249600 0 2.075129e-07
I10250 n1_m1_116000_254400 0 1.402286e-07
I10251 n1_m1_116000_259200 0 1.423317e-07
I10252 n1_m1_116000_264000 0 2.186211e-07
I10253 n1_m1_116000_268800 0 1.460297e-07
I10254 n1_m1_116000_273600 0 2.209783e-07
I10255 n1_m1_116000_278400 0 1.432350e-07
I10256 n1_m1_116000_283200 0 1.587329e-07
I10257 n1_m1_116000_288000 0 2.568999e-07
I10258 n1_m1_116000_292800 0 2.636185e-07
I10259 n1_m1_116000_297600 0 1.202861e-06
I10260 n1_m1_116000_302400 0 9.525101e-07
I10261 n1_m1_116000_307200 0 6.929566e-07
I10262 n1_m1_116000_312000 0 3.691252e-07
I10263 n1_m1_116000_316800 0 1.449711e-07
I10264 n1_m1_116000_321600 0 2.021070e-07
I10265 n1_m1_116000_326400 0 1.362342e-07
I10266 n1_m1_116000_331200 0 1.381255e-07
I10267 n1_m1_116000_336000 0 2.085856e-07
I10268 n1_m1_116000_340800 0 1.399040e-07
I10269 n1_m1_116000_345600 0 2.096160e-07
I10270 n1_m1_116000_350400 0 1.378574e-07
I10271 n1_m1_116000_355200 0 1.429951e-07
I10272 n1_m1_116000_360000 0 2.151489e-07
I10273 n1_m1_116000_364800 0 1.545973e-07
I10274 n1_m1_116000_369600 0 3.641992e-07
I10275 n1_m1_116000_374400 0 4.071782e-07
I10276 n1_m1_116000_379200 0 5.797151e-07
I10277 n1_m1_116000_384000 0 1.260590e-06
I10278 n1_m1_116000_388800 0 4.890288e-07
I10279 n1_m1_116000_393600 0 3.004294e-07
I10280 n1_m1_116000_398400 0 1.558253e-07
I10281 n1_m1_116000_403200 0 1.459733e-07
I10282 n1_m1_116000_408000 0 2.123542e-07
I10283 n1_m1_116000_412800 0 1.415695e-07
I10284 n1_m1_116000_417600 0 2.098560e-07
I10285 n1_m1_116000_422400 0 1.399040e-07
I10286 n1_m1_116000_427200 0 1.399040e-07
I10287 n1_m1_116000_432000 0 2.098560e-07
I10288 n1_m1_116000_436800 0 1.399040e-07
I10289 n1_m1_116000_441600 0 2.124389e-07
I10290 n1_m1_116000_446400 0 1.399322e-07
I10291 n1_m1_116000_451200 0 1.380550e-07
I10292 n1_m1_116000_456000 0 2.262007e-07
I10293 n1_m1_116000_460800 0 1.821349e-07
I10294 n1_m1_116000_465600 0 2.548392e-07
I10295 n1_m1_116000_470400 0 7.890065e-08
I10296 n1_m1_172000_0 0 1.153608e-07
I10297 n1_m1_172000_4800 0 1.789774e-07
I10298 n1_m1_172000_9600 0 1.858264e-07
I10299 n1_m1_172000_14400 0 8.364316e-08
I10300 n1_m1_172000_19200 0 8.859104e-08
I10301 n1_m1_172000_24000 0 1.274988e-07
I10302 n1_m1_172000_28800 0 8.361493e-08
I10303 n1_m1_172000_33600 0 1.281747e-07
I10304 n1_m1_172000_38400 0 8.203481e-08
I10305 n1_m1_172000_43200 0 8.076378e-08
I10306 n1_m1_172000_48000 0 1.236533e-07
I10307 n1_m1_172000_52800 0 9.137485e-08
I10308 n1_m1_172000_57600 0 1.421667e-07
I10309 n1_m1_172000_62400 0 9.036661e-08
I10310 n1_m1_172000_67200 0 8.647146e-08
I10311 n1_m1_172000_72000 0 1.804549e-07
I10312 n1_m1_172000_76800 0 1.956531e-07
I10313 n1_m1_172000_81600 0 1.859428e-07
I10314 n1_m1_172000_86400 0 8.503452e-08
I10315 n1_m1_172000_91200 0 8.477232e-08
I10316 n1_m1_172000_96000 0 1.367988e-07
I10317 n1_m1_172000_100800 0 9.297040e-08
I10318 n1_m1_172000_105600 0 1.352214e-07
I10319 n1_m1_172000_110400 0 8.578774e-08
I10320 n1_m1_172000_115200 0 8.520091e-08
I10321 n1_m1_172000_120000 0 1.490165e-07
I10322 n1_m1_172000_124800 0 1.321878e-07
I10323 n1_m1_172000_129600 0 2.267650e-07
I10324 n1_m1_172000_134400 0 1.720807e-07
I10325 n1_m1_172000_139200 0 2.222539e-07
I10326 n1_m1_172000_144000 0 5.096451e-07
I10327 n1_m1_172000_148800 0 5.482528e-07
I10328 n1_m1_172000_153600 0 6.213155e-07
I10329 n1_m1_172000_158400 0 3.169846e-07
I10330 n1_m1_172000_163200 0 2.700611e-07
I10331 n1_m1_172000_168000 0 5.412516e-07
I10332 n1_m1_172000_172800 0 1.562114e-07
I10333 n1_m1_172000_177600 0 1.525022e-07
I10334 n1_m1_172000_182400 0 1.693076e-07
I10335 n1_m1_172000_187200 0 2.869028e-07
I10336 n1_m1_172000_192000 0 3.156495e-07
I10337 n1_m1_172000_196800 0 1.318749e-07
I10338 n1_m1_172000_201600 0 1.708998e-07
I10339 n1_m1_172000_206400 0 2.199131e-07
I10340 n1_m1_172000_211200 0 3.900228e-07
I10341 n1_m1_172000_216000 0 4.808907e-07
I10342 n1_m1_172000_220800 0 2.215359e-07
I10343 n1_m1_172000_225600 0 3.010925e-07
I10344 n1_m1_172000_230400 0 4.641287e-07
I10345 n1_m1_172000_235200 0 5.621706e-07
I10346 n1_m1_172000_240000 0 8.593045e-07
I10347 n1_m1_172000_244800 0 4.604974e-07
I10348 n1_m1_172000_249600 0 4.803781e-07
I10349 n1_m1_172000_254400 0 3.883966e-07
I10350 n1_m1_172000_259200 0 4.657413e-07
I10351 n1_m1_172000_264000 0 5.859792e-07
I10352 n1_m1_172000_268800 0 2.779991e-07
I10353 n1_m1_172000_273600 0 4.947696e-07
I10354 n1_m1_172000_278400 0 3.025884e-07
I10355 n1_m1_172000_283200 0 3.356083e-07
I10356 n1_m1_172000_288000 0 3.358023e-07
I10357 n1_m1_172000_292800 0 2.686209e-07
I10358 n1_m1_172000_297600 0 6.310349e-07
I10359 n1_m1_172000_302400 0 4.875442e-07
I10360 n1_m1_172000_307200 0 3.231522e-07
I10361 n1_m1_172000_312000 0 2.014117e-07
I10362 n1_m1_172000_316800 0 1.380208e-07
I10363 n1_m1_172000_321600 0 1.520092e-07
I10364 n1_m1_172000_326400 0 1.976222e-07
I10365 n1_m1_172000_331200 0 2.263863e-07
I10366 n1_m1_172000_336000 0 2.518402e-07
I10367 n1_m1_172000_340800 0 1.359243e-07
I10368 n1_m1_172000_345600 0 1.549662e-07
I10369 n1_m1_172000_350400 0 1.162733e-07
I10370 n1_m1_172000_355200 0 8.619587e-08
I10371 n1_m1_172000_360000 0 1.180293e-07
I10372 n1_m1_172000_364800 0 1.428970e-07
I10373 n1_m1_172000_369600 0 3.323660e-07
I10374 n1_m1_172000_374400 0 3.168167e-07
I10375 n1_m1_172000_379200 0 1.535030e-07
I10376 n1_m1_172000_384000 0 3.356433e-07
I10377 n1_m1_172000_388800 0 1.617443e-07
I10378 n1_m1_172000_393600 0 1.932973e-07
I10379 n1_m1_172000_398400 0 7.713979e-08
I10380 n1_m1_172000_403200 0 7.220973e-08
I10381 n1_m1_172000_408000 0 1.200350e-07
I10382 n1_m1_172000_412800 0 8.555568e-08
I10383 n1_m1_172000_417600 0 1.165015e-07
I10384 n1_m1_172000_422400 0 7.328303e-08
I10385 n1_m1_172000_427200 0 7.406843e-08
I10386 n1_m1_172000_432000 0 1.158386e-07
I10387 n1_m1_172000_436800 0 7.761048e-08
I10388 n1_m1_172000_441600 0 1.152175e-07
I10389 n1_m1_172000_446400 0 7.991690e-08
I10390 n1_m1_172000_451200 0 8.353024e-08
I10391 n1_m1_172000_456000 0 1.373322e-07
I10392 n1_m1_172000_460800 0 1.133682e-07
I10393 n1_m1_172000_465600 0 1.352831e-07
I10394 n1_m1_172000_470400 0 3.983142e-08
I10395 n1_m1_200000_0 0 1.068346e-07
I10396 n1_m1_200000_4800 0 1.735771e-07
I10397 n1_m1_200000_9600 0 4.924855e-07
I10398 n1_m1_200000_14400 0 2.254740e-07
I10399 n1_m1_200000_19200 0 1.301974e-07
I10400 n1_m1_200000_24000 0 1.322314e-07
I10401 n1_m1_200000_28800 0 7.541817e-08
I10402 n1_m1_200000_33600 0 1.149904e-07
I10403 n1_m1_200000_38400 0 7.664231e-08
I10404 n1_m1_200000_43200 0 7.521482e-08
I10405 n1_m1_200000_48000 0 1.139232e-07
I10406 n1_m1_200000_52800 0 7.978221e-08
I10407 n1_m1_200000_57600 0 1.175541e-07
I10408 n1_m1_200000_62400 0 7.930997e-08
I10409 n1_m1_200000_67200 0 7.964274e-08
I10410 n1_m1_200000_72000 0 1.191522e-07
I10411 n1_m1_200000_76800 0 9.025884e-08
I10412 n1_m1_200000_81600 0 1.274466e-07
I10413 n1_m1_200000_86400 0 1.031809e-07
I10414 n1_m1_200000_91200 0 1.026766e-07
I10415 n1_m1_200000_96000 0 1.955396e-07
I10416 n1_m1_200000_100800 0 9.225474e-08
I10417 n1_m1_200000_105600 0 2.392954e-07
I10418 n1_m1_200000_110400 0 1.143958e-07
I10419 n1_m1_200000_115200 0 9.972316e-08
I10420 n1_m1_200000_120000 0 2.395070e-07
I10421 n1_m1_200000_124800 0 1.027644e-07
I10422 n1_m1_200000_129600 0 2.644767e-07
I10423 n1_m1_200000_134400 0 1.383155e-07
I10424 n1_m1_200000_139200 0 2.196977e-07
I10425 n1_m1_200000_144000 0 2.143595e-07
I10426 n1_m1_200000_148800 0 9.111517e-08
I10427 n1_m1_200000_153600 0 1.520840e-07
I10428 n1_m1_200000_158400 0 9.561318e-08
I10429 n1_m1_200000_163200 0 1.373382e-07
I10430 n1_m1_200000_168000 0 2.001138e-07
I10431 n1_m1_200000_172800 0 9.401309e-08
I10432 n1_m1_200000_177600 0 1.659210e-07
I10433 n1_m1_200000_182400 0 1.797651e-07
I10434 n1_m1_200000_187200 0 1.480412e-07
I10435 n1_m1_200000_192000 0 1.348148e-07
I10436 n1_m1_200000_196800 0 8.578774e-08
I10437 n1_m1_200000_201600 0 2.619996e-07
I10438 n1_m1_200000_206400 0 3.314787e-07
I10439 n1_m1_200000_211200 0 2.354347e-07
I10440 n1_m1_200000_216000 0 2.298966e-07
I10441 n1_m1_200000_220800 0 2.316975e-07
I10442 n1_m1_200000_225600 0 7.190630e-07
I10443 n1_m1_200000_230400 0 2.446092e-07
I10444 n1_m1_200000_235200 0 1.809916e-07
I10445 n1_m1_200000_240000 0 2.022271e-07
I10446 n1_m1_200000_244800 0 2.087226e-07
I10447 n1_m1_200000_249600 0 3.586389e-07
I10448 n1_m1_200000_254400 0 1.450626e-07
I10449 n1_m1_200000_259200 0 1.497737e-07
I10450 n1_m1_200000_264000 0 2.167587e-07
I10451 n1_m1_200000_268800 0 1.317383e-07
I10452 n1_m1_200000_273600 0 2.837134e-07
I10453 n1_m1_200000_278400 0 1.552121e-07
I10454 n1_m1_200000_283200 0 1.157580e-07
I10455 n1_m1_200000_288000 0 2.129142e-07
I10456 n1_m1_200000_292800 0 9.234637e-08
I10457 n1_m1_200000_297600 0 2.285884e-07
I10458 n1_m1_200000_302400 0 1.093857e-07
I10459 n1_m1_200000_307200 0 9.640049e-08
I10460 n1_m1_200000_312000 0 3.539910e-07
I10461 n1_m1_200000_316800 0 1.518496e-07
I10462 n1_m1_200000_321600 0 1.248250e-07
I10463 n1_m1_200000_326400 0 8.545030e-08
I10464 n1_m1_200000_331200 0 8.506777e-08
I10465 n1_m1_200000_336000 0 1.240821e-07
I10466 n1_m1_200000_340800 0 7.343865e-08
I10467 n1_m1_200000_345600 0 1.150393e-07
I10468 n1_m1_200000_350400 0 7.433960e-08
I10469 n1_m1_200000_355200 0 7.278579e-08
I10470 n1_m1_200000_360000 0 1.051914e-07
I10471 n1_m1_200000_364800 0 7.246439e-08
I10472 n1_m1_200000_369600 0 1.142120e-07
I10473 n1_m1_200000_374400 0 7.508970e-08
I10474 n1_m1_200000_379200 0 7.331126e-08
I10475 n1_m1_200000_384000 0 1.130015e-07
I10476 n1_m1_200000_388800 0 7.332538e-08
I10477 n1_m1_200000_393600 0 1.096771e-07
I10478 n1_m1_200000_398400 0 7.047004e-08
I10479 n1_m1_200000_403200 0 6.998022e-08
I10480 n1_m1_200000_408000 0 1.049703e-07
I10481 n1_m1_200000_412800 0 7.483564e-08
I10482 n1_m1_200000_417600 0 1.063423e-07
I10483 n1_m1_200000_422400 0 6.995199e-08
I10484 n1_m1_200000_427200 0 6.995199e-08
I10485 n1_m1_200000_432000 0 1.079974e-07
I10486 n1_m1_200000_436800 0 7.090389e-08
I10487 n1_m1_200000_441600 0 1.099464e-07
I10488 n1_m1_200000_446400 0 7.328698e-08
I10489 n1_m1_200000_451200 0 7.385683e-08
I10490 n1_m1_200000_456000 0 1.240292e-07
I10491 n1_m1_200000_460800 0 9.944757e-08
I10492 n1_m1_200000_465600 0 1.290556e-07
I10493 n1_m1_200000_470400 0 3.945032e-08
I10494 n1_m1_228000_0 0 1.447776e-07
I10495 n1_m1_228000_4800 0 2.723358e-07
I10496 n1_m1_228000_9600 0 2.891053e-07
I10497 n1_m1_228000_14400 0 9.353331e-08
I10498 n1_m1_228000_19200 0 1.082832e-07
I10499 n1_m1_228000_24000 0 1.315248e-07
I10500 n1_m1_228000_28800 0 8.115588e-08
I10501 n1_m1_228000_33600 0 2.439528e-07
I10502 n1_m1_228000_38400 0 1.116922e-07
I10503 n1_m1_228000_43200 0 8.411253e-08
I10504 n1_m1_228000_48000 0 1.812753e-07
I10505 n1_m1_228000_52800 0 1.062278e-07
I10506 n1_m1_228000_57600 0 2.448671e-07
I10507 n1_m1_228000_62400 0 1.250086e-07
I10508 n1_m1_228000_67200 0 1.224066e-07
I10509 n1_m1_228000_72000 0 3.088883e-07
I10510 n1_m1_228000_76800 0 4.345445e-07
I10511 n1_m1_228000_81600 0 3.734337e-07
I10512 n1_m1_228000_86400 0 1.715688e-07
I10513 n1_m1_228000_91200 0 2.755705e-07
I10514 n1_m1_228000_96000 0 4.626138e-07
I10515 n1_m1_228000_100800 0 5.877788e-07
I10516 n1_m1_228000_105600 0 7.823310e-07
I10517 n1_m1_228000_110400 0 3.869708e-07
I10518 n1_m1_228000_115200 0 3.546886e-07
I10519 n1_m1_228000_120000 0 7.551406e-07
I10520 n1_m1_228000_124800 0 6.684299e-07
I10521 n1_m1_228000_129600 0 9.849669e-07
I10522 n1_m1_228000_134400 0 6.403529e-07
I10523 n1_m1_228000_139200 0 6.029643e-07
I10524 n1_m1_228000_144000 0 9.061914e-07
I10525 n1_m1_228000_148800 0 5.967511e-07
I10526 n1_m1_228000_153600 0 8.087687e-07
I10527 n1_m1_228000_158400 0 3.367213e-07
I10528 n1_m1_228000_163200 0 4.528736e-07
I10529 n1_m1_228000_168000 0 8.967124e-07
I10530 n1_m1_228000_172800 0 4.298591e-07
I10531 n1_m1_228000_177600 0 4.609619e-07
I10532 n1_m1_228000_182400 0 4.020467e-07
I10533 n1_m1_228000_187200 0 4.486390e-07
I10534 n1_m1_228000_192000 0 8.118767e-07
I10535 n1_m1_228000_196800 0 4.991691e-07
I10536 n1_m1_228000_201600 0 9.285725e-07
I10537 n1_m1_228000_206400 0 6.390043e-07
I10538 n1_m1_228000_211200 0 7.100473e-07
I10539 n1_m1_228000_216000 0 8.185395e-07
I10540 n1_m1_228000_220800 0 5.540808e-07
I10541 n1_m1_228000_225600 0 7.649371e-07
I10542 n1_m1_228000_230400 0 4.402578e-07
I10543 n1_m1_228000_235200 0 6.480721e-07
I10544 n1_m1_228000_240000 0 8.234752e-07
I10545 n1_m1_228000_244800 0 5.239567e-07
I10546 n1_m1_228000_249600 0 4.663917e-07
I10547 n1_m1_228000_254400 0 4.677114e-07
I10548 n1_m1_228000_259200 0 4.652502e-07
I10549 n1_m1_228000_264000 0 4.441188e-07
I10550 n1_m1_228000_268800 0 2.595561e-07
I10551 n1_m1_228000_273600 0 4.800971e-07
I10552 n1_m1_228000_278400 0 6.202135e-07
I10553 n1_m1_228000_283200 0 4.963944e-07
I10554 n1_m1_228000_288000 0 6.347728e-07
I10555 n1_m1_228000_292800 0 3.252400e-07
I10556 n1_m1_228000_297600 0 7.560862e-07
I10557 n1_m1_228000_302400 0 3.881592e-07
I10558 n1_m1_228000_307200 0 2.019636e-07
I10559 n1_m1_228000_312000 0 3.597804e-07
I10560 n1_m1_228000_316800 0 2.418264e-07
I10561 n1_m1_228000_321600 0 7.292121e-07
I10562 n1_m1_228000_326400 0 4.219650e-07
I10563 n1_m1_228000_331200 0 2.463870e-07
I10564 n1_m1_228000_336000 0 2.567966e-07
I10565 n1_m1_228000_340800 0 9.397325e-08
I10566 n1_m1_228000_345600 0 1.891346e-07
I10567 n1_m1_228000_350400 0 9.160487e-08
I10568 n1_m1_228000_355200 0 7.364284e-08
I10569 n1_m1_228000_360000 0 1.086911e-07
I10570 n1_m1_228000_364800 0 8.549193e-08
I10571 n1_m1_228000_369600 0 1.197677e-07
I10572 n1_m1_228000_374400 0 8.124104e-08
I10573 n1_m1_228000_379200 0 8.468453e-08
I10574 n1_m1_228000_384000 0 1.349621e-07
I10575 n1_m1_228000_388800 0 8.352462e-08
I10576 n1_m1_228000_393600 0 1.131379e-07
I10577 n1_m1_228000_398400 0 7.085532e-08
I10578 n1_m1_228000_403200 0 7.293017e-08
I10579 n1_m1_228000_408000 0 1.099246e-07
I10580 n1_m1_228000_412800 0 7.328303e-08
I10581 n1_m1_228000_417600 0 1.107229e-07
I10582 n1_m1_228000_422400 0 7.689637e-08
I10583 n1_m1_228000_427200 0 7.861836e-08
I10584 n1_m1_228000_432000 0 1.136213e-07
I10585 n1_m1_228000_436800 0 7.328303e-08
I10586 n1_m1_228000_441600 0 1.157942e-07
I10587 n1_m1_228000_446400 0 7.647090e-08
I10588 n1_m1_228000_451200 0 7.945112e-08
I10589 n1_m1_228000_456000 0 1.327163e-07
I10590 n1_m1_228000_460800 0 9.104041e-08
I10591 n1_m1_228000_465600 0 1.324841e-07
I10592 n1_m1_228000_470400 0 4.353291e-08
I10593 n1_m1_256000_0 0 1.273798e-07
I10594 n1_m1_256000_4800 0 2.472305e-07
I10595 n1_m1_256000_9600 0 4.490453e-07
I10596 n1_m1_256000_14400 0 2.139011e-07
I10597 n1_m1_256000_19200 0 2.953309e-07
I10598 n1_m1_256000_24000 0 5.396184e-07
I10599 n1_m1_256000_28800 0 4.441481e-07
I10600 n1_m1_256000_33600 0 5.993832e-07
I10601 n1_m1_256000_38400 0 2.616616e-07
I10602 n1_m1_256000_43200 0 2.395974e-07
I10603 n1_m1_256000_48000 0 4.878187e-07
I10604 n1_m1_256000_52800 0 5.549699e-07
I10605 n1_m1_256000_57600 0 6.484370e-07
I10606 n1_m1_256000_62400 0 4.844912e-07
I10607 n1_m1_256000_67200 0 3.064765e-07
I10608 n1_m1_256000_72000 0 8.414336e-07
I10609 n1_m1_256000_76800 0 6.024925e-07
I10610 n1_m1_256000_81600 0 4.687902e-07
I10611 n1_m1_256000_86400 0 2.719736e-07
I10612 n1_m1_256000_91200 0 3.684927e-07
I10613 n1_m1_256000_96000 0 7.515204e-07
I10614 n1_m1_256000_100800 0 3.787482e-07
I10615 n1_m1_256000_105600 0 4.848783e-07
I10616 n1_m1_256000_110400 0 3.204833e-07
I10617 n1_m1_256000_115200 0 4.122008e-07
I10618 n1_m1_256000_120000 0 4.774682e-07
I10619 n1_m1_256000_124800 0 1.423523e-07
I10620 n1_m1_256000_129600 0 3.449754e-07
I10621 n1_m1_256000_134400 0 5.368136e-07
I10622 n1_m1_256000_139200 0 6.114136e-07
I10623 n1_m1_256000_144000 0 6.766430e-07
I10624 n1_m1_256000_148800 0 3.854777e-07
I10625 n1_m1_256000_153600 0 4.821933e-07
I10626 n1_m1_256000_158400 0 4.371898e-07
I10627 n1_m1_256000_163200 0 5.130737e-07
I10628 n1_m1_256000_168000 0 3.393053e-07
I10629 n1_m1_256000_172800 0 2.046053e-07
I10630 n1_m1_256000_177600 0 3.290491e-07
I10631 n1_m1_256000_182400 0 4.362992e-07
I10632 n1_m1_256000_187200 0 3.984907e-07
I10633 n1_m1_256000_192000 0 5.099602e-07
I10634 n1_m1_256000_196800 0 4.454141e-07
I10635 n1_m1_256000_201600 0 5.124273e-07
I10636 n1_m1_256000_206400 0 4.712060e-07
I10637 n1_m1_256000_211200 0 3.445417e-07
I10638 n1_m1_256000_216000 0 5.543943e-07
I10639 n1_m1_256000_220800 0 5.811074e-07
I10640 n1_m1_256000_225600 0 9.811009e-07
I10641 n1_m1_256000_230400 0 5.799424e-07
I10642 n1_m1_256000_235200 0 5.049077e-07
I10643 n1_m1_256000_240000 0 9.330764e-07
I10644 n1_m1_256000_244800 0 6.008851e-07
I10645 n1_m1_256000_249600 0 8.559376e-07
I10646 n1_m1_256000_254400 0 3.883416e-07
I10647 n1_m1_256000_259200 0 3.246270e-07
I10648 n1_m1_256000_264000 0 5.577528e-07
I10649 n1_m1_256000_268800 0 2.447717e-07
I10650 n1_m1_256000_273600 0 3.568658e-07
I10651 n1_m1_256000_278400 0 2.284313e-07
I10652 n1_m1_256000_283200 0 3.128098e-07
I10653 n1_m1_256000_288000 0 2.785384e-07
I10654 n1_m1_256000_292800 0 1.530019e-07
I10655 n1_m1_256000_297600 0 3.048500e-07
I10656 n1_m1_256000_302400 0 9.577586e-08
I10657 n1_m1_256000_307200 0 9.423258e-08
I10658 n1_m1_256000_312000 0 1.336434e-07
I10659 n1_m1_256000_316800 0 9.308439e-08
I10660 n1_m1_256000_321600 0 1.260146e-07
I10661 n1_m1_256000_326400 0 7.795975e-08
I10662 n1_m1_256000_331200 0 7.358566e-08
I10663 n1_m1_256000_336000 0 1.123450e-07
I10664 n1_m1_256000_340800 0 7.314930e-08
I10665 n1_m1_256000_345600 0 1.092374e-07
I10666 n1_m1_256000_350400 0 7.515358e-08
I10667 n1_m1_256000_355200 0 7.264860e-08
I10668 n1_m1_256000_360000 0 1.165289e-07
I10669 n1_m1_256000_364800 0 7.006144e-08
I10670 n1_m1_256000_369600 0 2.007919e-07
I10671 n1_m1_256000_374400 0 2.380316e-07
I10672 n1_m1_256000_379200 0 2.859744e-07
I10673 n1_m1_256000_384000 0 6.030140e-07
I10674 n1_m1_256000_388800 0 1.453615e-07
I10675 n1_m1_256000_393600 0 1.350535e-07
I10676 n1_m1_256000_398400 0 7.232073e-08
I10677 n1_m1_256000_403200 0 7.020605e-08
I10678 n1_m1_256000_408000 0 1.128664e-07
I10679 n1_m1_256000_412800 0 7.604842e-08
I10680 n1_m1_256000_417600 0 1.076903e-07
I10681 n1_m1_256000_422400 0 7.263376e-08
I10682 n1_m1_256000_427200 0 7.074241e-08
I10683 n1_m1_256000_432000 0 1.023878e-07
I10684 n1_m1_256000_436800 0 7.191966e-08
I10685 n1_m1_256000_441600 0 1.184672e-07
I10686 n1_m1_256000_446400 0 8.444948e-08
I10687 n1_m1_256000_451200 0 8.746199e-08
I10688 n1_m1_256000_456000 0 2.375221e-07
I10689 n1_m1_256000_460800 0 1.247127e-07
I10690 n1_m1_256000_465600 0 1.346988e-07
I10691 n1_m1_256000_470400 0 4.097841e-08
I10692 n1_m1_284000_0 0 2.662665e-07
I10693 n1_m1_284000_4800 0 5.617667e-07
I10694 n1_m1_284000_9600 0 1.204034e-06
I10695 n1_m1_284000_14400 0 4.044880e-07
I10696 n1_m1_284000_19200 0 2.103227e-07
I10697 n1_m1_284000_24000 0 2.627288e-07
I10698 n1_m1_284000_28800 0 1.729058e-07
I10699 n1_m1_284000_33600 0 2.720160e-07
I10700 n1_m1_284000_38400 0 2.223524e-07
I10701 n1_m1_284000_43200 0 2.220811e-07
I10702 n1_m1_284000_48000 0 4.261044e-07
I10703 n1_m1_284000_52800 0 2.134785e-07
I10704 n1_m1_284000_57600 0 3.077821e-07
I10705 n1_m1_284000_62400 0 1.721543e-07
I10706 n1_m1_284000_67200 0 1.870624e-07
I10707 n1_m1_284000_72000 0 3.564393e-07
I10708 n1_m1_284000_76800 0 3.324511e-07
I10709 n1_m1_284000_81600 0 3.922466e-07
I10710 n1_m1_284000_86400 0 1.858583e-07
I10711 n1_m1_284000_91200 0 3.770282e-07
I10712 n1_m1_284000_96000 0 4.691164e-07
I10713 n1_m1_284000_100800 0 2.096338e-07
I10714 n1_m1_284000_105600 0 3.549285e-07
I10715 n1_m1_284000_110400 0 2.302726e-07
I10716 n1_m1_284000_115200 0 3.009023e-07
I10717 n1_m1_284000_120000 0 8.453096e-07
I10718 n1_m1_284000_124800 0 5.496034e-07
I10719 n1_m1_284000_129600 0 3.661058e-07
I10720 n1_m1_284000_134400 0 2.900815e-07
I10721 n1_m1_284000_139200 0 3.735844e-07
I10722 n1_m1_284000_144000 0 6.487897e-07
I10723 n1_m1_284000_148800 0 2.804795e-07
I10724 n1_m1_284000_153600 0 3.676208e-07
I10725 n1_m1_284000_158400 0 3.345918e-07
I10726 n1_m1_284000_163200 0 3.564562e-07
I10727 n1_m1_284000_168000 0 3.987997e-07
I10728 n1_m1_284000_172800 0 3.069912e-07
I10729 n1_m1_284000_177600 0 4.132686e-07
I10730 n1_m1_284000_182400 0 3.197193e-07
I10731 n1_m1_284000_187200 0 2.757889e-07
I10732 n1_m1_284000_192000 0 6.363171e-07
I10733 n1_m1_284000_196800 0 2.609623e-07
I10734 n1_m1_284000_201600 0 6.805339e-07
I10735 n1_m1_284000_206400 0 6.138754e-07
I10736 n1_m1_284000_211200 0 8.910624e-07
I10737 n1_m1_284000_216000 0 1.043124e-06
I10738 n1_m1_284000_220800 0 6.600416e-07
I10739 n1_m1_284000_225600 0 6.933366e-07
I10740 n1_m1_284000_230400 0 4.386568e-07
I10741 n1_m1_284000_235200 0 5.385287e-07
I10742 n1_m1_284000_240000 0 6.663580e-07
I10743 n1_m1_284000_244800 0 4.259453e-07
I10744 n1_m1_284000_249600 0 7.360551e-07
I10745 n1_m1_284000_254400 0 6.343785e-07
I10746 n1_m1_284000_259200 0 7.281221e-07
I10747 n1_m1_284000_264000 0 7.206645e-07
I10748 n1_m1_284000_268800 0 4.211394e-07
I10749 n1_m1_284000_273600 0 7.784291e-07
I10750 n1_m1_284000_278400 0 9.434731e-07
I10751 n1_m1_284000_283200 0 6.721354e-07
I10752 n1_m1_284000_288000 0 6.586119e-07
I10753 n1_m1_284000_292800 0 4.948907e-07
I10754 n1_m1_284000_297600 0 7.353872e-07
I10755 n1_m1_284000_302400 0 5.772511e-07
I10756 n1_m1_284000_307200 0 5.607105e-07
I10757 n1_m1_284000_312000 0 9.751525e-07
I10758 n1_m1_284000_316800 0 7.453184e-07
I10759 n1_m1_284000_321600 0 8.016828e-07
I10760 n1_m1_284000_326400 0 4.351858e-07
I10761 n1_m1_284000_331200 0 3.740763e-07
I10762 n1_m1_284000_336000 0 3.968240e-07
I10763 n1_m1_284000_340800 0 2.046649e-07
I10764 n1_m1_284000_345600 0 3.560945e-07
I10765 n1_m1_284000_350400 0 1.837145e-07
I10766 n1_m1_284000_355200 0 1.801613e-07
I10767 n1_m1_284000_360000 0 4.573980e-07
I10768 n1_m1_284000_364800 0 2.405996e-07
I10769 n1_m1_284000_369600 0 8.444534e-07
I10770 n1_m1_284000_374400 0 8.882023e-07
I10771 n1_m1_284000_379200 0 5.746135e-07
I10772 n1_m1_284000_384000 0 8.110263e-07
I10773 n1_m1_284000_388800 0 3.108464e-07
I10774 n1_m1_284000_393600 0 3.664453e-07
I10775 n1_m1_284000_398400 0 1.491872e-07
I10776 n1_m1_284000_403200 0 1.417645e-07
I10777 n1_m1_284000_408000 0 2.153137e-07
I10778 n1_m1_284000_412800 0 1.456478e-07
I10779 n1_m1_284000_417600 0 2.165646e-07
I10780 n1_m1_284000_422400 0 1.399040e-07
I10781 n1_m1_284000_427200 0 1.399040e-07
I10782 n1_m1_284000_432000 0 2.098560e-07
I10783 n1_m1_284000_436800 0 1.399040e-07
I10784 n1_m1_284000_441600 0 2.159563e-07
I10785 n1_m1_284000_446400 0 1.469613e-07
I10786 n1_m1_284000_451200 0 1.490848e-07
I10787 n1_m1_284000_456000 0 2.487464e-07
I10788 n1_m1_284000_460800 0 1.979341e-07
I10789 n1_m1_284000_465600 0 2.635952e-07
I10790 n1_m1_284000_470400 0 7.973449e-08
I10791 n1_m1_340000_0 0 9.937735e-08
I10792 n1_m1_340000_4800 0 1.595954e-07
I10793 n1_m1_340000_9600 0 4.572455e-07
I10794 n1_m1_340000_14400 0 2.155192e-07
I10795 n1_m1_340000_19200 0 9.608578e-08
I10796 n1_m1_340000_24000 0 1.122548e-07
I10797 n1_m1_340000_28800 0 7.452775e-08
I10798 n1_m1_340000_33600 0 1.142996e-07
I10799 n1_m1_340000_38400 0 7.559305e-08
I10800 n1_m1_340000_43200 0 7.323495e-08
I10801 n1_m1_340000_48000 0 1.101829e-07
I10802 n1_m1_340000_52800 0 7.346676e-08
I10803 n1_m1_340000_57600 0 1.100729e-07
I10804 n1_m1_340000_62400 0 7.821776e-08
I10805 n1_m1_340000_67200 0 7.542965e-08
I10806 n1_m1_340000_72000 0 1.289143e-07
I10807 n1_m1_340000_76800 0 8.225394e-08
I10808 n1_m1_340000_81600 0 1.333489e-07
I10809 n1_m1_340000_86400 0 1.187749e-07
I10810 n1_m1_340000_91200 0 7.888606e-08
I10811 n1_m1_340000_96000 0 1.441406e-07
I10812 n1_m1_340000_100800 0 1.806121e-07
I10813 n1_m1_340000_105600 0 1.944242e-07
I10814 n1_m1_340000_110400 0 8.928457e-08
I10815 n1_m1_340000_115200 0 8.087310e-08
I10816 n1_m1_340000_120000 0 1.251464e-07
I10817 n1_m1_340000_124800 0 9.532909e-08
I10818 n1_m1_340000_129600 0 2.412019e-07
I10819 n1_m1_340000_134400 0 1.145061e-07
I10820 n1_m1_340000_139200 0 1.073782e-07
I10821 n1_m1_340000_144000 0 1.530774e-07
I10822 n1_m1_340000_148800 0 9.161707e-08
I10823 n1_m1_340000_153600 0 1.219583e-07
I10824 n1_m1_340000_158400 0 7.357215e-08
I10825 n1_m1_340000_163200 0 7.043344e-08
I10826 n1_m1_340000_168000 0 1.049280e-07
I10827 n1_m1_340000_172800 0 6.995199e-08
I10828 n1_m1_340000_177600 0 1.161773e-07
I10829 n1_m1_340000_182400 0 8.381803e-08
I10830 n1_m1_340000_187200 0 8.629670e-08
I10831 n1_m1_340000_192000 0 1.276358e-07
I10832 n1_m1_340000_196800 0 8.733269e-08
I10833 n1_m1_340000_201600 0 1.252067e-07
I10834 n1_m1_340000_206400 0 8.397569e-08
I10835 n1_m1_340000_211200 0 8.242404e-08
I10836 n1_m1_340000_216000 0 1.136284e-07
I10837 n1_m1_340000_220800 0 7.096513e-08
I10838 n1_m1_340000_225600 0 1.018369e-07
I10839 n1_m1_340000_230400 0 7.130005e-08
I10840 n1_m1_340000_235200 0 7.153282e-08
I10841 n1_m1_340000_240000 0 1.055393e-07
I10842 n1_m1_340000_244800 0 7.312251e-08
I10843 n1_m1_340000_249600 0 1.099199e-07
I10844 n1_m1_340000_254400 0 7.289668e-08
I10845 n1_m1_340000_259200 0 7.036657e-08
I10846 n1_m1_340000_264000 0 1.089352e-07
I10847 n1_m1_340000_268800 0 7.180507e-08
I10848 n1_m1_340000_273600 0 1.062903e-07
I10849 n1_m1_340000_278400 0 8.038316e-08
I10850 n1_m1_340000_283200 0 3.451241e-07
I10851 n1_m1_340000_288000 0 5.312539e-07
I10852 n1_m1_340000_292800 0 1.804434e-07
I10853 n1_m1_340000_297600 0 1.514699e-07
I10854 n1_m1_340000_302400 0 7.521171e-08
I10855 n1_m1_340000_307200 0 7.003883e-08
I10856 n1_m1_340000_312000 0 1.005186e-07
I10857 n1_m1_340000_316800 0 6.675611e-08
I10858 n1_m1_340000_321600 0 1.096304e-07
I10859 n1_m1_340000_326400 0 7.652939e-08
I10860 n1_m1_340000_331200 0 7.479617e-08
I10861 n1_m1_340000_336000 0 1.091283e-07
I10862 n1_m1_340000_340800 0 6.999326e-08
I10863 n1_m1_340000_345600 0 1.049341e-07
I10864 n1_m1_340000_350400 0 7.001371e-08
I10865 n1_m1_340000_355200 0 6.996168e-08
I10866 n1_m1_340000_360000 0 1.049280e-07
I10867 n1_m1_340000_364800 0 7.227671e-08
I10868 n1_m1_340000_369600 0 1.014615e-07
I10869 n1_m1_340000_374400 0 6.988979e-08
I10870 n1_m1_340000_379200 0 8.106329e-08
I10871 n1_m1_340000_384000 0 2.090868e-07
I10872 n1_m1_340000_388800 0 3.934009e-07
I10873 n1_m1_340000_393600 0 6.078753e-07
I10874 n1_m1_340000_398400 0 5.825262e-07
I10875 n1_m1_340000_403200 0 4.481709e-07
I10876 n1_m1_340000_408000 0 3.071057e-07
I10877 n1_m1_340000_412800 0 8.662481e-08
I10878 n1_m1_340000_417600 0 1.183916e-07
I10879 n1_m1_340000_422400 0 8.011163e-08
I10880 n1_m1_340000_427200 0 7.457321e-08
I10881 n1_m1_340000_432000 0 1.059975e-07
I10882 n1_m1_340000_436800 0 7.420455e-08
I10883 n1_m1_340000_441600 0 1.092973e-07
I10884 n1_m1_340000_446400 0 7.323256e-08
I10885 n1_m1_340000_451200 0 7.671528e-08
I10886 n1_m1_340000_456000 0 1.241662e-07
I10887 n1_m1_340000_460800 0 9.129578e-08
I10888 n1_m1_340000_465600 0 1.255960e-07
I10889 n1_m1_340000_470400 0 3.815621e-08
I10890 n1_m1_368000_0 0 1.249372e-07
I10891 n1_m1_368000_4800 0 2.256685e-07
I10892 n1_m1_368000_9600 0 2.596143e-07
I10893 n1_m1_368000_14400 0 8.492914e-08
I10894 n1_m1_368000_19200 0 8.024692e-08
I10895 n1_m1_368000_24000 0 1.189745e-07
I10896 n1_m1_368000_28800 0 8.122023e-08
I10897 n1_m1_368000_33600 0 2.187492e-07
I10898 n1_m1_368000_38400 0 1.063665e-07
I10899 n1_m1_368000_43200 0 8.976770e-08
I10900 n1_m1_368000_48000 0 1.131409e-07
I10901 n1_m1_368000_52800 0 7.553408e-08
I10902 n1_m1_368000_57600 0 1.169796e-07
I10903 n1_m1_368000_62400 0 7.624961e-08
I10904 n1_m1_368000_67200 0 7.287646e-08
I10905 n1_m1_368000_72000 0 1.026772e-07
I10906 n1_m1_368000_76800 0 6.712117e-08
I10907 n1_m1_368000_81600 0 1.022356e-07
I10908 n1_m1_368000_86400 0 6.926276e-08
I10909 n1_m1_368000_91200 0 6.955678e-08
I10910 n1_m1_368000_96000 0 1.114388e-07
I10911 n1_m1_368000_100800 0 7.996857e-08
I10912 n1_m1_368000_105600 0 1.194763e-07
I10913 n1_m1_368000_110400 0 7.643538e-08
I10914 n1_m1_368000_115200 0 7.532953e-08
I10915 n1_m1_368000_120000 0 1.158577e-07
I10916 n1_m1_368000_124800 0 7.438397e-08
I10917 n1_m1_368000_129600 0 1.075761e-07
I10918 n1_m1_368000_134400 0 6.923071e-08
I10919 n1_m1_368000_139200 0 6.806063e-08
I10920 n1_m1_368000_144000 0 1.021732e-07
I10921 n1_m1_368000_148800 0 6.881457e-08
I10922 n1_m1_368000_153600 0 1.049219e-07
I10923 n1_m1_368000_158400 0 6.995199e-08
I10924 n1_m1_368000_163200 0 6.995199e-08
I10925 n1_m1_368000_168000 0 1.049280e-07
I10926 n1_m1_368000_172800 0 6.995199e-08
I10927 n1_m1_368000_177600 0 1.067276e-07
I10928 n1_m1_368000_182400 0 7.196511e-08
I10929 n1_m1_368000_187200 0 7.535405e-08
I10930 n1_m1_368000_192000 0 1.168061e-07
I10931 n1_m1_368000_196800 0 7.788607e-08
I10932 n1_m1_368000_201600 0 1.265624e-07
I10933 n1_m1_368000_206400 0 8.772945e-08
I10934 n1_m1_368000_211200 0 8.370894e-08
I10935 n1_m1_368000_216000 0 1.141457e-07
I10936 n1_m1_368000_220800 0 7.184335e-08
I10937 n1_m1_368000_225600 0 1.047597e-07
I10938 n1_m1_368000_230400 0 6.884602e-08
I10939 n1_m1_368000_235200 0 6.828646e-08
I10940 n1_m1_368000_240000 0 1.031681e-07
I10941 n1_m1_368000_244800 0 6.857354e-08
I10942 n1_m1_368000_249600 0 1.049280e-07
I10943 n1_m1_368000_254400 0 6.995199e-08
I10944 n1_m1_368000_259200 0 7.041777e-08
I10945 n1_m1_368000_264000 0 1.108303e-07
I10946 n1_m1_368000_268800 0 7.141249e-08
I10947 n1_m1_368000_273600 0 2.569636e-07
I10948 n1_m1_368000_278400 0 3.520735e-07
I10949 n1_m1_368000_283200 0 2.168745e-07
I10950 n1_m1_368000_288000 0 2.809350e-07
I10951 n1_m1_368000_292800 0 8.659359e-08
I10952 n1_m1_368000_297600 0 1.245626e-07
I10953 n1_m1_368000_302400 0 7.566984e-08
I10954 n1_m1_368000_307200 0 8.532375e-08
I10955 n1_m1_368000_312000 0 1.184876e-07
I10956 n1_m1_368000_316800 0 6.806960e-08
I10957 n1_m1_368000_321600 0 1.140862e-07
I10958 n1_m1_368000_326400 0 1.031553e-07
I10959 n1_m1_368000_331200 0 1.096631e-07
I10960 n1_m1_368000_336000 0 2.641368e-07
I10961 n1_m1_368000_340800 0 1.166313e-07
I10962 n1_m1_368000_345600 0 1.320033e-07
I10963 n1_m1_368000_350400 0 7.554580e-08
I10964 n1_m1_368000_355200 0 6.986252e-08
I10965 n1_m1_368000_360000 0 1.001714e-07
I10966 n1_m1_368000_364800 0 6.662094e-08
I10967 n1_m1_368000_369600 0 9.993141e-08
I10968 n1_m1_368000_374400 0 6.817355e-08
I10969 n1_m1_368000_379200 0 6.995199e-08
I10970 n1_m1_368000_384000 0 1.049280e-07
I10971 n1_m1_368000_388800 0 6.995199e-08
I10972 n1_m1_368000_393600 0 1.050439e-07
I10973 n1_m1_368000_398400 0 7.117816e-08
I10974 n1_m1_368000_403200 0 7.146632e-08
I10975 n1_m1_368000_408000 0 1.077363e-07
I10976 n1_m1_368000_412800 0 7.285254e-08
I10977 n1_m1_368000_417600 0 1.050462e-07
I10978 n1_m1_368000_422400 0 6.920774e-08
I10979 n1_m1_368000_427200 0 6.806063e-08
I10980 n1_m1_368000_432000 0 1.020315e-07
I10981 n1_m1_368000_436800 0 6.995199e-08
I10982 n1_m1_368000_441600 0 1.049280e-07
I10983 n1_m1_368000_446400 0 6.995199e-08
I10984 n1_m1_368000_451200 0 7.053069e-08
I10985 n1_m1_368000_456000 0 1.167701e-07
I10986 n1_m1_368000_460800 0 8.823040e-08
I10987 n1_m1_368000_465600 0 1.270224e-07
I10988 n1_m1_368000_470400 0 4.000546e-08
I10989 n1_m1_396000_0 0 8.384076e-08
I10990 n1_m1_396000_4800 0 9.935271e-08
I10991 n1_m1_396000_9600 0 1.278078e-07
I10992 n1_m1_396000_14400 0 7.400288e-08
I10993 n1_m1_396000_19200 0 7.295840e-08
I10994 n1_m1_396000_24000 0 1.072004e-07
I10995 n1_m1_396000_28800 0 7.328303e-08
I10996 n1_m1_396000_33600 0 2.320438e-07
I10997 n1_m1_396000_38400 0 1.277314e-07
I10998 n1_m1_396000_43200 0 9.084160e-08
I10999 n1_m1_396000_48000 0 1.089840e-07
I11000 n1_m1_396000_52800 0 6.908274e-08
I11001 n1_m1_396000_57600 0 1.025595e-07
I11002 n1_m1_396000_62400 0 7.216643e-08
I11003 n1_m1_396000_67200 0 7.245063e-08
I11004 n1_m1_396000_72000 0 1.052714e-07
I11005 n1_m1_396000_76800 0 6.960199e-08
I11006 n1_m1_396000_81600 0 1.014590e-07
I11007 n1_m1_396000_86400 0 6.961108e-08
I11008 n1_m1_396000_91200 0 6.995199e-08
I11009 n1_m1_396000_96000 0 1.049280e-07
I11010 n1_m1_396000_100800 0 6.995199e-08
I11011 n1_m1_396000_105600 0 1.074386e-07
I11012 n1_m1_396000_110400 0 7.289213e-08
I11013 n1_m1_396000_115200 0 7.319895e-08
I11014 n1_m1_396000_120000 0 1.154544e-07
I11015 n1_m1_396000_124800 0 8.309891e-08
I11016 n1_m1_396000_129600 0 1.141602e-07
I11017 n1_m1_396000_134400 0 6.995199e-08
I11018 n1_m1_396000_139200 0 6.995199e-08
I11019 n1_m1_396000_144000 0 1.020345e-07
I11020 n1_m1_396000_148800 0 6.979673e-08
I11021 n1_m1_396000_153600 0 1.049280e-07
I11022 n1_m1_396000_158400 0 6.972699e-08
I11023 n1_m1_396000_163200 0 6.750585e-08
I11024 n1_m1_396000_168000 0 1.019925e-07
I11025 n1_m1_396000_172800 0 7.223855e-08
I11026 n1_m1_396000_177600 0 1.057607e-07
I11027 n1_m1_396000_182400 0 6.862521e-08
I11028 n1_m1_396000_187200 0 7.144814e-08
I11029 n1_m1_396000_192000 0 1.241234e-07
I11030 n1_m1_396000_196800 0 1.162950e-07
I11031 n1_m1_396000_201600 0 2.515905e-07
I11032 n1_m1_396000_206400 0 1.732268e-07
I11033 n1_m1_396000_211200 0 9.596401e-08
I11034 n1_m1_396000_216000 0 1.141138e-07
I11035 n1_m1_396000_220800 0 6.875607e-08
I11036 n1_m1_396000_225600 0 1.021333e-07
I11037 n1_m1_396000_230400 0 7.189980e-08
I11038 n1_m1_396000_235200 0 7.134933e-08
I11039 n1_m1_396000_240000 0 1.024752e-07
I11040 n1_m1_396000_244800 0 6.755502e-08
I11041 n1_m1_396000_249600 0 1.054592e-07
I11042 n1_m1_396000_254400 0 7.258580e-08
I11043 n1_m1_396000_259200 0 7.688752e-08
I11044 n1_m1_396000_264000 0 1.234918e-07
I11045 n1_m1_396000_268800 0 8.435774e-08
I11046 n1_m1_396000_273600 0 1.752450e-07
I11047 n1_m1_396000_278400 0 1.798261e-07
I11048 n1_m1_396000_283200 0 1.159749e-07
I11049 n1_m1_396000_288000 0 1.324076e-07
I11050 n1_m1_396000_292800 0 7.286235e-08
I11051 n1_m1_396000_297600 0 1.049280e-07
I11052 n1_m1_396000_302400 0 6.995199e-08
I11053 n1_m1_396000_307200 0 6.995199e-08
I11054 n1_m1_396000_312000 0 1.049280e-07
I11055 n1_m1_396000_316800 0 6.994015e-08
I11056 n1_m1_396000_321600 0 1.034004e-07
I11057 n1_m1_396000_326400 0 6.999529e-08
I11058 n1_m1_396000_331200 0 6.839938e-08
I11059 n1_m1_396000_336000 0 1.093741e-07
I11060 n1_m1_396000_340800 0 8.304376e-08
I11061 n1_m1_396000_345600 0 1.560976e-07
I11062 n1_m1_396000_350400 0 8.051522e-08
I11063 n1_m1_396000_355200 0 7.013057e-08
I11064 n1_m1_396000_360000 0 1.001714e-07
I11065 n1_m1_396000_364800 0 6.662094e-08
I11066 n1_m1_396000_369600 0 9.993141e-08
I11067 n1_m1_396000_374400 0 6.687094e-08
I11068 n1_m1_396000_379200 0 6.686185e-08
I11069 n1_m1_396000_384000 0 1.037141e-07
I11070 n1_m1_396000_388800 0 6.995199e-08
I11071 n1_m1_396000_393600 0 1.049280e-07
I11072 n1_m1_396000_398400 0 7.001790e-08
I11073 n1_m1_396000_403200 0 7.089336e-08
I11074 n1_m1_396000_408000 0 1.097469e-07
I11075 n1_m1_396000_412800 0 7.078475e-08
I11076 n1_m1_396000_417600 0 1.049280e-07
I11077 n1_m1_396000_422400 0 6.995199e-08
I11078 n1_m1_396000_427200 0 6.995199e-08
I11079 n1_m1_396000_432000 0 1.049280e-07
I11080 n1_m1_396000_436800 0 6.995199e-08
I11081 n1_m1_396000_441600 0 1.023450e-07
I11082 n1_m1_396000_446400 0 6.948621e-08
I11083 n1_m1_396000_451200 0 7.043751e-08
I11084 n1_m1_396000_456000 0 1.116864e-07
I11085 n1_m1_396000_460800 0 8.166711e-08
I11086 n1_m1_396000_465600 0 1.223705e-07
I11087 n1_m1_396000_470400 0 3.927604e-08
I11088 n1_m1_424000_0 0 7.577103e-08
I11089 n1_m1_424000_4800 0 7.996953e-08
I11090 n1_m1_424000_9600 0 1.053093e-07
I11091 n1_m1_424000_14400 0 7.001227e-08
I11092 n1_m1_424000_19200 0 7.227707e-08
I11093 n1_m1_424000_24000 0 1.037619e-07
I11094 n1_m1_424000_28800 0 7.236750e-08
I11095 n1_m1_424000_33600 0 1.466356e-07
I11096 n1_m1_424000_38400 0 8.694597e-08
I11097 n1_m1_424000_43200 0 9.020549e-08
I11098 n1_m1_424000_48000 0 1.179555e-07
I11099 n1_m1_424000_52800 0 7.194275e-08
I11100 n1_m1_424000_57600 0 1.049812e-07
I11101 n1_m1_424000_62400 0 7.011167e-08
I11102 n1_m1_424000_67200 0 7.204920e-08
I11103 n1_m1_424000_72000 0 1.072700e-07
I11104 n1_m1_424000_76800 0 6.995199e-08
I11105 n1_m1_424000_81600 0 1.058595e-07
I11106 n1_m1_424000_86400 0 7.206918e-08
I11107 n1_m1_424000_91200 0 6.995199e-08
I11108 n1_m1_424000_96000 0 1.049280e-07
I11109 n1_m1_424000_100800 0 6.995199e-08
I11110 n1_m1_424000_105600 0 1.049280e-07
I11111 n1_m1_424000_110400 0 6.995199e-08
I11112 n1_m1_424000_115200 0 7.033308e-08
I11113 n1_m1_424000_120000 0 1.095435e-07
I11114 n1_m1_424000_124800 0 7.328303e-08
I11115 n1_m1_424000_129600 0 1.057890e-07
I11116 n1_m1_424000_134400 0 6.995199e-08
I11117 n1_m1_424000_139200 0 6.995199e-08
I11118 n1_m1_424000_144000 0 1.055349e-07
I11119 n1_m1_424000_148800 0 7.312777e-08
I11120 n1_m1_424000_153600 0 1.099246e-07
I11121 n1_m1_424000_158400 0 7.328303e-08
I11122 n1_m1_424000_163200 0 7.328303e-08
I11123 n1_m1_424000_168000 0 1.099246e-07
I11124 n1_m1_424000_172800 0 7.328303e-08
I11125 n1_m1_424000_177600 0 1.088801e-07
I11126 n1_m1_424000_182400 0 6.995199e-08
I11127 n1_m1_424000_187200 0 7.277467e-08
I11128 n1_m1_424000_192000 0 1.145673e-07
I11129 n1_m1_424000_196800 0 7.758117e-08
I11130 n1_m1_424000_201600 0 1.288988e-07
I11131 n1_m1_424000_206400 0 8.979102e-08
I11132 n1_m1_424000_211200 0 8.619790e-08
I11133 n1_m1_424000_216000 0 1.179998e-07
I11134 n1_m1_424000_220800 0 7.168521e-08
I11135 n1_m1_424000_225600 0 1.049280e-07
I11136 n1_m1_424000_230400 0 6.995199e-08
I11137 n1_m1_424000_235200 0 6.954266e-08
I11138 n1_m1_424000_240000 0 1.045880e-07
I11139 n1_m1_424000_244800 0 6.995199e-08
I11140 n1_m1_424000_249600 0 1.069745e-07
I11141 n1_m1_424000_254400 0 7.338566e-08
I11142 n1_m1_424000_259200 0 7.557989e-08
I11143 n1_m1_424000_264000 0 1.143280e-07
I11144 n1_m1_424000_268800 0 7.760521e-08
I11145 n1_m1_424000_273600 0 1.321576e-07
I11146 n1_m1_424000_278400 0 1.148984e-07
I11147 n1_m1_424000_283200 0 1.226270e-07
I11148 n1_m1_424000_288000 0 1.337674e-07
I11149 n1_m1_424000_292800 0 7.264465e-08
I11150 n1_m1_424000_297600 0 1.049280e-07
I11151 n1_m1_424000_302400 0 6.995199e-08
I11152 n1_m1_424000_307200 0 6.995199e-08
I11153 n1_m1_424000_312000 0 1.049280e-07
I11154 n1_m1_424000_316800 0 6.995546e-08
I11155 n1_m1_424000_321600 0 1.056738e-07
I11156 n1_m1_424000_326400 0 7.108044e-08
I11157 n1_m1_424000_331200 0 7.156010e-08
I11158 n1_m1_424000_336000 0 1.089664e-07
I11159 n1_m1_424000_340800 0 7.328303e-08
I11160 n1_m1_424000_345600 0 1.106044e-07
I11161 n1_m1_424000_350400 0 7.362693e-08
I11162 n1_m1_424000_355200 0 7.042674e-08
I11163 n1_m1_424000_360000 0 1.049280e-07
I11164 n1_m1_424000_364800 0 6.995199e-08
I11165 n1_m1_424000_369600 0 1.049280e-07
I11166 n1_m1_424000_374400 0 6.995199e-08
I11167 n1_m1_424000_379200 0 6.995199e-08
I11168 n1_m1_424000_384000 0 1.160945e-07
I11169 n1_m1_424000_388800 0 8.355117e-08
I11170 n1_m1_424000_393600 0 1.265516e-07
I11171 n1_m1_424000_398400 0 7.709218e-08
I11172 n1_m1_424000_403200 0 7.290397e-08
I11173 n1_m1_424000_408000 0 1.086966e-07
I11174 n1_m1_424000_412800 0 7.058009e-08
I11175 n1_m1_424000_417600 0 1.049280e-07
I11176 n1_m1_424000_422400 0 6.995199e-08
I11177 n1_m1_424000_427200 0 6.995199e-08
I11178 n1_m1_424000_432000 0 1.049280e-07
I11179 n1_m1_424000_436800 0 6.995199e-08
I11180 n1_m1_424000_441600 0 1.058592e-07
I11181 n1_m1_424000_446400 0 7.282419e-08
I11182 n1_m1_424000_451200 0 7.254417e-08
I11183 n1_m1_424000_456000 0 1.133826e-07
I11184 n1_m1_424000_460800 0 8.470163e-08
I11185 n1_m1_424000_465600 0 1.214280e-07
I11186 n1_m1_424000_470400 0 3.778480e-08
I11187 n1_m1_452000_0 0 1.704604e-07
I11188 n1_m1_452000_4800 0 1.750848e-07
I11189 n1_m1_452000_9600 0 2.492489e-07
I11190 n1_m1_452000_14400 0 1.537884e-07
I11191 n1_m1_452000_19200 0 1.489990e-07
I11192 n1_m1_452000_24000 0 2.330192e-07
I11193 n1_m1_452000_28800 0 1.510717e-07
I11194 n1_m1_452000_33600 0 2.332305e-07
I11195 n1_m1_452000_38400 0 1.459091e-07
I11196 n1_m1_452000_43200 0 1.438814e-07
I11197 n1_m1_452000_48000 0 2.164652e-07
I11198 n1_m1_452000_52800 0 1.433594e-07
I11199 n1_m1_452000_57600 0 2.286566e-07
I11200 n1_m1_452000_62400 0 1.612541e-07
I11201 n1_m1_452000_67200 0 1.581664e-07
I11202 n1_m1_452000_72000 0 2.227347e-07
I11203 n1_m1_452000_76800 0 1.474488e-07
I11204 n1_m1_452000_81600 0 2.142080e-07
I11205 n1_m1_452000_86400 0 1.491067e-07
I11206 n1_m1_452000_91200 0 1.461144e-07
I11207 n1_m1_452000_96000 0 2.110402e-07
I11208 n1_m1_452000_100800 0 1.413437e-07
I11209 n1_m1_452000_105600 0 2.198867e-07
I11210 n1_m1_452000_110400 0 1.498667e-07
I11211 n1_m1_452000_115200 0 1.502160e-07
I11212 n1_m1_452000_120000 0 2.179106e-07
I11213 n1_m1_452000_124800 0 1.435030e-07
I11214 n1_m1_452000_129600 0 2.180142e-07
I11215 n1_m1_452000_134400 0 1.516564e-07
I11216 n1_m1_452000_139200 0 1.532282e-07
I11217 n1_m1_452000_144000 0 2.262622e-07
I11218 n1_m1_452000_148800 0 1.515399e-07
I11219 n1_m1_452000_153600 0 2.200345e-07
I11220 n1_m1_452000_158400 0 1.499017e-07
I11221 n1_m1_452000_163200 0 1.506875e-07
I11222 n1_m1_452000_168000 0 2.235514e-07
I11223 n1_m1_452000_172800 0 1.483101e-07
I11224 n1_m1_452000_177600 0 2.241557e-07
I11225 n1_m1_452000_182400 0 1.523291e-07
I11226 n1_m1_452000_187200 0 1.560363e-07
I11227 n1_m1_452000_192000 0 2.330661e-07
I11228 n1_m1_452000_196800 0 1.493608e-07
I11229 n1_m1_452000_201600 0 2.284990e-07
I11230 n1_m1_452000_206400 0 1.503545e-07
I11231 n1_m1_452000_211200 0 1.563965e-07
I11232 n1_m1_452000_216000 0 2.329166e-07
I11233 n1_m1_452000_220800 0 1.444206e-07
I11234 n1_m1_452000_225600 0 2.188537e-07
I11235 n1_m1_452000_230400 0 1.437996e-07
I11236 n1_m1_452000_235200 0 1.399040e-07
I11237 n1_m1_452000_240000 0 2.170826e-07
I11238 n1_m1_452000_244800 0 1.465661e-07
I11239 n1_m1_452000_249600 0 2.197092e-07
I11240 n1_m1_452000_254400 0 1.444668e-07
I11241 n1_m1_452000_259200 0 1.440254e-07
I11242 n1_m1_452000_264000 0 2.176530e-07
I11243 n1_m1_452000_268800 0 1.495349e-07
I11244 n1_m1_452000_273600 0 2.344718e-07
I11245 n1_m1_452000_278400 0 1.544702e-07
I11246 n1_m1_452000_283200 0 1.506875e-07
I11247 n1_m1_452000_288000 0 2.356099e-07
I11248 n1_m1_452000_292800 0 1.625129e-07
I11249 n1_m1_452000_297600 0 2.195871e-07
I11250 n1_m1_452000_302400 0 1.431257e-07
I11251 n1_m1_452000_307200 0 1.430558e-07
I11252 n1_m1_452000_312000 0 2.238646e-07
I11253 n1_m1_452000_316800 0 1.483337e-07
I11254 n1_m1_452000_321600 0 2.196125e-07
I11255 n1_m1_452000_326400 0 1.508483e-07
I11256 n1_m1_452000_331200 0 1.491067e-07
I11257 n1_m1_452000_336000 0 2.598748e-07
I11258 n1_m1_452000_340800 0 1.938727e-07
I11259 n1_m1_452000_345600 0 2.318621e-07
I11260 n1_m1_452000_350400 0 1.508380e-07
I11261 n1_m1_452000_355200 0 1.500414e-07
I11262 n1_m1_452000_360000 0 2.201460e-07
I11263 n1_m1_452000_364800 0 1.464814e-07
I11264 n1_m1_452000_369600 0 2.112957e-07
I11265 n1_m1_452000_374400 0 1.418250e-07
I11266 n1_m1_452000_379200 0 1.513650e-07
I11267 n1_m1_452000_384000 0 2.162133e-07
I11268 n1_m1_452000_388800 0 1.405822e-07
I11269 n1_m1_452000_393600 0 2.139987e-07
I11270 n1_m1_452000_398400 0 1.459548e-07
I11271 n1_m1_452000_403200 0 1.465661e-07
I11272 n1_m1_452000_408000 0 2.198491e-07
I11273 n1_m1_452000_412800 0 1.415695e-07
I11274 n1_m1_452000_417600 0 2.098560e-07
I11275 n1_m1_452000_422400 0 1.399040e-07
I11276 n1_m1_452000_427200 0 1.413465e-07
I11277 n1_m1_452000_432000 0 2.136669e-07
I11278 n1_m1_452000_436800 0 1.424446e-07
I11279 n1_m1_452000_441600 0 2.124303e-07
I11280 n1_m1_452000_446400 0 1.491797e-07
I11281 n1_m1_452000_451200 0 1.499715e-07
I11282 n1_m1_452000_456000 0 2.200761e-07
I11283 n1_m1_452000_460800 0 1.516191e-07
I11284 n1_m1_452000_465600 0 2.243093e-07
I11285 n1_m1_452000_470400 0 7.147637e-08
.op
.end
