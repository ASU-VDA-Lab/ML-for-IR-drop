R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_470400_0 n1_m1_475200_0 5.356235
R114 n1_m1_475200_0 n1_m1_480000_0 5.356235
R115 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R116 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R117 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R118 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R119 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R120 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R121 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R122 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R123 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R124 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R125 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R126 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R127 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R128 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R129 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R130 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R131 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R132 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R133 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R134 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R135 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R136 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R137 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R138 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R139 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R140 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R141 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R142 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R143 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R144 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R145 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R146 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R147 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R148 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R149 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R150 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R151 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R152 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R153 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R154 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R155 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R156 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R157 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R158 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R159 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R160 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R161 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R162 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R163 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R164 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R165 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R166 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R167 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R168 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R169 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R170 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R171 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R172 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R173 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R174 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R175 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R176 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R177 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R178 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R179 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R180 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R181 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R182 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R183 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R184 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R185 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R186 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R187 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R188 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R189 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R190 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R191 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R192 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R193 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R194 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R195 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R196 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R197 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R198 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R199 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R200 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R201 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R202 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R203 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R204 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R205 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R206 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R207 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R208 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R209 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R210 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R211 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R212 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R213 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R214 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R215 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R216 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R217 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R218 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R219 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R220 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R221 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R222 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R223 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R224 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R225 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R226 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R227 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R228 n1_m1_470400_4800 n1_m1_475200_4800 5.356235
R229 n1_m1_475200_4800 n1_m1_480000_4800 5.356235
R230 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R231 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R232 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R233 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R234 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R235 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R236 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R237 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R238 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R239 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R240 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R241 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R242 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R243 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R244 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R245 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R246 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R247 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R248 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R249 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R250 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R251 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R252 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R253 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R254 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R255 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R256 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R257 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R258 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R259 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R260 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R261 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R262 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R263 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R264 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R265 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R266 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R267 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R268 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R269 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R270 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R271 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R272 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R273 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R274 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R275 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R276 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R277 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R278 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R279 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R280 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R281 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R282 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R283 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R284 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R285 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R286 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R287 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R288 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R289 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R290 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R291 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R292 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R293 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R294 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R295 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R296 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R297 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R298 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R299 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R300 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R301 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R302 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R303 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R304 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R305 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R306 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R307 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R308 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R309 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R310 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R311 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R312 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R313 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R314 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R315 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R316 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R317 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R318 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R319 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R320 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R321 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R322 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R323 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R324 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R325 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R326 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R327 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R328 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R329 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R330 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R331 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R332 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R333 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R334 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R335 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R336 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R337 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R338 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R339 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R340 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R341 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R342 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R343 n1_m1_470400_9600 n1_m1_475200_9600 5.356235
R344 n1_m1_475200_9600 n1_m1_480000_9600 5.356235
R345 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R346 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R347 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R348 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R349 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R350 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R351 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R352 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R353 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R354 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R355 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R356 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R357 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R358 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R359 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R360 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R361 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R362 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R363 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R364 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R365 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R366 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R367 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R368 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R369 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R370 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R371 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R372 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R373 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R374 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R375 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R376 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R377 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R378 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R379 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R380 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R381 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R382 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R383 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R384 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R385 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R386 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R387 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R388 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R389 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R390 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R391 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R392 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R393 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R394 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R395 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R396 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R397 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R398 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R399 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R400 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R401 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R402 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R403 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R404 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R405 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R406 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R407 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R408 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R409 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R410 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R411 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R412 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R413 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R414 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R415 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R416 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R417 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R418 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R419 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R420 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R421 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R422 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R423 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R424 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R425 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R426 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R427 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R428 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R429 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R430 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R431 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R432 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R433 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R434 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R435 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R436 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R437 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R438 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R439 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R440 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R441 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R442 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R443 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R444 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R445 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R446 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R447 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R448 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R449 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R450 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R451 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R452 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R453 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R454 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R455 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R456 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R457 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R458 n1_m1_470400_14400 n1_m1_475200_14400 5.356235
R459 n1_m1_475200_14400 n1_m1_480000_14400 5.356235
R460 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R461 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R462 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R463 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R464 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R465 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R466 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R467 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R468 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R469 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R470 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R471 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R472 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R473 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R474 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R475 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R476 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R477 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R478 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R479 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R480 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R481 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R482 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R483 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R484 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R485 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R486 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R487 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R488 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R489 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R490 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R491 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R492 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R493 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R494 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R495 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R496 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R497 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R498 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R499 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R500 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R501 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R502 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R503 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R504 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R505 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R506 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R507 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R508 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R509 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R510 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R511 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R512 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R513 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R514 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R515 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R516 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R517 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R518 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R519 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R520 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R521 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R522 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R523 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R524 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R525 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R526 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R527 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R528 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R529 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R530 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R531 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R532 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R533 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R534 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R535 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R536 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R537 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R538 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R539 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R540 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R541 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R542 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R543 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R544 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R545 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R546 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R547 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R548 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R549 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R550 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R551 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R552 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R553 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R554 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R555 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R556 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R557 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R558 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R559 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R560 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R561 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R562 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R563 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R564 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R565 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R566 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R567 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R568 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R569 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R570 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R571 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R572 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R573 n1_m1_470400_19200 n1_m1_475200_19200 5.356235
R574 n1_m1_475200_19200 n1_m1_480000_19200 5.356235
R575 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R576 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R577 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R578 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R579 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R580 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R581 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R582 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R583 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R584 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R585 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R586 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R587 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R588 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R589 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R590 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R591 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R592 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R593 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R594 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R595 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R596 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R597 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R598 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R599 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R600 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R601 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R602 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R603 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R604 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R605 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R606 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R607 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R608 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R609 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R610 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R611 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R612 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R613 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R614 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R615 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R616 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R617 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R618 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R619 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R620 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R621 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R622 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R623 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R624 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R625 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R626 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R627 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R628 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R629 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R630 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R631 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R632 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R633 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R634 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R635 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R636 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R637 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R638 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R639 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R640 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R641 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R642 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R643 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R644 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R645 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R646 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R647 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R648 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R649 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R650 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R651 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R652 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R653 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R654 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R655 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R656 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R657 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R658 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R659 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R660 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R661 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R662 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R663 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R664 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R665 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R666 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R667 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R668 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R669 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R670 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R671 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R672 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R673 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R674 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R675 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R676 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R677 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R678 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R679 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R680 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R681 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R682 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R683 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R684 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R685 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R686 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R687 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R688 n1_m1_470400_24000 n1_m1_475200_24000 5.356235
R689 n1_m1_475200_24000 n1_m1_480000_24000 5.356235
R690 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R691 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R692 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R693 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R694 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R695 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R696 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R697 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R698 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R699 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R700 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R701 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R702 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R703 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R704 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R705 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R706 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R707 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R708 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R709 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R710 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R711 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R712 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R713 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R714 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R715 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R716 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R717 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R718 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R719 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R720 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R721 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R722 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R723 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R724 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R725 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R726 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R727 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R728 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R729 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R730 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R731 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R732 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R733 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R734 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R735 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R736 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R737 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R738 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R739 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R740 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R741 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R742 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R743 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R744 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R745 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R746 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R747 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R748 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R749 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R750 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R751 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R752 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R753 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R754 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R755 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R756 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R757 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R758 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R759 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R760 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R761 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R762 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R763 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R764 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R765 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R766 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R767 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R768 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R769 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R770 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R771 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R772 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R773 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R774 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R775 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R776 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R777 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R778 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R779 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R780 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R781 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R782 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R783 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R784 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R785 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R786 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R787 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R788 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R789 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R790 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R791 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R792 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R793 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R794 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R795 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R796 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R797 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R798 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R799 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R800 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R801 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R802 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R803 n1_m1_470400_28800 n1_m1_475200_28800 5.356235
R804 n1_m1_475200_28800 n1_m1_480000_28800 5.356235
R805 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R806 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R807 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R808 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R809 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R810 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R811 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R812 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R813 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R814 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R815 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R816 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R817 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R818 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R819 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R820 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R821 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R822 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R823 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R824 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R825 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R826 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R827 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R828 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R829 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R830 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R831 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R832 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R833 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R834 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R835 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R836 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R837 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R838 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R839 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R840 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R841 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R842 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R843 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R844 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R845 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R846 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R847 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R848 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R849 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R850 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R851 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R852 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R853 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R854 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R855 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R856 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R857 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R858 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R859 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R860 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R861 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R862 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R863 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R864 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R865 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R866 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R867 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R868 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R869 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R870 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R871 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R872 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R873 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R874 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R875 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R876 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R877 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R878 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R879 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R880 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R881 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R882 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R883 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R884 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R885 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R886 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R887 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R888 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R889 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R890 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R891 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R892 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R893 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R894 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R895 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R896 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R897 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R898 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R899 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R900 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R901 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R902 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R903 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R904 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R905 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R906 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R907 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R908 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R909 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R910 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R911 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R912 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R913 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R914 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R915 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R916 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R917 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R918 n1_m1_470400_33600 n1_m1_475200_33600 5.356235
R919 n1_m1_475200_33600 n1_m1_480000_33600 5.356235
R920 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R921 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R922 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R923 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R924 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R925 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R926 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R927 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R928 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R929 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R930 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R931 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R932 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R933 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R934 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R935 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R936 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R937 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R938 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R939 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R940 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R941 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R942 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R943 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R944 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R945 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R946 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R947 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R948 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R949 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R950 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R951 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R952 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R953 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R954 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R955 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R956 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R957 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R958 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R959 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R960 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R961 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R962 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R963 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R964 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R965 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R966 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R967 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R968 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R969 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R970 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R971 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R972 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R973 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R974 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R975 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R976 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R977 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R978 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R979 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R980 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R981 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R982 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R983 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R984 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R985 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R986 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R987 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R988 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R989 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R990 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R991 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R992 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R993 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R994 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R995 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R996 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R997 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R998 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R999 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R1000 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R1001 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R1002 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R1003 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R1004 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R1005 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R1006 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R1007 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R1008 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R1009 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R1010 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R1011 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R1012 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R1013 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R1014 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R1015 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1016 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1017 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1018 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1019 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1020 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1021 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1022 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1023 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1024 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1025 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1026 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1027 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1028 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1029 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1030 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1031 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1032 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1033 n1_m1_470400_38400 n1_m1_475200_38400 5.356235
R1034 n1_m1_475200_38400 n1_m1_480000_38400 5.356235
R1035 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1036 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1037 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1038 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1039 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1040 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1041 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1042 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1043 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1044 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1045 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1046 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1047 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1048 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1049 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1050 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1051 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1052 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1053 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1054 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1055 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1056 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1057 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1058 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1059 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1060 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1061 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1062 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1063 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1064 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1065 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1066 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1067 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1068 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1069 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1070 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1071 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1072 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1073 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1074 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1075 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1076 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1077 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1078 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1079 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1080 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1081 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1082 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1083 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1084 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1085 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1086 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1087 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1088 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1089 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1090 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1091 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1092 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1093 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1094 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1095 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1096 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1097 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1098 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1099 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1100 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1101 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1102 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1103 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1104 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1105 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1106 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1107 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1108 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1109 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1110 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1111 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1112 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1113 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1114 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1115 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1116 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1117 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1118 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1119 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1120 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1121 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1122 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1123 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1124 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1125 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1126 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1127 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1128 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1129 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1130 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1131 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1132 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1133 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1134 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1135 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1136 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1137 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1138 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1139 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1140 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1141 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1142 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1143 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1144 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1145 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1146 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1147 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1148 n1_m1_470400_43200 n1_m1_475200_43200 5.356235
R1149 n1_m1_475200_43200 n1_m1_480000_43200 5.356235
R1150 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1151 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1152 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1153 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1154 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1155 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1156 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1157 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1158 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1159 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1160 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1161 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1162 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1163 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1164 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1165 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1166 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1167 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1168 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1169 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1170 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1171 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1172 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1173 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1174 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1175 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1176 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1177 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1178 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1179 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1180 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1181 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1182 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1183 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1184 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1185 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1186 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1187 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1188 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1189 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1190 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1191 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1192 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1193 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1194 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1195 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1196 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1197 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1198 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1199 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1200 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1201 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1202 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1203 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1204 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1205 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1206 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1207 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1208 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1209 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1210 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1211 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1212 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1213 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1214 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1215 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1216 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1217 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1218 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1219 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1220 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1221 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1222 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1223 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1224 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1225 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1226 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1227 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1228 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1229 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1230 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1231 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1232 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1233 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1234 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1235 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1236 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1237 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1238 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1239 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1240 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1241 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1242 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1243 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1244 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1245 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1246 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1247 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1248 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1249 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1250 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1251 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1252 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1253 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1254 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1255 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1256 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1257 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1258 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1259 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1260 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1261 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1262 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1263 n1_m1_470400_48000 n1_m1_475200_48000 5.356235
R1264 n1_m1_475200_48000 n1_m1_480000_48000 5.356235
R1265 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1266 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1267 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1268 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1269 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1270 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1271 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1272 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1273 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1274 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1275 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1276 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1277 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1278 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1279 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1280 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1281 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1282 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1283 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1284 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1285 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1286 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1287 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1288 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1289 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1290 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1291 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1292 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1293 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1294 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1295 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1296 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1297 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1298 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1299 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1300 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1301 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1302 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1303 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1304 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1305 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1306 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1307 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1308 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1309 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1310 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1311 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1312 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1313 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1314 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1315 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1316 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1317 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1318 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1319 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1320 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1321 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1322 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1323 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1324 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1325 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1326 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1327 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1328 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1329 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1330 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1331 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1332 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1333 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1334 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1335 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1336 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1337 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1338 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1339 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1340 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1341 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1342 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1343 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1344 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1345 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1346 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1347 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1348 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1349 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1350 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1351 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1352 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1353 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1354 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1355 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1356 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1357 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1358 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1359 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1360 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1361 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1362 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1363 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1364 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1365 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1366 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1367 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1368 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1369 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1370 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1371 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1372 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1373 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1374 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1375 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1376 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1377 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1378 n1_m1_470400_52800 n1_m1_475200_52800 5.356235
R1379 n1_m1_475200_52800 n1_m1_480000_52800 5.356235
R1380 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1381 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1382 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1383 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1384 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1385 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1386 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1387 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1388 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1389 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1390 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1391 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1392 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1393 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1394 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1395 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1396 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1397 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1398 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1399 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1400 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1401 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1402 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1403 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1404 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1405 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1406 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1407 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1408 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1409 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1410 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1411 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1412 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1413 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1414 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1415 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1416 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1417 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1418 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1419 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1420 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1421 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1422 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1423 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1424 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1425 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1426 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1427 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1428 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1429 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1430 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1431 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1432 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1433 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1434 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1435 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1436 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1437 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1438 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1439 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1440 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1441 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1442 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1443 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1444 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1445 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1446 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1447 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1448 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1449 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1450 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1451 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1452 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1453 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1454 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1455 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1456 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1457 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1458 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1459 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1460 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1461 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1462 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1463 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1464 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1465 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1466 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1467 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1468 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1469 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1470 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1471 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1472 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1473 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1474 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1475 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1476 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1477 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1478 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1479 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1480 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1481 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1482 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1483 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1484 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1485 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1486 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1487 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1488 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1489 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1490 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1491 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1492 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1493 n1_m1_470400_57600 n1_m1_475200_57600 5.356235
R1494 n1_m1_475200_57600 n1_m1_480000_57600 5.356235
R1495 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1496 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1497 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1498 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1499 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1500 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1501 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1502 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1503 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1504 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1505 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1506 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1507 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1508 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1509 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1510 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1511 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1512 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1513 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1514 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1515 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1516 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1517 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1518 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1519 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1520 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1521 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1522 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1523 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1524 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1525 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1526 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1527 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1528 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1529 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1530 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1531 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1532 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1533 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1534 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1535 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1536 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1537 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1538 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1539 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1540 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1541 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1542 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1543 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1544 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1545 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1546 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1547 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1548 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1549 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1550 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1551 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1552 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1553 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1554 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1555 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1556 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1557 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1558 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1559 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1560 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1561 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1562 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1563 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1564 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1565 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1566 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1567 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1568 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1569 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1570 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1571 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1572 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1573 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1574 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1575 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1576 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1577 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1578 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1579 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1580 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1581 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1582 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1583 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1584 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1585 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1586 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1587 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1588 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1589 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1590 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1591 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1592 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1593 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1594 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1595 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1596 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1597 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1598 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1599 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1600 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1601 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1602 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1603 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1604 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1605 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1606 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1607 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1608 n1_m1_470400_62400 n1_m1_475200_62400 5.356235
R1609 n1_m1_475200_62400 n1_m1_480000_62400 5.356235
R1610 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1611 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1612 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1613 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1614 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1615 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1616 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1617 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1618 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1619 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1620 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1621 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1622 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1623 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1624 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1625 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1626 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1627 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1628 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1629 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1630 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1631 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1632 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1633 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1634 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1635 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1636 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1637 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1638 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1639 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1640 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1641 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1642 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1643 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1644 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1645 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1646 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1647 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1648 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1649 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1650 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1651 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1652 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1653 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1654 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1655 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1656 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1657 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1658 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1659 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1660 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1661 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1662 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1663 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1664 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1665 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1666 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1667 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1668 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1669 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1670 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1671 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1672 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1673 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1674 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1675 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1676 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1677 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1678 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1679 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1680 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1681 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1682 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1683 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1684 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1685 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1686 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1687 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1688 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1689 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1690 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1691 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1692 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1693 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1694 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1695 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1696 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1697 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1698 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1699 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1700 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1701 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1702 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1703 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1704 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1705 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1706 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1707 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1708 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R1709 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R1710 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R1711 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R1712 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R1713 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R1714 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R1715 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R1716 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R1717 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R1718 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R1719 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R1720 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R1721 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R1722 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R1723 n1_m1_470400_67200 n1_m1_475200_67200 5.356235
R1724 n1_m1_475200_67200 n1_m1_480000_67200 5.356235
R1725 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1726 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1727 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1728 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1729 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R1730 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R1731 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R1732 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R1733 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R1734 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R1735 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R1736 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R1737 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R1738 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R1739 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R1740 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R1741 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R1742 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R1743 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R1744 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R1745 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R1746 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R1747 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R1748 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R1749 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R1750 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R1751 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R1752 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R1753 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R1754 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R1755 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R1756 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R1757 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R1758 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R1759 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R1760 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R1761 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R1762 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R1763 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R1764 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R1765 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R1766 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R1767 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R1768 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R1769 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R1770 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R1771 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R1772 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R1773 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R1774 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R1775 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R1776 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R1777 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R1778 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R1779 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R1780 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R1781 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R1782 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R1783 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R1784 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R1785 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R1786 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R1787 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R1788 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R1789 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R1790 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R1791 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R1792 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R1793 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R1794 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R1795 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R1796 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R1797 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R1798 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R1799 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R1800 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R1801 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R1802 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R1803 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R1804 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R1805 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R1806 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R1807 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R1808 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R1809 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R1810 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R1811 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R1812 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R1813 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R1814 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R1815 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R1816 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R1817 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R1818 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R1819 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R1820 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R1821 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R1822 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R1823 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R1824 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R1825 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R1826 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R1827 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R1828 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R1829 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R1830 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R1831 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R1832 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R1833 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R1834 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R1835 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R1836 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R1837 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R1838 n1_m1_470400_72000 n1_m1_475200_72000 5.356235
R1839 n1_m1_475200_72000 n1_m1_480000_72000 5.356235
R1840 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R1841 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R1842 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R1843 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R1844 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R1845 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R1846 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R1847 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R1848 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R1849 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R1850 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R1851 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R1852 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R1853 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R1854 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R1855 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R1856 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R1857 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R1858 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R1859 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R1860 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R1861 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R1862 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R1863 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R1864 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R1865 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R1866 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R1867 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R1868 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R1869 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R1870 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R1871 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R1872 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R1873 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R1874 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R1875 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R1876 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R1877 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R1878 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R1879 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R1880 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R1881 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R1882 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R1883 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R1884 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R1885 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R1886 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R1887 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R1888 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R1889 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R1890 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R1891 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R1892 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R1893 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R1894 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R1895 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R1896 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R1897 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R1898 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R1899 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R1900 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R1901 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R1902 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R1903 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R1904 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R1905 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R1906 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R1907 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R1908 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R1909 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R1910 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R1911 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R1912 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R1913 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R1914 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R1915 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R1916 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R1917 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R1918 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R1919 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R1920 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R1921 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R1922 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R1923 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R1924 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R1925 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R1926 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R1927 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R1928 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R1929 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R1930 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R1931 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R1932 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R1933 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R1934 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R1935 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R1936 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R1937 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R1938 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R1939 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R1940 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R1941 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R1942 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R1943 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R1944 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R1945 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R1946 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R1947 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R1948 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R1949 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R1950 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R1951 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R1952 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R1953 n1_m1_470400_76800 n1_m1_475200_76800 5.356235
R1954 n1_m1_475200_76800 n1_m1_480000_76800 5.356235
R1955 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R1956 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R1957 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R1958 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R1959 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R1960 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R1961 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R1962 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R1963 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R1964 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R1965 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R1966 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R1967 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R1968 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R1969 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R1970 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R1971 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R1972 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R1973 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R1974 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R1975 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R1976 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R1977 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R1978 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R1979 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R1980 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R1981 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R1982 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R1983 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R1984 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R1985 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R1986 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R1987 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R1988 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R1989 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R1990 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R1991 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R1992 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R1993 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R1994 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R1995 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R1996 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R1997 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R1998 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R1999 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R2000 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R2001 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R2002 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R2003 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R2004 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R2005 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R2006 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R2007 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R2008 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R2009 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R2010 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R2011 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R2012 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R2013 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R2014 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R2015 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R2016 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R2017 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R2018 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R2019 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R2020 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R2021 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R2022 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R2023 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R2024 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R2025 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R2026 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R2027 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R2028 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R2029 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R2030 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R2031 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R2032 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R2033 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2034 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2035 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2036 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2037 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2038 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2039 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2040 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2041 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2042 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2043 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2044 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2045 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2046 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2047 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2048 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2049 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2050 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2051 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2052 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2053 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2054 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2055 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2056 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2057 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2058 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2059 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2060 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2061 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2062 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2063 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2064 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2065 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2066 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2067 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2068 n1_m1_470400_81600 n1_m1_475200_81600 5.356235
R2069 n1_m1_475200_81600 n1_m1_480000_81600 5.356235
R2070 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2071 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2072 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2073 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2074 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2075 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2076 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2077 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2078 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2079 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2080 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2081 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2082 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2083 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2084 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2085 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2086 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2087 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2088 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2089 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2090 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2091 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2092 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2093 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2094 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2095 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2096 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2097 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2098 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2099 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2100 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2101 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2102 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2103 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2104 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2105 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2106 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2107 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2108 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2109 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2110 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2111 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2112 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2113 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2114 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2115 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2116 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2117 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2118 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2119 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2120 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2121 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2122 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2123 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2124 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2125 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2126 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2127 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2128 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2129 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2130 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2131 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2132 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2133 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2134 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2135 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2136 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2137 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2138 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2139 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2140 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2141 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2142 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2143 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2144 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2145 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2146 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2147 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2148 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2149 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2150 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2151 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2152 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2153 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2154 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2155 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2156 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2157 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2158 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2159 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2160 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2161 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2162 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2163 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2164 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2165 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2166 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2167 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2168 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2169 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2170 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2171 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2172 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2173 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2174 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2175 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2176 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2177 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2178 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2179 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2180 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2181 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2182 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2183 n1_m1_470400_86400 n1_m1_475200_86400 5.356235
R2184 n1_m1_475200_86400 n1_m1_480000_86400 5.356235
R2185 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2186 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2187 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2188 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2189 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2190 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2191 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2192 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2193 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2194 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2195 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2196 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2197 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2198 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2199 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2200 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2201 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2202 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2203 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2204 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2205 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2206 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2207 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2208 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2209 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2210 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2211 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2212 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2213 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2214 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2215 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2216 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2217 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2218 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2219 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2220 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2221 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2222 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2223 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2224 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2225 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2226 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2227 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2228 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2229 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2230 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2231 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2232 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2233 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2234 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2235 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2236 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2237 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2238 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2239 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2240 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2241 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2242 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2243 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2244 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2245 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2246 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2247 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2248 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2249 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2250 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2251 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2252 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2253 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2254 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2255 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2256 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2257 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2258 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2259 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2260 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2261 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2262 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2263 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2264 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2265 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2266 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2267 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2268 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2269 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2270 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2271 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2272 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2273 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2274 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2275 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2276 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2277 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2278 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2279 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2280 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2281 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2282 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2283 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2284 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2285 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2286 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2287 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2288 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2289 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2290 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2291 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2292 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2293 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2294 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2295 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2296 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2297 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2298 n1_m1_470400_91200 n1_m1_475200_91200 5.356235
R2299 n1_m1_475200_91200 n1_m1_480000_91200 5.356235
R2300 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2301 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2302 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2303 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2304 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2305 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2306 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2307 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2308 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2309 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2310 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2311 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2312 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2313 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2314 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2315 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2316 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2317 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2318 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2319 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2320 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2321 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2322 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2323 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2324 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2325 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2326 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2327 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2328 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2329 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2330 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2331 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2332 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2333 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2334 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2335 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2336 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2337 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2338 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2339 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2340 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2341 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2342 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2343 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2344 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2345 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2346 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2347 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2348 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2349 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2350 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2351 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2352 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2353 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2354 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2355 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2356 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2357 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2358 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2359 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2360 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2361 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2362 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2363 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2364 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2365 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2366 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2367 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2368 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2369 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2370 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2371 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2372 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2373 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2374 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2375 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2376 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2377 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2378 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2379 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2380 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2381 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2382 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2383 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2384 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2385 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2386 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2387 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2388 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2389 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2390 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2391 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2392 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2393 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2394 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2395 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2396 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2397 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2398 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2399 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2400 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2401 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2402 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2403 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2404 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2405 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2406 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2407 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2408 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2409 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2410 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2411 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2412 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2413 n1_m1_470400_96000 n1_m1_475200_96000 5.356235
R2414 n1_m1_475200_96000 n1_m1_480000_96000 5.356235
R2415 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2416 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2417 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2418 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2419 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2420 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2421 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2422 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2423 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2424 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2425 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2426 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2427 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2428 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2429 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2430 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2431 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2432 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2433 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2434 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2435 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2436 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2437 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2438 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2439 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2440 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2441 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2442 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2443 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2444 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2445 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2446 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2447 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2448 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2449 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2450 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2451 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2452 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2453 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2454 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2455 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2456 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2457 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2458 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2459 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2460 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2461 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2462 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2463 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2464 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2465 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2466 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2467 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2468 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2469 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2470 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2471 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2472 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2473 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2474 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2475 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2476 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2477 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2478 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2479 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2480 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2481 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2482 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2483 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2484 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2485 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2486 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2487 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2488 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2489 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2490 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2491 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2492 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2493 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2494 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2495 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2496 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2497 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2498 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2499 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2500 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2501 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2502 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2503 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2504 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2505 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2506 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2507 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2508 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2509 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2510 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2511 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2512 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2513 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R2514 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R2515 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R2516 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R2517 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R2518 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R2519 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R2520 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R2521 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R2522 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R2523 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R2524 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R2525 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R2526 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R2527 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R2528 n1_m1_470400_100800 n1_m1_475200_100800 5.356235
R2529 n1_m1_475200_100800 n1_m1_480000_100800 5.356235
R2530 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2531 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2532 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2533 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2534 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2535 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2536 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2537 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2538 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2539 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2540 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2541 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2542 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2543 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2544 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2545 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2546 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2547 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2548 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2549 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2550 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2551 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2552 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2553 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2554 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2555 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2556 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2557 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2558 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2559 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2560 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2561 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2562 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2563 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2564 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2565 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2566 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2567 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2568 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2569 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2570 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2571 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2572 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2573 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2574 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2575 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2576 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2577 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2578 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2579 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2580 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2581 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2582 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2583 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2584 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2585 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2586 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2587 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2588 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2589 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2590 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2591 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2592 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2593 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2594 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2595 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2596 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2597 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2598 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2599 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2600 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2601 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2602 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2603 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R2604 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R2605 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R2606 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R2607 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R2608 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R2609 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R2610 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R2611 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R2612 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R2613 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R2614 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R2615 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R2616 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R2617 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R2618 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R2619 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R2620 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R2621 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R2622 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R2623 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R2624 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R2625 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R2626 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R2627 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R2628 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R2629 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R2630 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R2631 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R2632 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R2633 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R2634 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R2635 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R2636 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R2637 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R2638 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R2639 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R2640 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R2641 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R2642 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R2643 n1_m1_470400_105600 n1_m1_475200_105600 5.356235
R2644 n1_m1_475200_105600 n1_m1_480000_105600 5.356235
R2645 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R2646 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R2647 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R2648 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R2649 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R2650 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R2651 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R2652 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R2653 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R2654 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R2655 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R2656 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R2657 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R2658 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R2659 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R2660 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R2661 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R2662 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R2663 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R2664 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R2665 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R2666 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R2667 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R2668 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R2669 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R2670 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R2671 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R2672 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R2673 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R2674 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R2675 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R2676 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R2677 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R2678 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R2679 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R2680 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R2681 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R2682 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R2683 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R2684 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R2685 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R2686 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R2687 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R2688 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R2689 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R2690 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R2691 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R2692 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R2693 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R2694 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R2695 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R2696 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R2697 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R2698 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R2699 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R2700 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R2701 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R2702 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R2703 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R2704 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R2705 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R2706 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R2707 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R2708 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R2709 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R2710 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R2711 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R2712 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R2713 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R2714 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R2715 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R2716 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R2717 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R2718 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R2719 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R2720 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R2721 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R2722 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R2723 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R2724 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R2725 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R2726 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R2727 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R2728 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R2729 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R2730 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R2731 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R2732 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R2733 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R2734 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R2735 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R2736 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R2737 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R2738 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R2739 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R2740 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R2741 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R2742 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R2743 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R2744 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R2745 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R2746 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R2747 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R2748 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R2749 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R2750 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R2751 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R2752 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R2753 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R2754 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R2755 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R2756 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R2757 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R2758 n1_m1_470400_110400 n1_m1_475200_110400 5.356235
R2759 n1_m1_475200_110400 n1_m1_480000_110400 5.356235
R2760 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R2761 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R2762 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R2763 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R2764 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R2765 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R2766 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R2767 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R2768 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R2769 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R2770 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R2771 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R2772 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R2773 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R2774 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R2775 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R2776 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R2777 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R2778 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R2779 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R2780 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R2781 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R2782 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R2783 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R2784 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R2785 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R2786 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R2787 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R2788 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R2789 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R2790 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R2791 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R2792 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R2793 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R2794 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R2795 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R2796 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R2797 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R2798 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R2799 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R2800 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R2801 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R2802 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R2803 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R2804 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R2805 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R2806 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R2807 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R2808 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R2809 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R2810 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R2811 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R2812 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R2813 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R2814 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R2815 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R2816 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R2817 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R2818 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R2819 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R2820 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R2821 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R2822 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R2823 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R2824 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R2825 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R2826 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R2827 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R2828 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R2829 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R2830 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R2831 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R2832 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R2833 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R2834 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R2835 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R2836 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R2837 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R2838 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R2839 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R2840 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R2841 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R2842 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R2843 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R2844 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R2845 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R2846 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R2847 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R2848 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R2849 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R2850 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R2851 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R2852 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R2853 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R2854 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R2855 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R2856 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R2857 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R2858 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R2859 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R2860 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R2861 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R2862 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R2863 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R2864 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R2865 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R2866 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R2867 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R2868 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R2869 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R2870 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R2871 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R2872 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R2873 n1_m1_470400_115200 n1_m1_475200_115200 5.356235
R2874 n1_m1_475200_115200 n1_m1_480000_115200 5.356235
R2875 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R2876 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R2877 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R2878 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R2879 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R2880 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R2881 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R2882 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R2883 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R2884 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R2885 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R2886 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R2887 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R2888 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R2889 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R2890 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R2891 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R2892 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R2893 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R2894 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R2895 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R2896 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R2897 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R2898 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R2899 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R2900 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R2901 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R2902 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R2903 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R2904 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R2905 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R2906 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R2907 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R2908 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R2909 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R2910 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R2911 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R2912 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R2913 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R2914 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R2915 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R2916 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R2917 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R2918 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R2919 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R2920 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R2921 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R2922 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R2923 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R2924 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R2925 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R2926 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R2927 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R2928 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R2929 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R2930 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R2931 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R2932 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R2933 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R2934 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R2935 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R2936 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R2937 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R2938 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R2939 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R2940 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R2941 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R2942 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R2943 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R2944 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R2945 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R2946 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R2947 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R2948 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R2949 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R2950 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R2951 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R2952 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R2953 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R2954 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R2955 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R2956 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R2957 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R2958 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R2959 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R2960 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R2961 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R2962 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R2963 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R2964 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R2965 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R2966 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R2967 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R2968 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R2969 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R2970 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R2971 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R2972 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R2973 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R2974 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R2975 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R2976 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R2977 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R2978 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R2979 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R2980 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R2981 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R2982 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R2983 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R2984 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R2985 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R2986 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R2987 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R2988 n1_m1_470400_120000 n1_m1_475200_120000 5.356235
R2989 n1_m1_475200_120000 n1_m1_480000_120000 5.356235
R2990 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R2991 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R2992 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R2993 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R2994 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R2995 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R2996 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R2997 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R2998 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R2999 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R3000 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R3001 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R3002 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R3003 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R3004 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R3005 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R3006 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R3007 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R3008 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R3009 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R3010 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R3011 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R3012 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R3013 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R3014 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R3015 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R3016 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R3017 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R3018 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R3019 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R3020 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R3021 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R3022 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R3023 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R3024 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R3025 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R3026 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R3027 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R3028 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R3029 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R3030 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R3031 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R3032 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R3033 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R3034 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R3035 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R3036 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R3037 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R3038 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R3039 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R3040 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R3041 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R3042 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R3043 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R3044 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R3045 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R3046 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R3047 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R3048 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R3049 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R3050 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R3051 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3052 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3053 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3054 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3055 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3056 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3057 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3058 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3059 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3060 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3061 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3062 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3063 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3064 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3065 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3066 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3067 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3068 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3069 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3070 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3071 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3072 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3073 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3074 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3075 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3076 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3077 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3078 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3079 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3080 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3081 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3082 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3083 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3084 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3085 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3086 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3087 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3088 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3089 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3090 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3091 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3092 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3093 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3094 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3095 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3096 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3097 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3098 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3099 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3100 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3101 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3102 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3103 n1_m1_470400_124800 n1_m1_475200_124800 5.356235
R3104 n1_m1_475200_124800 n1_m1_480000_124800 5.356235
R3105 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3106 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3107 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3108 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3109 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3110 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3111 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3112 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3113 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3114 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3115 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3116 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3117 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3118 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3119 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3120 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3121 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3122 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3123 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3124 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3125 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3126 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3127 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3128 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3129 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3130 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3131 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3132 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3133 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3134 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3135 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3136 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3137 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3138 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3139 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3140 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3141 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3142 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3143 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3144 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3145 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3146 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3147 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3148 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3149 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3150 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3151 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3152 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3153 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3154 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3155 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3156 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3157 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3158 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3159 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3160 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3161 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3162 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3163 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3164 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3165 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3166 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3167 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3168 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3169 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3170 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3171 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3172 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3173 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3174 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3175 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3176 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3177 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3178 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3179 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3180 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3181 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3182 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3183 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3184 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3185 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3186 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3187 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3188 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3189 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3190 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3191 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3192 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3193 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3194 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3195 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3196 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3197 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3198 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3199 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3200 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3201 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3202 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3203 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3204 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3205 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3206 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3207 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3208 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3209 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3210 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3211 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3212 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3213 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3214 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3215 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3216 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3217 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3218 n1_m1_470400_129600 n1_m1_475200_129600 5.356235
R3219 n1_m1_475200_129600 n1_m1_480000_129600 5.356235
R3220 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R3221 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R3222 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R3223 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R3224 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R3225 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R3226 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R3227 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R3228 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R3229 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R3230 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R3231 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R3232 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R3233 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R3234 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R3235 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R3236 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R3237 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R3238 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R3239 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R3240 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R3241 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R3242 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R3243 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R3244 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R3245 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R3246 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R3247 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R3248 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R3249 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R3250 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R3251 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R3252 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R3253 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R3254 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R3255 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R3256 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R3257 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R3258 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R3259 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R3260 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R3261 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R3262 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R3263 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R3264 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R3265 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R3266 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R3267 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R3268 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R3269 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R3270 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R3271 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R3272 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R3273 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R3274 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R3275 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R3276 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R3277 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R3278 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R3279 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R3280 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R3281 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R3282 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R3283 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R3284 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R3285 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R3286 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R3287 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R3288 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R3289 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R3290 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R3291 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R3292 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R3293 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R3294 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R3295 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R3296 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R3297 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R3298 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R3299 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R3300 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R3301 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R3302 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R3303 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R3304 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R3305 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R3306 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R3307 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R3308 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R3309 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R3310 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R3311 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R3312 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R3313 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R3314 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R3315 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R3316 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R3317 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R3318 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R3319 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R3320 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R3321 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R3322 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R3323 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R3324 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R3325 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R3326 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R3327 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R3328 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R3329 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R3330 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R3331 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R3332 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R3333 n1_m1_470400_134400 n1_m1_475200_134400 5.356235
R3334 n1_m1_475200_134400 n1_m1_480000_134400 5.356235
R3335 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R3336 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R3337 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R3338 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R3339 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R3340 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R3341 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R3342 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R3343 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R3344 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R3345 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R3346 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R3347 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R3348 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R3349 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R3350 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R3351 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R3352 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R3353 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R3354 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R3355 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R3356 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R3357 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R3358 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R3359 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R3360 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R3361 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R3362 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R3363 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R3364 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R3365 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R3366 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R3367 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R3368 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R3369 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R3370 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R3371 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R3372 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R3373 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R3374 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R3375 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R3376 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R3377 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R3378 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R3379 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R3380 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R3381 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R3382 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R3383 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R3384 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R3385 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R3386 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R3387 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R3388 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R3389 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R3390 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R3391 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R3392 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R3393 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R3394 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R3395 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R3396 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R3397 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R3398 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R3399 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R3400 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R3401 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R3402 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R3403 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R3404 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R3405 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R3406 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R3407 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R3408 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R3409 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R3410 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R3411 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R3412 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R3413 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R3414 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R3415 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R3416 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R3417 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R3418 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R3419 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R3420 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R3421 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R3422 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R3423 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R3424 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R3425 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R3426 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R3427 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R3428 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R3429 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R3430 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R3431 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R3432 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R3433 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R3434 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R3435 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R3436 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R3437 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R3438 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R3439 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R3440 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R3441 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R3442 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R3443 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R3444 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R3445 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R3446 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R3447 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R3448 n1_m1_470400_139200 n1_m1_475200_139200 5.356235
R3449 n1_m1_475200_139200 n1_m1_480000_139200 5.356235
R3450 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R3451 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R3452 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R3453 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R3454 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R3455 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R3456 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R3457 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R3458 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R3459 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R3460 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R3461 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R3462 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R3463 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R3464 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R3465 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R3466 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R3467 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R3468 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R3469 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R3470 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R3471 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R3472 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R3473 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R3474 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R3475 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R3476 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R3477 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R3478 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R3479 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R3480 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R3481 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R3482 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R3483 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R3484 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R3485 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R3486 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R3487 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R3488 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R3489 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R3490 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R3491 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R3492 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R3493 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R3494 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R3495 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R3496 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R3497 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R3498 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R3499 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R3500 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R3501 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R3502 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R3503 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R3504 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R3505 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R3506 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R3507 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R3508 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R3509 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R3510 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R3511 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R3512 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R3513 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R3514 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R3515 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R3516 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R3517 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R3518 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R3519 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R3520 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R3521 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R3522 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R3523 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R3524 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R3525 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R3526 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R3527 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R3528 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R3529 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R3530 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R3531 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R3532 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R3533 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R3534 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R3535 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R3536 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R3537 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R3538 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R3539 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R3540 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R3541 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R3542 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R3543 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R3544 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R3545 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R3546 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R3547 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R3548 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R3549 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R3550 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R3551 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R3552 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R3553 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R3554 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R3555 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R3556 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R3557 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R3558 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R3559 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R3560 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R3561 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R3562 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R3563 n1_m1_470400_144000 n1_m1_475200_144000 5.356235
R3564 n1_m1_475200_144000 n1_m1_480000_144000 5.356235
R3565 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R3566 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R3567 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R3568 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R3569 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R3570 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R3571 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R3572 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R3573 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R3574 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R3575 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R3576 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R3577 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R3578 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R3579 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R3580 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R3581 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R3582 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R3583 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R3584 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R3585 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R3586 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R3587 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R3588 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R3589 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R3590 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R3591 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R3592 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R3593 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R3594 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R3595 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R3596 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R3597 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R3598 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R3599 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R3600 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R3601 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R3602 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R3603 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R3604 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R3605 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R3606 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R3607 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R3608 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R3609 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R3610 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R3611 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R3612 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R3613 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R3614 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R3615 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R3616 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R3617 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R3618 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R3619 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R3620 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R3621 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R3622 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R3623 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R3624 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R3625 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R3626 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R3627 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R3628 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R3629 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R3630 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R3631 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R3632 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R3633 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R3634 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R3635 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R3636 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R3637 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R3638 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R3639 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R3640 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R3641 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R3642 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R3643 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R3644 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R3645 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R3646 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R3647 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R3648 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R3649 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R3650 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R3651 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R3652 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R3653 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R3654 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R3655 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R3656 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R3657 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R3658 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R3659 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R3660 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R3661 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R3662 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R3663 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R3664 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R3665 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R3666 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R3667 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R3668 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R3669 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R3670 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R3671 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R3672 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R3673 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R3674 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R3675 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R3676 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R3677 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R3678 n1_m1_470400_148800 n1_m1_475200_148800 5.356235
R3679 n1_m1_475200_148800 n1_m1_480000_148800 5.356235
R3680 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R3681 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R3682 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R3683 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R3684 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R3685 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R3686 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R3687 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R3688 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R3689 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R3690 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R3691 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R3692 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R3693 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R3694 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R3695 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R3696 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R3697 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R3698 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R3699 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R3700 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R3701 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R3702 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R3703 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R3704 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R3705 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R3706 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R3707 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R3708 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R3709 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R3710 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R3711 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R3712 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R3713 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R3714 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R3715 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R3716 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R3717 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R3718 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R3719 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R3720 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R3721 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R3722 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R3723 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R3724 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R3725 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R3726 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R3727 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R3728 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R3729 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R3730 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R3731 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R3732 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R3733 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R3734 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R3735 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R3736 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R3737 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R3738 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R3739 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R3740 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R3741 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R3742 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R3743 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R3744 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R3745 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R3746 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R3747 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R3748 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R3749 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R3750 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R3751 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R3752 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R3753 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R3754 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R3755 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R3756 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R3757 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R3758 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R3759 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R3760 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R3761 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R3762 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R3763 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R3764 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R3765 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R3766 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R3767 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R3768 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R3769 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R3770 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R3771 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R3772 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R3773 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R3774 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R3775 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R3776 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R3777 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R3778 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R3779 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R3780 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R3781 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R3782 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R3783 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R3784 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R3785 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R3786 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R3787 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R3788 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R3789 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R3790 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R3791 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R3792 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R3793 n1_m1_470400_153600 n1_m1_475200_153600 5.356235
R3794 n1_m1_475200_153600 n1_m1_480000_153600 5.356235
R3795 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R3796 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R3797 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R3798 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R3799 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R3800 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R3801 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R3802 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R3803 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R3804 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R3805 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R3806 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R3807 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R3808 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R3809 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R3810 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R3811 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R3812 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R3813 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R3814 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R3815 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R3816 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R3817 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R3818 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R3819 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R3820 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R3821 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R3822 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R3823 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R3824 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R3825 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R3826 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R3827 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R3828 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R3829 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R3830 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R3831 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R3832 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R3833 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R3834 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R3835 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R3836 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R3837 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R3838 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R3839 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R3840 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R3841 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R3842 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R3843 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R3844 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R3845 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R3846 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R3847 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R3848 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R3849 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R3850 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R3851 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R3852 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R3853 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R3854 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R3855 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R3856 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R3857 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R3858 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R3859 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R3860 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R3861 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R3862 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R3863 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R3864 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R3865 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R3866 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R3867 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R3868 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R3869 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R3870 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R3871 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R3872 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R3873 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R3874 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R3875 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R3876 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R3877 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R3878 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R3879 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R3880 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R3881 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R3882 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R3883 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R3884 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R3885 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R3886 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R3887 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R3888 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R3889 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R3890 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R3891 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R3892 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R3893 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R3894 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R3895 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R3896 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R3897 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R3898 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R3899 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R3900 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R3901 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R3902 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R3903 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R3904 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R3905 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R3906 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R3907 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R3908 n1_m1_470400_158400 n1_m1_475200_158400 5.356235
R3909 n1_m1_475200_158400 n1_m1_480000_158400 5.356235
R3910 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R3911 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R3912 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R3913 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R3914 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R3915 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R3916 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R3917 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R3918 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R3919 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R3920 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R3921 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R3922 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R3923 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R3924 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R3925 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R3926 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R3927 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R3928 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R3929 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R3930 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R3931 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R3932 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R3933 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R3934 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R3935 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R3936 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R3937 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R3938 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R3939 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R3940 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R3941 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R3942 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R3943 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R3944 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R3945 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R3946 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R3947 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R3948 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R3949 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R3950 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R3951 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R3952 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R3953 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R3954 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R3955 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R3956 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R3957 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R3958 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R3959 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R3960 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R3961 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R3962 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R3963 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R3964 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R3965 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R3966 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R3967 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R3968 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R3969 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R3970 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R3971 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R3972 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R3973 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R3974 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R3975 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R3976 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R3977 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R3978 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R3979 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R3980 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R3981 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R3982 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R3983 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R3984 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R3985 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R3986 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R3987 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R3988 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R3989 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R3990 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R3991 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R3992 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R3993 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R3994 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R3995 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R3996 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R3997 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R3998 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R3999 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R4000 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R4001 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R4002 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R4003 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R4004 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R4005 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R4006 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R4007 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R4008 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R4009 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R4010 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R4011 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R4012 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R4013 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R4014 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R4015 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R4016 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R4017 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R4018 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R4019 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R4020 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R4021 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R4022 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R4023 n1_m1_470400_163200 n1_m1_475200_163200 5.356235
R4024 n1_m1_475200_163200 n1_m1_480000_163200 5.356235
R4025 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R4026 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R4027 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R4028 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R4029 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R4030 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R4031 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R4032 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R4033 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R4034 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R4035 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R4036 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R4037 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R4038 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R4039 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R4040 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R4041 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R4042 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R4043 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R4044 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R4045 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R4046 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R4047 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R4048 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R4049 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R4050 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R4051 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R4052 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R4053 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R4054 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R4055 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R4056 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R4057 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R4058 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R4059 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R4060 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R4061 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R4062 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R4063 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R4064 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R4065 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R4066 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R4067 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R4068 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R4069 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R4070 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R4071 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R4072 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R4073 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R4074 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R4075 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R4076 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R4077 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R4078 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R4079 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R4080 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R4081 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R4082 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R4083 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R4084 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R4085 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R4086 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R4087 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R4088 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R4089 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R4090 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R4091 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R4092 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R4093 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R4094 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R4095 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R4096 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R4097 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R4098 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R4099 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R4100 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R4101 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R4102 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R4103 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R4104 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R4105 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R4106 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R4107 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R4108 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R4109 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R4110 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R4111 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R4112 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R4113 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R4114 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R4115 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R4116 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R4117 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R4118 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R4119 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R4120 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R4121 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R4122 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R4123 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R4124 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R4125 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R4126 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R4127 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R4128 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R4129 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R4130 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R4131 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R4132 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R4133 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R4134 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R4135 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R4136 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R4137 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R4138 n1_m1_470400_168000 n1_m1_475200_168000 5.356235
R4139 n1_m1_475200_168000 n1_m1_480000_168000 5.356235
R4140 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R4141 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R4142 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R4143 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R4144 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R4145 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R4146 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R4147 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R4148 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R4149 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R4150 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R4151 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R4152 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R4153 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R4154 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R4155 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R4156 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R4157 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R4158 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R4159 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R4160 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R4161 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R4162 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R4163 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R4164 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R4165 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R4166 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R4167 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R4168 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R4169 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R4170 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R4171 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R4172 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R4173 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R4174 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R4175 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R4176 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R4177 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R4178 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R4179 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R4180 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R4181 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R4182 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R4183 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R4184 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R4185 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R4186 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R4187 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R4188 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R4189 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R4190 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R4191 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R4192 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R4193 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R4194 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R4195 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R4196 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R4197 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R4198 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R4199 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R4200 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R4201 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R4202 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R4203 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R4204 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R4205 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R4206 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R4207 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R4208 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R4209 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R4210 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R4211 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R4212 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R4213 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R4214 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R4215 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R4216 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R4217 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R4218 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R4219 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R4220 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R4221 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R4222 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R4223 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R4224 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R4225 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R4226 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R4227 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R4228 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R4229 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R4230 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R4231 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R4232 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R4233 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R4234 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R4235 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R4236 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R4237 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R4238 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R4239 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R4240 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R4241 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R4242 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R4243 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R4244 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R4245 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R4246 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R4247 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R4248 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R4249 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R4250 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R4251 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R4252 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R4253 n1_m1_470400_172800 n1_m1_475200_172800 5.356235
R4254 n1_m1_475200_172800 n1_m1_480000_172800 5.356235
R4255 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R4256 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R4257 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R4258 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R4259 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R4260 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R4261 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R4262 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R4263 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R4264 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R4265 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R4266 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R4267 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R4268 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R4269 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R4270 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R4271 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R4272 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R4273 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R4274 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R4275 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R4276 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R4277 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R4278 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R4279 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R4280 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R4281 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R4282 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R4283 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R4284 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R4285 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R4286 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R4287 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R4288 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R4289 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R4290 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R4291 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R4292 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R4293 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R4294 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R4295 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R4296 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R4297 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R4298 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R4299 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R4300 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R4301 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R4302 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R4303 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R4304 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R4305 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R4306 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R4307 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R4308 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R4309 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R4310 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R4311 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R4312 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R4313 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R4314 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R4315 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R4316 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R4317 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R4318 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R4319 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R4320 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R4321 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R4322 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R4323 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R4324 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R4325 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R4326 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R4327 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R4328 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R4329 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R4330 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R4331 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R4332 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R4333 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R4334 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R4335 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R4336 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R4337 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R4338 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R4339 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R4340 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R4341 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R4342 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R4343 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R4344 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R4345 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R4346 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R4347 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R4348 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R4349 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R4350 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R4351 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R4352 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R4353 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R4354 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R4355 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R4356 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R4357 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R4358 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R4359 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R4360 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R4361 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R4362 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R4363 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R4364 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R4365 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R4366 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R4367 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R4368 n1_m1_470400_177600 n1_m1_475200_177600 5.356235
R4369 n1_m1_475200_177600 n1_m1_480000_177600 5.356235
R4370 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R4371 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R4372 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R4373 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R4374 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R4375 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R4376 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R4377 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R4378 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R4379 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R4380 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R4381 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R4382 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R4383 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R4384 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R4385 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R4386 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R4387 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R4388 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R4389 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R4390 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R4391 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R4392 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R4393 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R4394 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R4395 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R4396 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R4397 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R4398 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R4399 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R4400 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R4401 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R4402 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R4403 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R4404 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R4405 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R4406 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R4407 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R4408 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R4409 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R4410 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R4411 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R4412 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R4413 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R4414 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R4415 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R4416 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R4417 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R4418 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R4419 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R4420 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R4421 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R4422 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R4423 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R4424 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R4425 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R4426 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R4427 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R4428 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R4429 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R4430 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R4431 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R4432 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R4433 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R4434 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R4435 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R4436 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R4437 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R4438 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R4439 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R4440 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R4441 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R4442 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R4443 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R4444 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R4445 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R4446 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R4447 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R4448 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R4449 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R4450 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R4451 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R4452 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R4453 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R4454 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R4455 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R4456 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R4457 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R4458 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R4459 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R4460 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R4461 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R4462 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R4463 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R4464 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R4465 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R4466 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R4467 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R4468 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R4469 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R4470 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R4471 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R4472 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R4473 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R4474 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R4475 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R4476 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R4477 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R4478 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R4479 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R4480 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R4481 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R4482 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R4483 n1_m1_470400_182400 n1_m1_475200_182400 5.356235
R4484 n1_m1_475200_182400 n1_m1_480000_182400 5.356235
R4485 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R4486 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R4487 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R4488 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R4489 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R4490 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R4491 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R4492 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R4493 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R4494 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R4495 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R4496 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R4497 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R4498 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R4499 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R4500 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R4501 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R4502 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R4503 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R4504 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R4505 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R4506 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R4507 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R4508 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R4509 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R4510 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R4511 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R4512 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R4513 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R4514 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R4515 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R4516 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R4517 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R4518 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R4519 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R4520 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R4521 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R4522 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R4523 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R4524 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R4525 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R4526 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R4527 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R4528 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R4529 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R4530 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R4531 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R4532 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R4533 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R4534 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R4535 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R4536 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R4537 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R4538 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R4539 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R4540 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R4541 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R4542 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R4543 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R4544 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R4545 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R4546 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R4547 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R4548 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R4549 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R4550 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R4551 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R4552 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R4553 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R4554 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R4555 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R4556 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R4557 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R4558 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R4559 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R4560 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R4561 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R4562 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R4563 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R4564 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R4565 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R4566 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R4567 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R4568 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R4569 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R4570 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R4571 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R4572 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R4573 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R4574 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R4575 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R4576 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R4577 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R4578 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R4579 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R4580 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R4581 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R4582 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R4583 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R4584 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R4585 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R4586 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R4587 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R4588 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R4589 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R4590 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R4591 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R4592 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R4593 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R4594 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R4595 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R4596 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R4597 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R4598 n1_m1_470400_187200 n1_m1_475200_187200 5.356235
R4599 n1_m1_475200_187200 n1_m1_480000_187200 5.356235
R4600 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R4601 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R4602 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R4603 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R4604 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R4605 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R4606 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R4607 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R4608 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R4609 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R4610 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R4611 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R4612 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R4613 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R4614 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R4615 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R4616 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R4617 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R4618 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R4619 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R4620 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R4621 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R4622 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R4623 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R4624 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R4625 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R4626 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R4627 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R4628 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R4629 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R4630 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R4631 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R4632 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R4633 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R4634 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R4635 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R4636 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R4637 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R4638 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R4639 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R4640 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R4641 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R4642 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R4643 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R4644 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R4645 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R4646 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R4647 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R4648 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R4649 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R4650 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R4651 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R4652 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R4653 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R4654 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R4655 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R4656 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R4657 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R4658 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R4659 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R4660 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R4661 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R4662 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R4663 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R4664 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R4665 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R4666 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R4667 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R4668 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R4669 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R4670 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R4671 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R4672 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R4673 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R4674 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R4675 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R4676 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R4677 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R4678 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R4679 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R4680 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R4681 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R4682 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R4683 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R4684 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R4685 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R4686 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R4687 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R4688 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R4689 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R4690 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R4691 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R4692 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R4693 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R4694 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R4695 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R4696 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R4697 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R4698 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R4699 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R4700 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R4701 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R4702 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R4703 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R4704 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R4705 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R4706 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R4707 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R4708 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R4709 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R4710 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R4711 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R4712 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R4713 n1_m1_470400_192000 n1_m1_475200_192000 5.356235
R4714 n1_m1_475200_192000 n1_m1_480000_192000 5.356235
R4715 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R4716 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R4717 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R4718 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R4719 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R4720 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R4721 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R4722 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R4723 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R4724 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R4725 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R4726 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R4727 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R4728 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R4729 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R4730 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R4731 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R4732 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R4733 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R4734 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R4735 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R4736 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R4737 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R4738 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R4739 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R4740 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R4741 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R4742 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R4743 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R4744 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R4745 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R4746 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R4747 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R4748 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R4749 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R4750 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R4751 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R4752 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R4753 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R4754 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R4755 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R4756 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R4757 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R4758 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R4759 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R4760 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R4761 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R4762 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R4763 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R4764 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R4765 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R4766 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R4767 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R4768 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R4769 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R4770 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R4771 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R4772 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R4773 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R4774 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R4775 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R4776 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R4777 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R4778 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R4779 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R4780 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R4781 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R4782 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R4783 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R4784 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R4785 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R4786 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R4787 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R4788 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R4789 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R4790 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R4791 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R4792 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R4793 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R4794 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R4795 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R4796 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R4797 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R4798 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R4799 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R4800 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R4801 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R4802 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R4803 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R4804 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R4805 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R4806 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R4807 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R4808 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R4809 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R4810 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R4811 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R4812 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R4813 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R4814 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R4815 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R4816 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R4817 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R4818 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R4819 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R4820 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R4821 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R4822 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R4823 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R4824 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R4825 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R4826 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R4827 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R4828 n1_m1_470400_196800 n1_m1_475200_196800 5.356235
R4829 n1_m1_475200_196800 n1_m1_480000_196800 5.356235
R4830 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R4831 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R4832 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R4833 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R4834 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R4835 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R4836 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R4837 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R4838 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R4839 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R4840 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R4841 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R4842 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R4843 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R4844 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R4845 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R4846 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R4847 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R4848 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R4849 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R4850 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R4851 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R4852 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R4853 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R4854 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R4855 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R4856 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R4857 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R4858 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R4859 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R4860 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R4861 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R4862 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R4863 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R4864 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R4865 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R4866 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R4867 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R4868 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R4869 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R4870 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R4871 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R4872 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R4873 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R4874 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R4875 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R4876 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R4877 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R4878 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R4879 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R4880 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R4881 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R4882 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R4883 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R4884 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R4885 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R4886 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R4887 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R4888 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R4889 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R4890 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R4891 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R4892 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R4893 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R4894 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R4895 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R4896 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R4897 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R4898 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R4899 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R4900 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R4901 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R4902 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R4903 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R4904 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R4905 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R4906 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R4907 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R4908 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R4909 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R4910 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R4911 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R4912 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R4913 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R4914 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R4915 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R4916 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R4917 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R4918 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R4919 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R4920 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R4921 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R4922 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R4923 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R4924 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R4925 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R4926 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R4927 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R4928 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R4929 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R4930 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R4931 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R4932 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R4933 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R4934 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R4935 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R4936 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R4937 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R4938 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R4939 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R4940 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R4941 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R4942 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R4943 n1_m1_470400_201600 n1_m1_475200_201600 5.356235
R4944 n1_m1_475200_201600 n1_m1_480000_201600 5.356235
R4945 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R4946 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R4947 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R4948 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R4949 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R4950 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R4951 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R4952 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R4953 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R4954 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R4955 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R4956 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R4957 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R4958 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R4959 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R4960 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R4961 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R4962 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R4963 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R4964 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R4965 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R4966 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R4967 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R4968 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R4969 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R4970 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R4971 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R4972 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R4973 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R4974 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R4975 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R4976 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R4977 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R4978 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R4979 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R4980 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R4981 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R4982 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R4983 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R4984 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R4985 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R4986 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R4987 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R4988 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R4989 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R4990 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R4991 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R4992 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R4993 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R4994 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R4995 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R4996 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R4997 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R4998 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R4999 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R5000 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R5001 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R5002 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R5003 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R5004 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R5005 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R5006 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R5007 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R5008 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R5009 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R5010 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R5011 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R5012 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R5013 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R5014 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R5015 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R5016 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R5017 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R5018 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R5019 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R5020 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R5021 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R5022 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R5023 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R5024 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R5025 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R5026 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R5027 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R5028 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R5029 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R5030 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R5031 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R5032 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R5033 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R5034 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R5035 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R5036 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R5037 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R5038 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R5039 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R5040 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R5041 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R5042 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R5043 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R5044 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R5045 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R5046 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R5047 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R5048 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R5049 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R5050 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R5051 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R5052 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R5053 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R5054 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R5055 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R5056 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R5057 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R5058 n1_m1_470400_206400 n1_m1_475200_206400 5.356235
R5059 n1_m1_475200_206400 n1_m1_480000_206400 5.356235
R5060 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R5061 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R5062 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R5063 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R5064 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R5065 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R5066 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R5067 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R5068 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R5069 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R5070 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R5071 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R5072 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R5073 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R5074 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R5075 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R5076 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R5077 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R5078 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R5079 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R5080 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R5081 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R5082 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R5083 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R5084 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R5085 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R5086 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R5087 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R5088 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R5089 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R5090 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R5091 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R5092 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R5093 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R5094 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R5095 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R5096 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R5097 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R5098 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R5099 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R5100 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R5101 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R5102 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R5103 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R5104 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R5105 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R5106 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R5107 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R5108 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R5109 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R5110 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R5111 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R5112 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R5113 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R5114 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R5115 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R5116 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R5117 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R5118 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R5119 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R5120 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R5121 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R5122 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R5123 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R5124 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R5125 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R5126 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R5127 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R5128 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R5129 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R5130 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R5131 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R5132 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R5133 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R5134 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R5135 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R5136 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R5137 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R5138 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R5139 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R5140 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R5141 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R5142 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R5143 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R5144 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R5145 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R5146 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R5147 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R5148 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R5149 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R5150 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R5151 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R5152 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R5153 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R5154 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R5155 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R5156 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R5157 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R5158 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R5159 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R5160 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R5161 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R5162 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R5163 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R5164 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R5165 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R5166 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R5167 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R5168 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R5169 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R5170 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R5171 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R5172 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R5173 n1_m1_470400_211200 n1_m1_475200_211200 5.356235
R5174 n1_m1_475200_211200 n1_m1_480000_211200 5.356235
R5175 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R5176 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R5177 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R5178 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R5179 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R5180 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R5181 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R5182 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R5183 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R5184 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R5185 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R5186 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R5187 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R5188 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R5189 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R5190 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R5191 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R5192 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R5193 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R5194 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R5195 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R5196 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R5197 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R5198 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R5199 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R5200 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R5201 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R5202 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R5203 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R5204 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R5205 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R5206 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R5207 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R5208 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R5209 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R5210 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R5211 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R5212 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R5213 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R5214 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R5215 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R5216 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R5217 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R5218 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R5219 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R5220 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R5221 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R5222 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R5223 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R5224 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R5225 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R5226 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R5227 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R5228 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R5229 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R5230 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R5231 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R5232 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R5233 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R5234 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R5235 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R5236 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R5237 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R5238 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R5239 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R5240 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R5241 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R5242 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R5243 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R5244 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R5245 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R5246 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R5247 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R5248 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R5249 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R5250 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R5251 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R5252 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R5253 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R5254 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R5255 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R5256 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R5257 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R5258 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R5259 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R5260 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R5261 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R5262 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R5263 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R5264 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R5265 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R5266 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R5267 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R5268 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R5269 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R5270 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R5271 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R5272 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R5273 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R5274 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R5275 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R5276 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R5277 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R5278 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R5279 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R5280 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R5281 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R5282 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R5283 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R5284 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R5285 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R5286 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R5287 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R5288 n1_m1_470400_216000 n1_m1_475200_216000 5.356235
R5289 n1_m1_475200_216000 n1_m1_480000_216000 5.356235
R5290 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R5291 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R5292 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R5293 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R5294 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R5295 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R5296 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R5297 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R5298 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R5299 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R5300 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R5301 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R5302 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R5303 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R5304 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R5305 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R5306 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R5307 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R5308 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R5309 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R5310 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R5311 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R5312 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R5313 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R5314 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R5315 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R5316 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R5317 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R5318 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R5319 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R5320 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R5321 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R5322 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R5323 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R5324 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R5325 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R5326 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R5327 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R5328 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R5329 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R5330 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R5331 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R5332 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R5333 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R5334 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R5335 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R5336 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R5337 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R5338 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R5339 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R5340 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R5341 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R5342 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R5343 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R5344 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R5345 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R5346 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R5347 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R5348 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R5349 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R5350 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R5351 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R5352 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R5353 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R5354 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R5355 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R5356 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R5357 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R5358 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R5359 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R5360 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R5361 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R5362 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R5363 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R5364 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R5365 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R5366 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R5367 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R5368 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R5369 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R5370 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R5371 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R5372 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R5373 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R5374 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R5375 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R5376 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R5377 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R5378 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R5379 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R5380 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R5381 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R5382 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R5383 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R5384 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R5385 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R5386 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R5387 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R5388 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R5389 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R5390 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R5391 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R5392 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R5393 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R5394 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R5395 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R5396 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R5397 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R5398 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R5399 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R5400 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R5401 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R5402 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R5403 n1_m1_470400_220800 n1_m1_475200_220800 5.356235
R5404 n1_m1_475200_220800 n1_m1_480000_220800 5.356235
R5405 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R5406 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R5407 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R5408 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R5409 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R5410 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R5411 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R5412 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R5413 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R5414 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R5415 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R5416 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R5417 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R5418 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R5419 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R5420 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R5421 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R5422 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R5423 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R5424 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R5425 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R5426 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R5427 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R5428 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R5429 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R5430 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R5431 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R5432 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R5433 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R5434 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R5435 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R5436 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R5437 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R5438 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R5439 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R5440 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R5441 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R5442 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R5443 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R5444 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R5445 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R5446 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R5447 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R5448 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R5449 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R5450 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R5451 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R5452 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R5453 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R5454 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R5455 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R5456 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R5457 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R5458 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R5459 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R5460 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R5461 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R5462 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R5463 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R5464 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R5465 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R5466 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R5467 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R5468 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R5469 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R5470 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R5471 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R5472 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R5473 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R5474 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R5475 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R5476 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R5477 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R5478 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R5479 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R5480 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R5481 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R5482 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R5483 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R5484 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R5485 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R5486 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R5487 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R5488 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R5489 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R5490 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R5491 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R5492 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R5493 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R5494 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R5495 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R5496 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R5497 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R5498 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R5499 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R5500 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R5501 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R5502 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R5503 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R5504 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R5505 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R5506 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R5507 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R5508 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R5509 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R5510 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R5511 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R5512 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R5513 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R5514 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R5515 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R5516 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R5517 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R5518 n1_m1_470400_225600 n1_m1_475200_225600 5.356235
R5519 n1_m1_475200_225600 n1_m1_480000_225600 5.356235
R5520 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R5521 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R5522 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R5523 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R5524 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R5525 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R5526 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R5527 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R5528 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R5529 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R5530 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R5531 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R5532 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R5533 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R5534 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R5535 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R5536 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R5537 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R5538 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R5539 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R5540 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R5541 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R5542 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R5543 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R5544 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R5545 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R5546 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R5547 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R5548 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R5549 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R5550 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R5551 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R5552 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R5553 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R5554 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R5555 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R5556 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R5557 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R5558 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R5559 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R5560 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R5561 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R5562 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R5563 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R5564 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R5565 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R5566 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R5567 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R5568 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R5569 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R5570 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R5571 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R5572 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R5573 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R5574 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R5575 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R5576 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R5577 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R5578 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R5579 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R5580 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R5581 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R5582 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R5583 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R5584 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R5585 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R5586 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R5587 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R5588 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R5589 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R5590 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R5591 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R5592 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R5593 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R5594 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R5595 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R5596 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R5597 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R5598 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R5599 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R5600 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R5601 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R5602 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R5603 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R5604 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R5605 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R5606 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R5607 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R5608 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R5609 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R5610 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R5611 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R5612 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R5613 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R5614 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R5615 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R5616 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R5617 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R5618 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R5619 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R5620 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R5621 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R5622 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R5623 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R5624 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R5625 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R5626 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R5627 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R5628 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R5629 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R5630 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R5631 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R5632 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R5633 n1_m1_470400_230400 n1_m1_475200_230400 5.356235
R5634 n1_m1_475200_230400 n1_m1_480000_230400 5.356235
R5635 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R5636 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R5637 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R5638 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R5639 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R5640 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R5641 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R5642 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R5643 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R5644 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R5645 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R5646 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R5647 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R5648 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R5649 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R5650 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R5651 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R5652 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R5653 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R5654 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R5655 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R5656 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R5657 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R5658 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R5659 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R5660 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R5661 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R5662 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R5663 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R5664 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R5665 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R5666 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R5667 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R5668 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R5669 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R5670 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R5671 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R5672 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R5673 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R5674 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R5675 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R5676 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R5677 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R5678 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R5679 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R5680 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R5681 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R5682 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R5683 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R5684 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R5685 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R5686 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R5687 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R5688 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R5689 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R5690 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R5691 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R5692 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R5693 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R5694 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R5695 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R5696 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R5697 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R5698 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R5699 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R5700 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R5701 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R5702 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R5703 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R5704 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R5705 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R5706 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R5707 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R5708 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R5709 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R5710 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R5711 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R5712 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R5713 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R5714 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R5715 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R5716 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R5717 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R5718 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R5719 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R5720 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R5721 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R5722 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R5723 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R5724 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R5725 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R5726 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R5727 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R5728 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R5729 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R5730 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R5731 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R5732 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R5733 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R5734 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R5735 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R5736 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R5737 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R5738 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R5739 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R5740 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R5741 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R5742 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R5743 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R5744 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R5745 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R5746 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R5747 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R5748 n1_m1_470400_235200 n1_m1_475200_235200 5.356235
R5749 n1_m1_475200_235200 n1_m1_480000_235200 5.356235
R5750 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R5751 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R5752 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R5753 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R5754 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R5755 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R5756 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R5757 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R5758 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R5759 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R5760 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R5761 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R5762 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R5763 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R5764 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R5765 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R5766 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R5767 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R5768 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R5769 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R5770 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R5771 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R5772 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R5773 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R5774 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R5775 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R5776 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R5777 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R5778 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R5779 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R5780 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R5781 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R5782 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R5783 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R5784 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R5785 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R5786 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R5787 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R5788 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R5789 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R5790 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R5791 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R5792 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R5793 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R5794 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R5795 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R5796 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R5797 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R5798 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R5799 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R5800 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R5801 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R5802 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R5803 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R5804 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R5805 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R5806 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R5807 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R5808 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R5809 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R5810 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R5811 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R5812 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R5813 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R5814 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R5815 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R5816 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R5817 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R5818 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R5819 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R5820 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R5821 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R5822 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R5823 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R5824 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R5825 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R5826 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R5827 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R5828 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R5829 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R5830 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R5831 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R5832 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R5833 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R5834 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R5835 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R5836 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R5837 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R5838 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R5839 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R5840 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R5841 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R5842 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R5843 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R5844 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R5845 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R5846 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R5847 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R5848 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R5849 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R5850 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R5851 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R5852 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R5853 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R5854 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R5855 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R5856 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R5857 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R5858 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R5859 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R5860 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R5861 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R5862 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R5863 n1_m1_470400_240000 n1_m1_475200_240000 5.356235
R5864 n1_m1_475200_240000 n1_m1_480000_240000 5.356235
R5865 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R5866 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R5867 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R5868 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R5869 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R5870 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R5871 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R5872 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R5873 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R5874 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R5875 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R5876 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R5877 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R5878 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R5879 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R5880 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R5881 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R5882 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R5883 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R5884 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R5885 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R5886 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R5887 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R5888 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R5889 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R5890 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R5891 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R5892 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R5893 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R5894 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R5895 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R5896 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R5897 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R5898 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R5899 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R5900 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R5901 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R5902 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R5903 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R5904 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R5905 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R5906 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R5907 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R5908 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R5909 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R5910 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R5911 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R5912 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R5913 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R5914 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R5915 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R5916 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R5917 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R5918 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R5919 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R5920 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R5921 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R5922 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R5923 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R5924 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R5925 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R5926 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R5927 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R5928 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R5929 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R5930 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R5931 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R5932 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R5933 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R5934 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R5935 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R5936 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R5937 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R5938 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R5939 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R5940 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R5941 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R5942 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R5943 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R5944 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R5945 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R5946 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R5947 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R5948 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R5949 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R5950 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R5951 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R5952 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R5953 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R5954 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R5955 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R5956 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R5957 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R5958 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R5959 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R5960 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R5961 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R5962 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R5963 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R5964 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R5965 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R5966 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R5967 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R5968 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R5969 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R5970 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R5971 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R5972 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R5973 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R5974 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R5975 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R5976 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R5977 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R5978 n1_m1_470400_244800 n1_m1_475200_244800 5.356235
R5979 n1_m1_475200_244800 n1_m1_480000_244800 5.356235
R5980 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R5981 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R5982 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R5983 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R5984 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R5985 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R5986 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R5987 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R5988 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R5989 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R5990 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R5991 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R5992 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R5993 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R5994 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R5995 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R5996 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R5997 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R5998 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R5999 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R6000 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R6001 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R6002 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R6003 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R6004 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R6005 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R6006 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R6007 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R6008 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R6009 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R6010 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R6011 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R6012 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R6013 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R6014 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R6015 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R6016 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R6017 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R6018 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R6019 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R6020 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R6021 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R6022 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R6023 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R6024 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R6025 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R6026 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R6027 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R6028 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R6029 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R6030 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R6031 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R6032 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R6033 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R6034 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R6035 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R6036 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R6037 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R6038 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R6039 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R6040 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R6041 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R6042 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R6043 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R6044 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R6045 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R6046 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R6047 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R6048 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R6049 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R6050 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R6051 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R6052 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R6053 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R6054 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R6055 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R6056 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R6057 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R6058 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R6059 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R6060 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R6061 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R6062 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R6063 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R6064 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R6065 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R6066 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R6067 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R6068 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R6069 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R6070 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R6071 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R6072 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R6073 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R6074 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R6075 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R6076 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R6077 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R6078 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R6079 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R6080 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R6081 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R6082 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R6083 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R6084 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R6085 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R6086 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R6087 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R6088 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R6089 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R6090 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R6091 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R6092 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R6093 n1_m1_470400_249600 n1_m1_475200_249600 5.356235
R6094 n1_m1_475200_249600 n1_m1_480000_249600 5.356235
R6095 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R6096 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R6097 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R6098 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R6099 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R6100 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R6101 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R6102 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R6103 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R6104 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R6105 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R6106 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R6107 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R6108 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R6109 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R6110 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R6111 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R6112 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R6113 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R6114 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R6115 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R6116 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R6117 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R6118 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R6119 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R6120 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R6121 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R6122 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R6123 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R6124 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R6125 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R6126 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R6127 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R6128 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R6129 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R6130 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R6131 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R6132 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R6133 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R6134 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R6135 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R6136 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R6137 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R6138 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R6139 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R6140 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R6141 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R6142 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R6143 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R6144 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R6145 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R6146 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R6147 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R6148 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R6149 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R6150 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R6151 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R6152 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R6153 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R6154 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R6155 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R6156 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R6157 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R6158 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R6159 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R6160 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R6161 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R6162 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R6163 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R6164 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R6165 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R6166 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R6167 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R6168 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R6169 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R6170 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R6171 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R6172 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R6173 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R6174 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R6175 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R6176 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R6177 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R6178 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R6179 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R6180 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R6181 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R6182 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R6183 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R6184 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R6185 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R6186 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R6187 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R6188 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R6189 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R6190 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R6191 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R6192 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R6193 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R6194 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R6195 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R6196 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R6197 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R6198 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R6199 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R6200 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R6201 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R6202 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R6203 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R6204 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R6205 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R6206 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R6207 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R6208 n1_m1_470400_254400 n1_m1_475200_254400 5.356235
R6209 n1_m1_475200_254400 n1_m1_480000_254400 5.356235
R6210 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R6211 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R6212 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R6213 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R6214 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R6215 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R6216 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R6217 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R6218 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R6219 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R6220 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R6221 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R6222 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R6223 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R6224 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R6225 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R6226 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R6227 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R6228 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R6229 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R6230 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R6231 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R6232 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R6233 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R6234 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R6235 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R6236 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R6237 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R6238 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R6239 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R6240 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R6241 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R6242 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R6243 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R6244 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R6245 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R6246 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R6247 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R6248 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R6249 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R6250 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R6251 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R6252 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R6253 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R6254 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R6255 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R6256 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R6257 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R6258 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R6259 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R6260 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R6261 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R6262 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R6263 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R6264 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R6265 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R6266 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R6267 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R6268 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R6269 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R6270 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R6271 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R6272 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R6273 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R6274 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R6275 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R6276 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R6277 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R6278 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R6279 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R6280 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R6281 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R6282 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R6283 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R6284 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R6285 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R6286 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R6287 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R6288 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R6289 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R6290 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R6291 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R6292 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R6293 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R6294 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R6295 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R6296 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R6297 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R6298 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R6299 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R6300 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R6301 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R6302 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R6303 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R6304 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R6305 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R6306 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R6307 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R6308 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R6309 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R6310 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R6311 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R6312 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R6313 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R6314 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R6315 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R6316 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R6317 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R6318 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R6319 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R6320 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R6321 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R6322 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R6323 n1_m1_470400_259200 n1_m1_475200_259200 5.356235
R6324 n1_m1_475200_259200 n1_m1_480000_259200 5.356235
R6325 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R6326 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R6327 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R6328 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R6329 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R6330 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R6331 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R6332 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R6333 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R6334 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R6335 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R6336 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R6337 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R6338 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R6339 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R6340 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R6341 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R6342 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R6343 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R6344 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R6345 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R6346 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R6347 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R6348 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R6349 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R6350 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R6351 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R6352 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R6353 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R6354 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R6355 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R6356 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R6357 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R6358 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R6359 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R6360 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R6361 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R6362 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R6363 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R6364 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R6365 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R6366 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R6367 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R6368 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R6369 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R6370 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R6371 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R6372 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R6373 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R6374 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R6375 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R6376 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R6377 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R6378 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R6379 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R6380 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R6381 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R6382 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R6383 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R6384 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R6385 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R6386 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R6387 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R6388 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R6389 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R6390 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R6391 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R6392 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R6393 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R6394 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R6395 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R6396 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R6397 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R6398 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R6399 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R6400 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R6401 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R6402 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R6403 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R6404 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R6405 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R6406 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R6407 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R6408 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R6409 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R6410 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R6411 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R6412 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R6413 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R6414 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R6415 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R6416 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R6417 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R6418 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R6419 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R6420 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R6421 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R6422 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R6423 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R6424 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R6425 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R6426 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R6427 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R6428 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R6429 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R6430 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R6431 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R6432 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R6433 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R6434 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R6435 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R6436 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R6437 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R6438 n1_m1_470400_264000 n1_m1_475200_264000 5.356235
R6439 n1_m1_475200_264000 n1_m1_480000_264000 5.356235
R6440 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R6441 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R6442 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R6443 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R6444 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R6445 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R6446 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R6447 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R6448 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R6449 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R6450 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R6451 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R6452 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R6453 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R6454 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R6455 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R6456 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R6457 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R6458 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R6459 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R6460 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R6461 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R6462 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R6463 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R6464 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R6465 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R6466 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R6467 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R6468 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R6469 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R6470 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R6471 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R6472 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R6473 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R6474 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R6475 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R6476 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R6477 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R6478 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R6479 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R6480 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R6481 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R6482 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R6483 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R6484 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R6485 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R6486 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R6487 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R6488 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R6489 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R6490 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R6491 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R6492 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R6493 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R6494 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R6495 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R6496 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R6497 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R6498 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R6499 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R6500 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R6501 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R6502 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R6503 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R6504 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R6505 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R6506 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R6507 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R6508 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R6509 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R6510 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R6511 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R6512 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R6513 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R6514 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R6515 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R6516 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R6517 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R6518 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R6519 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R6520 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R6521 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R6522 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R6523 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R6524 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R6525 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R6526 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R6527 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R6528 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R6529 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R6530 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R6531 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R6532 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R6533 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R6534 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R6535 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R6536 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R6537 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R6538 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R6539 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R6540 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R6541 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R6542 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R6543 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R6544 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R6545 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R6546 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R6547 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R6548 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R6549 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R6550 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R6551 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R6552 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R6553 n1_m1_470400_268800 n1_m1_475200_268800 5.356235
R6554 n1_m1_475200_268800 n1_m1_480000_268800 5.356235
R6555 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R6556 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R6557 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R6558 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R6559 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R6560 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R6561 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R6562 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R6563 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R6564 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R6565 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R6566 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R6567 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R6568 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R6569 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R6570 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R6571 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R6572 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R6573 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R6574 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R6575 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R6576 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R6577 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R6578 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R6579 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R6580 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R6581 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R6582 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R6583 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R6584 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R6585 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R6586 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R6587 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R6588 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R6589 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R6590 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R6591 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R6592 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R6593 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R6594 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R6595 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R6596 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R6597 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R6598 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R6599 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R6600 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R6601 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R6602 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R6603 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R6604 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R6605 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R6606 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R6607 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R6608 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R6609 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R6610 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R6611 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R6612 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R6613 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R6614 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R6615 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R6616 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R6617 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R6618 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R6619 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R6620 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R6621 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R6622 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R6623 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R6624 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R6625 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R6626 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R6627 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R6628 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R6629 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R6630 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R6631 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R6632 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R6633 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R6634 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R6635 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R6636 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R6637 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R6638 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R6639 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R6640 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R6641 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R6642 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R6643 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R6644 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R6645 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R6646 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R6647 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R6648 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R6649 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R6650 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R6651 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R6652 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R6653 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R6654 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R6655 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R6656 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R6657 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R6658 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R6659 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R6660 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R6661 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R6662 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R6663 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R6664 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R6665 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R6666 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R6667 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R6668 n1_m1_470400_273600 n1_m1_475200_273600 5.356235
R6669 n1_m1_475200_273600 n1_m1_480000_273600 5.356235
R6670 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R6671 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R6672 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R6673 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R6674 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R6675 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R6676 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R6677 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R6678 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R6679 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R6680 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R6681 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R6682 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R6683 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R6684 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R6685 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R6686 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R6687 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R6688 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R6689 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R6690 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R6691 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R6692 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R6693 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R6694 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R6695 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R6696 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R6697 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R6698 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R6699 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R6700 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R6701 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R6702 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R6703 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R6704 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R6705 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R6706 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R6707 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R6708 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R6709 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R6710 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R6711 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R6712 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R6713 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R6714 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R6715 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R6716 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R6717 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R6718 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R6719 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R6720 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R6721 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R6722 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R6723 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R6724 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R6725 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R6726 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R6727 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R6728 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R6729 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R6730 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R6731 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R6732 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R6733 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R6734 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R6735 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R6736 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R6737 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R6738 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R6739 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R6740 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R6741 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R6742 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R6743 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R6744 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R6745 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R6746 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R6747 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R6748 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R6749 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R6750 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R6751 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R6752 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R6753 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R6754 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R6755 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R6756 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R6757 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R6758 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R6759 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R6760 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R6761 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R6762 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R6763 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R6764 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R6765 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R6766 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R6767 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R6768 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R6769 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R6770 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R6771 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R6772 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R6773 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R6774 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R6775 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R6776 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R6777 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R6778 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R6779 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R6780 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R6781 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R6782 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R6783 n1_m1_470400_278400 n1_m1_475200_278400 5.356235
R6784 n1_m1_475200_278400 n1_m1_480000_278400 5.356235
R6785 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R6786 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R6787 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R6788 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R6789 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R6790 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R6791 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R6792 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R6793 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R6794 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R6795 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R6796 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R6797 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R6798 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R6799 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R6800 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R6801 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R6802 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R6803 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R6804 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R6805 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R6806 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R6807 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R6808 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R6809 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R6810 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R6811 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R6812 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R6813 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R6814 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R6815 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R6816 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R6817 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R6818 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R6819 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R6820 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R6821 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R6822 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R6823 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R6824 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R6825 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R6826 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R6827 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R6828 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R6829 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R6830 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R6831 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R6832 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R6833 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R6834 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R6835 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R6836 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R6837 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R6838 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R6839 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R6840 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R6841 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R6842 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R6843 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R6844 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R6845 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R6846 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R6847 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R6848 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R6849 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R6850 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R6851 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R6852 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R6853 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R6854 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R6855 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R6856 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R6857 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R6858 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R6859 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R6860 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R6861 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R6862 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R6863 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R6864 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R6865 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R6866 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R6867 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R6868 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R6869 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R6870 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R6871 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R6872 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R6873 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R6874 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R6875 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R6876 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R6877 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R6878 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R6879 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R6880 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R6881 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R6882 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R6883 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R6884 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R6885 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R6886 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R6887 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R6888 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R6889 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R6890 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R6891 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R6892 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R6893 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R6894 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R6895 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R6896 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R6897 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R6898 n1_m1_470400_283200 n1_m1_475200_283200 5.356235
R6899 n1_m1_475200_283200 n1_m1_480000_283200 5.356235
R6900 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R6901 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R6902 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R6903 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R6904 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R6905 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R6906 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R6907 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R6908 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R6909 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R6910 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R6911 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R6912 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R6913 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R6914 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R6915 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R6916 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R6917 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R6918 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R6919 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R6920 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R6921 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R6922 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R6923 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R6924 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R6925 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R6926 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R6927 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R6928 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R6929 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R6930 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R6931 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R6932 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R6933 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R6934 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R6935 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R6936 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R6937 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R6938 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R6939 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R6940 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R6941 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R6942 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R6943 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R6944 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R6945 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R6946 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R6947 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R6948 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R6949 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R6950 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R6951 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R6952 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R6953 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R6954 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R6955 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R6956 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R6957 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R6958 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R6959 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R6960 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R6961 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R6962 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R6963 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R6964 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R6965 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R6966 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R6967 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R6968 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R6969 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R6970 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R6971 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R6972 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R6973 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R6974 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R6975 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R6976 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R6977 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R6978 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R6979 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R6980 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R6981 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R6982 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R6983 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R6984 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R6985 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R6986 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R6987 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R6988 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R6989 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R6990 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R6991 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R6992 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R6993 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R6994 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R6995 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R6996 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R6997 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R6998 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R6999 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R7000 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R7001 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R7002 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R7003 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R7004 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R7005 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R7006 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R7007 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R7008 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R7009 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R7010 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R7011 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R7012 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R7013 n1_m1_470400_288000 n1_m1_475200_288000 5.356235
R7014 n1_m1_475200_288000 n1_m1_480000_288000 5.356235
R7015 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R7016 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R7017 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R7018 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R7019 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R7020 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R7021 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R7022 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R7023 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R7024 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R7025 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R7026 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R7027 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R7028 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R7029 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R7030 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R7031 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R7032 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R7033 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R7034 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R7035 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R7036 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R7037 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R7038 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R7039 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R7040 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R7041 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R7042 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R7043 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R7044 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R7045 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R7046 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R7047 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R7048 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R7049 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R7050 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R7051 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R7052 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R7053 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R7054 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R7055 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R7056 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R7057 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R7058 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R7059 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R7060 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R7061 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R7062 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R7063 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R7064 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R7065 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R7066 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R7067 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R7068 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R7069 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R7070 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R7071 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R7072 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R7073 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R7074 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R7075 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R7076 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R7077 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R7078 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R7079 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R7080 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R7081 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R7082 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R7083 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R7084 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R7085 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R7086 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R7087 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R7088 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R7089 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R7090 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R7091 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R7092 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R7093 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R7094 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R7095 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R7096 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R7097 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R7098 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R7099 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R7100 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R7101 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R7102 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R7103 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R7104 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R7105 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R7106 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R7107 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R7108 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R7109 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R7110 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R7111 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R7112 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R7113 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R7114 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R7115 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R7116 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R7117 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R7118 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R7119 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R7120 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R7121 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R7122 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R7123 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R7124 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R7125 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R7126 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R7127 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R7128 n1_m1_470400_292800 n1_m1_475200_292800 5.356235
R7129 n1_m1_475200_292800 n1_m1_480000_292800 5.356235
R7130 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R7131 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R7132 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R7133 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R7134 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R7135 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R7136 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R7137 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R7138 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R7139 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R7140 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R7141 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R7142 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R7143 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R7144 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R7145 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R7146 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R7147 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R7148 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R7149 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R7150 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R7151 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R7152 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R7153 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R7154 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R7155 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R7156 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R7157 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R7158 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R7159 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R7160 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R7161 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R7162 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R7163 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R7164 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R7165 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R7166 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R7167 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R7168 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R7169 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R7170 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R7171 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R7172 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R7173 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R7174 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R7175 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R7176 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R7177 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R7178 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R7179 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R7180 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R7181 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R7182 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R7183 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R7184 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R7185 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R7186 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R7187 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R7188 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R7189 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R7190 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R7191 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R7192 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R7193 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R7194 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R7195 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R7196 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R7197 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R7198 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R7199 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R7200 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R7201 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R7202 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R7203 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R7204 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R7205 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R7206 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R7207 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R7208 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R7209 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R7210 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R7211 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R7212 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R7213 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R7214 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R7215 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R7216 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R7217 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R7218 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R7219 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R7220 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R7221 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R7222 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R7223 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R7224 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R7225 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R7226 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R7227 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R7228 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R7229 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R7230 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R7231 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R7232 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R7233 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R7234 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R7235 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R7236 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R7237 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R7238 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R7239 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R7240 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R7241 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R7242 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R7243 n1_m1_470400_297600 n1_m1_475200_297600 5.356235
R7244 n1_m1_475200_297600 n1_m1_480000_297600 5.356235
R7245 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R7246 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R7247 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R7248 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R7249 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R7250 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R7251 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R7252 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R7253 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R7254 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R7255 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R7256 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R7257 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R7258 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R7259 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R7260 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R7261 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R7262 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R7263 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R7264 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R7265 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R7266 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R7267 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R7268 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R7269 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R7270 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R7271 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R7272 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R7273 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R7274 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R7275 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R7276 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R7277 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R7278 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R7279 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R7280 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R7281 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R7282 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R7283 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R7284 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R7285 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R7286 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R7287 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R7288 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R7289 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R7290 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R7291 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R7292 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R7293 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R7294 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R7295 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R7296 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R7297 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R7298 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R7299 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R7300 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R7301 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R7302 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R7303 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R7304 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R7305 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R7306 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R7307 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R7308 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R7309 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R7310 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R7311 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R7312 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R7313 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R7314 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R7315 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R7316 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R7317 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R7318 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R7319 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R7320 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R7321 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R7322 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R7323 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R7324 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R7325 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R7326 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R7327 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R7328 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R7329 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R7330 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R7331 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R7332 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R7333 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R7334 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R7335 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R7336 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R7337 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R7338 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R7339 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R7340 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R7341 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R7342 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R7343 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R7344 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R7345 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R7346 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R7347 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R7348 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R7349 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R7350 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R7351 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R7352 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R7353 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R7354 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R7355 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R7356 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R7357 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R7358 n1_m1_470400_302400 n1_m1_475200_302400 5.356235
R7359 n1_m1_475200_302400 n1_m1_480000_302400 5.356235
R7360 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R7361 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R7362 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R7363 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R7364 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R7365 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R7366 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R7367 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R7368 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R7369 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R7370 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R7371 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R7372 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R7373 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R7374 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R7375 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R7376 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R7377 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R7378 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R7379 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R7380 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R7381 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R7382 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R7383 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R7384 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R7385 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R7386 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R7387 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R7388 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R7389 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R7390 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R7391 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R7392 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R7393 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R7394 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R7395 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R7396 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R7397 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R7398 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R7399 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R7400 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R7401 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R7402 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R7403 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R7404 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R7405 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R7406 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R7407 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R7408 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R7409 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R7410 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R7411 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R7412 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R7413 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R7414 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R7415 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R7416 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R7417 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R7418 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R7419 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R7420 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R7421 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R7422 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R7423 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R7424 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R7425 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R7426 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R7427 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R7428 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R7429 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R7430 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R7431 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R7432 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R7433 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R7434 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R7435 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R7436 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R7437 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R7438 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R7439 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R7440 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R7441 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R7442 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R7443 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R7444 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R7445 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R7446 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R7447 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R7448 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R7449 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R7450 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R7451 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R7452 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R7453 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R7454 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R7455 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R7456 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R7457 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R7458 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R7459 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R7460 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R7461 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R7462 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R7463 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R7464 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R7465 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R7466 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R7467 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R7468 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R7469 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R7470 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R7471 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R7472 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R7473 n1_m1_470400_307200 n1_m1_475200_307200 5.356235
R7474 n1_m1_475200_307200 n1_m1_480000_307200 5.356235
R7475 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R7476 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R7477 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R7478 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R7479 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R7480 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R7481 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R7482 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R7483 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R7484 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R7485 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R7486 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R7487 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R7488 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R7489 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R7490 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R7491 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R7492 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R7493 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R7494 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R7495 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R7496 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R7497 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R7498 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R7499 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R7500 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R7501 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R7502 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R7503 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R7504 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R7505 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R7506 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R7507 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R7508 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R7509 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R7510 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R7511 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R7512 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R7513 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R7514 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R7515 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R7516 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R7517 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R7518 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R7519 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R7520 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R7521 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R7522 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R7523 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R7524 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R7525 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R7526 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R7527 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R7528 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R7529 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R7530 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R7531 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R7532 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R7533 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R7534 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R7535 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R7536 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R7537 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R7538 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R7539 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R7540 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R7541 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R7542 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R7543 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R7544 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R7545 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R7546 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R7547 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R7548 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R7549 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R7550 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R7551 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R7552 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R7553 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R7554 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R7555 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R7556 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R7557 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R7558 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R7559 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R7560 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R7561 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R7562 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R7563 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R7564 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R7565 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R7566 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R7567 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R7568 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R7569 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R7570 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R7571 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R7572 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R7573 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R7574 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R7575 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R7576 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R7577 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R7578 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R7579 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R7580 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R7581 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R7582 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R7583 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R7584 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R7585 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R7586 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R7587 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R7588 n1_m1_470400_312000 n1_m1_475200_312000 5.356235
R7589 n1_m1_475200_312000 n1_m1_480000_312000 5.356235
R7590 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R7591 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R7592 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R7593 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R7594 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R7595 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R7596 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R7597 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R7598 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R7599 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R7600 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R7601 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R7602 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R7603 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R7604 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R7605 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R7606 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R7607 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R7608 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R7609 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R7610 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R7611 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R7612 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R7613 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R7614 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R7615 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R7616 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R7617 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R7618 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R7619 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R7620 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R7621 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R7622 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R7623 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R7624 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R7625 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R7626 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R7627 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R7628 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R7629 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R7630 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R7631 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R7632 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R7633 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R7634 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R7635 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R7636 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R7637 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R7638 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R7639 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R7640 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R7641 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R7642 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R7643 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R7644 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R7645 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R7646 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R7647 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R7648 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R7649 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R7650 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R7651 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R7652 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R7653 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R7654 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R7655 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R7656 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R7657 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R7658 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R7659 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R7660 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R7661 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R7662 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R7663 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R7664 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R7665 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R7666 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R7667 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R7668 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R7669 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R7670 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R7671 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R7672 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R7673 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R7674 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R7675 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R7676 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R7677 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R7678 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R7679 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R7680 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R7681 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R7682 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R7683 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R7684 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R7685 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R7686 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R7687 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R7688 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R7689 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R7690 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R7691 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R7692 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R7693 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R7694 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R7695 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R7696 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R7697 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R7698 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R7699 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R7700 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R7701 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R7702 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R7703 n1_m1_470400_316800 n1_m1_475200_316800 5.356235
R7704 n1_m1_475200_316800 n1_m1_480000_316800 5.356235
R7705 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R7706 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R7707 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R7708 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R7709 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R7710 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R7711 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R7712 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R7713 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R7714 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R7715 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R7716 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R7717 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R7718 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R7719 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R7720 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R7721 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R7722 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R7723 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R7724 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R7725 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R7726 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R7727 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R7728 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R7729 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R7730 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R7731 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R7732 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R7733 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R7734 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R7735 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R7736 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R7737 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R7738 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R7739 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R7740 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R7741 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R7742 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R7743 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R7744 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R7745 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R7746 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R7747 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R7748 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R7749 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R7750 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R7751 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R7752 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R7753 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R7754 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R7755 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R7756 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R7757 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R7758 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R7759 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R7760 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R7761 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R7762 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R7763 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R7764 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R7765 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R7766 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R7767 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R7768 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R7769 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R7770 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R7771 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R7772 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R7773 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R7774 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R7775 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R7776 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R7777 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R7778 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R7779 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R7780 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R7781 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R7782 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R7783 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R7784 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R7785 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R7786 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R7787 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R7788 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R7789 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R7790 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R7791 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R7792 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R7793 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R7794 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R7795 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R7796 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R7797 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R7798 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R7799 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R7800 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R7801 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R7802 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R7803 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R7804 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R7805 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R7806 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R7807 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R7808 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R7809 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R7810 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R7811 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R7812 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R7813 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R7814 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R7815 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R7816 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R7817 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R7818 n1_m1_470400_321600 n1_m1_475200_321600 5.356235
R7819 n1_m1_475200_321600 n1_m1_480000_321600 5.356235
R7820 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R7821 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R7822 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R7823 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R7824 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R7825 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R7826 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R7827 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R7828 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R7829 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R7830 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R7831 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R7832 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R7833 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R7834 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R7835 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R7836 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R7837 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R7838 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R7839 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R7840 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R7841 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R7842 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R7843 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R7844 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R7845 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R7846 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R7847 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R7848 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R7849 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R7850 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R7851 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R7852 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R7853 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R7854 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R7855 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R7856 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R7857 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R7858 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R7859 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R7860 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R7861 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R7862 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R7863 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R7864 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R7865 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R7866 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R7867 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R7868 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R7869 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R7870 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R7871 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R7872 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R7873 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R7874 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R7875 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R7876 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R7877 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R7878 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R7879 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R7880 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R7881 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R7882 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R7883 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R7884 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R7885 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R7886 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R7887 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R7888 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R7889 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R7890 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R7891 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R7892 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R7893 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R7894 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R7895 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R7896 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R7897 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R7898 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R7899 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R7900 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R7901 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R7902 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R7903 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R7904 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R7905 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R7906 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R7907 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R7908 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R7909 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R7910 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R7911 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R7912 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R7913 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R7914 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R7915 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R7916 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R7917 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R7918 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R7919 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R7920 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R7921 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R7922 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R7923 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R7924 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R7925 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R7926 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R7927 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R7928 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R7929 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R7930 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R7931 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R7932 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R7933 n1_m1_470400_326400 n1_m1_475200_326400 5.356235
R7934 n1_m1_475200_326400 n1_m1_480000_326400 5.356235
R7935 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R7936 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R7937 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R7938 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R7939 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R7940 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R7941 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R7942 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R7943 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R7944 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R7945 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R7946 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R7947 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R7948 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R7949 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R7950 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R7951 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R7952 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R7953 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R7954 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R7955 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R7956 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R7957 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R7958 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R7959 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R7960 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R7961 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R7962 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R7963 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R7964 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R7965 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R7966 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R7967 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R7968 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R7969 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R7970 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R7971 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R7972 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R7973 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R7974 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R7975 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R7976 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R7977 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R7978 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R7979 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R7980 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R7981 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R7982 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R7983 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R7984 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R7985 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R7986 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R7987 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R7988 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R7989 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R7990 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R7991 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R7992 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R7993 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R7994 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R7995 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R7996 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R7997 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R7998 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R7999 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R8000 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R8001 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R8002 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R8003 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R8004 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R8005 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R8006 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R8007 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R8008 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R8009 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R8010 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R8011 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R8012 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R8013 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R8014 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R8015 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R8016 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R8017 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R8018 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R8019 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R8020 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R8021 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R8022 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R8023 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R8024 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R8025 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R8026 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R8027 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R8028 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R8029 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R8030 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R8031 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R8032 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R8033 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R8034 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R8035 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R8036 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R8037 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R8038 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R8039 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R8040 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R8041 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R8042 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R8043 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R8044 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R8045 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R8046 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R8047 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R8048 n1_m1_470400_331200 n1_m1_475200_331200 5.356235
R8049 n1_m1_475200_331200 n1_m1_480000_331200 5.356235
R8050 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R8051 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R8052 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R8053 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R8054 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R8055 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R8056 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R8057 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R8058 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R8059 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R8060 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R8061 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R8062 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R8063 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R8064 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R8065 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R8066 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R8067 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R8068 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R8069 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R8070 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R8071 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R8072 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R8073 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R8074 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R8075 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R8076 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R8077 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R8078 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R8079 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R8080 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R8081 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R8082 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R8083 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R8084 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R8085 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R8086 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R8087 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R8088 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R8089 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R8090 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R8091 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R8092 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R8093 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R8094 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R8095 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R8096 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R8097 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R8098 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R8099 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R8100 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R8101 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R8102 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R8103 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R8104 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R8105 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R8106 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R8107 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R8108 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R8109 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R8110 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R8111 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R8112 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R8113 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R8114 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R8115 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R8116 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R8117 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R8118 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R8119 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R8120 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R8121 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R8122 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R8123 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R8124 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R8125 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R8126 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R8127 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R8128 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R8129 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R8130 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R8131 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R8132 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R8133 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R8134 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R8135 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R8136 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R8137 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R8138 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R8139 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R8140 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R8141 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R8142 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R8143 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R8144 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R8145 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R8146 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R8147 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R8148 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R8149 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R8150 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R8151 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R8152 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R8153 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R8154 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R8155 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R8156 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R8157 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R8158 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R8159 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R8160 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R8161 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R8162 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R8163 n1_m1_470400_336000 n1_m1_475200_336000 5.356235
R8164 n1_m1_475200_336000 n1_m1_480000_336000 5.356235
R8165 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R8166 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R8167 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R8168 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R8169 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R8170 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R8171 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R8172 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R8173 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R8174 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R8175 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R8176 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R8177 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R8178 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R8179 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R8180 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R8181 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R8182 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R8183 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R8184 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R8185 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R8186 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R8187 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R8188 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R8189 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R8190 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R8191 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R8192 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R8193 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R8194 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R8195 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R8196 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R8197 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R8198 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R8199 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R8200 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R8201 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R8202 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R8203 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R8204 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R8205 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R8206 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R8207 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R8208 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R8209 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R8210 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R8211 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R8212 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R8213 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R8214 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R8215 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R8216 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R8217 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R8218 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R8219 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R8220 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R8221 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R8222 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R8223 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R8224 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R8225 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R8226 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R8227 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R8228 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R8229 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R8230 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R8231 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R8232 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R8233 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R8234 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R8235 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R8236 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R8237 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R8238 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R8239 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R8240 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R8241 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R8242 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R8243 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R8244 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R8245 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R8246 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R8247 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R8248 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R8249 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R8250 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R8251 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R8252 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R8253 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R8254 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R8255 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R8256 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R8257 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R8258 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R8259 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R8260 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R8261 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R8262 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R8263 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R8264 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R8265 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R8266 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R8267 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R8268 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R8269 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R8270 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R8271 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R8272 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R8273 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R8274 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R8275 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R8276 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R8277 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R8278 n1_m1_470400_340800 n1_m1_475200_340800 5.356235
R8279 n1_m1_475200_340800 n1_m1_480000_340800 5.356235
R8280 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R8281 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R8282 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R8283 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R8284 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R8285 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R8286 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R8287 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R8288 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R8289 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R8290 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R8291 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R8292 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R8293 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R8294 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R8295 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R8296 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R8297 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R8298 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R8299 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R8300 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R8301 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R8302 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R8303 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R8304 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R8305 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R8306 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R8307 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R8308 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R8309 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R8310 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R8311 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R8312 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R8313 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R8314 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R8315 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R8316 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R8317 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R8318 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R8319 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R8320 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R8321 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R8322 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R8323 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R8324 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R8325 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R8326 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R8327 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R8328 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R8329 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R8330 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R8331 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R8332 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R8333 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R8334 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R8335 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R8336 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R8337 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R8338 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R8339 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R8340 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R8341 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R8342 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R8343 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R8344 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R8345 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R8346 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R8347 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R8348 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R8349 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R8350 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R8351 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R8352 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R8353 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R8354 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R8355 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R8356 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R8357 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R8358 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R8359 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R8360 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R8361 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R8362 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R8363 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R8364 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R8365 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R8366 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R8367 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R8368 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R8369 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R8370 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R8371 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R8372 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R8373 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R8374 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R8375 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R8376 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R8377 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R8378 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R8379 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R8380 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R8381 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R8382 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R8383 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R8384 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R8385 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R8386 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R8387 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R8388 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R8389 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R8390 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R8391 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R8392 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R8393 n1_m1_470400_345600 n1_m1_475200_345600 5.356235
R8394 n1_m1_475200_345600 n1_m1_480000_345600 5.356235
R8395 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R8396 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R8397 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R8398 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R8399 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R8400 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R8401 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R8402 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R8403 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R8404 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R8405 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R8406 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R8407 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R8408 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R8409 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R8410 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R8411 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R8412 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R8413 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R8414 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R8415 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R8416 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R8417 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R8418 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R8419 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R8420 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R8421 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R8422 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R8423 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R8424 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R8425 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R8426 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R8427 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R8428 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R8429 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R8430 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R8431 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R8432 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R8433 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R8434 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R8435 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R8436 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R8437 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R8438 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R8439 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R8440 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R8441 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R8442 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R8443 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R8444 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R8445 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R8446 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R8447 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R8448 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R8449 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R8450 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R8451 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R8452 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R8453 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R8454 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R8455 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R8456 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R8457 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R8458 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R8459 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R8460 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R8461 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R8462 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R8463 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R8464 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R8465 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R8466 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R8467 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R8468 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R8469 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R8470 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R8471 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R8472 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R8473 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R8474 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R8475 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R8476 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R8477 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R8478 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R8479 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R8480 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R8481 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R8482 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R8483 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R8484 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R8485 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R8486 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R8487 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R8488 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R8489 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R8490 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R8491 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R8492 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R8493 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R8494 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R8495 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R8496 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R8497 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R8498 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R8499 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R8500 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R8501 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R8502 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R8503 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R8504 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R8505 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R8506 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R8507 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R8508 n1_m1_470400_350400 n1_m1_475200_350400 5.356235
R8509 n1_m1_475200_350400 n1_m1_480000_350400 5.356235
R8510 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R8511 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R8512 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R8513 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R8514 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R8515 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R8516 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R8517 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R8518 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R8519 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R8520 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R8521 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R8522 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R8523 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R8524 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R8525 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R8526 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R8527 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R8528 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R8529 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R8530 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R8531 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R8532 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R8533 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R8534 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R8535 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R8536 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R8537 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R8538 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R8539 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R8540 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R8541 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R8542 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R8543 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R8544 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R8545 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R8546 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R8547 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R8548 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R8549 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R8550 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R8551 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R8552 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R8553 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R8554 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R8555 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R8556 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R8557 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R8558 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R8559 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R8560 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R8561 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R8562 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R8563 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R8564 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R8565 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R8566 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R8567 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R8568 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R8569 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R8570 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R8571 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R8572 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R8573 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R8574 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R8575 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R8576 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R8577 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R8578 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R8579 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R8580 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R8581 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R8582 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R8583 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R8584 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R8585 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R8586 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R8587 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R8588 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R8589 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R8590 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R8591 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R8592 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R8593 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R8594 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R8595 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R8596 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R8597 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R8598 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R8599 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R8600 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R8601 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R8602 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R8603 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R8604 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R8605 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R8606 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R8607 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R8608 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R8609 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R8610 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R8611 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R8612 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R8613 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R8614 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R8615 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R8616 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R8617 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R8618 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R8619 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R8620 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R8621 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R8622 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R8623 n1_m1_470400_355200 n1_m1_475200_355200 5.356235
R8624 n1_m1_475200_355200 n1_m1_480000_355200 5.356235
R8625 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R8626 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R8627 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R8628 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R8629 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R8630 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R8631 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R8632 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R8633 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R8634 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R8635 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R8636 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R8637 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R8638 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R8639 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R8640 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R8641 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R8642 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R8643 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R8644 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R8645 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R8646 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R8647 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R8648 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R8649 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R8650 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R8651 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R8652 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R8653 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R8654 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R8655 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R8656 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R8657 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R8658 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R8659 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R8660 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R8661 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R8662 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R8663 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R8664 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R8665 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R8666 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R8667 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R8668 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R8669 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R8670 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R8671 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R8672 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R8673 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R8674 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R8675 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R8676 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R8677 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R8678 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R8679 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R8680 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R8681 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R8682 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R8683 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R8684 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R8685 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R8686 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R8687 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R8688 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R8689 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R8690 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R8691 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R8692 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R8693 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R8694 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R8695 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R8696 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R8697 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R8698 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R8699 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R8700 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R8701 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R8702 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R8703 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R8704 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R8705 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R8706 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R8707 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R8708 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R8709 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R8710 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R8711 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R8712 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R8713 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R8714 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R8715 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R8716 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R8717 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R8718 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R8719 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R8720 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R8721 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R8722 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R8723 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R8724 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R8725 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R8726 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R8727 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R8728 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R8729 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R8730 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R8731 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R8732 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R8733 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R8734 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R8735 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R8736 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R8737 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R8738 n1_m1_470400_360000 n1_m1_475200_360000 5.356235
R8739 n1_m1_475200_360000 n1_m1_480000_360000 5.356235
R8740 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R8741 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R8742 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R8743 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R8744 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R8745 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R8746 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R8747 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R8748 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R8749 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R8750 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R8751 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R8752 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R8753 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R8754 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R8755 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R8756 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R8757 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R8758 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R8759 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R8760 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R8761 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R8762 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R8763 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R8764 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R8765 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R8766 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R8767 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R8768 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R8769 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R8770 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R8771 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R8772 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R8773 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R8774 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R8775 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R8776 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R8777 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R8778 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R8779 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R8780 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R8781 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R8782 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R8783 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R8784 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R8785 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R8786 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R8787 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R8788 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R8789 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R8790 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R8791 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R8792 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R8793 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R8794 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R8795 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R8796 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R8797 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R8798 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R8799 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R8800 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R8801 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R8802 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R8803 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R8804 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R8805 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R8806 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R8807 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R8808 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R8809 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R8810 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R8811 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R8812 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R8813 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R8814 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R8815 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R8816 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R8817 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R8818 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R8819 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R8820 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R8821 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R8822 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R8823 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R8824 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R8825 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R8826 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R8827 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R8828 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R8829 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R8830 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R8831 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R8832 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R8833 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R8834 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R8835 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R8836 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R8837 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R8838 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R8839 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R8840 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R8841 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R8842 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R8843 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R8844 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R8845 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R8846 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R8847 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R8848 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R8849 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R8850 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R8851 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R8852 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R8853 n1_m1_470400_364800 n1_m1_475200_364800 5.356235
R8854 n1_m1_475200_364800 n1_m1_480000_364800 5.356235
R8855 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R8856 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R8857 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R8858 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R8859 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R8860 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R8861 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R8862 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R8863 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R8864 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R8865 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R8866 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R8867 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R8868 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R8869 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R8870 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R8871 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R8872 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R8873 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R8874 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R8875 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R8876 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R8877 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R8878 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R8879 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R8880 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R8881 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R8882 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R8883 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R8884 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R8885 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R8886 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R8887 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R8888 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R8889 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R8890 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R8891 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R8892 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R8893 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R8894 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R8895 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R8896 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R8897 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R8898 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R8899 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R8900 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R8901 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R8902 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R8903 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R8904 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R8905 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R8906 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R8907 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R8908 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R8909 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R8910 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R8911 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R8912 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R8913 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R8914 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R8915 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R8916 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R8917 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R8918 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R8919 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R8920 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R8921 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R8922 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R8923 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R8924 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R8925 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R8926 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R8927 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R8928 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R8929 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R8930 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R8931 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R8932 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R8933 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R8934 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R8935 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R8936 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R8937 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R8938 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R8939 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R8940 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R8941 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R8942 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R8943 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R8944 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R8945 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R8946 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R8947 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R8948 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R8949 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R8950 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R8951 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R8952 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R8953 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R8954 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R8955 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R8956 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R8957 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R8958 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R8959 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R8960 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R8961 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R8962 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R8963 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R8964 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R8965 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R8966 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R8967 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R8968 n1_m1_470400_369600 n1_m1_475200_369600 5.356235
R8969 n1_m1_475200_369600 n1_m1_480000_369600 5.356235
R8970 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R8971 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R8972 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R8973 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R8974 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R8975 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R8976 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R8977 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R8978 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R8979 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R8980 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R8981 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R8982 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R8983 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R8984 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R8985 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R8986 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R8987 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R8988 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R8989 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R8990 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R8991 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R8992 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R8993 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R8994 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R8995 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R8996 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R8997 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R8998 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R8999 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R9000 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R9001 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R9002 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R9003 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R9004 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R9005 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R9006 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R9007 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R9008 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R9009 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R9010 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R9011 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R9012 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R9013 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R9014 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R9015 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R9016 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R9017 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R9018 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R9019 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R9020 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R9021 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R9022 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R9023 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R9024 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R9025 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R9026 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R9027 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R9028 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R9029 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R9030 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R9031 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R9032 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R9033 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R9034 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R9035 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R9036 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R9037 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R9038 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R9039 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R9040 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R9041 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R9042 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R9043 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R9044 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R9045 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R9046 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R9047 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R9048 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R9049 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R9050 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R9051 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R9052 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R9053 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R9054 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R9055 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R9056 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R9057 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R9058 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R9059 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R9060 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R9061 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R9062 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R9063 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R9064 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R9065 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R9066 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R9067 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R9068 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R9069 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R9070 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R9071 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R9072 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R9073 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R9074 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R9075 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R9076 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R9077 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R9078 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R9079 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R9080 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R9081 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R9082 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R9083 n1_m1_470400_374400 n1_m1_475200_374400 5.356235
R9084 n1_m1_475200_374400 n1_m1_480000_374400 5.356235
R9085 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R9086 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R9087 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R9088 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R9089 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R9090 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R9091 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R9092 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R9093 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R9094 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R9095 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R9096 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R9097 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R9098 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R9099 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R9100 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R9101 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R9102 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R9103 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R9104 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R9105 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R9106 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R9107 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R9108 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R9109 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R9110 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R9111 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R9112 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R9113 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R9114 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R9115 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R9116 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R9117 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R9118 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R9119 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R9120 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R9121 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R9122 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R9123 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R9124 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R9125 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R9126 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R9127 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R9128 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R9129 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R9130 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R9131 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R9132 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R9133 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R9134 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R9135 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R9136 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R9137 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R9138 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R9139 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R9140 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R9141 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R9142 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R9143 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R9144 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R9145 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R9146 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R9147 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R9148 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R9149 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R9150 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R9151 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R9152 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R9153 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R9154 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R9155 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R9156 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R9157 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R9158 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R9159 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R9160 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R9161 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R9162 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R9163 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R9164 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R9165 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R9166 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R9167 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R9168 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R9169 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R9170 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R9171 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R9172 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R9173 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R9174 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R9175 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R9176 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R9177 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R9178 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R9179 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R9180 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R9181 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R9182 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R9183 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R9184 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R9185 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R9186 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R9187 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R9188 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R9189 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R9190 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R9191 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R9192 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R9193 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R9194 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R9195 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R9196 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R9197 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R9198 n1_m1_470400_379200 n1_m1_475200_379200 5.356235
R9199 n1_m1_475200_379200 n1_m1_480000_379200 5.356235
R9200 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R9201 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R9202 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R9203 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R9204 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R9205 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R9206 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R9207 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R9208 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R9209 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R9210 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R9211 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R9212 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R9213 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R9214 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R9215 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R9216 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R9217 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R9218 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R9219 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R9220 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R9221 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R9222 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R9223 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R9224 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R9225 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R9226 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R9227 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R9228 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R9229 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R9230 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R9231 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R9232 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R9233 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R9234 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R9235 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R9236 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R9237 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R9238 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R9239 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R9240 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R9241 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R9242 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R9243 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R9244 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R9245 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R9246 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R9247 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R9248 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R9249 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R9250 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R9251 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R9252 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R9253 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R9254 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R9255 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R9256 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R9257 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R9258 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R9259 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R9260 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R9261 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R9262 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R9263 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R9264 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R9265 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R9266 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R9267 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R9268 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R9269 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R9270 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R9271 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R9272 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R9273 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R9274 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R9275 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R9276 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R9277 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R9278 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R9279 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R9280 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R9281 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R9282 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R9283 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R9284 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R9285 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R9286 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R9287 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R9288 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R9289 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R9290 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R9291 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R9292 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R9293 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R9294 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R9295 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R9296 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R9297 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R9298 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R9299 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R9300 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R9301 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R9302 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R9303 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R9304 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R9305 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R9306 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R9307 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R9308 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R9309 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R9310 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R9311 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R9312 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R9313 n1_m1_470400_384000 n1_m1_475200_384000 5.356235
R9314 n1_m1_475200_384000 n1_m1_480000_384000 5.356235
R9315 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R9316 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R9317 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R9318 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R9319 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R9320 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R9321 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R9322 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R9323 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R9324 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R9325 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R9326 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R9327 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R9328 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R9329 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R9330 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R9331 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R9332 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R9333 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R9334 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R9335 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R9336 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R9337 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R9338 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R9339 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R9340 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R9341 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R9342 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R9343 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R9344 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R9345 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R9346 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R9347 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R9348 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R9349 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R9350 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R9351 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R9352 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R9353 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R9354 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R9355 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R9356 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R9357 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R9358 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R9359 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R9360 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R9361 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R9362 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R9363 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R9364 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R9365 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R9366 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R9367 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R9368 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R9369 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R9370 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R9371 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R9372 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R9373 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R9374 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R9375 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R9376 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R9377 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R9378 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R9379 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R9380 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R9381 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R9382 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R9383 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R9384 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R9385 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R9386 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R9387 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R9388 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R9389 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R9390 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R9391 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R9392 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R9393 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R9394 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R9395 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R9396 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R9397 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R9398 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R9399 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R9400 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R9401 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R9402 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R9403 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R9404 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R9405 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R9406 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R9407 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R9408 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R9409 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R9410 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R9411 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R9412 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R9413 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R9414 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R9415 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R9416 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R9417 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R9418 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R9419 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R9420 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R9421 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R9422 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R9423 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R9424 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R9425 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R9426 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R9427 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R9428 n1_m1_470400_388800 n1_m1_475200_388800 5.356235
R9429 n1_m1_475200_388800 n1_m1_480000_388800 5.356235
R9430 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R9431 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R9432 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R9433 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R9434 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R9435 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R9436 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R9437 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R9438 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R9439 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R9440 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R9441 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R9442 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R9443 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R9444 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R9445 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R9446 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R9447 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R9448 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R9449 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R9450 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R9451 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R9452 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R9453 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R9454 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R9455 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R9456 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R9457 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R9458 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R9459 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R9460 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R9461 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R9462 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R9463 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R9464 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R9465 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R9466 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R9467 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R9468 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R9469 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R9470 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R9471 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R9472 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R9473 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R9474 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R9475 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R9476 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R9477 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R9478 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R9479 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R9480 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R9481 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R9482 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R9483 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R9484 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R9485 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R9486 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R9487 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R9488 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R9489 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R9490 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R9491 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R9492 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R9493 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R9494 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R9495 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R9496 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R9497 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R9498 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R9499 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R9500 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R9501 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R9502 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R9503 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R9504 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R9505 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R9506 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R9507 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R9508 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R9509 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R9510 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R9511 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R9512 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R9513 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R9514 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R9515 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R9516 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R9517 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R9518 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R9519 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R9520 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R9521 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R9522 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R9523 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R9524 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R9525 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R9526 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R9527 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R9528 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R9529 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R9530 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R9531 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R9532 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R9533 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R9534 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R9535 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R9536 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R9537 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R9538 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R9539 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R9540 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R9541 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R9542 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R9543 n1_m1_470400_393600 n1_m1_475200_393600 5.356235
R9544 n1_m1_475200_393600 n1_m1_480000_393600 5.356235
R9545 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R9546 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R9547 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R9548 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R9549 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R9550 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R9551 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R9552 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R9553 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R9554 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R9555 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R9556 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R9557 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R9558 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R9559 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R9560 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R9561 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R9562 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R9563 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R9564 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R9565 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R9566 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R9567 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R9568 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R9569 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R9570 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R9571 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R9572 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R9573 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R9574 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R9575 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R9576 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R9577 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R9578 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R9579 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R9580 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R9581 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R9582 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R9583 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R9584 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R9585 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R9586 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R9587 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R9588 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R9589 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R9590 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R9591 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R9592 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R9593 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R9594 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R9595 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R9596 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R9597 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R9598 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R9599 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R9600 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R9601 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R9602 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R9603 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R9604 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R9605 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R9606 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R9607 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R9608 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R9609 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R9610 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R9611 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R9612 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R9613 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R9614 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R9615 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R9616 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R9617 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R9618 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R9619 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R9620 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R9621 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R9622 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R9623 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R9624 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R9625 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R9626 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R9627 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R9628 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R9629 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R9630 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R9631 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R9632 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R9633 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R9634 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R9635 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R9636 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R9637 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R9638 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R9639 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R9640 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R9641 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R9642 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R9643 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R9644 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R9645 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R9646 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R9647 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R9648 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R9649 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R9650 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R9651 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R9652 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R9653 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R9654 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R9655 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R9656 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R9657 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R9658 n1_m1_470400_398400 n1_m1_475200_398400 5.356235
R9659 n1_m1_475200_398400 n1_m1_480000_398400 5.356235
R9660 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R9661 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R9662 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R9663 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R9664 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R9665 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R9666 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R9667 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R9668 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R9669 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R9670 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R9671 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R9672 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R9673 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R9674 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R9675 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R9676 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R9677 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R9678 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R9679 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R9680 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R9681 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R9682 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R9683 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R9684 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R9685 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R9686 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R9687 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R9688 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R9689 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R9690 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R9691 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R9692 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R9693 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R9694 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R9695 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R9696 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R9697 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R9698 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R9699 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R9700 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R9701 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R9702 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R9703 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R9704 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R9705 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R9706 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R9707 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R9708 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R9709 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R9710 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R9711 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R9712 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R9713 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R9714 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R9715 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R9716 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R9717 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R9718 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R9719 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R9720 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R9721 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R9722 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R9723 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R9724 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R9725 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R9726 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R9727 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R9728 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R9729 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R9730 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R9731 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R9732 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R9733 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R9734 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R9735 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R9736 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R9737 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R9738 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R9739 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R9740 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R9741 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R9742 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R9743 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R9744 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R9745 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R9746 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R9747 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R9748 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R9749 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R9750 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R9751 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R9752 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R9753 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R9754 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R9755 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R9756 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R9757 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R9758 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R9759 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R9760 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R9761 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R9762 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R9763 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R9764 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R9765 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R9766 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R9767 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R9768 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R9769 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R9770 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R9771 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R9772 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R9773 n1_m1_470400_403200 n1_m1_475200_403200 5.356235
R9774 n1_m1_475200_403200 n1_m1_480000_403200 5.356235
R9775 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R9776 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R9777 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R9778 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R9779 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R9780 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R9781 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R9782 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R9783 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R9784 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R9785 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R9786 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R9787 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R9788 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R9789 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R9790 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R9791 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R9792 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R9793 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R9794 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R9795 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R9796 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R9797 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R9798 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R9799 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R9800 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R9801 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R9802 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R9803 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R9804 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R9805 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R9806 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R9807 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R9808 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R9809 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R9810 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R9811 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R9812 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R9813 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R9814 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R9815 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R9816 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R9817 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R9818 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R9819 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R9820 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R9821 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R9822 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R9823 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R9824 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R9825 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R9826 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R9827 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R9828 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R9829 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R9830 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R9831 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R9832 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R9833 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R9834 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R9835 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R9836 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R9837 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R9838 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R9839 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R9840 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R9841 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R9842 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R9843 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R9844 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R9845 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R9846 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R9847 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R9848 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R9849 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R9850 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R9851 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R9852 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R9853 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R9854 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R9855 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R9856 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R9857 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R9858 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R9859 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R9860 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R9861 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R9862 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R9863 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R9864 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R9865 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R9866 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R9867 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R9868 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R9869 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R9870 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R9871 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R9872 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R9873 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R9874 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R9875 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R9876 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R9877 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R9878 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R9879 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R9880 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R9881 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R9882 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R9883 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R9884 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R9885 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R9886 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R9887 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R9888 n1_m1_470400_408000 n1_m1_475200_408000 5.356235
R9889 n1_m1_475200_408000 n1_m1_480000_408000 5.356235
R9890 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R9891 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R9892 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R9893 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R9894 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R9895 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R9896 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R9897 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R9898 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R9899 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R9900 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R9901 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R9902 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R9903 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R9904 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R9905 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R9906 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R9907 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R9908 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R9909 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R9910 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R9911 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R9912 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R9913 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R9914 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R9915 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R9916 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R9917 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R9918 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R9919 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R9920 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R9921 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R9922 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R9923 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R9924 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R9925 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R9926 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R9927 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R9928 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R9929 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R9930 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R9931 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R9932 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R9933 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R9934 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R9935 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R9936 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R9937 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R9938 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R9939 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R9940 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R9941 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R9942 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R9943 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R9944 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R9945 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R9946 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R9947 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R9948 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R9949 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R9950 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R9951 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R9952 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R9953 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R9954 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R9955 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R9956 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R9957 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R9958 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R9959 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R9960 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R9961 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R9962 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R9963 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R9964 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R9965 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R9966 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R9967 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R9968 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R9969 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R9970 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R9971 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R9972 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R9973 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R9974 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R9975 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R9976 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R9977 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R9978 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R9979 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R9980 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R9981 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R9982 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R9983 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R9984 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R9985 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R9986 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R9987 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R9988 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R9989 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R9990 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R9991 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R9992 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R9993 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R9994 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R9995 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R9996 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R9997 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R9998 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R9999 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R10000 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R10001 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R10002 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R10003 n1_m1_470400_412800 n1_m1_475200_412800 5.356235
R10004 n1_m1_475200_412800 n1_m1_480000_412800 5.356235
R10005 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R10006 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R10007 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R10008 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R10009 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R10010 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R10011 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R10012 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R10013 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R10014 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R10015 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R10016 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R10017 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R10018 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R10019 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R10020 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R10021 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R10022 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R10023 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R10024 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R10025 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R10026 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R10027 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R10028 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R10029 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R10030 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R10031 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R10032 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R10033 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R10034 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R10035 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R10036 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R10037 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R10038 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R10039 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R10040 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R10041 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R10042 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R10043 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R10044 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R10045 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R10046 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R10047 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R10048 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R10049 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R10050 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R10051 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R10052 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R10053 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R10054 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R10055 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R10056 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R10057 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R10058 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R10059 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R10060 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R10061 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R10062 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R10063 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R10064 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R10065 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R10066 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R10067 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R10068 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R10069 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R10070 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R10071 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R10072 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R10073 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R10074 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R10075 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R10076 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R10077 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R10078 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R10079 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R10080 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R10081 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R10082 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R10083 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R10084 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R10085 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R10086 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R10087 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R10088 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R10089 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R10090 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R10091 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R10092 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R10093 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R10094 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R10095 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R10096 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R10097 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R10098 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R10099 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R10100 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R10101 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R10102 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R10103 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R10104 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R10105 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R10106 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R10107 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R10108 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R10109 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R10110 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R10111 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R10112 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R10113 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R10114 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R10115 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R10116 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R10117 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R10118 n1_m1_470400_417600 n1_m1_475200_417600 5.356235
R10119 n1_m1_475200_417600 n1_m1_480000_417600 5.356235
R10120 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R10121 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R10122 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R10123 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R10124 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R10125 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R10126 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R10127 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R10128 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R10129 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R10130 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R10131 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R10132 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R10133 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R10134 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R10135 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R10136 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R10137 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R10138 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R10139 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R10140 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R10141 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R10142 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R10143 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R10144 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R10145 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R10146 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R10147 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R10148 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R10149 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R10150 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R10151 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R10152 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R10153 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R10154 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R10155 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R10156 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R10157 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R10158 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R10159 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R10160 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R10161 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R10162 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R10163 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R10164 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R10165 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R10166 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R10167 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R10168 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R10169 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R10170 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R10171 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R10172 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R10173 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R10174 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R10175 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R10176 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R10177 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R10178 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R10179 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R10180 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R10181 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R10182 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R10183 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R10184 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R10185 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R10186 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R10187 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R10188 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R10189 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R10190 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R10191 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R10192 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R10193 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R10194 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R10195 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R10196 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R10197 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R10198 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R10199 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R10200 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R10201 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R10202 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R10203 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R10204 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R10205 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R10206 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R10207 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R10208 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R10209 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R10210 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R10211 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R10212 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R10213 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R10214 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R10215 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R10216 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R10217 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R10218 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R10219 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R10220 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R10221 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R10222 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R10223 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R10224 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R10225 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R10226 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R10227 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R10228 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R10229 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R10230 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R10231 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R10232 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R10233 n1_m1_470400_422400 n1_m1_475200_422400 5.356235
R10234 n1_m1_475200_422400 n1_m1_480000_422400 5.356235
R10235 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R10236 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R10237 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R10238 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R10239 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R10240 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R10241 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R10242 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R10243 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R10244 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R10245 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R10246 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R10247 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R10248 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R10249 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R10250 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R10251 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R10252 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R10253 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R10254 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R10255 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R10256 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R10257 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R10258 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R10259 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R10260 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R10261 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R10262 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R10263 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R10264 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R10265 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R10266 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R10267 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R10268 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R10269 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R10270 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R10271 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R10272 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R10273 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R10274 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R10275 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R10276 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R10277 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R10278 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R10279 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R10280 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R10281 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R10282 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R10283 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R10284 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R10285 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R10286 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R10287 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R10288 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R10289 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R10290 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R10291 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R10292 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R10293 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R10294 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R10295 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R10296 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R10297 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R10298 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R10299 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R10300 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R10301 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R10302 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R10303 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R10304 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R10305 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R10306 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R10307 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R10308 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R10309 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R10310 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R10311 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R10312 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R10313 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R10314 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R10315 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R10316 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R10317 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R10318 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R10319 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R10320 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R10321 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R10322 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R10323 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R10324 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R10325 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R10326 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R10327 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R10328 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R10329 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R10330 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R10331 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R10332 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R10333 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R10334 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R10335 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R10336 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R10337 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R10338 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R10339 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R10340 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R10341 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R10342 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R10343 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R10344 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R10345 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R10346 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R10347 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R10348 n1_m1_470400_427200 n1_m1_475200_427200 5.356235
R10349 n1_m1_475200_427200 n1_m1_480000_427200 5.356235
R10350 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R10351 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R10352 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R10353 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R10354 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R10355 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R10356 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R10357 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R10358 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R10359 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R10360 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R10361 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R10362 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R10363 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R10364 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R10365 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R10366 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R10367 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R10368 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R10369 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R10370 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R10371 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R10372 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R10373 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R10374 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R10375 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R10376 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R10377 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R10378 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R10379 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R10380 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R10381 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R10382 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R10383 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R10384 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R10385 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R10386 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R10387 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R10388 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R10389 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R10390 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R10391 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R10392 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R10393 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R10394 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R10395 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R10396 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R10397 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R10398 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R10399 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R10400 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R10401 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R10402 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R10403 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R10404 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R10405 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R10406 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R10407 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R10408 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R10409 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R10410 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R10411 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R10412 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R10413 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R10414 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R10415 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R10416 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R10417 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R10418 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R10419 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R10420 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R10421 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R10422 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R10423 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R10424 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R10425 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R10426 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R10427 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R10428 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R10429 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R10430 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R10431 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R10432 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R10433 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R10434 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R10435 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R10436 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R10437 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R10438 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R10439 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R10440 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R10441 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R10442 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R10443 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R10444 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R10445 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R10446 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R10447 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R10448 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R10449 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R10450 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R10451 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R10452 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R10453 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R10454 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R10455 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R10456 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R10457 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R10458 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R10459 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R10460 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R10461 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R10462 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R10463 n1_m1_470400_432000 n1_m1_475200_432000 5.356235
R10464 n1_m1_475200_432000 n1_m1_480000_432000 5.356235
R10465 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R10466 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R10467 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R10468 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R10469 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R10470 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R10471 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R10472 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R10473 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R10474 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R10475 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R10476 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R10477 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R10478 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R10479 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R10480 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R10481 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R10482 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R10483 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R10484 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R10485 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R10486 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R10487 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R10488 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R10489 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R10490 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R10491 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R10492 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R10493 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R10494 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R10495 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R10496 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R10497 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R10498 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R10499 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R10500 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R10501 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R10502 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R10503 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R10504 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R10505 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R10506 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R10507 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R10508 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R10509 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R10510 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R10511 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R10512 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R10513 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R10514 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R10515 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R10516 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R10517 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R10518 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R10519 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R10520 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R10521 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R10522 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R10523 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R10524 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R10525 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R10526 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R10527 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R10528 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R10529 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R10530 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R10531 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R10532 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R10533 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R10534 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R10535 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R10536 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R10537 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R10538 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R10539 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R10540 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R10541 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R10542 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R10543 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R10544 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R10545 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R10546 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R10547 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R10548 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R10549 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R10550 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R10551 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R10552 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R10553 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R10554 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R10555 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R10556 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R10557 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R10558 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R10559 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R10560 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R10561 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R10562 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R10563 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R10564 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R10565 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R10566 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R10567 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R10568 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R10569 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R10570 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R10571 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R10572 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R10573 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R10574 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R10575 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R10576 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R10577 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R10578 n1_m1_470400_436800 n1_m1_475200_436800 5.356235
R10579 n1_m1_475200_436800 n1_m1_480000_436800 5.356235
R10580 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R10581 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R10582 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R10583 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R10584 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R10585 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R10586 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R10587 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R10588 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R10589 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R10590 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R10591 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R10592 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R10593 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R10594 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R10595 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R10596 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R10597 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R10598 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R10599 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R10600 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R10601 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R10602 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R10603 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R10604 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R10605 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R10606 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R10607 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R10608 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R10609 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R10610 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R10611 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R10612 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R10613 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R10614 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R10615 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R10616 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R10617 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R10618 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R10619 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R10620 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R10621 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R10622 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R10623 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R10624 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R10625 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R10626 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R10627 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R10628 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R10629 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R10630 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R10631 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R10632 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R10633 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R10634 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R10635 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R10636 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R10637 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R10638 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R10639 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R10640 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R10641 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R10642 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R10643 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R10644 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R10645 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R10646 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R10647 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R10648 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R10649 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R10650 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R10651 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R10652 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R10653 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R10654 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R10655 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R10656 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R10657 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R10658 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R10659 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R10660 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R10661 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R10662 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R10663 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R10664 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R10665 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R10666 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R10667 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R10668 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R10669 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R10670 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R10671 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R10672 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R10673 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R10674 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R10675 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R10676 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R10677 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R10678 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R10679 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R10680 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R10681 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R10682 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R10683 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R10684 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R10685 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R10686 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R10687 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R10688 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R10689 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R10690 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R10691 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R10692 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R10693 n1_m1_470400_441600 n1_m1_475200_441600 5.356235
R10694 n1_m1_475200_441600 n1_m1_480000_441600 5.356235
R10695 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R10696 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R10697 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R10698 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R10699 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R10700 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R10701 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R10702 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R10703 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R10704 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R10705 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R10706 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R10707 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R10708 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R10709 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R10710 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R10711 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R10712 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R10713 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R10714 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R10715 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R10716 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R10717 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R10718 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R10719 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R10720 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R10721 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R10722 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R10723 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R10724 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R10725 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R10726 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R10727 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R10728 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R10729 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R10730 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R10731 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R10732 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R10733 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R10734 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R10735 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R10736 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R10737 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R10738 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R10739 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R10740 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R10741 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R10742 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R10743 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R10744 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R10745 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R10746 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R10747 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R10748 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R10749 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R10750 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R10751 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R10752 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R10753 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R10754 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R10755 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R10756 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R10757 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R10758 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R10759 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R10760 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R10761 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R10762 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R10763 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R10764 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R10765 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R10766 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R10767 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R10768 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R10769 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R10770 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R10771 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R10772 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R10773 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R10774 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R10775 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R10776 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R10777 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R10778 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R10779 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R10780 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R10781 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R10782 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R10783 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R10784 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R10785 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R10786 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R10787 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R10788 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R10789 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R10790 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R10791 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R10792 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R10793 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R10794 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R10795 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R10796 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R10797 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R10798 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R10799 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R10800 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R10801 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R10802 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R10803 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R10804 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R10805 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R10806 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R10807 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R10808 n1_m1_470400_446400 n1_m1_475200_446400 5.356235
R10809 n1_m1_475200_446400 n1_m1_480000_446400 5.356235
R10810 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R10811 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R10812 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R10813 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R10814 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R10815 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R10816 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R10817 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R10818 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R10819 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R10820 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R10821 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R10822 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R10823 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R10824 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R10825 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R10826 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R10827 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R10828 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R10829 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R10830 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R10831 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R10832 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R10833 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R10834 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R10835 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R10836 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R10837 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R10838 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R10839 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R10840 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R10841 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R10842 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R10843 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R10844 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R10845 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R10846 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R10847 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R10848 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R10849 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R10850 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R10851 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R10852 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R10853 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R10854 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R10855 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R10856 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R10857 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R10858 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R10859 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R10860 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R10861 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R10862 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R10863 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R10864 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R10865 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R10866 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R10867 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R10868 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R10869 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R10870 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R10871 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R10872 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R10873 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R10874 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R10875 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R10876 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R10877 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R10878 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R10879 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R10880 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R10881 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R10882 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R10883 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R10884 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R10885 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R10886 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R10887 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R10888 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R10889 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R10890 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R10891 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R10892 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R10893 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R10894 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R10895 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R10896 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R10897 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R10898 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R10899 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R10900 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R10901 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R10902 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R10903 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R10904 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R10905 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R10906 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R10907 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R10908 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R10909 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R10910 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R10911 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R10912 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R10913 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R10914 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R10915 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R10916 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R10917 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R10918 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R10919 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R10920 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R10921 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R10922 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R10923 n1_m1_470400_451200 n1_m1_475200_451200 5.356235
R10924 n1_m1_475200_451200 n1_m1_480000_451200 5.356235
R10925 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R10926 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R10927 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R10928 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R10929 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R10930 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R10931 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R10932 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R10933 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R10934 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R10935 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R10936 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R10937 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R10938 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R10939 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R10940 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R10941 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R10942 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R10943 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R10944 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R10945 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R10946 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R10947 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R10948 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R10949 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R10950 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R10951 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R10952 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R10953 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R10954 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R10955 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R10956 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R10957 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R10958 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R10959 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R10960 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R10961 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R10962 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R10963 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R10964 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R10965 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R10966 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R10967 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R10968 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R10969 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R10970 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R10971 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R10972 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R10973 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R10974 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R10975 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R10976 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R10977 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R10978 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R10979 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R10980 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R10981 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R10982 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R10983 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R10984 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R10985 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R10986 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R10987 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R10988 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R10989 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R10990 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R10991 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R10992 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R10993 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R10994 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R10995 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R10996 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R10997 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R10998 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R10999 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R11000 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R11001 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R11002 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R11003 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R11004 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R11005 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R11006 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R11007 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R11008 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R11009 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R11010 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R11011 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R11012 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R11013 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R11014 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R11015 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R11016 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R11017 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R11018 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R11019 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R11020 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R11021 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R11022 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R11023 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R11024 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R11025 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R11026 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R11027 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R11028 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R11029 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R11030 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R11031 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R11032 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R11033 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R11034 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R11035 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R11036 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R11037 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R11038 n1_m1_470400_456000 n1_m1_475200_456000 5.356235
R11039 n1_m1_475200_456000 n1_m1_480000_456000 5.356235
R11040 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R11041 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R11042 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R11043 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R11044 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R11045 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R11046 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R11047 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R11048 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R11049 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R11050 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R11051 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R11052 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R11053 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R11054 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R11055 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R11056 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R11057 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R11058 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R11059 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R11060 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R11061 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R11062 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R11063 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R11064 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R11065 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R11066 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R11067 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R11068 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R11069 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R11070 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R11071 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R11072 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R11073 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R11074 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R11075 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R11076 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R11077 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R11078 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R11079 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R11080 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R11081 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R11082 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R11083 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R11084 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R11085 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R11086 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R11087 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R11088 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R11089 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R11090 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R11091 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R11092 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R11093 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R11094 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R11095 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R11096 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R11097 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R11098 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R11099 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R11100 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R11101 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R11102 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R11103 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R11104 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R11105 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R11106 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R11107 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R11108 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R11109 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R11110 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R11111 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R11112 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R11113 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R11114 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R11115 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R11116 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R11117 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R11118 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R11119 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R11120 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R11121 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R11122 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R11123 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R11124 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R11125 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R11126 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R11127 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R11128 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R11129 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R11130 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R11131 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R11132 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R11133 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R11134 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R11135 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R11136 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R11137 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R11138 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R11139 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R11140 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R11141 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R11142 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R11143 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R11144 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R11145 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R11146 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R11147 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R11148 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R11149 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R11150 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R11151 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R11152 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R11153 n1_m1_470400_460800 n1_m1_475200_460800 5.356235
R11154 n1_m1_475200_460800 n1_m1_480000_460800 5.356235
R11155 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R11156 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R11157 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R11158 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R11159 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R11160 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R11161 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R11162 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R11163 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R11164 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R11165 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R11166 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R11167 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R11168 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R11169 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R11170 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R11171 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R11172 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R11173 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R11174 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R11175 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R11176 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R11177 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R11178 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R11179 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R11180 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R11181 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R11182 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R11183 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R11184 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R11185 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R11186 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R11187 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R11188 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R11189 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R11190 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R11191 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R11192 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R11193 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R11194 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R11195 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R11196 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R11197 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R11198 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R11199 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R11200 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R11201 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R11202 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R11203 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R11204 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R11205 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R11206 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R11207 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R11208 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R11209 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R11210 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R11211 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R11212 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R11213 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R11214 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R11215 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R11216 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R11217 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R11218 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R11219 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R11220 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R11221 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R11222 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R11223 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R11224 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R11225 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R11226 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R11227 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R11228 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R11229 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R11230 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R11231 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R11232 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R11233 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R11234 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R11235 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R11236 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R11237 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R11238 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R11239 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R11240 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R11241 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R11242 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R11243 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R11244 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R11245 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R11246 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R11247 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R11248 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R11249 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R11250 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R11251 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R11252 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R11253 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R11254 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R11255 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R11256 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R11257 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R11258 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R11259 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R11260 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R11261 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R11262 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R11263 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R11264 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R11265 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R11266 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R11267 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R11268 n1_m1_470400_465600 n1_m1_475200_465600 5.356235
R11269 n1_m1_475200_465600 n1_m1_480000_465600 5.356235
R11270 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R11271 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R11272 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R11273 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R11274 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R11275 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R11276 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R11277 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R11278 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R11279 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R11280 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R11281 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R11282 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R11283 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R11284 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R11285 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R11286 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R11287 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R11288 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R11289 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R11290 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R11291 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R11292 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R11293 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R11294 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R11295 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R11296 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R11297 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R11298 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R11299 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R11300 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R11301 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R11302 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R11303 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R11304 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R11305 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R11306 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R11307 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R11308 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R11309 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R11310 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R11311 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R11312 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R11313 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R11314 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R11315 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R11316 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R11317 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R11318 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R11319 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R11320 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R11321 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R11322 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R11323 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R11324 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R11325 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R11326 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R11327 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R11328 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R11329 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R11330 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R11331 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R11332 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R11333 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R11334 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R11335 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R11336 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R11337 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R11338 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R11339 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R11340 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R11341 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R11342 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R11343 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R11344 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R11345 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R11346 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R11347 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R11348 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R11349 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R11350 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R11351 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R11352 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R11353 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R11354 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R11355 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R11356 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R11357 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R11358 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R11359 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R11360 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R11361 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R11362 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R11363 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R11364 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R11365 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R11366 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R11367 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R11368 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R11369 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R11370 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R11371 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R11372 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R11373 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R11374 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R11375 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R11376 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R11377 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R11378 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R11379 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R11380 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R11381 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R11382 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R11383 n1_m1_470400_470400 n1_m1_475200_470400 5.356235
R11384 n1_m1_475200_470400 n1_m1_480000_470400 5.356235
R11385 n1_m1_0_475200 n1_m1_4000_475200 4.463529
R11386 n1_m1_4800_475200 n1_m1_4000_475200 0.892706
R11387 n1_m1_4800_475200 n1_m1_9600_475200 5.356235
R11388 n1_m1_9600_475200 n1_m1_14400_475200 5.356235
R11389 n1_m1_14400_475200 n1_m1_19200_475200 5.356235
R11390 n1_m1_19200_475200 n1_m1_24000_475200 5.356235
R11391 n1_m1_24000_475200 n1_m1_28800_475200 5.356235
R11392 n1_m1_28800_475200 n1_m1_32000_475200 3.570824
R11393 n1_m1_33600_475200 n1_m1_32000_475200 1.785412
R11394 n1_m1_33600_475200 n1_m1_38400_475200 5.356235
R11395 n1_m1_38400_475200 n1_m1_43200_475200 5.356235
R11396 n1_m1_43200_475200 n1_m1_48000_475200 5.356235
R11397 n1_m1_48000_475200 n1_m1_52800_475200 5.356235
R11398 n1_m1_52800_475200 n1_m1_57600_475200 5.356235
R11399 n1_m1_57600_475200 n1_m1_60000_475200 2.678118
R11400 n1_m1_62400_475200 n1_m1_60000_475200 2.678118
R11401 n1_m1_62400_475200 n1_m1_67200_475200 5.356235
R11402 n1_m1_67200_475200 n1_m1_72000_475200 5.356235
R11403 n1_m1_72000_475200 n1_m1_76800_475200 5.356235
R11404 n1_m1_76800_475200 n1_m1_81600_475200 5.356235
R11405 n1_m1_81600_475200 n1_m1_86400_475200 5.356235
R11406 n1_m1_86400_475200 n1_m1_88000_475200 1.785412
R11407 n1_m1_91200_475200 n1_m1_88000_475200 3.570824
R11408 n1_m1_91200_475200 n1_m1_96000_475200 5.356235
R11409 n1_m1_96000_475200 n1_m1_100800_475200 5.356235
R11410 n1_m1_100800_475200 n1_m1_105600_475200 5.356235
R11411 n1_m1_105600_475200 n1_m1_110400_475200 5.356235
R11412 n1_m1_110400_475200 n1_m1_115200_475200 5.356235
R11413 n1_m1_115200_475200 n1_m1_116000_475200 0.892706
R11414 n1_m1_120000_475200 n1_m1_116000_475200 4.463529
R11415 n1_m1_120000_475200 n1_m1_124800_475200 5.356235
R11416 n1_m1_124800_475200 n1_m1_129600_475200 5.356235
R11417 n1_m1_129600_475200 n1_m1_134400_475200 5.356235
R11418 n1_m1_134400_475200 n1_m1_139200_475200 5.356235
R11419 n1_m1_139200_475200 n1_m1_144000_475200 5.356235
R11420 n1_m1_144000_475200 n1_m1_148800_475200 5.356235
R11421 n1_m1_148800_475200 n1_m1_153600_475200 5.356235
R11422 n1_m1_153600_475200 n1_m1_158400_475200 5.356235
R11423 n1_m1_158400_475200 n1_m1_163200_475200 5.356235
R11424 n1_m1_163200_475200 n1_m1_168000_475200 5.356235
R11425 n1_m1_168000_475200 n1_m1_172000_475200 4.463529
R11426 n1_m1_172800_475200 n1_m1_172000_475200 0.892706
R11427 n1_m1_172800_475200 n1_m1_177600_475200 5.356235
R11428 n1_m1_177600_475200 n1_m1_182400_475200 5.356235
R11429 n1_m1_182400_475200 n1_m1_187200_475200 5.356235
R11430 n1_m1_187200_475200 n1_m1_192000_475200 5.356235
R11431 n1_m1_192000_475200 n1_m1_196800_475200 5.356235
R11432 n1_m1_196800_475200 n1_m1_200000_475200 3.570824
R11433 n1_m1_201600_475200 n1_m1_200000_475200 1.785412
R11434 n1_m1_201600_475200 n1_m1_206400_475200 5.356235
R11435 n1_m1_206400_475200 n1_m1_211200_475200 5.356235
R11436 n1_m1_211200_475200 n1_m1_216000_475200 5.356235
R11437 n1_m1_216000_475200 n1_m1_220800_475200 5.356235
R11438 n1_m1_220800_475200 n1_m1_225600_475200 5.356235
R11439 n1_m1_225600_475200 n1_m1_228000_475200 2.678118
R11440 n1_m1_230400_475200 n1_m1_228000_475200 2.678118
R11441 n1_m1_230400_475200 n1_m1_235200_475200 5.356235
R11442 n1_m1_235200_475200 n1_m1_240000_475200 5.356235
R11443 n1_m1_240000_475200 n1_m1_244800_475200 5.356235
R11444 n1_m1_244800_475200 n1_m1_249600_475200 5.356235
R11445 n1_m1_249600_475200 n1_m1_254400_475200 5.356235
R11446 n1_m1_254400_475200 n1_m1_256000_475200 1.785412
R11447 n1_m1_259200_475200 n1_m1_256000_475200 3.570824
R11448 n1_m1_259200_475200 n1_m1_264000_475200 5.356235
R11449 n1_m1_264000_475200 n1_m1_268800_475200 5.356235
R11450 n1_m1_268800_475200 n1_m1_273600_475200 5.356235
R11451 n1_m1_273600_475200 n1_m1_278400_475200 5.356235
R11452 n1_m1_278400_475200 n1_m1_283200_475200 5.356235
R11453 n1_m1_283200_475200 n1_m1_284000_475200 0.892706
R11454 n1_m1_288000_475200 n1_m1_284000_475200 4.463529
R11455 n1_m1_288000_475200 n1_m1_292800_475200 5.356235
R11456 n1_m1_292800_475200 n1_m1_297600_475200 5.356235
R11457 n1_m1_297600_475200 n1_m1_302400_475200 5.356235
R11458 n1_m1_302400_475200 n1_m1_307200_475200 5.356235
R11459 n1_m1_307200_475200 n1_m1_312000_475200 5.356235
R11460 n1_m1_312000_475200 n1_m1_316800_475200 5.356235
R11461 n1_m1_316800_475200 n1_m1_321600_475200 5.356235
R11462 n1_m1_321600_475200 n1_m1_326400_475200 5.356235
R11463 n1_m1_326400_475200 n1_m1_331200_475200 5.356235
R11464 n1_m1_331200_475200 n1_m1_336000_475200 5.356235
R11465 n1_m1_336000_475200 n1_m1_340000_475200 4.463529
R11466 n1_m1_340800_475200 n1_m1_340000_475200 0.892706
R11467 n1_m1_340800_475200 n1_m1_345600_475200 5.356235
R11468 n1_m1_345600_475200 n1_m1_350400_475200 5.356235
R11469 n1_m1_350400_475200 n1_m1_355200_475200 5.356235
R11470 n1_m1_355200_475200 n1_m1_360000_475200 5.356235
R11471 n1_m1_360000_475200 n1_m1_364800_475200 5.356235
R11472 n1_m1_364800_475200 n1_m1_368000_475200 3.570824
R11473 n1_m1_369600_475200 n1_m1_368000_475200 1.785412
R11474 n1_m1_369600_475200 n1_m1_374400_475200 5.356235
R11475 n1_m1_374400_475200 n1_m1_379200_475200 5.356235
R11476 n1_m1_379200_475200 n1_m1_384000_475200 5.356235
R11477 n1_m1_384000_475200 n1_m1_388800_475200 5.356235
R11478 n1_m1_388800_475200 n1_m1_393600_475200 5.356235
R11479 n1_m1_393600_475200 n1_m1_396000_475200 2.678118
R11480 n1_m1_398400_475200 n1_m1_396000_475200 2.678118
R11481 n1_m1_398400_475200 n1_m1_403200_475200 5.356235
R11482 n1_m1_403200_475200 n1_m1_408000_475200 5.356235
R11483 n1_m1_408000_475200 n1_m1_412800_475200 5.356235
R11484 n1_m1_412800_475200 n1_m1_417600_475200 5.356235
R11485 n1_m1_417600_475200 n1_m1_422400_475200 5.356235
R11486 n1_m1_422400_475200 n1_m1_424000_475200 1.785412
R11487 n1_m1_427200_475200 n1_m1_424000_475200 3.570824
R11488 n1_m1_427200_475200 n1_m1_432000_475200 5.356235
R11489 n1_m1_432000_475200 n1_m1_436800_475200 5.356235
R11490 n1_m1_436800_475200 n1_m1_441600_475200 5.356235
R11491 n1_m1_441600_475200 n1_m1_446400_475200 5.356235
R11492 n1_m1_446400_475200 n1_m1_451200_475200 5.356235
R11493 n1_m1_451200_475200 n1_m1_452000_475200 0.892706
R11494 n1_m1_456000_475200 n1_m1_452000_475200 4.463529
R11495 n1_m1_456000_475200 n1_m1_460800_475200 5.356235
R11496 n1_m1_460800_475200 n1_m1_465600_475200 5.356235
R11497 n1_m1_465600_475200 n1_m1_470400_475200 5.356235
R11498 n1_m1_470400_475200 n1_m1_475200_475200 5.356235
R11499 n1_m1_475200_475200 n1_m1_480000_475200 5.356235
R11500 n1_m1_0_480000 n1_m1_4000_480000 4.463529
R11501 n1_m1_4800_480000 n1_m1_4000_480000 0.892706
R11502 n1_m1_4800_480000 n1_m1_9600_480000 5.356235
R11503 n1_m1_9600_480000 n1_m1_14400_480000 5.356235
R11504 n1_m1_14400_480000 n1_m1_19200_480000 5.356235
R11505 n1_m1_19200_480000 n1_m1_24000_480000 5.356235
R11506 n1_m1_24000_480000 n1_m1_28800_480000 5.356235
R11507 n1_m1_28800_480000 n1_m1_32000_480000 3.570824
R11508 n1_m1_33600_480000 n1_m1_32000_480000 1.785412
R11509 n1_m1_33600_480000 n1_m1_38400_480000 5.356235
R11510 n1_m1_38400_480000 n1_m1_43200_480000 5.356235
R11511 n1_m1_43200_480000 n1_m1_48000_480000 5.356235
R11512 n1_m1_48000_480000 n1_m1_52800_480000 5.356235
R11513 n1_m1_52800_480000 n1_m1_57600_480000 5.356235
R11514 n1_m1_57600_480000 n1_m1_60000_480000 2.678118
R11515 n1_m1_62400_480000 n1_m1_60000_480000 2.678118
R11516 n1_m1_62400_480000 n1_m1_67200_480000 5.356235
R11517 n1_m1_67200_480000 n1_m1_72000_480000 5.356235
R11518 n1_m1_72000_480000 n1_m1_76800_480000 5.356235
R11519 n1_m1_76800_480000 n1_m1_81600_480000 5.356235
R11520 n1_m1_81600_480000 n1_m1_86400_480000 5.356235
R11521 n1_m1_86400_480000 n1_m1_88000_480000 1.785412
R11522 n1_m1_91200_480000 n1_m1_88000_480000 3.570824
R11523 n1_m1_91200_480000 n1_m1_96000_480000 5.356235
R11524 n1_m1_96000_480000 n1_m1_100800_480000 5.356235
R11525 n1_m1_100800_480000 n1_m1_105600_480000 5.356235
R11526 n1_m1_105600_480000 n1_m1_110400_480000 5.356235
R11527 n1_m1_110400_480000 n1_m1_115200_480000 5.356235
R11528 n1_m1_115200_480000 n1_m1_116000_480000 0.892706
R11529 n1_m1_120000_480000 n1_m1_116000_480000 4.463529
R11530 n1_m1_120000_480000 n1_m1_124800_480000 5.356235
R11531 n1_m1_124800_480000 n1_m1_129600_480000 5.356235
R11532 n1_m1_129600_480000 n1_m1_134400_480000 5.356235
R11533 n1_m1_134400_480000 n1_m1_139200_480000 5.356235
R11534 n1_m1_139200_480000 n1_m1_144000_480000 5.356235
R11535 n1_m1_144000_480000 n1_m1_148800_480000 5.356235
R11536 n1_m1_148800_480000 n1_m1_153600_480000 5.356235
R11537 n1_m1_153600_480000 n1_m1_158400_480000 5.356235
R11538 n1_m1_158400_480000 n1_m1_163200_480000 5.356235
R11539 n1_m1_163200_480000 n1_m1_168000_480000 5.356235
R11540 n1_m1_168000_480000 n1_m1_172000_480000 4.463529
R11541 n1_m1_172800_480000 n1_m1_172000_480000 0.892706
R11542 n1_m1_172800_480000 n1_m1_177600_480000 5.356235
R11543 n1_m1_177600_480000 n1_m1_182400_480000 5.356235
R11544 n1_m1_182400_480000 n1_m1_187200_480000 5.356235
R11545 n1_m1_187200_480000 n1_m1_192000_480000 5.356235
R11546 n1_m1_192000_480000 n1_m1_196800_480000 5.356235
R11547 n1_m1_196800_480000 n1_m1_200000_480000 3.570824
R11548 n1_m1_201600_480000 n1_m1_200000_480000 1.785412
R11549 n1_m1_201600_480000 n1_m1_206400_480000 5.356235
R11550 n1_m1_206400_480000 n1_m1_211200_480000 5.356235
R11551 n1_m1_211200_480000 n1_m1_216000_480000 5.356235
R11552 n1_m1_216000_480000 n1_m1_220800_480000 5.356235
R11553 n1_m1_220800_480000 n1_m1_225600_480000 5.356235
R11554 n1_m1_225600_480000 n1_m1_228000_480000 2.678118
R11555 n1_m1_230400_480000 n1_m1_228000_480000 2.678118
R11556 n1_m1_230400_480000 n1_m1_235200_480000 5.356235
R11557 n1_m1_235200_480000 n1_m1_240000_480000 5.356235
R11558 n1_m1_240000_480000 n1_m1_244800_480000 5.356235
R11559 n1_m1_244800_480000 n1_m1_249600_480000 5.356235
R11560 n1_m1_249600_480000 n1_m1_254400_480000 5.356235
R11561 n1_m1_254400_480000 n1_m1_256000_480000 1.785412
R11562 n1_m1_259200_480000 n1_m1_256000_480000 3.570824
R11563 n1_m1_259200_480000 n1_m1_264000_480000 5.356235
R11564 n1_m1_264000_480000 n1_m1_268800_480000 5.356235
R11565 n1_m1_268800_480000 n1_m1_273600_480000 5.356235
R11566 n1_m1_273600_480000 n1_m1_278400_480000 5.356235
R11567 n1_m1_278400_480000 n1_m1_283200_480000 5.356235
R11568 n1_m1_283200_480000 n1_m1_284000_480000 0.892706
R11569 n1_m1_288000_480000 n1_m1_284000_480000 4.463529
R11570 n1_m1_288000_480000 n1_m1_292800_480000 5.356235
R11571 n1_m1_292800_480000 n1_m1_297600_480000 5.356235
R11572 n1_m1_297600_480000 n1_m1_302400_480000 5.356235
R11573 n1_m1_302400_480000 n1_m1_307200_480000 5.356235
R11574 n1_m1_307200_480000 n1_m1_312000_480000 5.356235
R11575 n1_m1_312000_480000 n1_m1_316800_480000 5.356235
R11576 n1_m1_316800_480000 n1_m1_321600_480000 5.356235
R11577 n1_m1_321600_480000 n1_m1_326400_480000 5.356235
R11578 n1_m1_326400_480000 n1_m1_331200_480000 5.356235
R11579 n1_m1_331200_480000 n1_m1_336000_480000 5.356235
R11580 n1_m1_336000_480000 n1_m1_340000_480000 4.463529
R11581 n1_m1_340800_480000 n1_m1_340000_480000 0.892706
R11582 n1_m1_340800_480000 n1_m1_345600_480000 5.356235
R11583 n1_m1_345600_480000 n1_m1_350400_480000 5.356235
R11584 n1_m1_350400_480000 n1_m1_355200_480000 5.356235
R11585 n1_m1_355200_480000 n1_m1_360000_480000 5.356235
R11586 n1_m1_360000_480000 n1_m1_364800_480000 5.356235
R11587 n1_m1_364800_480000 n1_m1_368000_480000 3.570824
R11588 n1_m1_369600_480000 n1_m1_368000_480000 1.785412
R11589 n1_m1_369600_480000 n1_m1_374400_480000 5.356235
R11590 n1_m1_374400_480000 n1_m1_379200_480000 5.356235
R11591 n1_m1_379200_480000 n1_m1_384000_480000 5.356235
R11592 n1_m1_384000_480000 n1_m1_388800_480000 5.356235
R11593 n1_m1_388800_480000 n1_m1_393600_480000 5.356235
R11594 n1_m1_393600_480000 n1_m1_396000_480000 2.678118
R11595 n1_m1_398400_480000 n1_m1_396000_480000 2.678118
R11596 n1_m1_398400_480000 n1_m1_403200_480000 5.356235
R11597 n1_m1_403200_480000 n1_m1_408000_480000 5.356235
R11598 n1_m1_408000_480000 n1_m1_412800_480000 5.356235
R11599 n1_m1_412800_480000 n1_m1_417600_480000 5.356235
R11600 n1_m1_417600_480000 n1_m1_422400_480000 5.356235
R11601 n1_m1_422400_480000 n1_m1_424000_480000 1.785412
R11602 n1_m1_427200_480000 n1_m1_424000_480000 3.570824
R11603 n1_m1_427200_480000 n1_m1_432000_480000 5.356235
R11604 n1_m1_432000_480000 n1_m1_436800_480000 5.356235
R11605 n1_m1_436800_480000 n1_m1_441600_480000 5.356235
R11606 n1_m1_441600_480000 n1_m1_446400_480000 5.356235
R11607 n1_m1_446400_480000 n1_m1_451200_480000 5.356235
R11608 n1_m1_451200_480000 n1_m1_452000_480000 0.892706
R11609 n1_m1_456000_480000 n1_m1_452000_480000 4.463529
R11610 n1_m1_456000_480000 n1_m1_460800_480000 5.356235
R11611 n1_m1_460800_480000 n1_m1_465600_480000 5.356235
R11612 n1_m1_465600_480000 n1_m1_470400_480000 5.356235
R11613 n1_m1_470400_480000 n1_m1_475200_480000 5.356235
R11614 n1_m1_475200_480000 n1_m1_480000_480000 5.356235
R11615 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R11616 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R11617 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R11618 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R11619 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R11620 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R11621 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R11622 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R11623 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R11624 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R11625 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R11626 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R11627 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R11628 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R11629 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R11630 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R11631 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R11632 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R11633 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R11634 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R11635 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R11636 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R11637 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R11638 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R11639 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R11640 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R11641 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R11642 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R11643 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R11644 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R11645 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R11646 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R11647 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R11648 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R11649 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R11650 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R11651 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R11652 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R11653 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R11654 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R11655 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R11656 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R11657 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R11658 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R11659 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R11660 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R11661 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R11662 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R11663 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R11664 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R11665 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R11666 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R11667 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R11668 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R11669 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R11670 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R11671 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R11672 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R11673 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R11674 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R11675 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R11676 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R11677 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R11678 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R11679 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R11680 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R11681 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R11682 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R11683 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R11684 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R11685 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R11686 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R11687 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R11688 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R11689 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R11690 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R11691 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R11692 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R11693 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R11694 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R11695 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R11696 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R11697 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R11698 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R11699 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R11700 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R11701 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R11702 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R11703 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R11704 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R11705 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R11706 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R11707 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R11708 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R11709 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R11710 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R11711 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R11712 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R11713 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R11714 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R11715 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R11716 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R11717 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R11718 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R11719 n1_m4_4000_470400 n1_m4_4000_475200 1.400000
R11720 n1_m4_4000_475200 n1_m4_4000_480000 1.400000
R11721 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R11722 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R11723 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R11724 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R11725 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R11726 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R11727 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R11728 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R11729 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R11730 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R11731 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R11732 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R11733 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R11734 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R11735 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R11736 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R11737 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R11738 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R11739 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R11740 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R11741 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R11742 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R11743 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R11744 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R11745 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R11746 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R11747 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R11748 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R11749 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R11750 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R11751 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R11752 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R11753 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R11754 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R11755 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R11756 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R11757 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R11758 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R11759 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R11760 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R11761 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R11762 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R11763 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R11764 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R11765 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R11766 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R11767 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R11768 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R11769 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R11770 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R11771 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R11772 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R11773 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R11774 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R11775 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R11776 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R11777 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R11778 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R11779 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R11780 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R11781 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R11782 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R11783 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R11784 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R11785 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R11786 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R11787 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R11788 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R11789 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R11790 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R11791 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R11792 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R11793 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R11794 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R11795 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R11796 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R11797 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R11798 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R11799 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R11800 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R11801 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R11802 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R11803 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R11804 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R11805 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R11806 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R11807 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R11808 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R11809 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R11810 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R11811 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R11812 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R11813 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R11814 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R11815 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R11816 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R11817 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R11818 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R11819 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R11820 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R11821 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R11822 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R11823 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R11824 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R11825 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R11826 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R11827 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R11828 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R11829 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R11830 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R11831 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R11832 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R11833 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R11834 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R11835 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R11836 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R11837 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R11838 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R11839 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R11840 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R11841 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R11842 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R11843 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R11844 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R11845 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R11846 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R11847 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R11848 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R11849 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R11850 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R11851 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R11852 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R11853 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R11854 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R11855 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R11856 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R11857 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R11858 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R11859 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R11860 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R11861 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R11862 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R11863 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R11864 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R11865 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R11866 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R11867 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R11868 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R11869 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R11870 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R11871 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R11872 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R11873 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R11874 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R11875 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R11876 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R11877 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R11878 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R11879 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R11880 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R11881 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R11882 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R11883 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R11884 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R11885 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R11886 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R11887 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R11888 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R11889 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R11890 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R11891 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R11892 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R11893 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R11894 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R11895 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R11896 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R11897 n1_m4_88000_398400 n1_m4_88000_403200 1.400000
R11898 n1_m4_88000_403200 n1_m4_88000_404000 0.233333
R11899 n1_m4_88000_408000 n1_m4_88000_404000 1.166667
R11900 n1_m4_88000_408000 n1_m4_88000_412800 1.400000
R11901 n1_m4_88000_412800 n1_m4_88000_417600 1.400000
R11902 n1_m4_88000_417600 n1_m4_88000_422400 1.400000
R11903 n1_m4_88000_422400 n1_m4_88000_427200 1.400000
R11904 n1_m4_88000_427200 n1_m4_88000_432000 1.400000
R11905 n1_m4_88000_432000 n1_m4_88000_436800 1.400000
R11906 n1_m4_88000_436800 n1_m4_88000_441600 1.400000
R11907 n1_m4_88000_441600 n1_m4_88000_446400 1.400000
R11908 n1_m4_88000_446400 n1_m4_88000_451200 1.400000
R11909 n1_m4_88000_451200 n1_m4_88000_456000 1.400000
R11910 n1_m4_88000_456000 n1_m4_88000_460800 1.400000
R11911 n1_m4_88000_460800 n1_m4_88000_465600 1.400000
R11912 n1_m4_88000_465600 n1_m4_88000_470400 1.400000
R11913 n1_m4_88000_470400 n1_m4_88000_475200 1.400000
R11914 n1_m4_88000_475200 n1_m4_88000_480000 1.400000
R11915 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R11916 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R11917 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R11918 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R11919 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R11920 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R11921 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R11922 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R11923 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R11924 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R11925 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R11926 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R11927 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R11928 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R11929 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R11930 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R11931 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R11932 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R11933 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R11934 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R11935 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R11936 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R11937 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R11938 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R11939 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R11940 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R11941 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R11942 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R11943 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R11944 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R11945 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R11946 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R11947 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R11948 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R11949 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R11950 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R11951 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R11952 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R11953 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R11954 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R11955 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R11956 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R11957 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R11958 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R11959 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R11960 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R11961 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R11962 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R11963 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R11964 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R11965 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R11966 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R11967 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R11968 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R11969 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R11970 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R11971 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R11972 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R11973 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R11974 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R11975 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R11976 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R11977 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R11978 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R11979 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R11980 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R11981 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R11982 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R11983 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R11984 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R11985 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R11986 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R11987 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R11988 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R11989 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R11990 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R11991 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R11992 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R11993 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R11994 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R11995 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R11996 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R11997 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R11998 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R11999 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R12000 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R12001 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R12002 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R12003 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R12004 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R12005 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R12006 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R12007 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R12008 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R12009 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R12010 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R12011 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R12012 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R12013 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R12014 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R12015 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R12016 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R12017 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R12018 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R12019 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R12020 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R12021 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R12022 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R12023 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R12024 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R12025 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R12026 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R12027 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R12028 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R12029 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R12030 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R12031 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R12032 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R12033 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R12034 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R12035 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R12036 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R12037 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R12038 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R12039 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R12040 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R12041 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R12042 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R12043 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R12044 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R12045 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R12046 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R12047 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R12048 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R12049 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R12050 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R12051 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R12052 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R12053 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R12054 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R12055 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R12056 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R12057 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R12058 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R12059 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R12060 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R12061 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R12062 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R12063 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R12064 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R12065 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R12066 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R12067 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R12068 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R12069 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R12070 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R12071 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R12072 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R12073 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R12074 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R12075 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R12076 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R12077 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R12078 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R12079 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R12080 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R12081 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R12082 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R12083 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R12084 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R12085 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R12086 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R12087 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R12088 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R12089 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R12090 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R12091 n1_m4_172000_398400 n1_m4_172000_403200 1.400000
R12092 n1_m4_172000_403200 n1_m4_172000_404000 0.233333
R12093 n1_m4_172000_408000 n1_m4_172000_404000 1.166667
R12094 n1_m4_172000_408000 n1_m4_172000_412800 1.400000
R12095 n1_m4_172000_412800 n1_m4_172000_417600 1.400000
R12096 n1_m4_172000_417600 n1_m4_172000_422400 1.400000
R12097 n1_m4_172000_422400 n1_m4_172000_427200 1.400000
R12098 n1_m4_172000_427200 n1_m4_172000_432000 1.400000
R12099 n1_m4_172000_432000 n1_m4_172000_436800 1.400000
R12100 n1_m4_172000_436800 n1_m4_172000_441600 1.400000
R12101 n1_m4_172000_441600 n1_m4_172000_446400 1.400000
R12102 n1_m4_172000_446400 n1_m4_172000_451200 1.400000
R12103 n1_m4_172000_451200 n1_m4_172000_456000 1.400000
R12104 n1_m4_172000_456000 n1_m4_172000_460800 1.400000
R12105 n1_m4_172000_460800 n1_m4_172000_465600 1.400000
R12106 n1_m4_172000_465600 n1_m4_172000_470400 1.400000
R12107 n1_m4_172000_470400 n1_m4_172000_475200 1.400000
R12108 n1_m4_172000_475200 n1_m4_172000_480000 1.400000
R12109 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R12110 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R12111 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R12112 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R12113 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R12114 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R12115 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R12116 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R12117 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R12118 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R12119 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R12120 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R12121 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R12122 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R12123 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R12124 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R12125 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R12126 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R12127 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R12128 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R12129 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R12130 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R12131 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R12132 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R12133 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R12134 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R12135 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R12136 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R12137 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R12138 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R12139 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R12140 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R12141 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R12142 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R12143 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R12144 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R12145 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R12146 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R12147 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R12148 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R12149 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R12150 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R12151 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R12152 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R12153 n1_m4_284000_0 n1_m4_284000_4000 1.166667
R12154 n1_m4_284000_4800 n1_m4_284000_4000 0.233333
R12155 n1_m4_284000_4800 n1_m4_284000_9600 1.400000
R12156 n1_m4_284000_9600 n1_m4_284000_14400 1.400000
R12157 n1_m4_284000_14400 n1_m4_284000_19200 1.400000
R12158 n1_m4_284000_19200 n1_m4_284000_24000 1.400000
R12159 n1_m4_284000_24000 n1_m4_284000_28800 1.400000
R12160 n1_m4_284000_28800 n1_m4_284000_33600 1.400000
R12161 n1_m4_284000_33600 n1_m4_284000_38400 1.400000
R12162 n1_m4_284000_38400 n1_m4_284000_43200 1.400000
R12163 n1_m4_284000_43200 n1_m4_284000_48000 1.400000
R12164 n1_m4_284000_48000 n1_m4_284000_52800 1.400000
R12165 n1_m4_284000_52800 n1_m4_284000_57600 1.400000
R12166 n1_m4_284000_57600 n1_m4_284000_62400 1.400000
R12167 n1_m4_284000_62400 n1_m4_284000_67200 1.400000
R12168 n1_m4_284000_67200 n1_m4_284000_72000 1.400000
R12169 n1_m4_284000_72000 n1_m4_284000_76800 1.400000
R12170 n1_m4_284000_76800 n1_m4_284000_81600 1.400000
R12171 n1_m4_284000_81600 n1_m4_284000_84000 0.700000
R12172 n1_m4_284000_86400 n1_m4_284000_84000 0.700000
R12173 n1_m4_284000_86400 n1_m4_284000_91200 1.400000
R12174 n1_m4_284000_91200 n1_m4_284000_96000 1.400000
R12175 n1_m4_284000_96000 n1_m4_284000_100800 1.400000
R12176 n1_m4_284000_100800 n1_m4_284000_105600 1.400000
R12177 n1_m4_284000_105600 n1_m4_284000_110400 1.400000
R12178 n1_m4_284000_110400 n1_m4_284000_115200 1.400000
R12179 n1_m4_284000_115200 n1_m4_284000_120000 1.400000
R12180 n1_m4_284000_120000 n1_m4_284000_124800 1.400000
R12181 n1_m4_284000_124800 n1_m4_284000_129600 1.400000
R12182 n1_m4_284000_129600 n1_m4_284000_134400 1.400000
R12183 n1_m4_284000_134400 n1_m4_284000_139200 1.400000
R12184 n1_m4_284000_139200 n1_m4_284000_144000 1.400000
R12185 n1_m4_284000_144000 n1_m4_284000_148800 1.400000
R12186 n1_m4_284000_148800 n1_m4_284000_153600 1.400000
R12187 n1_m4_284000_153600 n1_m4_284000_158400 1.400000
R12188 n1_m4_284000_158400 n1_m4_284000_163200 1.400000
R12189 n1_m4_284000_163200 n1_m4_284000_164000 0.233333
R12190 n1_m4_284000_168000 n1_m4_284000_164000 1.166667
R12191 n1_m4_284000_168000 n1_m4_284000_172800 1.400000
R12192 n1_m4_284000_172800 n1_m4_284000_177600 1.400000
R12193 n1_m4_284000_177600 n1_m4_284000_182400 1.400000
R12194 n1_m4_284000_182400 n1_m4_284000_187200 1.400000
R12195 n1_m4_284000_187200 n1_m4_284000_192000 1.400000
R12196 n1_m4_284000_192000 n1_m4_284000_196800 1.400000
R12197 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R12198 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R12199 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R12200 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R12201 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R12202 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R12203 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R12204 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R12205 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R12206 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R12207 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R12208 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R12209 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R12210 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R12211 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R12212 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R12213 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R12214 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R12215 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R12216 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R12217 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R12218 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R12219 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R12220 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R12221 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R12222 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R12223 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R12224 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R12225 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R12226 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R12227 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R12228 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R12229 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R12230 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R12231 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R12232 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R12233 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R12234 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R12235 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R12236 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R12237 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R12238 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R12239 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R12240 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R12241 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R12242 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R12243 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R12244 n1_m4_312000_408000 n1_m4_312000_412800 1.400000
R12245 n1_m4_312000_412800 n1_m4_312000_417600 1.400000
R12246 n1_m4_312000_417600 n1_m4_312000_422400 1.400000
R12247 n1_m4_312000_422400 n1_m4_312000_427200 1.400000
R12248 n1_m4_312000_427200 n1_m4_312000_432000 1.400000
R12249 n1_m4_312000_432000 n1_m4_312000_436800 1.400000
R12250 n1_m4_312000_436800 n1_m4_312000_441600 1.400000
R12251 n1_m4_312000_441600 n1_m4_312000_446400 1.400000
R12252 n1_m4_312000_446400 n1_m4_312000_451200 1.400000
R12253 n1_m4_312000_451200 n1_m4_312000_456000 1.400000
R12254 n1_m4_312000_456000 n1_m4_312000_460800 1.400000
R12255 n1_m4_312000_460800 n1_m4_312000_465600 1.400000
R12256 n1_m4_312000_465600 n1_m4_312000_470400 1.400000
R12257 n1_m4_312000_470400 n1_m4_312000_475200 1.400000
R12258 n1_m4_312000_475200 n1_m4_312000_480000 1.400000
R12259 n1_m4_368000_0 n1_m4_368000_4000 1.166667
R12260 n1_m4_368000_4800 n1_m4_368000_4000 0.233333
R12261 n1_m4_368000_4800 n1_m4_368000_9600 1.400000
R12262 n1_m4_368000_9600 n1_m4_368000_14400 1.400000
R12263 n1_m4_368000_14400 n1_m4_368000_19200 1.400000
R12264 n1_m4_368000_19200 n1_m4_368000_24000 1.400000
R12265 n1_m4_368000_24000 n1_m4_368000_28800 1.400000
R12266 n1_m4_368000_28800 n1_m4_368000_33600 1.400000
R12267 n1_m4_368000_33600 n1_m4_368000_38400 1.400000
R12268 n1_m4_368000_38400 n1_m4_368000_43200 1.400000
R12269 n1_m4_368000_43200 n1_m4_368000_48000 1.400000
R12270 n1_m4_368000_48000 n1_m4_368000_52800 1.400000
R12271 n1_m4_368000_52800 n1_m4_368000_57600 1.400000
R12272 n1_m4_368000_57600 n1_m4_368000_62400 1.400000
R12273 n1_m4_368000_62400 n1_m4_368000_67200 1.400000
R12274 n1_m4_368000_67200 n1_m4_368000_72000 1.400000
R12275 n1_m4_368000_72000 n1_m4_368000_76800 1.400000
R12276 n1_m4_368000_76800 n1_m4_368000_81600 1.400000
R12277 n1_m4_368000_81600 n1_m4_368000_84000 0.700000
R12278 n1_m4_368000_86400 n1_m4_368000_84000 0.700000
R12279 n1_m4_368000_86400 n1_m4_368000_91200 1.400000
R12280 n1_m4_368000_91200 n1_m4_368000_96000 1.400000
R12281 n1_m4_368000_96000 n1_m4_368000_100800 1.400000
R12282 n1_m4_368000_100800 n1_m4_368000_105600 1.400000
R12283 n1_m4_368000_105600 n1_m4_368000_110400 1.400000
R12284 n1_m4_368000_110400 n1_m4_368000_115200 1.400000
R12285 n1_m4_368000_115200 n1_m4_368000_120000 1.400000
R12286 n1_m4_368000_120000 n1_m4_368000_124800 1.400000
R12287 n1_m4_368000_124800 n1_m4_368000_129600 1.400000
R12288 n1_m4_368000_129600 n1_m4_368000_134400 1.400000
R12289 n1_m4_368000_134400 n1_m4_368000_139200 1.400000
R12290 n1_m4_368000_139200 n1_m4_368000_144000 1.400000
R12291 n1_m4_368000_144000 n1_m4_368000_148800 1.400000
R12292 n1_m4_368000_148800 n1_m4_368000_153600 1.400000
R12293 n1_m4_368000_153600 n1_m4_368000_158400 1.400000
R12294 n1_m4_368000_158400 n1_m4_368000_163200 1.400000
R12295 n1_m4_368000_163200 n1_m4_368000_164000 0.233333
R12296 n1_m4_368000_168000 n1_m4_368000_164000 1.166667
R12297 n1_m4_368000_168000 n1_m4_368000_172800 1.400000
R12298 n1_m4_368000_172800 n1_m4_368000_177600 1.400000
R12299 n1_m4_368000_177600 n1_m4_368000_182400 1.400000
R12300 n1_m4_368000_182400 n1_m4_368000_187200 1.400000
R12301 n1_m4_368000_187200 n1_m4_368000_192000 1.400000
R12302 n1_m4_368000_192000 n1_m4_368000_196800 1.400000
R12303 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R12304 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R12305 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R12306 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R12307 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R12308 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R12309 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R12310 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R12311 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R12312 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R12313 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R12314 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R12315 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R12316 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R12317 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R12318 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R12319 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R12320 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R12321 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R12322 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R12323 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R12324 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R12325 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R12326 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R12327 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R12328 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R12329 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R12330 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R12331 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R12332 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R12333 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R12334 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R12335 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R12336 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R12337 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R12338 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R12339 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R12340 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R12341 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R12342 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R12343 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R12344 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R12345 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R12346 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R12347 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R12348 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R12349 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R12350 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R12351 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R12352 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R12353 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R12354 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R12355 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R12356 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R12357 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R12358 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R12359 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R12360 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R12361 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R12362 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R12363 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R12364 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R12365 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R12366 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R12367 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R12368 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R12369 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R12370 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R12371 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R12372 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R12373 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R12374 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R12375 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R12376 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R12377 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R12378 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R12379 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R12380 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R12381 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R12382 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R12383 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R12384 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R12385 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R12386 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R12387 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R12388 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R12389 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R12390 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R12391 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R12392 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R12393 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R12394 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R12395 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R12396 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R12397 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R12398 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R12399 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R12400 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R12401 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R12402 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R12403 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R12404 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R12405 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R12406 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R12407 n1_m4_424000_470400 n1_m4_424000_475200 1.400000
R12408 n1_m4_424000_475200 n1_m4_424000_480000 1.400000
R12409 n1_m4_480000_0 n1_m4_480000_4000 1.166667
R12410 n1_m4_480000_4800 n1_m4_480000_4000 0.233333
R12411 n1_m4_480000_4800 n1_m4_480000_9600 1.400000
R12412 n1_m4_480000_9600 n1_m4_480000_14400 1.400000
R12413 n1_m4_480000_14400 n1_m4_480000_19200 1.400000
R12414 n1_m4_480000_19200 n1_m4_480000_24000 1.400000
R12415 n1_m4_480000_24000 n1_m4_480000_28800 1.400000
R12416 n1_m4_480000_28800 n1_m4_480000_33600 1.400000
R12417 n1_m4_480000_33600 n1_m4_480000_38400 1.400000
R12418 n1_m4_480000_38400 n1_m4_480000_43200 1.400000
R12419 n1_m4_480000_43200 n1_m4_480000_48000 1.400000
R12420 n1_m4_480000_48000 n1_m4_480000_52800 1.400000
R12421 n1_m4_480000_52800 n1_m4_480000_57600 1.400000
R12422 n1_m4_480000_57600 n1_m4_480000_62400 1.400000
R12423 n1_m4_480000_62400 n1_m4_480000_67200 1.400000
R12424 n1_m4_480000_67200 n1_m4_480000_72000 1.400000
R12425 n1_m4_480000_72000 n1_m4_480000_76800 1.400000
R12426 n1_m4_480000_76800 n1_m4_480000_81600 1.400000
R12427 n1_m4_480000_81600 n1_m4_480000_84000 0.700000
R12428 n1_m4_480000_86400 n1_m4_480000_84000 0.700000
R12429 n1_m4_480000_86400 n1_m4_480000_91200 1.400000
R12430 n1_m4_480000_91200 n1_m4_480000_96000 1.400000
R12431 n1_m4_480000_96000 n1_m4_480000_100800 1.400000
R12432 n1_m4_480000_100800 n1_m4_480000_105600 1.400000
R12433 n1_m4_480000_105600 n1_m4_480000_110400 1.400000
R12434 n1_m4_480000_110400 n1_m4_480000_115200 1.400000
R12435 n1_m4_480000_115200 n1_m4_480000_120000 1.400000
R12436 n1_m4_480000_120000 n1_m4_480000_124800 1.400000
R12437 n1_m4_480000_124800 n1_m4_480000_129600 1.400000
R12438 n1_m4_480000_129600 n1_m4_480000_134400 1.400000
R12439 n1_m4_480000_134400 n1_m4_480000_139200 1.400000
R12440 n1_m4_480000_139200 n1_m4_480000_144000 1.400000
R12441 n1_m4_480000_144000 n1_m4_480000_148800 1.400000
R12442 n1_m4_480000_148800 n1_m4_480000_153600 1.400000
R12443 n1_m4_480000_153600 n1_m4_480000_158400 1.400000
R12444 n1_m4_480000_158400 n1_m4_480000_163200 1.400000
R12445 n1_m4_480000_163200 n1_m4_480000_164000 0.233333
R12446 n1_m4_480000_168000 n1_m4_480000_164000 1.166667
R12447 n1_m4_480000_168000 n1_m4_480000_172800 1.400000
R12448 n1_m4_480000_172800 n1_m4_480000_177600 1.400000
R12449 n1_m4_480000_177600 n1_m4_480000_182400 1.400000
R12450 n1_m4_480000_182400 n1_m4_480000_187200 1.400000
R12451 n1_m4_480000_187200 n1_m4_480000_192000 1.400000
R12452 n1_m4_480000_192000 n1_m4_480000_196800 1.400000
R12453 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R12454 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R12455 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R12456 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R12457 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R12458 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R12459 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R12460 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R12461 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R12462 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R12463 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R12464 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R12465 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R12466 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R12467 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R12468 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R12469 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R12470 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R12471 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R12472 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R12473 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R12474 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R12475 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R12476 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R12477 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R12478 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R12479 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R12480 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R12481 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R12482 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R12483 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R12484 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R12485 n1_m7_452000_4000 n1_m7_474400_4000 0.594240
R12486 n1_m7_480000_4000 n1_m7_474400_4000 0.148560
R12487 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R12488 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R12489 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R12490 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R12491 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R12492 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R12493 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R12494 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R12495 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R12496 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R12497 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R12498 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R12499 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R12500 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R12501 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R12502 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R12503 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R12504 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R12505 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R12506 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R12507 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R12508 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R12509 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R12510 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R12511 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R12512 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R12513 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R12514 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R12515 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R12516 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R12517 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R12518 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R12519 n1_m7_452000_84000 n1_m7_474400_84000 0.594240
R12520 n1_m7_480000_84000 n1_m7_474400_84000 0.148560
R12521 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R12522 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R12523 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R12524 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R12525 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R12526 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R12527 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R12528 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R12529 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R12530 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R12531 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R12532 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R12533 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R12534 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R12535 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R12536 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R12537 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R12538 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R12539 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R12540 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R12541 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R12542 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R12543 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R12544 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R12545 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R12546 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R12547 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R12548 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R12549 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R12550 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R12551 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R12552 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R12553 n1_m7_452000_164000 n1_m7_474400_164000 0.594240
R12554 n1_m7_480000_164000 n1_m7_474400_164000 0.148560
R12555 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R12556 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R12557 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R12558 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R12559 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R12560 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R12561 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R12562 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R12563 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R12564 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R12565 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R12566 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R12567 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R12568 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R12569 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R12570 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R12571 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R12572 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R12573 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R12574 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R12575 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R12576 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R12577 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R12578 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R12579 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R12580 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R12581 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R12582 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R12583 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R12584 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R12585 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R12586 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R12587 n1_m7_452000_244000 n1_m7_474400_244000 0.594240
R12588 n1_m7_480000_244000 n1_m7_474400_244000 0.148560
R12589 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R12590 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R12591 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R12592 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R12593 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R12594 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R12595 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R12596 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R12597 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R12598 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R12599 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R12600 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R12601 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R12602 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R12603 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R12604 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R12605 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R12606 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R12607 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R12608 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R12609 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R12610 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R12611 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R12612 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R12613 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R12614 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R12615 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R12616 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R12617 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R12618 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R12619 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R12620 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R12621 n1_m7_452000_324000 n1_m7_474400_324000 0.594240
R12622 n1_m7_480000_324000 n1_m7_474400_324000 0.148560
R12623 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R12624 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R12625 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R12626 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R12627 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R12628 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R12629 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R12630 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R12631 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R12632 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R12633 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R12634 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R12635 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R12636 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R12637 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R12638 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R12639 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R12640 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R12641 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R12642 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R12643 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R12644 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R12645 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R12646 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R12647 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R12648 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R12649 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R12650 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R12651 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R12652 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R12653 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R12654 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R12655 n1_m7_452000_404000 n1_m7_474400_404000 0.594240
R12656 n1_m7_480000_404000 n1_m7_474400_404000 0.148560
R12657 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R12658 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R12659 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R12660 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R12661 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R12662 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R12663 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R12664 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R12665 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R12666 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R12667 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R12668 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R12669 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R12670 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R12671 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R12672 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R12673 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R12674 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R12675 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R12676 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R12677 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R12678 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R12679 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R12680 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R12681 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R12682 n1_m8_4000_452000 n1_m8_4000_474400 0.120000
R12683 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R12684 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R12685 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R12686 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R12687 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R12688 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R12689 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R12690 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R12691 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R12692 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R12693 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R12694 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R12695 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R12696 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R12697 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R12698 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R12699 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R12700 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R12701 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R12702 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R12703 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R12704 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R12705 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R12706 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R12707 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R12708 n1_m8_26400_452000 n1_m8_26400_474400 0.120000
R12709 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R12710 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R12711 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R12712 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R12713 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R12714 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R12715 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R12716 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R12717 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R12718 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R12719 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R12720 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R12721 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R12722 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R12723 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R12724 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R12725 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R12726 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R12727 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R12728 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R12729 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R12730 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R12731 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R12732 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R12733 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R12734 n1_m8_48800_452000 n1_m8_48800_474400 0.120000
R12735 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R12736 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R12737 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R12738 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R12739 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R12740 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R12741 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R12742 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R12743 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R12744 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R12745 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R12746 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R12747 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R12748 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R12749 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R12750 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R12751 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R12752 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R12753 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R12754 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R12755 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R12756 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R12757 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R12758 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R12759 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R12760 n1_m8_71200_452000 n1_m8_71200_474400 0.120000
R12761 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R12762 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R12763 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R12764 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R12765 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R12766 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R12767 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R12768 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R12769 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R12770 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R12771 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R12772 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R12773 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R12774 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R12775 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R12776 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R12777 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R12778 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R12779 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R12780 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R12781 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R12782 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R12783 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R12784 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R12785 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R12786 n1_m8_93600_452000 n1_m8_93600_474400 0.120000
R12787 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R12788 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R12789 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R12790 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R12791 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R12792 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R12793 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R12794 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R12795 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R12796 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R12797 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R12798 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R12799 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R12800 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R12801 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R12802 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R12803 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R12804 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R12805 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R12806 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R12807 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R12808 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R12809 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R12810 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R12811 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R12812 n1_m8_116000_452000 n1_m8_116000_474400 0.120000
R12813 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R12814 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R12815 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R12816 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R12817 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R12818 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R12819 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R12820 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R12821 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R12822 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R12823 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R12824 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R12825 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R12826 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R12827 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R12828 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R12829 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R12830 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R12831 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R12832 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R12833 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R12834 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R12835 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R12836 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R12837 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R12838 n1_m8_138400_452000 n1_m8_138400_474400 0.120000
R12839 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R12840 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R12841 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R12842 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R12843 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R12844 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R12845 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R12846 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R12847 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R12848 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R12849 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R12850 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R12851 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R12852 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R12853 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R12854 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R12855 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R12856 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R12857 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R12858 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R12859 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R12860 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R12861 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R12862 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R12863 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R12864 n1_m8_160800_452000 n1_m8_160800_474400 0.120000
R12865 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R12866 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R12867 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R12868 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R12869 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R12870 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R12871 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R12872 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R12873 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R12874 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R12875 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R12876 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R12877 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R12878 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R12879 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R12880 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R12881 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R12882 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R12883 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R12884 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R12885 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R12886 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R12887 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R12888 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R12889 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R12890 n1_m8_183200_452000 n1_m8_183200_474400 0.120000
R12891 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R12892 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R12893 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R12894 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R12895 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R12896 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R12897 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R12898 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R12899 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R12900 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R12901 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R12902 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R12903 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R12904 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R12905 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R12906 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R12907 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R12908 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R12909 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R12910 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R12911 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R12912 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R12913 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R12914 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R12915 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R12916 n1_m8_205600_452000 n1_m8_205600_474400 0.120000
R12917 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R12918 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R12919 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R12920 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R12921 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R12922 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R12923 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R12924 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R12925 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R12926 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R12927 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R12928 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R12929 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R12930 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R12931 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R12932 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R12933 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R12934 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R12935 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R12936 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R12937 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R12938 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R12939 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R12940 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R12941 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R12942 n1_m8_228000_452000 n1_m8_228000_474400 0.120000
R12943 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R12944 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R12945 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R12946 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R12947 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R12948 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R12949 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R12950 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R12951 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R12952 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R12953 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R12954 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R12955 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R12956 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R12957 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R12958 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R12959 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R12960 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R12961 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R12962 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R12963 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R12964 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R12965 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R12966 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R12967 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R12968 n1_m8_250400_452000 n1_m8_250400_474400 0.120000
R12969 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R12970 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R12971 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R12972 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R12973 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R12974 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R12975 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R12976 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R12977 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R12978 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R12979 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R12980 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R12981 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R12982 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R12983 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R12984 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R12985 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R12986 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R12987 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R12988 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R12989 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R12990 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R12991 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R12992 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R12993 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R12994 n1_m8_272800_452000 n1_m8_272800_474400 0.120000
R12995 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R12996 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R12997 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R12998 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R12999 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R13000 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R13001 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R13002 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R13003 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R13004 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R13005 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R13006 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R13007 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R13008 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R13009 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R13010 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R13011 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R13012 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R13013 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R13014 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R13015 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R13016 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R13017 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R13018 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R13019 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R13020 n1_m8_295200_452000 n1_m8_295200_474400 0.120000
R13021 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R13022 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R13023 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R13024 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R13025 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R13026 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R13027 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R13028 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R13029 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R13030 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R13031 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R13032 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R13033 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R13034 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R13035 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R13036 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R13037 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R13038 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R13039 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R13040 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R13041 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R13042 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R13043 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R13044 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R13045 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R13046 n1_m8_317600_452000 n1_m8_317600_474400 0.120000
R13047 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R13048 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R13049 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R13050 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R13051 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R13052 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R13053 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R13054 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R13055 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R13056 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R13057 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R13058 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R13059 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R13060 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R13061 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R13062 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R13063 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R13064 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R13065 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R13066 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R13067 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R13068 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R13069 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R13070 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R13071 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R13072 n1_m8_340000_452000 n1_m8_340000_474400 0.120000
R13073 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R13074 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R13075 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R13076 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R13077 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R13078 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R13079 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R13080 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R13081 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R13082 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R13083 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R13084 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R13085 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R13086 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R13087 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R13088 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R13089 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R13090 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R13091 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R13092 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R13093 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R13094 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R13095 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R13096 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R13097 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R13098 n1_m8_362400_452000 n1_m8_362400_474400 0.120000
R13099 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R13100 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R13101 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R13102 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R13103 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R13104 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R13105 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R13106 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R13107 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R13108 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R13109 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R13110 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R13111 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R13112 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R13113 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R13114 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R13115 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R13116 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R13117 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R13118 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R13119 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R13120 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R13121 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R13122 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R13123 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R13124 n1_m8_384800_452000 n1_m8_384800_474400 0.120000
R13125 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R13126 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R13127 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R13128 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R13129 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R13130 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R13131 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R13132 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R13133 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R13134 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R13135 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R13136 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R13137 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R13138 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R13139 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R13140 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R13141 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R13142 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R13143 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R13144 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R13145 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R13146 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R13147 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R13148 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R13149 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R13150 n1_m8_407200_452000 n1_m8_407200_474400 0.120000
R13151 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R13152 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R13153 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R13154 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R13155 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R13156 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R13157 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R13158 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R13159 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R13160 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R13161 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R13162 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R13163 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R13164 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R13165 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R13166 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R13167 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R13168 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R13169 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R13170 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R13171 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R13172 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R13173 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R13174 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R13175 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R13176 n1_m8_429600_452000 n1_m8_429600_474400 0.120000
R13177 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R13178 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R13179 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R13180 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R13181 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R13182 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R13183 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R13184 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R13185 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R13186 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R13187 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R13188 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R13189 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R13190 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R13191 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R13192 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R13193 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R13194 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R13195 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R13196 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R13197 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R13198 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R13199 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R13200 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R13201 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R13202 n1_m8_452000_452000 n1_m8_452000_474400 0.120000
R13203 n1_m8_474400_4000 n1_m8_474400_26400 0.120000
R13204 n1_m8_474400_26400 n1_m8_474400_48800 0.120000
R13205 n1_m8_474400_48800 n1_m8_474400_71200 0.120000
R13206 n1_m8_474400_84000 n1_m8_474400_71200 0.068571
R13207 n1_m8_474400_84000 n1_m8_474400_93600 0.051429
R13208 n1_m8_474400_93600 n1_m8_474400_116000 0.120000
R13209 n1_m8_474400_116000 n1_m8_474400_138400 0.120000
R13210 n1_m8_474400_138400 n1_m8_474400_160800 0.120000
R13211 n1_m8_474400_164000 n1_m8_474400_160800 0.017143
R13212 n1_m8_474400_164000 n1_m8_474400_183200 0.102857
R13213 n1_m8_474400_183200 n1_m8_474400_205600 0.120000
R13214 n1_m8_474400_205600 n1_m8_474400_228000 0.120000
R13215 n1_m8_474400_244000 n1_m8_474400_228000 0.085714
R13216 n1_m8_474400_244000 n1_m8_474400_250400 0.034286
R13217 n1_m8_474400_250400 n1_m8_474400_272800 0.120000
R13218 n1_m8_474400_272800 n1_m8_474400_295200 0.120000
R13219 n1_m8_474400_295200 n1_m8_474400_317600 0.120000
R13220 n1_m8_474400_324000 n1_m8_474400_317600 0.034286
R13221 n1_m8_474400_324000 n1_m8_474400_340000 0.085714
R13222 n1_m8_474400_340000 n1_m8_474400_362400 0.120000
R13223 n1_m8_474400_362400 n1_m8_474400_384800 0.120000
R13224 n1_m8_474400_404000 n1_m8_474400_384800 0.102857
R13225 n1_m8_474400_404000 n1_m8_474400_407200 0.017143
R13226 n1_m8_474400_407200 n1_m8_474400_429600 0.120000
R13227 n1_m8_474400_429600 n1_m8_474400_452000 0.120000
R13228 n1_m8_474400_452000 n1_m8_474400_474400 0.120000
R13229 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R13230 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R13231 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R13232 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R13233 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R13234 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R13235 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R13236 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R13237 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R13238 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R13239 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R13240 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R13241 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R13242 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R13243 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R13244 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R13245 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R13246 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R13247 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R13248 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R13249 n1_m9_452000_4000 n1_m9_474400_4000 0.096000
R13250 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R13251 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R13252 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R13253 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R13254 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R13255 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R13256 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R13257 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R13258 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R13259 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R13260 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R13261 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R13262 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R13263 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R13264 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R13265 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R13266 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R13267 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R13268 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R13269 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R13270 n1_m9_452000_26400 n1_m9_474400_26400 0.096000
R13271 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R13272 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R13273 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R13274 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R13275 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R13276 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R13277 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R13278 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R13279 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R13280 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R13281 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R13282 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R13283 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R13284 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R13285 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R13286 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R13287 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R13288 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R13289 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R13290 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R13291 n1_m9_452000_48800 n1_m9_474400_48800 0.096000
R13292 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R13293 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R13294 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R13295 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R13296 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R13297 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R13298 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R13299 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R13300 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R13301 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R13302 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R13303 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R13304 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R13305 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R13306 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R13307 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R13308 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R13309 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R13310 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R13311 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R13312 n1_m9_452000_71200 n1_m9_474400_71200 0.096000
R13313 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R13314 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R13315 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R13316 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R13317 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R13318 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R13319 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R13320 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R13321 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R13322 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R13323 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R13324 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R13325 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R13326 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R13327 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R13328 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R13329 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R13330 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R13331 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R13332 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R13333 n1_m9_452000_93600 n1_m9_474400_93600 0.096000
R13334 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R13335 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R13336 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R13337 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R13338 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R13339 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R13340 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R13341 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R13342 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R13343 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R13344 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R13345 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R13346 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R13347 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R13348 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R13349 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R13350 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R13351 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R13352 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R13353 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R13354 n1_m9_452000_116000 n1_m9_474400_116000 0.096000
R13355 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R13356 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R13357 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R13358 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R13359 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R13360 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R13361 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R13362 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R13363 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R13364 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R13365 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R13366 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R13367 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R13368 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R13369 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R13370 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R13371 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R13372 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R13373 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R13374 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R13375 n1_m9_452000_138400 n1_m9_474400_138400 0.096000
R13376 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R13377 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R13378 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R13379 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R13380 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R13381 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R13382 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R13383 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R13384 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R13385 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R13386 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R13387 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R13388 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R13389 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R13390 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R13391 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R13392 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R13393 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R13394 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R13395 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R13396 n1_m9_452000_160800 n1_m9_474400_160800 0.096000
R13397 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R13398 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R13399 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R13400 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R13401 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R13402 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R13403 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R13404 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R13405 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R13406 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R13407 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R13408 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R13409 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R13410 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R13411 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R13412 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R13413 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R13414 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R13415 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R13416 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R13417 n1_m9_452000_183200 n1_m9_474400_183200 0.096000
R13418 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R13419 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R13420 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R13421 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R13422 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R13423 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R13424 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R13425 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R13426 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R13427 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R13428 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R13429 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R13430 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R13431 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R13432 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R13433 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R13434 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R13435 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R13436 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R13437 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R13438 n1_m9_452000_205600 n1_m9_474400_205600 0.096000
R13439 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R13440 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R13441 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R13442 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R13443 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R13444 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R13445 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R13446 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R13447 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R13448 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R13449 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R13450 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R13451 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R13452 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R13453 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R13454 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R13455 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R13456 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R13457 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R13458 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R13459 n1_m9_452000_228000 n1_m9_474400_228000 0.096000
R13460 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R13461 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R13462 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R13463 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R13464 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R13465 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R13466 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R13467 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R13468 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R13469 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R13470 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R13471 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R13472 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R13473 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R13474 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R13475 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R13476 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R13477 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R13478 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R13479 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R13480 n1_m9_452000_250400 n1_m9_474400_250400 0.096000
R13481 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R13482 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R13483 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R13484 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R13485 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R13486 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R13487 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R13488 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R13489 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R13490 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R13491 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R13492 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R13493 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R13494 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R13495 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R13496 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R13497 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R13498 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R13499 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R13500 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R13501 n1_m9_452000_272800 n1_m9_474400_272800 0.096000
R13502 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R13503 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R13504 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R13505 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R13506 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R13507 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R13508 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R13509 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R13510 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R13511 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R13512 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R13513 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R13514 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R13515 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R13516 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R13517 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R13518 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R13519 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R13520 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R13521 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R13522 n1_m9_452000_295200 n1_m9_474400_295200 0.096000
R13523 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R13524 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R13525 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R13526 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R13527 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R13528 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R13529 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R13530 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R13531 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R13532 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R13533 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R13534 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R13535 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R13536 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R13537 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R13538 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R13539 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R13540 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R13541 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R13542 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R13543 n1_m9_452000_317600 n1_m9_474400_317600 0.096000
R13544 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R13545 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R13546 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R13547 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R13548 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R13549 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R13550 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R13551 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R13552 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R13553 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R13554 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R13555 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R13556 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R13557 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R13558 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R13559 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R13560 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R13561 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R13562 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R13563 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R13564 n1_m9_452000_340000 n1_m9_474400_340000 0.096000
R13565 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R13566 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R13567 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R13568 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R13569 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R13570 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R13571 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R13572 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R13573 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R13574 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R13575 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R13576 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R13577 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R13578 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R13579 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R13580 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R13581 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R13582 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R13583 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R13584 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R13585 n1_m9_452000_362400 n1_m9_474400_362400 0.096000
R13586 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R13587 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R13588 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R13589 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R13590 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R13591 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R13592 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R13593 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R13594 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R13595 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R13596 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R13597 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R13598 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R13599 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R13600 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R13601 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R13602 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R13603 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R13604 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R13605 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R13606 n1_m9_452000_384800 n1_m9_474400_384800 0.096000
R13607 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R13608 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R13609 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R13610 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R13611 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R13612 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R13613 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R13614 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R13615 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R13616 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R13617 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R13618 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R13619 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R13620 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R13621 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R13622 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R13623 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R13624 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R13625 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R13626 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R13627 n1_m9_452000_407200 n1_m9_474400_407200 0.096000
R13628 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R13629 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R13630 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R13631 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R13632 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R13633 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R13634 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R13635 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R13636 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R13637 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R13638 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R13639 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R13640 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R13641 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R13642 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R13643 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R13644 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R13645 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R13646 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R13647 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R13648 n1_m9_452000_429600 n1_m9_474400_429600 0.096000
R13649 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R13650 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R13651 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R13652 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R13653 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R13654 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R13655 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R13656 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R13657 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R13658 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R13659 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R13660 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R13661 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R13662 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R13663 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R13664 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R13665 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R13666 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R13667 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R13668 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R13669 n1_m9_452000_452000 n1_m9_474400_452000 0.096000
R13670 n1_m9_4000_474400 n1_m9_26400_474400 0.096000
R13671 n1_m9_26400_474400 n1_m9_48800_474400 0.096000
R13672 n1_m9_48800_474400 n1_m9_71200_474400 0.096000
R13673 n1_m9_71200_474400 n1_m9_93600_474400 0.096000
R13674 n1_m9_93600_474400 n1_m9_116000_474400 0.096000
R13675 n1_m9_116000_474400 n1_m9_138400_474400 0.096000
R13676 n1_m9_138400_474400 n1_m9_160800_474400 0.096000
R13677 n1_m9_160800_474400 n1_m9_183200_474400 0.096000
R13678 n1_m9_183200_474400 n1_m9_205600_474400 0.096000
R13679 n1_m9_205600_474400 n1_m9_228000_474400 0.096000
R13680 n1_m9_228000_474400 n1_m9_250400_474400 0.096000
R13681 n1_m9_250400_474400 n1_m9_272800_474400 0.096000
R13682 n1_m9_272800_474400 n1_m9_295200_474400 0.096000
R13683 n1_m9_295200_474400 n1_m9_317600_474400 0.096000
R13684 n1_m9_317600_474400 n1_m9_340000_474400 0.096000
R13685 n1_m9_340000_474400 n1_m9_362400_474400 0.096000
R13686 n1_m9_362400_474400 n1_m9_384800_474400 0.096000
R13687 n1_m9_384800_474400 n1_m9_407200_474400 0.096000
R13688 n1_m9_407200_474400 n1_m9_429600_474400 0.096000
R13689 n1_m9_429600_474400 n1_m9_452000_474400 0.096000
R13690 n1_m9_452000_474400 n1_m9_474400_474400 0.096000
R13691 n1_m1_4000_0 n1_m4_4000_0 15.000000
R13692 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R13693 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R13694 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R13695 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R13696 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R13697 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R13698 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R13699 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R13700 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R13701 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R13702 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R13703 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R13704 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R13705 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R13706 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R13707 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R13708 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R13709 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R13710 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R13711 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R13712 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R13713 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R13714 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R13715 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R13716 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R13717 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R13718 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R13719 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R13720 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R13721 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R13722 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R13723 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R13724 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R13725 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R13726 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R13727 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R13728 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R13729 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R13730 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R13731 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R13732 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R13733 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R13734 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R13735 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R13736 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R13737 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R13738 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R13739 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R13740 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R13741 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R13742 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R13743 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R13744 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R13745 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R13746 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R13747 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R13748 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R13749 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R13750 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R13751 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R13752 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R13753 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R13754 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R13755 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R13756 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R13757 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R13758 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R13759 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R13760 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R13761 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R13762 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R13763 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R13764 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R13765 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R13766 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R13767 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R13768 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R13769 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R13770 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R13771 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R13772 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R13773 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R13774 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R13775 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R13776 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R13777 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R13778 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R13779 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R13780 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R13781 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R13782 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R13783 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R13784 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R13785 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R13786 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R13787 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R13788 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R13789 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R13790 n1_m1_4000_475200 n1_m4_4000_475200 15.000000
R13791 n1_m1_4000_480000 n1_m4_4000_480000 15.000000
R13792 n1_m1_32000_0 n1_m4_32000_0 15.000000
R13793 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R13794 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R13795 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R13796 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R13797 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R13798 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R13799 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R13800 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R13801 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R13802 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R13803 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R13804 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R13805 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R13806 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R13807 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R13808 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R13809 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R13810 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R13811 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R13812 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R13813 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R13814 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R13815 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R13816 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R13817 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R13818 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R13819 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R13820 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R13821 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R13822 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R13823 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R13824 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R13825 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R13826 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R13827 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R13828 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R13829 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R13830 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R13831 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R13832 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R13833 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R13834 n1_m1_60000_0 n1_m4_60000_0 15.000000
R13835 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R13836 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R13837 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R13838 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R13839 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R13840 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R13841 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R13842 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R13843 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R13844 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R13845 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R13846 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R13847 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R13848 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R13849 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R13850 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R13851 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R13852 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R13853 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R13854 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R13855 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R13856 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R13857 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R13858 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R13859 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R13860 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R13861 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R13862 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R13863 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R13864 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R13865 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R13866 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R13867 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R13868 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R13869 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R13870 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R13871 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R13872 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R13873 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R13874 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R13875 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R13876 n1_m1_88000_0 n1_m4_88000_0 15.000000
R13877 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R13878 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R13879 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R13880 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R13881 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R13882 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R13883 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R13884 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R13885 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R13886 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R13887 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R13888 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R13889 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R13890 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R13891 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R13892 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R13893 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R13894 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R13895 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R13896 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R13897 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R13898 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R13899 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R13900 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R13901 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R13902 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R13903 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R13904 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R13905 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R13906 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R13907 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R13908 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R13909 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R13910 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R13911 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R13912 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R13913 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R13914 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R13915 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R13916 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R13917 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R13918 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R13919 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R13920 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R13921 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R13922 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R13923 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R13924 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R13925 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R13926 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R13927 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R13928 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R13929 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R13930 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R13931 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R13932 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R13933 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R13934 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R13935 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R13936 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R13937 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R13938 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R13939 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R13940 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R13941 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R13942 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R13943 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R13944 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R13945 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R13946 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R13947 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R13948 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R13949 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R13950 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R13951 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R13952 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R13953 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R13954 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R13955 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R13956 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R13957 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R13958 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R13959 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R13960 n1_m1_88000_403200 n1_m4_88000_403200 15.000000
R13961 n1_m1_88000_408000 n1_m4_88000_408000 15.000000
R13962 n1_m1_88000_412800 n1_m4_88000_412800 15.000000
R13963 n1_m1_88000_417600 n1_m4_88000_417600 15.000000
R13964 n1_m1_88000_422400 n1_m4_88000_422400 15.000000
R13965 n1_m1_88000_427200 n1_m4_88000_427200 15.000000
R13966 n1_m1_88000_432000 n1_m4_88000_432000 15.000000
R13967 n1_m1_88000_436800 n1_m4_88000_436800 15.000000
R13968 n1_m1_88000_441600 n1_m4_88000_441600 15.000000
R13969 n1_m1_88000_446400 n1_m4_88000_446400 15.000000
R13970 n1_m1_88000_451200 n1_m4_88000_451200 15.000000
R13971 n1_m1_88000_456000 n1_m4_88000_456000 15.000000
R13972 n1_m1_88000_460800 n1_m4_88000_460800 15.000000
R13973 n1_m1_88000_465600 n1_m4_88000_465600 15.000000
R13974 n1_m1_88000_470400 n1_m4_88000_470400 15.000000
R13975 n1_m1_88000_475200 n1_m4_88000_475200 15.000000
R13976 n1_m1_88000_480000 n1_m4_88000_480000 15.000000
R13977 n1_m1_116000_0 n1_m4_116000_0 15.000000
R13978 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R13979 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R13980 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R13981 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R13982 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R13983 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R13984 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R13985 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R13986 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R13987 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R13988 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R13989 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R13990 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R13991 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R13992 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R13993 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R13994 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R13995 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R13996 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R13997 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R13998 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R13999 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R14000 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R14001 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R14002 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R14003 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R14004 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R14005 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R14006 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R14007 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R14008 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R14009 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R14010 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R14011 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R14012 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R14013 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R14014 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R14015 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R14016 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R14017 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R14018 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R14019 n1_m1_144000_0 n1_m4_144000_0 15.000000
R14020 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R14021 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R14022 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R14023 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R14024 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R14025 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R14026 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R14027 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R14028 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R14029 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R14030 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R14031 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R14032 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R14033 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R14034 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R14035 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R14036 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R14037 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R14038 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R14039 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R14040 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R14041 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R14042 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R14043 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R14044 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R14045 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R14046 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R14047 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R14048 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R14049 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R14050 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R14051 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R14052 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R14053 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R14054 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R14055 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R14056 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R14057 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R14058 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R14059 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R14060 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R14061 n1_m1_172000_0 n1_m4_172000_0 15.000000
R14062 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R14063 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R14064 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R14065 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R14066 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R14067 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R14068 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R14069 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R14070 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R14071 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R14072 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R14073 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R14074 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R14075 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R14076 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R14077 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R14078 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R14079 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R14080 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R14081 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R14082 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R14083 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R14084 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R14085 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R14086 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R14087 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R14088 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R14089 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R14090 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R14091 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R14092 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R14093 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R14094 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R14095 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R14096 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R14097 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R14098 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R14099 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R14100 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R14101 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R14102 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R14103 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R14104 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R14105 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R14106 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R14107 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R14108 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R14109 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R14110 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R14111 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R14112 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R14113 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R14114 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R14115 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R14116 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R14117 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R14118 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R14119 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R14120 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R14121 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R14122 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R14123 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R14124 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R14125 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R14126 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R14127 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R14128 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R14129 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R14130 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R14131 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R14132 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R14133 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R14134 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R14135 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R14136 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R14137 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R14138 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R14139 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R14140 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R14141 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R14142 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R14143 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R14144 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R14145 n1_m1_172000_403200 n1_m4_172000_403200 15.000000
R14146 n1_m1_172000_408000 n1_m4_172000_408000 15.000000
R14147 n1_m1_172000_412800 n1_m4_172000_412800 15.000000
R14148 n1_m1_172000_417600 n1_m4_172000_417600 15.000000
R14149 n1_m1_172000_422400 n1_m4_172000_422400 15.000000
R14150 n1_m1_172000_427200 n1_m4_172000_427200 15.000000
R14151 n1_m1_172000_432000 n1_m4_172000_432000 15.000000
R14152 n1_m1_172000_436800 n1_m4_172000_436800 15.000000
R14153 n1_m1_172000_441600 n1_m4_172000_441600 15.000000
R14154 n1_m1_172000_446400 n1_m4_172000_446400 15.000000
R14155 n1_m1_172000_451200 n1_m4_172000_451200 15.000000
R14156 n1_m1_172000_456000 n1_m4_172000_456000 15.000000
R14157 n1_m1_172000_460800 n1_m4_172000_460800 15.000000
R14158 n1_m1_172000_465600 n1_m4_172000_465600 15.000000
R14159 n1_m1_172000_470400 n1_m4_172000_470400 15.000000
R14160 n1_m1_172000_475200 n1_m4_172000_475200 15.000000
R14161 n1_m1_172000_480000 n1_m4_172000_480000 15.000000
R14162 n1_m1_200000_0 n1_m4_200000_0 15.000000
R14163 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R14164 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R14165 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R14166 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R14167 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R14168 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R14169 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R14170 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R14171 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R14172 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R14173 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R14174 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R14175 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R14176 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R14177 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R14178 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R14179 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R14180 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R14181 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R14182 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R14183 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R14184 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R14185 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R14186 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R14187 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R14188 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R14189 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R14190 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R14191 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R14192 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R14193 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R14194 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R14195 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R14196 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R14197 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R14198 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R14199 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R14200 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R14201 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R14202 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R14203 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R14204 n1_m1_228000_0 n1_m4_228000_0 15.000000
R14205 n1_m1_256000_0 n1_m4_256000_0 15.000000
R14206 n1_m1_284000_0 n1_m4_284000_0 15.000000
R14207 n1_m1_284000_4800 n1_m4_284000_4800 15.000000
R14208 n1_m1_284000_9600 n1_m4_284000_9600 15.000000
R14209 n1_m1_284000_14400 n1_m4_284000_14400 15.000000
R14210 n1_m1_284000_19200 n1_m4_284000_19200 15.000000
R14211 n1_m1_284000_24000 n1_m4_284000_24000 15.000000
R14212 n1_m1_284000_28800 n1_m4_284000_28800 15.000000
R14213 n1_m1_284000_33600 n1_m4_284000_33600 15.000000
R14214 n1_m1_284000_38400 n1_m4_284000_38400 15.000000
R14215 n1_m1_284000_43200 n1_m4_284000_43200 15.000000
R14216 n1_m1_284000_48000 n1_m4_284000_48000 15.000000
R14217 n1_m1_284000_52800 n1_m4_284000_52800 15.000000
R14218 n1_m1_284000_57600 n1_m4_284000_57600 15.000000
R14219 n1_m1_284000_62400 n1_m4_284000_62400 15.000000
R14220 n1_m1_284000_67200 n1_m4_284000_67200 15.000000
R14221 n1_m1_284000_72000 n1_m4_284000_72000 15.000000
R14222 n1_m1_284000_76800 n1_m4_284000_76800 15.000000
R14223 n1_m1_284000_81600 n1_m4_284000_81600 15.000000
R14224 n1_m1_284000_86400 n1_m4_284000_86400 15.000000
R14225 n1_m1_284000_91200 n1_m4_284000_91200 15.000000
R14226 n1_m1_284000_96000 n1_m4_284000_96000 15.000000
R14227 n1_m1_284000_100800 n1_m4_284000_100800 15.000000
R14228 n1_m1_284000_105600 n1_m4_284000_105600 15.000000
R14229 n1_m1_284000_110400 n1_m4_284000_110400 15.000000
R14230 n1_m1_284000_115200 n1_m4_284000_115200 15.000000
R14231 n1_m1_284000_120000 n1_m4_284000_120000 15.000000
R14232 n1_m1_284000_124800 n1_m4_284000_124800 15.000000
R14233 n1_m1_284000_129600 n1_m4_284000_129600 15.000000
R14234 n1_m1_284000_134400 n1_m4_284000_134400 15.000000
R14235 n1_m1_284000_139200 n1_m4_284000_139200 15.000000
R14236 n1_m1_284000_144000 n1_m4_284000_144000 15.000000
R14237 n1_m1_284000_148800 n1_m4_284000_148800 15.000000
R14238 n1_m1_284000_153600 n1_m4_284000_153600 15.000000
R14239 n1_m1_284000_158400 n1_m4_284000_158400 15.000000
R14240 n1_m1_284000_163200 n1_m4_284000_163200 15.000000
R14241 n1_m1_284000_168000 n1_m4_284000_168000 15.000000
R14242 n1_m1_284000_172800 n1_m4_284000_172800 15.000000
R14243 n1_m1_284000_177600 n1_m4_284000_177600 15.000000
R14244 n1_m1_284000_182400 n1_m4_284000_182400 15.000000
R14245 n1_m1_284000_187200 n1_m4_284000_187200 15.000000
R14246 n1_m1_284000_192000 n1_m4_284000_192000 15.000000
R14247 n1_m1_284000_196800 n1_m4_284000_196800 15.000000
R14248 n1_m1_312000_0 n1_m4_312000_0 15.000000
R14249 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R14250 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R14251 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R14252 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R14253 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R14254 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R14255 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R14256 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R14257 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R14258 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R14259 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R14260 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R14261 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R14262 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R14263 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R14264 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R14265 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R14266 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R14267 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R14268 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R14269 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R14270 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R14271 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R14272 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R14273 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R14274 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R14275 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R14276 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R14277 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R14278 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R14279 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R14280 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R14281 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R14282 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R14283 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R14284 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R14285 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R14286 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R14287 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R14288 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R14289 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R14290 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R14291 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R14292 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R14293 n1_m1_312000_412800 n1_m4_312000_412800 15.000000
R14294 n1_m1_312000_417600 n1_m4_312000_417600 15.000000
R14295 n1_m1_312000_422400 n1_m4_312000_422400 15.000000
R14296 n1_m1_312000_427200 n1_m4_312000_427200 15.000000
R14297 n1_m1_312000_432000 n1_m4_312000_432000 15.000000
R14298 n1_m1_312000_436800 n1_m4_312000_436800 15.000000
R14299 n1_m1_312000_441600 n1_m4_312000_441600 15.000000
R14300 n1_m1_312000_446400 n1_m4_312000_446400 15.000000
R14301 n1_m1_312000_451200 n1_m4_312000_451200 15.000000
R14302 n1_m1_312000_456000 n1_m4_312000_456000 15.000000
R14303 n1_m1_312000_460800 n1_m4_312000_460800 15.000000
R14304 n1_m1_312000_465600 n1_m4_312000_465600 15.000000
R14305 n1_m1_312000_470400 n1_m4_312000_470400 15.000000
R14306 n1_m1_312000_475200 n1_m4_312000_475200 15.000000
R14307 n1_m1_312000_480000 n1_m4_312000_480000 15.000000
R14308 n1_m1_340000_0 n1_m4_340000_0 15.000000
R14309 n1_m1_368000_0 n1_m4_368000_0 15.000000
R14310 n1_m1_368000_4800 n1_m4_368000_4800 15.000000
R14311 n1_m1_368000_9600 n1_m4_368000_9600 15.000000
R14312 n1_m1_368000_14400 n1_m4_368000_14400 15.000000
R14313 n1_m1_368000_19200 n1_m4_368000_19200 15.000000
R14314 n1_m1_368000_24000 n1_m4_368000_24000 15.000000
R14315 n1_m1_368000_28800 n1_m4_368000_28800 15.000000
R14316 n1_m1_368000_33600 n1_m4_368000_33600 15.000000
R14317 n1_m1_368000_38400 n1_m4_368000_38400 15.000000
R14318 n1_m1_368000_43200 n1_m4_368000_43200 15.000000
R14319 n1_m1_368000_48000 n1_m4_368000_48000 15.000000
R14320 n1_m1_368000_52800 n1_m4_368000_52800 15.000000
R14321 n1_m1_368000_57600 n1_m4_368000_57600 15.000000
R14322 n1_m1_368000_62400 n1_m4_368000_62400 15.000000
R14323 n1_m1_368000_67200 n1_m4_368000_67200 15.000000
R14324 n1_m1_368000_72000 n1_m4_368000_72000 15.000000
R14325 n1_m1_368000_76800 n1_m4_368000_76800 15.000000
R14326 n1_m1_368000_81600 n1_m4_368000_81600 15.000000
R14327 n1_m1_368000_86400 n1_m4_368000_86400 15.000000
R14328 n1_m1_368000_91200 n1_m4_368000_91200 15.000000
R14329 n1_m1_368000_96000 n1_m4_368000_96000 15.000000
R14330 n1_m1_368000_100800 n1_m4_368000_100800 15.000000
R14331 n1_m1_368000_105600 n1_m4_368000_105600 15.000000
R14332 n1_m1_368000_110400 n1_m4_368000_110400 15.000000
R14333 n1_m1_368000_115200 n1_m4_368000_115200 15.000000
R14334 n1_m1_368000_120000 n1_m4_368000_120000 15.000000
R14335 n1_m1_368000_124800 n1_m4_368000_124800 15.000000
R14336 n1_m1_368000_129600 n1_m4_368000_129600 15.000000
R14337 n1_m1_368000_134400 n1_m4_368000_134400 15.000000
R14338 n1_m1_368000_139200 n1_m4_368000_139200 15.000000
R14339 n1_m1_368000_144000 n1_m4_368000_144000 15.000000
R14340 n1_m1_368000_148800 n1_m4_368000_148800 15.000000
R14341 n1_m1_368000_153600 n1_m4_368000_153600 15.000000
R14342 n1_m1_368000_158400 n1_m4_368000_158400 15.000000
R14343 n1_m1_368000_163200 n1_m4_368000_163200 15.000000
R14344 n1_m1_368000_168000 n1_m4_368000_168000 15.000000
R14345 n1_m1_368000_172800 n1_m4_368000_172800 15.000000
R14346 n1_m1_368000_177600 n1_m4_368000_177600 15.000000
R14347 n1_m1_368000_182400 n1_m4_368000_182400 15.000000
R14348 n1_m1_368000_187200 n1_m4_368000_187200 15.000000
R14349 n1_m1_368000_192000 n1_m4_368000_192000 15.000000
R14350 n1_m1_368000_196800 n1_m4_368000_196800 15.000000
R14351 n1_m1_396000_0 n1_m4_396000_0 15.000000
R14352 n1_m1_424000_0 n1_m4_424000_0 15.000000
R14353 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R14354 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R14355 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R14356 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R14357 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R14358 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R14359 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R14360 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R14361 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R14362 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R14363 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R14364 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R14365 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R14366 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R14367 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R14368 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R14369 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R14370 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R14371 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R14372 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R14373 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R14374 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R14375 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R14376 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R14377 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R14378 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R14379 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R14380 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R14381 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R14382 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R14383 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R14384 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R14385 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R14386 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R14387 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R14388 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R14389 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R14390 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R14391 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R14392 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R14393 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R14394 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R14395 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R14396 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R14397 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R14398 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R14399 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R14400 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R14401 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R14402 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R14403 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R14404 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R14405 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R14406 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R14407 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R14408 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R14409 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R14410 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R14411 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R14412 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R14413 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R14414 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R14415 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R14416 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R14417 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R14418 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R14419 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R14420 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R14421 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R14422 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R14423 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R14424 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R14425 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R14426 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R14427 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R14428 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R14429 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R14430 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R14431 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R14432 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R14433 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R14434 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R14435 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R14436 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R14437 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R14438 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R14439 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R14440 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R14441 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R14442 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R14443 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R14444 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R14445 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R14446 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R14447 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R14448 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R14449 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R14450 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R14451 n1_m1_424000_475200 n1_m4_424000_475200 15.000000
R14452 n1_m1_424000_480000 n1_m4_424000_480000 15.000000
R14453 n1_m1_452000_0 n1_m4_452000_0 15.000000
R14454 n1_m1_480000_0 n1_m4_480000_0 15.000000
R14455 n1_m1_480000_4800 n1_m4_480000_4800 15.000000
R14456 n1_m1_480000_9600 n1_m4_480000_9600 15.000000
R14457 n1_m1_480000_14400 n1_m4_480000_14400 15.000000
R14458 n1_m1_480000_19200 n1_m4_480000_19200 15.000000
R14459 n1_m1_480000_24000 n1_m4_480000_24000 15.000000
R14460 n1_m1_480000_28800 n1_m4_480000_28800 15.000000
R14461 n1_m1_480000_33600 n1_m4_480000_33600 15.000000
R14462 n1_m1_480000_38400 n1_m4_480000_38400 15.000000
R14463 n1_m1_480000_43200 n1_m4_480000_43200 15.000000
R14464 n1_m1_480000_48000 n1_m4_480000_48000 15.000000
R14465 n1_m1_480000_52800 n1_m4_480000_52800 15.000000
R14466 n1_m1_480000_57600 n1_m4_480000_57600 15.000000
R14467 n1_m1_480000_62400 n1_m4_480000_62400 15.000000
R14468 n1_m1_480000_67200 n1_m4_480000_67200 15.000000
R14469 n1_m1_480000_72000 n1_m4_480000_72000 15.000000
R14470 n1_m1_480000_76800 n1_m4_480000_76800 15.000000
R14471 n1_m1_480000_81600 n1_m4_480000_81600 15.000000
R14472 n1_m1_480000_86400 n1_m4_480000_86400 15.000000
R14473 n1_m1_480000_91200 n1_m4_480000_91200 15.000000
R14474 n1_m1_480000_96000 n1_m4_480000_96000 15.000000
R14475 n1_m1_480000_100800 n1_m4_480000_100800 15.000000
R14476 n1_m1_480000_105600 n1_m4_480000_105600 15.000000
R14477 n1_m1_480000_110400 n1_m4_480000_110400 15.000000
R14478 n1_m1_480000_115200 n1_m4_480000_115200 15.000000
R14479 n1_m1_480000_120000 n1_m4_480000_120000 15.000000
R14480 n1_m1_480000_124800 n1_m4_480000_124800 15.000000
R14481 n1_m1_480000_129600 n1_m4_480000_129600 15.000000
R14482 n1_m1_480000_134400 n1_m4_480000_134400 15.000000
R14483 n1_m1_480000_139200 n1_m4_480000_139200 15.000000
R14484 n1_m1_480000_144000 n1_m4_480000_144000 15.000000
R14485 n1_m1_480000_148800 n1_m4_480000_148800 15.000000
R14486 n1_m1_480000_153600 n1_m4_480000_153600 15.000000
R14487 n1_m1_480000_158400 n1_m4_480000_158400 15.000000
R14488 n1_m1_480000_163200 n1_m4_480000_163200 15.000000
R14489 n1_m1_480000_168000 n1_m4_480000_168000 15.000000
R14490 n1_m1_480000_172800 n1_m4_480000_172800 15.000000
R14491 n1_m1_480000_177600 n1_m4_480000_177600 15.000000
R14492 n1_m1_480000_182400 n1_m4_480000_182400 15.000000
R14493 n1_m1_480000_187200 n1_m4_480000_187200 15.000000
R14494 n1_m1_480000_192000 n1_m4_480000_192000 15.000000
R14495 n1_m1_480000_196800 n1_m4_480000_196800 15.000000
R14496 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R14497 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R14498 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R14499 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R14500 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R14501 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R14502 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R14503 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R14504 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R14505 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R14506 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R14507 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R14508 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R14509 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R14510 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R14511 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R14512 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R14513 n1_m4_88000_404000 n1_m7_88000_404000 9.000000
R14514 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R14515 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R14516 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R14517 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R14518 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R14519 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R14520 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R14521 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R14522 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R14523 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R14524 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R14525 n1_m4_172000_404000 n1_m7_172000_404000 9.000000
R14526 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R14527 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R14528 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R14529 n1_m4_284000_4000 n1_m7_284000_4000 9.000000
R14530 n1_m4_284000_84000 n1_m7_284000_84000 9.000000
R14531 n1_m4_284000_164000 n1_m7_284000_164000 9.000000
R14532 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R14533 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R14534 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R14535 n1_m4_368000_4000 n1_m7_368000_4000 9.000000
R14536 n1_m4_368000_84000 n1_m7_368000_84000 9.000000
R14537 n1_m4_368000_164000 n1_m7_368000_164000 9.000000
R14538 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R14539 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R14540 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R14541 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R14542 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R14543 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R14544 n1_m4_480000_4000 n1_m7_480000_4000 9.000000
R14545 n1_m4_480000_84000 n1_m7_480000_84000 9.000000
R14546 n1_m4_480000_164000 n1_m7_480000_164000 9.000000
R14547 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R14548 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R14549 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R14550 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R14551 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R14552 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R14553 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R14554 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R14555 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R14556 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R14557 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R14558 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R14559 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R14560 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R14561 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R14562 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R14563 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R14564 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R14565 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R14566 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R14567 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R14568 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R14569 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R14570 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R14571 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R14572 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R14573 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R14574 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R14575 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R14576 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R14577 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R14578 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R14579 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R14580 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R14581 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R14582 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R14583 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R14584 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R14585 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R14586 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R14587 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R14588 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R14589 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R14590 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R14591 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R14592 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R14593 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R14594 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R14595 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R14596 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R14597 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R14598 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R14599 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R14600 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R14601 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R14602 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R14603 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R14604 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R14605 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R14606 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R14607 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R14608 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R14609 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R14610 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R14611 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R14612 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R14613 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R14614 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R14615 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R14616 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R14617 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R14618 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R14619 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R14620 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R14621 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R14622 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R14623 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R14624 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R14625 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R14626 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R14627 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R14628 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R14629 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R14630 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R14631 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R14632 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R14633 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R14634 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R14635 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R14636 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R14637 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R14638 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R14639 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R14640 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R14641 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R14642 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R14643 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R14644 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R14645 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R14646 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R14647 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R14648 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R14649 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R14650 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R14651 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R14652 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R14653 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R14654 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R14655 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R14656 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R14657 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R14658 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R14659 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R14660 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R14661 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R14662 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R14663 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R14664 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R14665 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R14666 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R14667 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R14668 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R14669 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R14670 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R14671 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R14672 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R14673 n1_m7_474400_4000 n1_m8_474400_4000 1.000000
R14674 n1_m7_474400_84000 n1_m8_474400_84000 1.000000
R14675 n1_m7_474400_164000 n1_m8_474400_164000 1.000000
R14676 n1_m7_474400_244000 n1_m8_474400_244000 1.000000
R14677 n1_m7_474400_324000 n1_m8_474400_324000 1.000000
R14678 n1_m7_474400_404000 n1_m8_474400_404000 1.000000
R14679 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R14680 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R14681 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R14682 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R14683 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R14684 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R14685 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R14686 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R14687 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R14688 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R14689 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R14690 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R14691 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R14692 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R14693 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R14694 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R14695 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R14696 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R14697 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R14698 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R14699 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R14700 n1_m8_4000_474400 n1_m9_4000_474400 1.000000
R14701 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R14702 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R14703 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R14704 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R14705 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R14706 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R14707 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R14708 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R14709 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R14710 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R14711 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R14712 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R14713 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R14714 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R14715 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R14716 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R14717 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R14718 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R14719 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R14720 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R14721 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R14722 n1_m8_26400_474400 n1_m9_26400_474400 1.000000
R14723 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R14724 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R14725 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R14726 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R14727 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R14728 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R14729 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R14730 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R14731 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R14732 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R14733 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R14734 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R14735 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R14736 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R14737 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R14738 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R14739 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R14740 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R14741 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R14742 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R14743 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R14744 n1_m8_48800_474400 n1_m9_48800_474400 1.000000
R14745 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R14746 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R14747 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R14748 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R14749 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R14750 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R14751 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R14752 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R14753 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R14754 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R14755 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R14756 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R14757 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R14758 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R14759 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R14760 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R14761 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R14762 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R14763 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R14764 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R14765 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R14766 n1_m8_71200_474400 n1_m9_71200_474400 1.000000
R14767 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R14768 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R14769 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R14770 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R14771 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R14772 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R14773 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R14774 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R14775 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R14776 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R14777 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R14778 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R14779 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R14780 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R14781 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R14782 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R14783 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R14784 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R14785 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R14786 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R14787 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R14788 n1_m8_93600_474400 n1_m9_93600_474400 1.000000
R14789 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R14790 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R14791 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R14792 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R14793 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R14794 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R14795 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R14796 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R14797 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R14798 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R14799 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R14800 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R14801 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R14802 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R14803 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R14804 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R14805 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R14806 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R14807 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R14808 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R14809 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R14810 n1_m8_116000_474400 n1_m9_116000_474400 1.000000
R14811 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R14812 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R14813 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R14814 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R14815 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R14816 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R14817 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R14818 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R14819 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R14820 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R14821 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R14822 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R14823 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R14824 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R14825 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R14826 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R14827 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R14828 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R14829 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R14830 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R14831 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R14832 n1_m8_138400_474400 n1_m9_138400_474400 1.000000
R14833 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R14834 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R14835 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R14836 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R14837 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R14838 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R14839 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R14840 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R14841 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R14842 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R14843 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R14844 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R14845 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R14846 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R14847 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R14848 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R14849 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R14850 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R14851 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R14852 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R14853 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R14854 n1_m8_160800_474400 n1_m9_160800_474400 1.000000
R14855 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R14856 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R14857 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R14858 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R14859 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R14860 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R14861 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R14862 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R14863 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R14864 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R14865 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R14866 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R14867 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R14868 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R14869 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R14870 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R14871 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R14872 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R14873 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R14874 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R14875 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R14876 n1_m8_183200_474400 n1_m9_183200_474400 1.000000
R14877 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R14878 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R14879 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R14880 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R14881 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R14882 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R14883 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R14884 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R14885 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R14886 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R14887 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R14888 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R14889 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R14890 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R14891 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R14892 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R14893 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R14894 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R14895 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R14896 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R14897 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R14898 n1_m8_205600_474400 n1_m9_205600_474400 1.000000
R14899 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R14900 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R14901 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R14902 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R14903 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R14904 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R14905 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R14906 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R14907 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R14908 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R14909 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R14910 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R14911 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R14912 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R14913 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R14914 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R14915 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R14916 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R14917 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R14918 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R14919 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R14920 n1_m8_228000_474400 n1_m9_228000_474400 1.000000
R14921 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R14922 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R14923 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R14924 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R14925 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R14926 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R14927 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R14928 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R14929 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R14930 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R14931 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R14932 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R14933 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R14934 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R14935 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R14936 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R14937 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R14938 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R14939 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R14940 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R14941 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R14942 n1_m8_250400_474400 n1_m9_250400_474400 1.000000
R14943 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R14944 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R14945 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R14946 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R14947 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R14948 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R14949 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R14950 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R14951 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R14952 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R14953 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R14954 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R14955 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R14956 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R14957 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R14958 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R14959 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R14960 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R14961 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R14962 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R14963 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R14964 n1_m8_272800_474400 n1_m9_272800_474400 1.000000
R14965 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R14966 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R14967 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R14968 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R14969 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R14970 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R14971 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R14972 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R14973 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R14974 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R14975 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R14976 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R14977 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R14978 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R14979 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R14980 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R14981 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R14982 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R14983 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R14984 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R14985 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R14986 n1_m8_295200_474400 n1_m9_295200_474400 1.000000
R14987 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R14988 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R14989 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R14990 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R14991 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R14992 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R14993 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R14994 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R14995 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R14996 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R14997 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R14998 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R14999 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R15000 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R15001 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R15002 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R15003 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R15004 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R15005 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R15006 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R15007 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R15008 n1_m8_317600_474400 n1_m9_317600_474400 1.000000
R15009 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R15010 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R15011 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R15012 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R15013 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R15014 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R15015 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R15016 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R15017 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R15018 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R15019 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R15020 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R15021 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R15022 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R15023 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R15024 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R15025 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R15026 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R15027 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R15028 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R15029 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R15030 n1_m8_340000_474400 n1_m9_340000_474400 1.000000
R15031 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R15032 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R15033 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R15034 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R15035 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R15036 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R15037 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R15038 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R15039 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R15040 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R15041 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R15042 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R15043 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R15044 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R15045 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R15046 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R15047 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R15048 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R15049 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R15050 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R15051 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R15052 n1_m8_362400_474400 n1_m9_362400_474400 1.000000
R15053 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R15054 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R15055 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R15056 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R15057 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R15058 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R15059 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R15060 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R15061 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R15062 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R15063 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R15064 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R15065 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R15066 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R15067 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R15068 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R15069 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R15070 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R15071 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R15072 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R15073 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R15074 n1_m8_384800_474400 n1_m9_384800_474400 1.000000
R15075 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R15076 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R15077 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R15078 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R15079 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R15080 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R15081 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R15082 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R15083 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R15084 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R15085 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R15086 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R15087 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R15088 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R15089 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R15090 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R15091 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R15092 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R15093 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R15094 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R15095 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R15096 n1_m8_407200_474400 n1_m9_407200_474400 1.000000
R15097 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R15098 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R15099 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R15100 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R15101 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R15102 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R15103 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R15104 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R15105 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R15106 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R15107 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R15108 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R15109 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R15110 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R15111 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R15112 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R15113 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R15114 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R15115 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R15116 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R15117 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R15118 n1_m8_429600_474400 n1_m9_429600_474400 1.000000
R15119 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R15120 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R15121 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R15122 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R15123 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R15124 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R15125 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R15126 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R15127 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R15128 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R15129 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R15130 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R15131 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R15132 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R15133 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R15134 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R15135 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R15136 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R15137 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R15138 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R15139 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
R15140 n1_m8_452000_474400 n1_m9_452000_474400 1.000000
R15141 n1_m8_474400_4000 n1_m9_474400_4000 1.000000
R15142 n1_m8_474400_26400 n1_m9_474400_26400 1.000000
R15143 n1_m8_474400_48800 n1_m9_474400_48800 1.000000
R15144 n1_m8_474400_71200 n1_m9_474400_71200 1.000000
R15145 n1_m8_474400_93600 n1_m9_474400_93600 1.000000
R15146 n1_m8_474400_116000 n1_m9_474400_116000 1.000000
R15147 n1_m8_474400_138400 n1_m9_474400_138400 1.000000
R15148 n1_m8_474400_160800 n1_m9_474400_160800 1.000000
R15149 n1_m8_474400_183200 n1_m9_474400_183200 1.000000
R15150 n1_m8_474400_205600 n1_m9_474400_205600 1.000000
R15151 n1_m8_474400_228000 n1_m9_474400_228000 1.000000
R15152 n1_m8_474400_250400 n1_m9_474400_250400 1.000000
R15153 n1_m8_474400_272800 n1_m9_474400_272800 1.000000
R15154 n1_m8_474400_295200 n1_m9_474400_295200 1.000000
R15155 n1_m8_474400_317600 n1_m9_474400_317600 1.000000
R15156 n1_m8_474400_340000 n1_m9_474400_340000 1.000000
R15157 n1_m8_474400_362400 n1_m9_474400_362400 1.000000
R15158 n1_m8_474400_384800 n1_m9_474400_384800 1.000000
R15159 n1_m8_474400_407200 n1_m9_474400_407200 1.000000
R15160 n1_m8_474400_429600 n1_m9_474400_429600 1.000000
R15161 n1_m8_474400_452000 n1_m9_474400_452000 1.000000
R15162 n1_m8_474400_474400 n1_m9_474400_474400 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_452000_48800 0 1.100000
V2 n1_m9_250400_340000 0 1.100000
V3 n1_m9_452000_340000 0 1.100000
R15163 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R15164 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R15165 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R15166 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R15167 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R15168 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R15169 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R15170 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R15171 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R15172 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R15173 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R15174 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R15175 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R15176 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R15177 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R15178 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R15179 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R15180 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R15181 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R15182 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R15183 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R15184 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R15185 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R15186 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R15187 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R15188 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R15189 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R15190 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R15191 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R15192 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R15193 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R15194 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R15195 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R15196 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R15197 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R15198 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R15199 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R15200 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R15201 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R15202 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R15203 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R15204 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R15205 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R15206 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R15207 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R15208 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R15209 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R15210 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R15211 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R15212 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R15213 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R15214 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R15215 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R15216 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R15217 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R15218 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R15219 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R15220 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R15221 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R15222 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R15223 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R15224 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R15225 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R15226 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R15227 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R15228 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R15229 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R15230 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R15231 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R15232 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R15233 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R15234 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R15235 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R15236 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R15237 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R15238 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R15239 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R15240 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R15241 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R15242 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R15243 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R15244 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R15245 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R15246 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R15247 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R15248 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R15249 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R15250 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R15251 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R15252 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R15253 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R15254 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R15255 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R15256 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R15257 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R15258 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R15259 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R15260 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R15261 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R15262 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R15263 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R15264 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R15265 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R15266 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R15267 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R15268 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R15269 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R15270 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R15271 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R15272 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R15273 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R15274 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R15275 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R15276 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R15277 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R15278 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R15279 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R15280 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R15281 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R15282 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
R15283 n1_m4_200000_470400 n1_m4_200000_475200 1.400000
R15284 n1_m1_200000_475200 n1_m4_200000_475200 15.000000
R15285 n1_m4_200000_475200 n1_m4_200000_480000 1.400000
R15286 n1_m1_200000_480000 n1_m4_200000_480000 15.000000
I0 n1_m1_0_0 0 1.781952e-07
I1 n1_m1_0_4800 0 1.620390e-07
I2 n1_m1_0_9600 0 2.113471e-07
I3 n1_m1_0_14400 0 1.447767e-07
I4 n1_m1_0_19200 0 1.514663e-07
I5 n1_m1_0_24000 0 2.180716e-07
I6 n1_m1_0_28800 0 1.360160e-07
I7 n1_m1_0_33600 0 2.025599e-07
I8 n1_m1_0_38400 0 1.421889e-07
I9 n1_m1_0_43200 0 1.482543e-07
I10 n1_m1_0_48000 0 2.263469e-07
I11 n1_m1_0_52800 0 1.569434e-07
I12 n1_m1_0_57600 0 2.387426e-07
I13 n1_m1_0_62400 0 1.639227e-07
I14 n1_m1_0_67200 0 1.695271e-07
I15 n1_m1_0_72000 0 2.320544e-07
I16 n1_m1_0_76800 0 1.474745e-07
I17 n1_m1_0_81600 0 2.044120e-07
I18 n1_m1_0_86400 0 1.466939e-07
I19 n1_m1_0_91200 0 1.639342e-07
I20 n1_m1_0_96000 0 2.648776e-07
I21 n1_m1_0_100800 0 1.688744e-07
I22 n1_m1_0_105600 0 2.483390e-07
I23 n1_m1_0_110400 0 1.691219e-07
I24 n1_m1_0_115200 0 1.709020e-07
I25 n1_m1_0_120000 0 2.554287e-07
I26 n1_m1_0_124800 0 1.706425e-07
I27 n1_m1_0_129600 0 2.487054e-07
I28 n1_m1_0_134400 0 1.651759e-07
I29 n1_m1_0_139200 0 1.626043e-07
I30 n1_m1_0_144000 0 2.369222e-07
I31 n1_m1_0_148800 0 1.504901e-07
I32 n1_m1_0_153600 0 2.301726e-07
I33 n1_m1_0_158400 0 1.619137e-07
I34 n1_m1_0_163200 0 1.630799e-07
I35 n1_m1_0_168000 0 2.355350e-07
I36 n1_m1_0_172800 0 1.534727e-07
I37 n1_m1_0_177600 0 2.383977e-07
I38 n1_m1_0_182400 0 1.621892e-07
I39 n1_m1_0_187200 0 1.586252e-07
I40 n1_m1_0_192000 0 2.379428e-07
I41 n1_m1_0_196800 0 1.625448e-07
I42 n1_m1_0_201600 0 2.512560e-07
I43 n1_m1_0_206400 0 1.796725e-07
I44 n1_m1_0_211200 0 1.760097e-07
I45 n1_m1_0_216000 0 2.578218e-07
I46 n1_m1_0_220800 0 1.690064e-07
I47 n1_m1_0_225600 0 2.608871e-07
I48 n1_m1_0_230400 0 2.117407e-07
I49 n1_m1_0_235200 0 2.100410e-07
I50 n1_m1_0_240000 0 2.746246e-07
I51 n1_m1_0_244800 0 1.884962e-07
I52 n1_m1_0_249600 0 2.706427e-07
I53 n1_m1_0_254400 0 2.124025e-07
I54 n1_m1_0_259200 0 1.719488e-07
I55 n1_m1_0_264000 0 2.547715e-07
I56 n1_m1_0_268800 0 1.714883e-07
I57 n1_m1_0_273600 0 2.783710e-07
I58 n1_m1_0_278400 0 1.924326e-07
I59 n1_m1_0_283200 0 1.746633e-07
I60 n1_m1_0_288000 0 2.578570e-07
I61 n1_m1_0_292800 0 1.688895e-07
I62 n1_m1_0_297600 0 2.622596e-07
I63 n1_m1_0_302400 0 1.597602e-07
I64 n1_m1_0_307200 0 1.750538e-07
I65 n1_m1_0_312000 0 2.658241e-07
I66 n1_m1_0_316800 0 1.792086e-07
I67 n1_m1_0_321600 0 3.010764e-07
I68 n1_m1_0_326400 0 1.689322e-07
I69 n1_m1_0_331200 0 1.483425e-07
I70 n1_m1_0_336000 0 2.162701e-07
I71 n1_m1_0_340800 0 1.448317e-07
I72 n1_m1_0_345600 0 2.388232e-07
I73 n1_m1_0_350400 0 1.671655e-07
I74 n1_m1_0_355200 0 1.627510e-07
I75 n1_m1_0_360000 0 2.340557e-07
I76 n1_m1_0_364800 0 1.463734e-07
I77 n1_m1_0_369600 0 2.111264e-07
I78 n1_m1_0_374400 0 1.420527e-07
I79 n1_m1_0_379200 0 1.476626e-07
I80 n1_m1_0_384000 0 2.249491e-07
I81 n1_m1_0_388800 0 1.543569e-07
I82 n1_m1_0_393600 0 2.313785e-07
I83 n1_m1_0_398400 0 1.464284e-07
I84 n1_m1_0_403200 0 1.410616e-07
I85 n1_m1_0_408000 0 2.158574e-07
I86 n1_m1_0_412800 0 1.457264e-07
I87 n1_m1_0_417600 0 2.105855e-07
I88 n1_m1_0_422400 0 1.399040e-07
I89 n1_m1_0_427200 0 1.399040e-07
I90 n1_m1_0_432000 0 2.125315e-07
I91 n1_m1_0_436800 0 1.450679e-07
I92 n1_m1_0_441600 0 2.165456e-07
I93 n1_m1_0_446400 0 1.416659e-07
I94 n1_m1_0_451200 0 1.419316e-07
I95 n1_m1_0_456000 0 2.233062e-07
I96 n1_m1_0_460800 0 1.612943e-07
I97 n1_m1_0_465600 0 2.176501e-07
I98 n1_m1_0_470400 0 1.332419e-07
I99 n1_m1_0_475200 0 1.332419e-07
I100 n1_m1_0_480000 0 1.998628e-07
I101 n1_m1_4800_0 0 8.367535e-08
I102 n1_m1_4800_4800 0 7.781749e-08
I103 n1_m1_4800_9600 0 1.062447e-07
I104 n1_m1_4800_14400 0 7.355833e-08
I105 n1_m1_4800_19200 0 7.597971e-08
I106 n1_m1_4800_24000 0 1.070436e-07
I107 n1_m1_4800_28800 0 6.662094e-08
I108 n1_m1_4800_33600 0 1.023827e-07
I109 n1_m1_4800_38400 0 7.131335e-08
I110 n1_m1_4800_43200 0 7.472832e-08
I111 n1_m1_4800_48000 0 1.186995e-07
I112 n1_m1_4800_52800 0 8.531204e-08
I113 n1_m1_4800_57600 0 1.330393e-07
I114 n1_m1_4800_62400 0 9.444910e-08
I115 n1_m1_4800_67200 0 9.760979e-08
I116 n1_m1_4800_72000 0 1.245013e-07
I117 n1_m1_4800_76800 0 7.863749e-08
I118 n1_m1_4800_81600 0 1.078048e-07
I119 n1_m1_4800_86400 0 7.771415e-08
I120 n1_m1_4800_91200 0 9.003164e-08
I121 n1_m1_4800_96000 0 1.520565e-07
I122 n1_m1_4800_100800 0 9.453271e-08
I123 n1_m1_4800_105600 0 1.342398e-07
I124 n1_m1_4800_110400 0 9.577909e-08
I125 n1_m1_4800_115200 0 9.787303e-08
I126 n1_m1_4800_120000 0 1.398010e-07
I127 n1_m1_4800_124800 0 8.998244e-08
I128 n1_m1_4800_129600 0 1.331524e-07
I129 n1_m1_4800_134400 0 8.876827e-08
I130 n1_m1_4800_139200 0 8.876827e-08
I131 n1_m1_4800_144000 0 1.285135e-07
I132 n1_m1_4800_148800 0 8.045994e-08
I133 n1_m1_4800_153600 0 1.224125e-07
I134 n1_m1_4800_158400 0 8.382648e-08
I135 n1_m1_4800_163200 0 8.520758e-08
I136 n1_m1_4800_168000 0 1.271646e-07
I137 n1_m1_4800_172800 0 8.095126e-08
I138 n1_m1_4800_177600 0 1.183459e-07
I139 n1_m1_4800_182400 0 8.503268e-08
I140 n1_m1_4800_187200 0 8.543723e-08
I141 n1_m1_4800_192000 0 1.281969e-07
I142 n1_m1_4800_196800 0 8.658609e-08
I143 n1_m1_4800_201600 0 1.373369e-07
I144 n1_m1_4800_206400 0 1.021832e-07
I145 n1_m1_4800_211200 0 1.013662e-07
I146 n1_m1_4800_216000 0 1.437545e-07
I147 n1_m1_4800_220800 0 9.125578e-08
I148 n1_m1_4800_225600 0 1.552872e-07
I149 n1_m1_4800_230400 0 1.497556e-07
I150 n1_m1_4800_235200 0 1.389146e-07
I151 n1_m1_4800_240000 0 1.610155e-07
I152 n1_m1_4800_244800 0 1.321499e-07
I153 n1_m1_4800_249600 0 1.972639e-07
I154 n1_m1_4800_254400 0 1.891330e-07
I155 n1_m1_4800_259200 0 1.448246e-07
I156 n1_m1_4800_264000 0 2.310970e-07
I157 n1_m1_4800_268800 0 1.643243e-07
I158 n1_m1_4800_273600 0 2.883269e-07
I159 n1_m1_4800_278400 0 1.879741e-07
I160 n1_m1_4800_283200 0 1.419527e-07
I161 n1_m1_4800_288000 0 1.803834e-07
I162 n1_m1_4800_292800 0 1.181337e-07
I163 n1_m1_4800_297600 0 2.640180e-07
I164 n1_m1_4800_302400 0 1.202397e-07
I165 n1_m1_4800_307200 0 1.317451e-07
I166 n1_m1_4800_312000 0 2.142405e-07
I167 n1_m1_4800_316800 0 1.398163e-07
I168 n1_m1_4800_321600 0 2.096430e-07
I169 n1_m1_4800_326400 0 8.547852e-08
I170 n1_m1_4800_331200 0 7.331938e-08
I171 n1_m1_4800_336000 0 1.167984e-07
I172 n1_m1_4800_340800 0 7.614608e-08
I173 n1_m1_4800_345600 0 1.282427e-07
I174 n1_m1_4800_350400 0 9.917436e-08
I175 n1_m1_4800_355200 0 9.385921e-08
I176 n1_m1_4800_360000 0 1.240333e-07
I177 n1_m1_4800_364800 0 7.680679e-08
I178 n1_m1_4800_369600 0 1.090003e-07
I179 n1_m1_4800_374400 0 7.326754e-08
I180 n1_m1_4800_379200 0 7.660032e-08
I181 n1_m1_4800_384000 0 1.202484e-07
I182 n1_m1_4800_388800 0 8.249927e-08
I183 n1_m1_4800_393600 0 1.212179e-07
I184 n1_m1_4800_398400 0 7.533073e-08
I185 n1_m1_4800_403200 0 7.137185e-08
I186 n1_m1_4800_408000 0 1.069883e-07
I187 n1_m1_4800_412800 0 7.284871e-08
I188 n1_m1_4800_417600 0 1.069196e-07
I189 n1_m1_4800_422400 0 7.112198e-08
I190 n1_m1_4800_427200 0 7.112198e-08
I191 n1_m1_4800_432000 0 1.114176e-07
I192 n1_m1_4800_436800 0 7.661408e-08
I193 n1_m1_4800_441600 0 1.128835e-07
I194 n1_m1_4800_446400 0 7.344983e-08
I195 n1_m1_4800_451200 0 7.378544e-08
I196 n1_m1_4800_456000 0 1.195259e-07
I197 n1_m1_4800_460800 0 8.591962e-08
I198 n1_m1_4800_465600 0 1.148592e-07
I199 n1_m1_4800_470400 0 6.662094e-08
I200 n1_m1_4800_475200 0 6.662094e-08
I201 n1_m1_4800_480000 0 9.993141e-08
I202 n1_m1_9600_0 0 2.338537e-07
I203 n1_m1_9600_4800 0 2.239404e-07
I204 n1_m1_9600_9600 0 3.221986e-07
I205 n1_m1_9600_14400 0 2.267590e-07
I206 n1_m1_9600_19200 0 2.259207e-07
I207 n1_m1_9600_24000 0 3.146259e-07
I208 n1_m1_9600_28800 0 1.998628e-07
I209 n1_m1_9600_33600 0 3.002470e-07
I210 n1_m1_9600_38400 0 2.015682e-07
I211 n1_m1_9600_43200 0 2.078171e-07
I212 n1_m1_9600_48000 0 3.311157e-07
I213 n1_m1_9600_52800 0 2.417023e-07
I214 n1_m1_9600_57600 0 3.905884e-07
I215 n1_m1_9600_62400 0 3.119571e-07
I216 n1_m1_9600_67200 0 3.126578e-07
I217 n1_m1_9600_72000 0 3.667731e-07
I218 n1_m1_9600_76800 0 2.314252e-07
I219 n1_m1_9600_81600 0 3.198913e-07
I220 n1_m1_9600_86400 0 2.293115e-07
I221 n1_m1_9600_91200 0 2.454186e-07
I222 n1_m1_9600_96000 0 3.825244e-07
I223 n1_m1_9600_100800 0 2.529569e-07
I224 n1_m1_9600_105600 0 3.726683e-07
I225 n1_m1_9600_110400 0 2.612906e-07
I226 n1_m1_9600_115200 0 2.606360e-07
I227 n1_m1_9600_120000 0 3.787674e-07
I228 n1_m1_9600_124800 0 2.480645e-07
I229 n1_m1_9600_129600 0 3.683028e-07
I230 n1_m1_9600_134400 0 2.443670e-07
I231 n1_m1_9600_139200 0 2.444041e-07
I232 n1_m1_9600_144000 0 3.554928e-07
I233 n1_m1_9600_148800 0 2.289487e-07
I234 n1_m1_9600_153600 0 3.502658e-07
I235 n1_m1_9600_158400 0 2.315936e-07
I236 n1_m1_9600_163200 0 2.321570e-07
I237 n1_m1_9600_168000 0 3.482348e-07
I238 n1_m1_9600_172800 0 2.287155e-07
I239 n1_m1_9600_177600 0 3.361086e-07
I240 n1_m1_9600_182400 0 2.359333e-07
I241 n1_m1_9600_187200 0 2.367659e-07
I242 n1_m1_9600_192000 0 3.554858e-07
I243 n1_m1_9600_196800 0 2.450771e-07
I244 n1_m1_9600_201600 0 3.877756e-07
I245 n1_m1_9600_206400 0 2.756481e-07
I246 n1_m1_9600_211200 0 2.744359e-07
I247 n1_m1_9600_216000 0 4.057947e-07
I248 n1_m1_9600_220800 0 2.704723e-07
I249 n1_m1_9600_225600 0 4.405266e-07
I250 n1_m1_9600_230400 0 3.524977e-07
I251 n1_m1_9600_235200 0 3.181109e-07
I252 n1_m1_9600_240000 0 4.382385e-07
I253 n1_m1_9600_244800 0 3.692938e-07
I254 n1_m1_9600_249600 0 5.829336e-07
I255 n1_m1_9600_254400 0 5.363913e-07
I256 n1_m1_9600_259200 0 5.141898e-07
I257 n1_m1_9600_264000 0 9.392562e-07
I258 n1_m1_9600_268800 0 7.146713e-07
I259 n1_m1_9600_273600 0 1.115324e-06
I260 n1_m1_9600_278400 0 7.651653e-07
I261 n1_m1_9600_283200 0 6.552612e-07
I262 n1_m1_9600_288000 0 6.870746e-07
I263 n1_m1_9600_292800 0 5.279177e-07
I264 n1_m1_9600_297600 0 9.114960e-07
I265 n1_m1_9600_302400 0 5.062658e-07
I266 n1_m1_9600_307200 0 5.011837e-07
I267 n1_m1_9600_312000 0 6.656590e-07
I268 n1_m1_9600_316800 0 3.882558e-07
I269 n1_m1_9600_321600 0 5.288430e-07
I270 n1_m1_9600_326400 0 2.467935e-07
I271 n1_m1_9600_331200 0 2.195127e-07
I272 n1_m1_9600_336000 0 3.337096e-07
I273 n1_m1_9600_340800 0 2.169213e-07
I274 n1_m1_9600_345600 0 3.550367e-07
I275 n1_m1_9600_350400 0 2.697835e-07
I276 n1_m1_9600_355200 0 2.578643e-07
I277 n1_m1_9600_360000 0 3.469451e-07
I278 n1_m1_9600_364800 0 2.275298e-07
I279 n1_m1_9600_369600 0 3.260448e-07
I280 n1_m1_9600_374400 0 2.163084e-07
I281 n1_m1_9600_379200 0 2.247296e-07
I282 n1_m1_9600_384000 0 3.513010e-07
I283 n1_m1_9600_388800 0 2.378364e-07
I284 n1_m1_9600_393600 0 3.503591e-07
I285 n1_m1_9600_398400 0 2.178418e-07
I286 n1_m1_9600_403200 0 2.101182e-07
I287 n1_m1_9600_408000 0 3.156394e-07
I288 n1_m1_9600_412800 0 2.146046e-07
I289 n1_m1_9600_417600 0 3.224877e-07
I290 n1_m1_9600_422400 0 2.149627e-07
I291 n1_m1_9600_427200 0 2.149627e-07
I292 n1_m1_9600_432000 0 3.306337e-07
I293 n1_m1_9600_436800 0 2.253550e-07
I294 n1_m1_9600_441600 0 3.336134e-07
I295 n1_m1_9600_446400 0 2.193904e-07
I296 n1_m1_9600_451200 0 2.173790e-07
I297 n1_m1_9600_456000 0 3.500432e-07
I298 n1_m1_9600_460800 0 2.462328e-07
I299 n1_m1_9600_465600 0 3.323488e-07
I300 n1_m1_9600_470400 0 1.998628e-07
I301 n1_m1_9600_475200 0 1.998628e-07
I302 n1_m1_9600_480000 0 2.997942e-07
I303 n1_m1_14400_0 0 1.416934e-07
I304 n1_m1_14400_4800 0 1.413791e-07
I305 n1_m1_14400_9600 0 2.144505e-07
I306 n1_m1_14400_14400 0 1.478748e-07
I307 n1_m1_14400_19200 0 1.468123e-07
I308 n1_m1_14400_24000 0 2.087410e-07
I309 n1_m1_14400_28800 0 1.353561e-07
I310 n1_m1_14400_33600 0 2.071719e-07
I311 n1_m1_14400_38400 0 1.381146e-07
I312 n1_m1_14400_43200 0 1.384732e-07
I313 n1_m1_14400_48000 0 2.110871e-07
I314 n1_m1_14400_52800 0 1.507020e-07
I315 n1_m1_14400_57600 0 2.670343e-07
I316 n1_m1_14400_62400 0 2.461304e-07
I317 n1_m1_14400_67200 0 2.276001e-07
I318 n1_m1_14400_72000 0 2.463185e-07
I319 n1_m1_14400_76800 0 1.554856e-07
I320 n1_m1_14400_81600 0 2.142047e-07
I321 n1_m1_14400_86400 0 1.533217e-07
I322 n1_m1_14400_91200 0 1.452529e-07
I323 n1_m1_14400_96000 0 2.153205e-07
I324 n1_m1_14400_100800 0 1.460399e-07
I325 n1_m1_14400_105600 0 2.171069e-07
I326 n1_m1_14400_110400 0 1.541834e-07
I327 n1_m1_14400_115200 0 1.535448e-07
I328 n1_m1_14400_120000 0 2.226296e-07
I329 n1_m1_14400_124800 0 1.483555e-07
I330 n1_m1_14400_129600 0 2.218012e-07
I331 n1_m1_14400_134400 0 1.474016e-07
I332 n1_m1_14400_139200 0 1.448593e-07
I333 n1_m1_14400_144000 0 2.122036e-07
I334 n1_m1_14400_148800 0 1.414343e-07
I335 n1_m1_14400_153600 0 2.197252e-07
I336 n1_m1_14400_158400 0 1.463045e-07
I337 n1_m1_14400_163200 0 1.412116e-07
I338 n1_m1_14400_168000 0 2.098560e-07
I339 n1_m1_14400_172800 0 1.458620e-07
I340 n1_m1_14400_177600 0 2.401755e-07
I341 n1_m1_14400_182400 0 1.521938e-07
I342 n1_m1_14400_187200 0 1.502609e-07
I343 n1_m1_14400_192000 0 2.199120e-07
I344 n1_m1_14400_196800 0 1.481115e-07
I345 n1_m1_14400_201600 0 2.249105e-07
I346 n1_m1_14400_206400 0 1.510544e-07
I347 n1_m1_14400_211200 0 1.509213e-07
I348 n1_m1_14400_216000 0 2.416059e-07
I349 n1_m1_14400_220800 0 1.776464e-07
I350 n1_m1_14400_225600 0 2.555933e-07
I351 n1_m1_14400_230400 0 1.559018e-07
I352 n1_m1_14400_235200 0 1.565394e-07
I353 n1_m1_14400_240000 0 2.384884e-07
I354 n1_m1_14400_244800 0 1.645355e-07
I355 n1_m1_14400_249600 0 2.445915e-07
I356 n1_m1_14400_254400 0 1.824509e-07
I357 n1_m1_14400_259200 0 2.276429e-07
I358 n1_m1_14400_264000 0 5.785210e-07
I359 n1_m1_14400_268800 0 4.842697e-07
I360 n1_m1_14400_273600 0 5.948006e-07
I361 n1_m1_14400_278400 0 4.331081e-07
I362 n1_m1_14400_283200 0 4.238468e-07
I363 n1_m1_14400_288000 0 4.779845e-07
I364 n1_m1_14400_292800 0 4.577175e-07
I365 n1_m1_14400_297600 0 3.266359e-07
I366 n1_m1_14400_302400 0 2.300638e-07
I367 n1_m1_14400_307200 0 2.080349e-07
I368 n1_m1_14400_312000 0 2.496271e-07
I369 n1_m1_14400_316800 0 1.477788e-07
I370 n1_m1_14400_321600 0 2.229542e-07
I371 n1_m1_14400_326400 0 1.492220e-07
I372 n1_m1_14400_331200 0 1.430866e-07
I373 n1_m1_14400_336000 0 2.029194e-07
I374 n1_m1_14400_340800 0 1.391288e-07
I375 n1_m1_14400_345600 0 2.117637e-07
I376 n1_m1_14400_350400 0 1.445402e-07
I377 n1_m1_14400_355200 0 1.441113e-07
I378 n1_m1_14400_360000 0 2.160146e-07
I379 n1_m1_14400_364800 0 1.397388e-07
I380 n1_m1_14400_369600 0 2.025469e-07
I381 n1_m1_14400_374400 0 1.357058e-07
I382 n1_m1_14400_379200 0 1.407987e-07
I383 n1_m1_14400_384000 0 2.135827e-07
I384 n1_m1_14400_388800 0 1.392157e-07
I385 n1_m1_14400_393600 0 2.047911e-07
I386 n1_m1_14400_398400 0 1.350313e-07
I387 n1_m1_14400_403200 0 1.367025e-07
I388 n1_m1_14400_408000 0 2.054665e-07
I389 n1_m1_14400_412800 0 1.350313e-07
I390 n1_m1_14400_417600 0 2.025469e-07
I391 n1_m1_14400_422400 0 1.350313e-07
I392 n1_m1_14400_427200 0 1.383938e-07
I393 n1_m1_14400_432000 0 2.103514e-07
I394 n1_m1_14400_436800 0 1.416934e-07
I395 n1_m1_14400_441600 0 2.111093e-07
I396 n1_m1_14400_446400 0 1.412201e-07
I397 n1_m1_14400_451200 0 1.403772e-07
I398 n1_m1_14400_456000 0 2.135050e-07
I399 n1_m1_14400_460800 0 1.434828e-07
I400 n1_m1_14400_465600 0 2.042840e-07
I401 n1_m1_14400_470400 0 1.332419e-07
I402 n1_m1_14400_475200 0 1.332419e-07
I403 n1_m1_14400_480000 0 1.998628e-07
I404 n1_m1_19200_0 0 1.348248e-07
I405 n1_m1_19200_4800 0 1.348248e-07
I406 n1_m1_19200_9600 0 2.066040e-07
I407 n1_m1_19200_14400 0 1.414388e-07
I408 n1_m1_19200_19200 0 1.414444e-07
I409 n1_m1_19200_24000 0 2.077484e-07
I410 n1_m1_19200_28800 0 1.340300e-07
I411 n1_m1_19200_33600 0 2.070969e-07
I412 n1_m1_19200_38400 0 1.397250e-07
I413 n1_m1_19200_43200 0 1.397609e-07
I414 n1_m1_19200_48000 0 2.133932e-07
I415 n1_m1_19200_52800 0 1.549348e-07
I416 n1_m1_19200_57600 0 2.636500e-07
I417 n1_m1_19200_62400 0 2.094327e-07
I418 n1_m1_19200_67200 0 2.001830e-07
I419 n1_m1_19200_72000 0 2.417714e-07
I420 n1_m1_19200_76800 0 1.575799e-07
I421 n1_m1_19200_81600 0 2.191170e-07
I422 n1_m1_19200_86400 0 1.506055e-07
I423 n1_m1_19200_91200 0 1.435345e-07
I424 n1_m1_19200_96000 0 2.236094e-07
I425 n1_m1_19200_100800 0 1.459718e-07
I426 n1_m1_19200_105600 0 2.162640e-07
I427 n1_m1_19200_110400 0 1.524530e-07
I428 n1_m1_19200_115200 0 1.515764e-07
I429 n1_m1_19200_120000 0 2.160728e-07
I430 n1_m1_19200_124800 0 1.455242e-07
I431 n1_m1_19200_129600 0 2.262235e-07
I432 n1_m1_19200_134400 0 1.490946e-07
I433 n1_m1_19200_139200 0 1.428909e-07
I434 n1_m1_19200_144000 0 2.096212e-07
I435 n1_m1_19200_148800 0 1.402001e-07
I436 n1_m1_19200_153600 0 2.192475e-07
I437 n1_m1_19200_158400 0 1.509925e-07
I438 n1_m1_19200_163200 0 1.457304e-07
I439 n1_m1_19200_168000 0 2.104376e-07
I440 n1_m1_19200_172800 0 1.490460e-07
I441 n1_m1_19200_177600 0 2.577896e-07
I442 n1_m1_19200_182400 0 1.545693e-07
I443 n1_m1_19200_187200 0 1.514388e-07
I444 n1_m1_19200_192000 0 2.194023e-07
I445 n1_m1_19200_196800 0 1.423259e-07
I446 n1_m1_19200_201600 0 2.119620e-07
I447 n1_m1_19200_206400 0 1.413989e-07
I448 n1_m1_19200_211200 0 1.443623e-07
I449 n1_m1_19200_216000 0 2.385188e-07
I450 n1_m1_19200_220800 0 1.798829e-07
I451 n1_m1_19200_225600 0 2.609772e-07
I452 n1_m1_19200_230400 0 1.503886e-07
I453 n1_m1_19200_235200 0 1.497689e-07
I454 n1_m1_19200_240000 0 2.362542e-07
I455 n1_m1_19200_244800 0 1.473851e-07
I456 n1_m1_19200_249600 0 2.158152e-07
I457 n1_m1_19200_254400 0 1.489256e-07
I458 n1_m1_19200_259200 0 1.631748e-07
I459 n1_m1_19200_264000 0 3.313393e-07
I460 n1_m1_19200_268800 0 2.506460e-07
I461 n1_m1_19200_273600 0 3.452164e-07
I462 n1_m1_19200_278400 0 2.256450e-07
I463 n1_m1_19200_283200 0 2.197014e-07
I464 n1_m1_19200_288000 0 3.086446e-07
I465 n1_m1_19200_292800 0 2.292845e-07
I466 n1_m1_19200_297600 0 2.445595e-07
I467 n1_m1_19200_302400 0 1.563434e-07
I468 n1_m1_19200_307200 0 1.524164e-07
I469 n1_m1_19200_312000 0 2.182841e-07
I470 n1_m1_19200_316800 0 1.399757e-07
I471 n1_m1_19200_321600 0 2.101722e-07
I472 n1_m1_19200_326400 0 1.413389e-07
I473 n1_m1_19200_331200 0 1.389998e-07
I474 n1_m1_19200_336000 0 2.045839e-07
I475 n1_m1_19200_340800 0 1.437255e-07
I476 n1_m1_19200_345600 0 2.117370e-07
I477 n1_m1_19200_350400 0 1.348248e-07
I478 n1_m1_19200_355200 0 1.380039e-07
I479 n1_m1_19200_360000 0 2.160053e-07
I480 n1_m1_19200_364800 0 1.380019e-07
I481 n1_m1_19200_369600 0 2.001312e-07
I482 n1_m1_19200_374400 0 1.340953e-07
I483 n1_m1_19200_379200 0 1.391882e-07
I484 n1_m1_19200_384000 0 2.101244e-07
I485 n1_m1_19200_388800 0 1.358159e-07
I486 n1_m1_19200_393600 0 2.001312e-07
I487 n1_m1_19200_398400 0 1.348690e-07
I488 n1_m1_19200_403200 0 1.407235e-07
I489 n1_m1_19200_408000 0 2.109975e-07
I490 n1_m1_19200_412800 0 1.340992e-07
I491 n1_m1_19200_417600 0 2.002340e-07
I492 n1_m1_19200_422400 0 1.365847e-07
I493 n1_m1_19200_427200 0 1.394134e-07
I494 n1_m1_19200_432000 0 2.098560e-07
I495 n1_m1_19200_436800 0 1.399040e-07
I496 n1_m1_19200_441600 0 2.098560e-07
I497 n1_m1_19200_446400 0 1.399040e-07
I498 n1_m1_19200_451200 0 1.399040e-07
I499 n1_m1_19200_456000 0 2.098560e-07
I500 n1_m1_19200_460800 0 1.399040e-07
I501 n1_m1_19200_465600 0 2.016109e-07
I502 n1_m1_19200_470400 0 1.365580e-07
I503 n1_m1_19200_475200 0 1.434002e-07
I504 n1_m1_19200_480000 0 2.107656e-07
I505 n1_m1_24000_0 0 1.998628e-07
I506 n1_m1_24000_4800 0 1.998628e-07
I507 n1_m1_24000_9600 0 3.007306e-07
I508 n1_m1_24000_14400 0 2.057130e-07
I509 n1_m1_24000_19200 0 2.092607e-07
I510 n1_m1_24000_24000 0 3.142612e-07
I511 n1_m1_24000_28800 0 2.058200e-07
I512 n1_m1_24000_33600 0 3.074152e-07
I513 n1_m1_24000_38400 0 2.062634e-07
I514 n1_m1_24000_43200 0 2.069834e-07
I515 n1_m1_24000_48000 0 3.138515e-07
I516 n1_m1_24000_52800 0 2.111081e-07
I517 n1_m1_24000_57600 0 3.361212e-07
I518 n1_m1_24000_62400 0 2.423202e-07
I519 n1_m1_24000_67200 0 2.426916e-07
I520 n1_m1_24000_72000 0 3.346121e-07
I521 n1_m1_24000_76800 0 2.204025e-07
I522 n1_m1_24000_81600 0 3.155684e-07
I523 n1_m1_24000_86400 0 2.112852e-07
I524 n1_m1_24000_91200 0 2.110001e-07
I525 n1_m1_24000_96000 0 3.286732e-07
I526 n1_m1_24000_100800 0 2.145152e-07
I527 n1_m1_24000_105600 0 3.174423e-07
I528 n1_m1_24000_110400 0 2.181927e-07
I529 n1_m1_24000_115200 0 2.165249e-07
I530 n1_m1_24000_120000 0 3.141124e-07
I531 n1_m1_24000_124800 0 2.114811e-07
I532 n1_m1_24000_129600 0 3.321904e-07
I533 n1_m1_24000_134400 0 2.165731e-07
I534 n1_m1_24000_139200 0 2.060019e-07
I535 n1_m1_24000_144000 0 3.034971e-07
I536 n1_m1_24000_148800 0 2.075808e-07
I537 n1_m1_24000_153600 0 3.041764e-07
I538 n1_m1_24000_158400 0 2.087034e-07
I539 n1_m1_24000_163200 0 2.086742e-07
I540 n1_m1_24000_168000 0 3.053222e-07
I541 n1_m1_24000_172800 0 2.065570e-07
I542 n1_m1_24000_177600 0 3.344205e-07
I543 n1_m1_24000_182400 0 2.192788e-07
I544 n1_m1_24000_187200 0 2.169241e-07
I545 n1_m1_24000_192000 0 3.146601e-07
I546 n1_m1_24000_196800 0 2.029142e-07
I547 n1_m1_24000_201600 0 3.040794e-07
I548 n1_m1_24000_206400 0 2.043523e-07
I549 n1_m1_24000_211200 0 2.144263e-07
I550 n1_m1_24000_216000 0 3.322259e-07
I551 n1_m1_24000_220800 0 2.339403e-07
I552 n1_m1_24000_225600 0 3.631739e-07
I553 n1_m1_24000_230400 0 2.235590e-07
I554 n1_m1_24000_235200 0 2.188197e-07
I555 n1_m1_24000_240000 0 3.302726e-07
I556 n1_m1_24000_244800 0 2.239132e-07
I557 n1_m1_24000_249600 0 3.256244e-07
I558 n1_m1_24000_254400 0 2.200577e-07
I559 n1_m1_24000_259200 0 2.146299e-07
I560 n1_m1_24000_264000 0 3.667799e-07
I561 n1_m1_24000_268800 0 2.374100e-07
I562 n1_m1_24000_273600 0 3.949221e-07
I563 n1_m1_24000_278400 0 2.603027e-07
I564 n1_m1_24000_283200 0 2.326501e-07
I565 n1_m1_24000_288000 0 3.592419e-07
I566 n1_m1_24000_292800 0 2.279274e-07
I567 n1_m1_24000_297600 0 3.594984e-07
I568 n1_m1_24000_302400 0 2.065054e-07
I569 n1_m1_24000_307200 0 2.100270e-07
I570 n1_m1_24000_312000 0 3.159756e-07
I571 n1_m1_24000_316800 0 2.097949e-07
I572 n1_m1_24000_321600 0 3.096529e-07
I573 n1_m1_24000_326400 0 2.035023e-07
I574 n1_m1_24000_331200 0 2.083529e-07
I575 n1_m1_24000_336000 0 3.067324e-07
I576 n1_m1_24000_340800 0 2.073058e-07
I577 n1_m1_24000_345600 0 3.032765e-07
I578 n1_m1_24000_350400 0 2.013431e-07
I579 n1_m1_24000_355200 0 2.032699e-07
I580 n1_m1_24000_360000 0 3.119284e-07
I581 n1_m1_24000_364800 0 2.094481e-07
I582 n1_m1_24000_369600 0 3.128798e-07
I583 n1_m1_24000_374400 0 2.113201e-07
I584 n1_m1_24000_379200 0 2.174533e-07
I585 n1_m1_24000_384000 0 3.262287e-07
I586 n1_m1_24000_388800 0 2.111577e-07
I587 n1_m1_24000_393600 0 3.126986e-07
I588 n1_m1_24000_398400 0 2.113150e-07
I589 n1_m1_24000_403200 0 2.180765e-07
I590 n1_m1_24000_408000 0 3.191355e-07
I591 n1_m1_24000_412800 0 2.086582e-07
I592 n1_m1_24000_417600 0 3.176399e-07
I593 n1_m1_24000_422400 0 2.125086e-07
I594 n1_m1_24000_427200 0 2.098560e-07
I595 n1_m1_24000_432000 0 3.140904e-07
I596 n1_m1_24000_436800 0 2.073508e-07
I597 n1_m1_24000_441600 0 3.110262e-07
I598 n1_m1_24000_446400 0 2.073508e-07
I599 n1_m1_24000_451200 0 2.077286e-07
I600 n1_m1_24000_456000 0 3.145717e-07
I601 n1_m1_24000_460800 0 2.098560e-07
I602 n1_m1_24000_465600 0 3.024164e-07
I603 n1_m1_24000_470400 0 2.055695e-07
I604 n1_m1_24000_475200 0 2.173439e-07
I605 n1_m1_24000_480000 0 3.127509e-07
I606 n1_m1_28800_0 0 1.332419e-07
I607 n1_m1_28800_4800 0 1.332419e-07
I608 n1_m1_28800_9600 0 1.998628e-07
I609 n1_m1_28800_14400 0 1.332419e-07
I610 n1_m1_28800_19200 0 1.383210e-07
I611 n1_m1_28800_24000 0 2.098560e-07
I612 n1_m1_28800_28800 0 1.386498e-07
I613 n1_m1_28800_33600 0 2.092604e-07
I614 n1_m1_28800_38400 0 1.407849e-07
I615 n1_m1_28800_43200 0 1.400291e-07
I616 n1_m1_28800_48000 0 2.029252e-07
I617 n1_m1_28800_52800 0 1.333276e-07
I618 n1_m1_28800_57600 0 2.071676e-07
I619 n1_m1_28800_62400 0 1.452807e-07
I620 n1_m1_28800_67200 0 1.442261e-07
I621 n1_m1_28800_72000 0 2.078812e-07
I622 n1_m1_28800_76800 0 1.397875e-07
I623 n1_m1_28800_81600 0 2.029720e-07
I624 n1_m1_28800_86400 0 1.360861e-07
I625 n1_m1_28800_91200 0 1.371926e-07
I626 n1_m1_28800_96000 0 2.088942e-07
I627 n1_m1_28800_100800 0 1.370134e-07
I628 n1_m1_28800_105600 0 2.055201e-07
I629 n1_m1_28800_110400 0 1.370134e-07
I630 n1_m1_28800_115200 0 1.361796e-07
I631 n1_m1_28800_120000 0 2.027460e-07
I632 n1_m1_28800_124800 0 1.373407e-07
I633 n1_m1_28800_129600 0 2.138424e-07
I634 n1_m1_28800_134400 0 1.390238e-07
I635 n1_m1_28800_139200 0 1.350341e-07
I636 n1_m1_28800_144000 0 2.037014e-07
I637 n1_m1_28800_148800 0 1.382795e-07
I638 n1_m1_28800_153600 0 1.999867e-07
I639 n1_m1_28800_158400 0 1.332419e-07
I640 n1_m1_28800_163200 0 1.334990e-07
I641 n1_m1_28800_168000 0 2.031590e-07
I642 n1_m1_28800_172800 0 1.332419e-07
I643 n1_m1_28800_177600 0 2.005563e-07
I644 n1_m1_28800_182400 0 1.368186e-07
I645 n1_m1_28800_187200 0 1.370134e-07
I646 n1_m1_28800_192000 0 2.048357e-07
I647 n1_m1_28800_196800 0 1.361889e-07
I648 n1_m1_28800_201600 0 2.036703e-07
I649 n1_m1_28800_206400 0 1.332419e-07
I650 n1_m1_28800_211200 0 1.375121e-07
I651 n1_m1_28800_216000 0 2.069383e-07
I652 n1_m1_28800_220800 0 1.385963e-07
I653 n1_m1_28800_225600 0 2.182951e-07
I654 n1_m1_28800_230400 0 1.442210e-07
I655 n1_m1_28800_235200 0 1.408231e-07
I656 n1_m1_28800_240000 0 2.089915e-07
I657 n1_m1_28800_244800 0 1.374498e-07
I658 n1_m1_28800_249600 0 2.056672e-07
I659 n1_m1_28800_254400 0 1.450400e-07
I660 n1_m1_28800_259200 0 1.439886e-07
I661 n1_m1_28800_264000 0 2.250373e-07
I662 n1_m1_28800_268800 0 1.412299e-07
I663 n1_m1_28800_273600 0 2.099888e-07
I664 n1_m1_28800_278400 0 1.403881e-07
I665 n1_m1_28800_283200 0 1.407849e-07
I666 n1_m1_28800_288000 0 2.067825e-07
I667 n1_m1_28800_292800 0 1.370134e-07
I668 n1_m1_28800_297600 0 2.055201e-07
I669 n1_m1_28800_302400 0 1.370134e-07
I670 n1_m1_28800_307200 0 1.366004e-07
I671 n1_m1_28800_312000 0 2.003382e-07
I672 n1_m1_28800_316800 0 1.332419e-07
I673 n1_m1_28800_321600 0 1.998628e-07
I674 n1_m1_28800_326400 0 1.342003e-07
I675 n1_m1_28800_331200 0 1.390230e-07
I676 n1_m1_28800_336000 0 2.094988e-07
I677 n1_m1_28800_340800 0 1.338419e-07
I678 n1_m1_28800_345600 0 1.998628e-07
I679 n1_m1_28800_350400 0 1.388866e-07
I680 n1_m1_28800_355200 0 1.409193e-07
I681 n1_m1_28800_360000 0 2.027603e-07
I682 n1_m1_28800_364800 0 1.370134e-07
I683 n1_m1_28800_369600 0 2.060019e-07
I684 n1_m1_28800_374400 0 1.425881e-07
I685 n1_m1_28800_379200 0 1.436755e-07
I686 n1_m1_28800_384000 0 2.133158e-07
I687 n1_m1_28800_388800 0 1.380526e-07
I688 n1_m1_28800_393600 0 2.137797e-07
I689 n1_m1_28800_398400 0 1.397371e-07
I690 n1_m1_28800_403200 0 1.442811e-07
I691 n1_m1_28800_408000 0 2.118985e-07
I692 n1_m1_28800_412800 0 1.378137e-07
I693 n1_m1_28800_417600 0 2.126673e-07
I694 n1_m1_28800_422400 0 1.434171e-07
I695 n1_m1_28800_427200 0 1.399040e-07
I696 n1_m1_28800_432000 0 2.088118e-07
I697 n1_m1_28800_436800 0 1.371000e-07
I698 n1_m1_28800_441600 0 2.056858e-07
I699 n1_m1_28800_446400 0 1.336540e-07
I700 n1_m1_28800_451200 0 1.342467e-07
I701 n1_m1_28800_456000 0 2.092916e-07
I702 n1_m1_28800_460800 0 1.399040e-07
I703 n1_m1_28800_465600 0 2.044119e-07
I704 n1_m1_28800_470400 0 1.344731e-07
I705 n1_m1_28800_475200 0 1.381242e-07
I706 n1_m1_28800_480000 0 2.091297e-07
I707 n1_m1_33600_0 0 1.332419e-07
I708 n1_m1_33600_4800 0 1.332419e-07
I709 n1_m1_33600_9600 0 1.998628e-07
I710 n1_m1_33600_14400 0 1.332419e-07
I711 n1_m1_33600_19200 0 1.339927e-07
I712 n1_m1_33600_24000 0 2.055661e-07
I713 n1_m1_33600_28800 0 1.337016e-07
I714 n1_m1_33600_33600 0 1.998628e-07
I715 n1_m1_33600_38400 0 1.332419e-07
I716 n1_m1_33600_43200 0 1.332419e-07
I717 n1_m1_33600_48000 0 1.998628e-07
I718 n1_m1_33600_52800 0 1.332419e-07
I719 n1_m1_33600_57600 0 2.001615e-07
I720 n1_m1_33600_62400 0 1.340540e-07
I721 n1_m1_33600_67200 0 1.336614e-07
I722 n1_m1_33600_72000 0 1.998628e-07
I723 n1_m1_33600_76800 0 1.332419e-07
I724 n1_m1_33600_81600 0 1.998628e-07
I725 n1_m1_33600_86400 0 1.332419e-07
I726 n1_m1_33600_91200 0 1.332870e-07
I727 n1_m1_33600_96000 0 2.007125e-07
I728 n1_m1_33600_100800 0 1.332419e-07
I729 n1_m1_33600_105600 0 2.000178e-07
I730 n1_m1_33600_110400 0 1.341230e-07
I731 n1_m1_33600_115200 0 1.339817e-07
I732 n1_m1_33600_120000 0 1.998766e-07
I733 n1_m1_33600_124800 0 1.332419e-07
I734 n1_m1_33600_129600 0 1.998628e-07
I735 n1_m1_33600_134400 0 1.332419e-07
I736 n1_m1_33600_139200 0 1.332419e-07
I737 n1_m1_33600_144000 0 2.070755e-07
I738 n1_m1_33600_148800 0 1.384587e-07
I739 n1_m1_33600_153600 0 1.999867e-07
I740 n1_m1_33600_158400 0 1.332419e-07
I741 n1_m1_33600_163200 0 1.332419e-07
I742 n1_m1_33600_168000 0 1.998628e-07
I743 n1_m1_33600_172800 0 1.332419e-07
I744 n1_m1_33600_177600 0 1.998628e-07
I745 n1_m1_33600_182400 0 1.332419e-07
I746 n1_m1_33600_187200 0 1.332419e-07
I747 n1_m1_33600_192000 0 2.043005e-07
I748 n1_m1_33600_196800 0 1.385883e-07
I749 n1_m1_33600_201600 0 2.008424e-07
I750 n1_m1_33600_206400 0 1.332419e-07
I751 n1_m1_33600_211200 0 1.337796e-07
I752 n1_m1_33600_216000 0 2.002200e-07
I753 n1_m1_33600_220800 0 1.336605e-07
I754 n1_m1_33600_225600 0 2.077319e-07
I755 n1_m1_33600_230400 0 1.417466e-07
I756 n1_m1_33600_235200 0 1.405730e-07
I757 n1_m1_33600_240000 0 2.036507e-07
I758 n1_m1_33600_244800 0 1.341916e-07
I759 n1_m1_33600_249600 0 2.024559e-07
I760 n1_m1_33600_254400 0 1.399165e-07
I761 n1_m1_33600_259200 0 1.420002e-07
I762 n1_m1_33600_264000 0 2.133791e-07
I763 n1_m1_33600_268800 0 1.345082e-07
I764 n1_m1_33600_273600 0 2.009585e-07
I765 n1_m1_33600_278400 0 1.336077e-07
I766 n1_m1_33600_283200 0 1.332419e-07
I767 n1_m1_33600_288000 0 1.998628e-07
I768 n1_m1_33600_292800 0 1.332419e-07
I769 n1_m1_33600_297600 0 2.006321e-07
I770 n1_m1_33600_302400 0 1.341916e-07
I771 n1_m1_33600_307200 0 1.341916e-07
I772 n1_m1_33600_312000 0 2.007733e-07
I773 n1_m1_33600_316800 0 1.338110e-07
I774 n1_m1_33600_321600 0 2.012875e-07
I775 n1_m1_33600_326400 0 1.354369e-07
I776 n1_m1_33600_331200 0 1.393368e-07
I777 n1_m1_33600_336000 0 2.087833e-07
I778 n1_m1_33600_340800 0 1.349712e-07
I779 n1_m1_33600_345600 0 2.033933e-07
I780 n1_m1_33600_350400 0 1.460155e-07
I781 n1_m1_33600_355200 0 1.445813e-07
I782 n1_m1_33600_360000 0 2.032420e-07
I783 n1_m1_33600_364800 0 1.341916e-07
I784 n1_m1_33600_369600 0 2.025090e-07
I785 n1_m1_33600_374400 0 1.399214e-07
I786 n1_m1_33600_379200 0 1.408537e-07
I787 n1_m1_33600_384000 0 2.107272e-07
I788 n1_m1_33600_388800 0 1.362453e-07
I789 n1_m1_33600_393600 0 2.057175e-07
I790 n1_m1_33600_398400 0 1.426201e-07
I791 n1_m1_33600_403200 0 1.477745e-07
I792 n1_m1_33600_408000 0 2.158610e-07
I793 n1_m1_33600_412800 0 1.493171e-07
I794 n1_m1_33600_417600 0 2.205438e-07
I795 n1_m1_33600_422400 0 1.451527e-07
I796 n1_m1_33600_427200 0 1.420978e-07
I797 n1_m1_33600_432000 0 2.112629e-07
I798 n1_m1_33600_436800 0 1.401758e-07
I799 n1_m1_33600_441600 0 2.098182e-07
I800 n1_m1_33600_446400 0 1.348902e-07
I801 n1_m1_33600_451200 0 1.343546e-07
I802 n1_m1_33600_456000 0 2.092916e-07
I803 n1_m1_33600_460800 0 1.399040e-07
I804 n1_m1_33600_465600 0 2.083217e-07
I805 n1_m1_33600_470400 0 1.357913e-07
I806 n1_m1_33600_475200 0 1.397689e-07
I807 n1_m1_33600_480000 0 2.159897e-07
I808 n1_m1_38400_0 0 1.332419e-07
I809 n1_m1_38400_4800 0 1.332419e-07
I810 n1_m1_38400_9600 0 1.998628e-07
I811 n1_m1_38400_14400 0 1.332419e-07
I812 n1_m1_38400_19200 0 1.332585e-07
I813 n1_m1_38400_24000 0 2.004298e-07
I814 n1_m1_38400_28800 0 1.332419e-07
I815 n1_m1_38400_33600 0 1.998628e-07
I816 n1_m1_38400_38400 0 1.332419e-07
I817 n1_m1_38400_43200 0 1.332419e-07
I818 n1_m1_38400_48000 0 1.998628e-07
I819 n1_m1_38400_52800 0 1.332419e-07
I820 n1_m1_38400_57600 0 1.998628e-07
I821 n1_m1_38400_62400 0 1.332419e-07
I822 n1_m1_38400_67200 0 1.332419e-07
I823 n1_m1_38400_72000 0 1.998628e-07
I824 n1_m1_38400_76800 0 1.332419e-07
I825 n1_m1_38400_81600 0 1.998628e-07
I826 n1_m1_38400_86400 0 1.341035e-07
I827 n1_m1_38400_91200 0 1.345629e-07
I828 n1_m1_38400_96000 0 2.044615e-07
I829 n1_m1_38400_100800 0 1.332419e-07
I830 n1_m1_38400_105600 0 2.018429e-07
I831 n1_m1_38400_110400 0 1.389302e-07
I832 n1_m1_38400_115200 0 1.379487e-07
I833 n1_m1_38400_120000 0 1.999502e-07
I834 n1_m1_38400_124800 0 1.332419e-07
I835 n1_m1_38400_129600 0 1.998628e-07
I836 n1_m1_38400_134400 0 1.332419e-07
I837 n1_m1_38400_139200 0 1.332419e-07
I838 n1_m1_38400_144000 0 2.070755e-07
I839 n1_m1_38400_148800 0 1.384587e-07
I840 n1_m1_38400_153600 0 1.999867e-07
I841 n1_m1_38400_158400 0 1.332419e-07
I842 n1_m1_38400_163200 0 1.332419e-07
I843 n1_m1_38400_168000 0 1.998628e-07
I844 n1_m1_38400_172800 0 1.332419e-07
I845 n1_m1_38400_177600 0 1.998628e-07
I846 n1_m1_38400_182400 0 1.332419e-07
I847 n1_m1_38400_187200 0 1.332419e-07
I848 n1_m1_38400_192000 0 2.003440e-07
I849 n1_m1_38400_196800 0 1.338216e-07
I850 n1_m1_38400_201600 0 2.004836e-07
I851 n1_m1_38400_206400 0 1.343843e-07
I852 n1_m1_38400_211200 0 1.371584e-07
I853 n1_m1_38400_216000 0 2.034192e-07
I854 n1_m1_38400_220800 0 1.358201e-07
I855 n1_m1_38400_225600 0 2.195273e-07
I856 n1_m1_38400_230400 0 1.516957e-07
I857 n1_m1_38400_235200 0 1.473578e-07
I858 n1_m1_38400_240000 0 2.116178e-07
I859 n1_m1_38400_244800 0 1.397897e-07
I860 n1_m1_38400_249600 0 2.090535e-07
I861 n1_m1_38400_254400 0 1.398848e-07
I862 n1_m1_38400_259200 0 1.400665e-07
I863 n1_m1_38400_264000 0 2.099066e-07
I864 n1_m1_38400_268800 0 1.344394e-07
I865 n1_m1_38400_273600 0 1.998628e-07
I866 n1_m1_38400_278400 0 1.332419e-07
I867 n1_m1_38400_283200 0 1.332419e-07
I868 n1_m1_38400_288000 0 1.998628e-07
I869 n1_m1_38400_292800 0 1.332419e-07
I870 n1_m1_38400_297600 0 2.038906e-07
I871 n1_m1_38400_302400 0 1.390745e-07
I872 n1_m1_38400_307200 0 1.392846e-07
I873 n1_m1_38400_312000 0 2.056558e-07
I874 n1_m1_38400_316800 0 1.368625e-07
I875 n1_m1_38400_321600 0 2.089268e-07
I876 n1_m1_38400_326400 0 1.394420e-07
I877 n1_m1_38400_331200 0 1.395593e-07
I878 n1_m1_38400_336000 0 2.090769e-07
I879 n1_m1_38400_340800 0 1.392627e-07
I880 n1_m1_38400_345600 0 2.050799e-07
I881 n1_m1_38400_350400 0 1.410596e-07
I882 n1_m1_38400_355200 0 1.459805e-07
I883 n1_m1_38400_360000 0 2.122599e-07
I884 n1_m1_38400_364800 0 1.404270e-07
I885 n1_m1_38400_369600 0 2.148566e-07
I886 n1_m1_38400_374400 0 1.458456e-07
I887 n1_m1_38400_379200 0 1.459467e-07
I888 n1_m1_38400_384000 0 2.153993e-07
I889 n1_m1_38400_388800 0 1.395072e-07
I890 n1_m1_38400_393600 0 2.182054e-07
I891 n1_m1_38400_398400 0 1.524323e-07
I892 n1_m1_38400_403200 0 1.564527e-07
I893 n1_m1_38400_408000 0 2.505775e-07
I894 n1_m1_38400_412800 0 1.668640e-07
I895 n1_m1_38400_417600 0 2.814616e-07
I896 n1_m1_38400_422400 0 1.721394e-07
I897 n1_m1_38400_427200 0 1.594942e-07
I898 n1_m1_38400_432000 0 2.236112e-07
I899 n1_m1_38400_436800 0 1.406640e-07
I900 n1_m1_38400_441600 0 2.096922e-07
I901 n1_m1_38400_446400 0 1.377959e-07
I902 n1_m1_38400_451200 0 1.348035e-07
I903 n1_m1_38400_456000 0 2.092916e-07
I904 n1_m1_38400_460800 0 1.399040e-07
I905 n1_m1_38400_465600 0 2.096896e-07
I906 n1_m1_38400_470400 0 1.398597e-07
I907 n1_m1_38400_475200 0 1.429296e-07
I908 n1_m1_38400_480000 0 2.184888e-07
I909 n1_m1_43200_0 0 1.332419e-07
I910 n1_m1_43200_4800 0 1.332419e-07
I911 n1_m1_43200_9600 0 1.998628e-07
I912 n1_m1_43200_14400 0 1.332419e-07
I913 n1_m1_43200_19200 0 1.332419e-07
I914 n1_m1_43200_24000 0 1.998628e-07
I915 n1_m1_43200_28800 0 1.332419e-07
I916 n1_m1_43200_33600 0 1.998628e-07
I917 n1_m1_43200_38400 0 1.332419e-07
I918 n1_m1_43200_43200 0 1.332419e-07
I919 n1_m1_43200_48000 0 1.998628e-07
I920 n1_m1_43200_52800 0 1.332419e-07
I921 n1_m1_43200_57600 0 1.998628e-07
I922 n1_m1_43200_62400 0 1.332419e-07
I923 n1_m1_43200_67200 0 1.332419e-07
I924 n1_m1_43200_72000 0 1.998628e-07
I925 n1_m1_43200_76800 0 1.332419e-07
I926 n1_m1_43200_81600 0 1.998628e-07
I927 n1_m1_43200_86400 0 1.369373e-07
I928 n1_m1_43200_91200 0 1.379295e-07
I929 n1_m1_43200_96000 0 2.011659e-07
I930 n1_m1_43200_100800 0 1.332419e-07
I931 n1_m1_43200_105600 0 2.049947e-07
I932 n1_m1_43200_110400 0 1.385379e-07
I933 n1_m1_43200_115200 0 1.373912e-07
I934 n1_m1_43200_120000 0 1.999399e-07
I935 n1_m1_43200_124800 0 1.332419e-07
I936 n1_m1_43200_129600 0 1.998628e-07
I937 n1_m1_43200_134400 0 1.332419e-07
I938 n1_m1_43200_139200 0 1.332419e-07
I939 n1_m1_43200_144000 0 2.070755e-07
I940 n1_m1_43200_148800 0 1.384587e-07
I941 n1_m1_43200_153600 0 1.999867e-07
I942 n1_m1_43200_158400 0 1.332419e-07
I943 n1_m1_43200_163200 0 1.332419e-07
I944 n1_m1_43200_168000 0 1.998628e-07
I945 n1_m1_43200_172800 0 1.332419e-07
I946 n1_m1_43200_177600 0 2.012973e-07
I947 n1_m1_43200_182400 0 1.342929e-07
I948 n1_m1_43200_187200 0 1.332722e-07
I949 n1_m1_43200_192000 0 1.998628e-07
I950 n1_m1_43200_196800 0 1.332419e-07
I951 n1_m1_43200_201600 0 2.026713e-07
I952 n1_m1_43200_206400 0 1.394773e-07
I953 n1_m1_43200_211200 0 1.397188e-07
I954 n1_m1_43200_216000 0 2.117129e-07
I955 n1_m1_43200_220800 0 1.459761e-07
I956 n1_m1_43200_225600 0 2.275457e-07
I957 n1_m1_43200_230400 0 1.522205e-07
I958 n1_m1_43200_235200 0 1.522873e-07
I959 n1_m1_43200_240000 0 2.217974e-07
I960 n1_m1_43200_244800 0 1.420706e-07
I961 n1_m1_43200_249600 0 2.083663e-07
I962 n1_m1_43200_254400 0 1.388805e-07
I963 n1_m1_43200_259200 0 1.399012e-07
I964 n1_m1_43200_264000 0 2.094843e-07
I965 n1_m1_43200_268800 0 1.344394e-07
I966 n1_m1_43200_273600 0 1.998628e-07
I967 n1_m1_43200_278400 0 1.332419e-07
I968 n1_m1_43200_283200 0 1.332419e-07
I969 n1_m1_43200_288000 0 1.998628e-07
I970 n1_m1_43200_292800 0 1.332419e-07
I971 n1_m1_43200_297600 0 2.004615e-07
I972 n1_m1_43200_302400 0 1.376677e-07
I973 n1_m1_43200_307200 0 1.385688e-07
I974 n1_m1_43200_312000 0 2.049696e-07
I975 n1_m1_43200_316800 0 1.364336e-07
I976 n1_m1_43200_321600 0 2.078532e-07
I977 n1_m1_43200_326400 0 1.385688e-07
I978 n1_m1_43200_331200 0 1.370906e-07
I979 n1_m1_43200_336000 0 2.058622e-07
I980 n1_m1_43200_340800 0 1.392469e-07
I981 n1_m1_43200_345600 0 2.010871e-07
I982 n1_m1_43200_350400 0 1.366418e-07
I983 n1_m1_43200_355200 0 1.439070e-07
I984 n1_m1_43200_360000 0 2.183908e-07
I985 n1_m1_43200_364800 0 1.470828e-07
I986 n1_m1_43200_369600 0 2.194757e-07
I987 n1_m1_43200_374400 0 1.455840e-07
I988 n1_m1_43200_379200 0 1.463868e-07
I989 n1_m1_43200_384000 0 2.159675e-07
I990 n1_m1_43200_388800 0 1.407591e-07
I991 n1_m1_43200_393600 0 2.311033e-07
I992 n1_m1_43200_398400 0 1.919751e-07
I993 n1_m1_43200_403200 0 1.980017e-07
I994 n1_m1_43200_408000 0 3.800839e-07
I995 n1_m1_43200_412800 0 2.581667e-07
I996 n1_m1_43200_417600 0 5.074791e-07
I997 n1_m1_43200_422400 0 2.442825e-07
I998 n1_m1_43200_427200 0 1.890221e-07
I999 n1_m1_43200_432000 0 2.462870e-07
I1000 n1_m1_43200_436800 0 1.440523e-07
I1001 n1_m1_43200_441600 0 2.092762e-07
I1002 n1_m1_43200_446400 0 1.346683e-07
I1003 n1_m1_43200_451200 0 1.352773e-07
I1004 n1_m1_43200_456000 0 2.094047e-07
I1005 n1_m1_43200_460800 0 1.399040e-07
I1006 n1_m1_43200_465600 0 2.102146e-07
I1007 n1_m1_43200_470400 0 1.432747e-07
I1008 n1_m1_43200_475200 0 1.471254e-07
I1009 n1_m1_43200_480000 0 2.147088e-07
I1010 n1_m1_48000_0 0 2.034064e-07
I1011 n1_m1_48000_4800 0 2.002908e-07
I1012 n1_m1_48000_9600 0 2.997942e-07
I1013 n1_m1_48000_14400 0 1.998628e-07
I1014 n1_m1_48000_19200 0 1.998628e-07
I1015 n1_m1_48000_24000 0 2.997942e-07
I1016 n1_m1_48000_28800 0 1.998628e-07
I1017 n1_m1_48000_33600 0 2.997942e-07
I1018 n1_m1_48000_38400 0 1.998628e-07
I1019 n1_m1_48000_43200 0 1.998628e-07
I1020 n1_m1_48000_48000 0 2.997942e-07
I1021 n1_m1_48000_52800 0 1.998628e-07
I1022 n1_m1_48000_57600 0 2.997942e-07
I1023 n1_m1_48000_62400 0 1.998628e-07
I1024 n1_m1_48000_67200 0 1.998628e-07
I1025 n1_m1_48000_72000 0 2.997942e-07
I1026 n1_m1_48000_76800 0 1.998628e-07
I1027 n1_m1_48000_81600 0 2.997942e-07
I1028 n1_m1_48000_86400 0 2.000393e-07
I1029 n1_m1_48000_91200 0 2.000857e-07
I1030 n1_m1_48000_96000 0 2.998382e-07
I1031 n1_m1_48000_100800 0 1.998628e-07
I1032 n1_m1_48000_105600 0 3.000360e-07
I1033 n1_m1_48000_110400 0 2.000968e-07
I1034 n1_m1_48000_115200 0 2.000451e-07
I1035 n1_m1_48000_120000 0 2.997976e-07
I1036 n1_m1_48000_124800 0 1.998628e-07
I1037 n1_m1_48000_129600 0 2.997942e-07
I1038 n1_m1_48000_134400 0 1.998628e-07
I1039 n1_m1_48000_139200 0 1.998628e-07
I1040 n1_m1_48000_144000 0 3.106133e-07
I1041 n1_m1_48000_148800 0 2.076880e-07
I1042 n1_m1_48000_153600 0 2.999801e-07
I1043 n1_m1_48000_158400 0 1.998628e-07
I1044 n1_m1_48000_163200 0 2.001913e-07
I1045 n1_m1_48000_168000 0 3.062144e-07
I1046 n1_m1_48000_172800 0 2.046805e-07
I1047 n1_m1_48000_177600 0 3.123297e-07
I1048 n1_m1_48000_182400 0 2.085704e-07
I1049 n1_m1_48000_187200 0 2.036282e-07
I1050 n1_m1_48000_192000 0 2.997942e-07
I1051 n1_m1_48000_196800 0 1.998628e-07
I1052 n1_m1_48000_201600 0 3.042953e-07
I1053 n1_m1_48000_206400 0 2.123046e-07
I1054 n1_m1_48000_211200 0 2.146736e-07
I1055 n1_m1_48000_216000 0 3.553335e-07
I1056 n1_m1_48000_220800 0 2.662876e-07
I1057 n1_m1_48000_225600 0 3.726900e-07
I1058 n1_m1_48000_230400 0 2.233608e-07
I1059 n1_m1_48000_235200 0 2.250030e-07
I1060 n1_m1_48000_240000 0 3.381975e-07
I1061 n1_m1_48000_244800 0 2.072719e-07
I1062 n1_m1_48000_249600 0 3.020442e-07
I1063 n1_m1_48000_254400 0 2.012505e-07
I1064 n1_m1_48000_259200 0 2.062923e-07
I1065 n1_m1_48000_264000 0 3.144952e-07
I1066 n1_m1_48000_268800 0 2.052027e-07
I1067 n1_m1_48000_273600 0 3.005209e-07
I1068 n1_m1_48000_278400 0 1.998628e-07
I1069 n1_m1_48000_283200 0 1.998628e-07
I1070 n1_m1_48000_288000 0 2.997942e-07
I1071 n1_m1_48000_292800 0 1.998628e-07
I1072 n1_m1_48000_297600 0 2.998063e-07
I1073 n1_m1_48000_302400 0 2.000538e-07
I1074 n1_m1_48000_307200 0 2.000968e-07
I1075 n1_m1_48000_312000 0 3.000186e-07
I1076 n1_m1_48000_316800 0 2.000030e-07
I1077 n1_m1_48000_321600 0 3.001452e-07
I1078 n1_m1_48000_326400 0 2.000968e-07
I1079 n1_m1_48000_331200 0 2.000262e-07
I1080 n1_m1_48000_336000 0 3.083834e-07
I1081 n1_m1_48000_340800 0 2.088030e-07
I1082 n1_m1_48000_345600 0 3.010950e-07
I1083 n1_m1_48000_350400 0 2.056947e-07
I1084 n1_m1_48000_355200 0 2.194211e-07
I1085 n1_m1_48000_360000 0 3.288998e-07
I1086 n1_m1_48000_364800 0 2.281585e-07
I1087 n1_m1_48000_369600 0 3.284408e-07
I1088 n1_m1_48000_374400 0 2.118845e-07
I1089 n1_m1_48000_379200 0 2.185385e-07
I1090 n1_m1_48000_384000 0 3.239512e-07
I1091 n1_m1_48000_388800 0 2.161067e-07
I1092 n1_m1_48000_393600 0 3.597725e-07
I1093 n1_m1_48000_398400 0 3.536195e-07
I1094 n1_m1_48000_403200 0 8.015431e-07
I1095 n1_m1_48000_408000 0 2.086518e-06
I1096 n1_m1_48000_412800 0 7.787644e-07
I1097 n1_m1_48000_417600 0 5.855116e-07
I1098 n1_m1_48000_422400 0 3.425518e-07
I1099 n1_m1_48000_427200 0 2.758313e-07
I1100 n1_m1_48000_432000 0 3.538689e-07
I1101 n1_m1_48000_436800 0 2.132992e-07
I1102 n1_m1_48000_441600 0 3.143028e-07
I1103 n1_m1_48000_446400 0 2.060207e-07
I1104 n1_m1_48000_451200 0 2.098223e-07
I1105 n1_m1_48000_456000 0 3.185764e-07
I1106 n1_m1_48000_460800 0 2.098560e-07
I1107 n1_m1_48000_465600 0 3.186992e-07
I1108 n1_m1_48000_470400 0 2.261223e-07
I1109 n1_m1_48000_475200 0 2.258578e-07
I1110 n1_m1_48000_480000 0 3.215355e-07
I1111 n1_m1_52800_0 0 1.380307e-07
I1112 n1_m1_52800_4800 0 1.338203e-07
I1113 n1_m1_52800_9600 0 1.998628e-07
I1114 n1_m1_52800_14400 0 1.332419e-07
I1115 n1_m1_52800_19200 0 1.332419e-07
I1116 n1_m1_52800_24000 0 1.998628e-07
I1117 n1_m1_52800_28800 0 1.332419e-07
I1118 n1_m1_52800_33600 0 1.998628e-07
I1119 n1_m1_52800_38400 0 1.332419e-07
I1120 n1_m1_52800_43200 0 1.332419e-07
I1121 n1_m1_52800_48000 0 1.998628e-07
I1122 n1_m1_52800_52800 0 1.332419e-07
I1123 n1_m1_52800_57600 0 1.998628e-07
I1124 n1_m1_52800_62400 0 1.353920e-07
I1125 n1_m1_52800_67200 0 1.358512e-07
I1126 n1_m1_52800_72000 0 1.998628e-07
I1127 n1_m1_52800_76800 0 1.332419e-07
I1128 n1_m1_52800_81600 0 1.998628e-07
I1129 n1_m1_52800_86400 0 1.332419e-07
I1130 n1_m1_52800_91200 0 1.332419e-07
I1131 n1_m1_52800_96000 0 1.998628e-07
I1132 n1_m1_52800_100800 0 1.332419e-07
I1133 n1_m1_52800_105600 0 1.998628e-07
I1134 n1_m1_52800_110400 0 1.332419e-07
I1135 n1_m1_52800_115200 0 1.332419e-07
I1136 n1_m1_52800_120000 0 1.999742e-07
I1137 n1_m1_52800_124800 0 1.332754e-07
I1138 n1_m1_52800_129600 0 1.998628e-07
I1139 n1_m1_52800_134400 0 1.333126e-07
I1140 n1_m1_52800_139200 0 1.333933e-07
I1141 n1_m1_52800_144000 0 2.071387e-07
I1142 n1_m1_52800_148800 0 1.384915e-07
I1143 n1_m1_52800_153600 0 2.002094e-07
I1144 n1_m1_52800_158400 0 1.334743e-07
I1145 n1_m1_52800_163200 0 1.374118e-07
I1146 n1_m1_52800_168000 0 2.096559e-07
I1147 n1_m1_52800_172800 0 1.399772e-07
I1148 n1_m1_52800_177600 0 2.107849e-07
I1149 n1_m1_52800_182400 0 1.436196e-07
I1150 n1_m1_52800_187200 0 1.384449e-07
I1151 n1_m1_52800_192000 0 1.999723e-07
I1152 n1_m1_52800_196800 0 1.332419e-07
I1153 n1_m1_52800_201600 0 2.028635e-07
I1154 n1_m1_52800_206400 0 1.432901e-07
I1155 n1_m1_52800_211200 0 1.580053e-07
I1156 n1_m1_52800_216000 0 2.778368e-07
I1157 n1_m1_52800_220800 0 2.177786e-07
I1158 n1_m1_52800_225600 0 2.703378e-07
I1159 n1_m1_52800_230400 0 1.556392e-07
I1160 n1_m1_52800_235200 0 1.519253e-07
I1161 n1_m1_52800_240000 0 2.229661e-07
I1162 n1_m1_52800_244800 0 1.361875e-07
I1163 n1_m1_52800_249600 0 1.998628e-07
I1164 n1_m1_52800_254400 0 1.343859e-07
I1165 n1_m1_52800_259200 0 1.385943e-07
I1166 n1_m1_52800_264000 0 2.137158e-07
I1167 n1_m1_52800_268800 0 1.407870e-07
I1168 n1_m1_52800_273600 0 2.077060e-07
I1169 n1_m1_52800_278400 0 1.382103e-07
I1170 n1_m1_52800_283200 0 1.351655e-07
I1171 n1_m1_52800_288000 0 1.998628e-07
I1172 n1_m1_52800_292800 0 1.332419e-07
I1173 n1_m1_52800_297600 0 1.998706e-07
I1174 n1_m1_52800_302400 0 1.333533e-07
I1175 n1_m1_52800_307200 0 1.332653e-07
I1176 n1_m1_52800_312000 0 1.998628e-07
I1177 n1_m1_52800_316800 0 1.332419e-07
I1178 n1_m1_52800_321600 0 1.998628e-07
I1179 n1_m1_52800_326400 0 1.332419e-07
I1180 n1_m1_52800_331200 0 1.347657e-07
I1181 n1_m1_52800_336000 0 2.088245e-07
I1182 n1_m1_52800_340800 0 1.397502e-07
I1183 n1_m1_52800_345600 0 2.105501e-07
I1184 n1_m1_52800_350400 0 1.544445e-07
I1185 n1_m1_52800_355200 0 1.631668e-07
I1186 n1_m1_52800_360000 0 2.377841e-07
I1187 n1_m1_52800_364800 0 1.567977e-07
I1188 n1_m1_52800_369600 0 2.226714e-07
I1189 n1_m1_52800_374400 0 1.449672e-07
I1190 n1_m1_52800_379200 0 1.461984e-07
I1191 n1_m1_52800_384000 0 2.158286e-07
I1192 n1_m1_52800_388800 0 1.441710e-07
I1193 n1_m1_52800_393600 0 4.514386e-07
I1194 n1_m1_52800_398400 0 8.598608e-07
I1195 n1_m1_52800_403200 0 7.497590e-07
I1196 n1_m1_52800_408000 0 1.131030e-06
I1197 n1_m1_52800_412800 0 7.058822e-07
I1198 n1_m1_52800_417600 0 5.880209e-07
I1199 n1_m1_52800_422400 0 1.639106e-07
I1200 n1_m1_52800_427200 0 1.590725e-07
I1201 n1_m1_52800_432000 0 2.201803e-07
I1202 n1_m1_52800_436800 0 1.399040e-07
I1203 n1_m1_52800_441600 0 2.098419e-07
I1204 n1_m1_52800_446400 0 1.397741e-07
I1205 n1_m1_52800_451200 0 1.407802e-07
I1206 n1_m1_52800_456000 0 2.151150e-07
I1207 n1_m1_52800_460800 0 1.399040e-07
I1208 n1_m1_52800_465600 0 2.182238e-07
I1209 n1_m1_52800_470400 0 1.549792e-07
I1210 n1_m1_52800_475200 0 1.537782e-07
I1211 n1_m1_52800_480000 0 2.143570e-07
I1212 n1_m1_57600_0 0 1.342847e-07
I1213 n1_m1_57600_4800 0 1.333678e-07
I1214 n1_m1_57600_9600 0 2.000946e-07
I1215 n1_m1_57600_14400 0 1.335860e-07
I1216 n1_m1_57600_19200 0 1.333236e-07
I1217 n1_m1_57600_24000 0 1.998628e-07
I1218 n1_m1_57600_28800 0 1.332419e-07
I1219 n1_m1_57600_33600 0 1.998628e-07
I1220 n1_m1_57600_38400 0 1.332419e-07
I1221 n1_m1_57600_43200 0 1.332419e-07
I1222 n1_m1_57600_48000 0 1.998628e-07
I1223 n1_m1_57600_52800 0 1.335028e-07
I1224 n1_m1_57600_57600 0 2.003790e-07
I1225 n1_m1_57600_62400 0 1.362751e-07
I1226 n1_m1_57600_67200 0 1.368494e-07
I1227 n1_m1_57600_72000 0 2.000207e-07
I1228 n1_m1_57600_76800 0 1.332419e-07
I1229 n1_m1_57600_81600 0 1.998628e-07
I1230 n1_m1_57600_86400 0 1.332419e-07
I1231 n1_m1_57600_91200 0 1.332419e-07
I1232 n1_m1_57600_96000 0 1.998628e-07
I1233 n1_m1_57600_100800 0 1.332419e-07
I1234 n1_m1_57600_105600 0 1.998628e-07
I1235 n1_m1_57600_110400 0 1.332419e-07
I1236 n1_m1_57600_115200 0 1.332419e-07
I1237 n1_m1_57600_120000 0 2.034671e-07
I1238 n1_m1_57600_124800 0 1.343401e-07
I1239 n1_m1_57600_129600 0 2.005944e-07
I1240 n1_m1_57600_134400 0 1.367230e-07
I1241 n1_m1_57600_139200 0 1.393380e-07
I1242 n1_m1_57600_144000 0 2.099240e-07
I1243 n1_m1_57600_148800 0 1.398659e-07
I1244 n1_m1_57600_153600 0 2.079681e-07
I1245 n1_m1_57600_158400 0 1.352817e-07
I1246 n1_m1_57600_163200 0 1.390080e-07
I1247 n1_m1_57600_168000 0 2.126198e-07
I1248 n1_m1_57600_172800 0 1.427950e-07
I1249 n1_m1_57600_177600 0 2.122932e-07
I1250 n1_m1_57600_182400 0 1.448575e-07
I1251 n1_m1_57600_187200 0 1.397127e-07
I1252 n1_m1_57600_192000 0 2.036552e-07
I1253 n1_m1_57600_196800 0 1.332419e-07
I1254 n1_m1_57600_201600 0 2.028635e-07
I1255 n1_m1_57600_206400 0 1.431152e-07
I1256 n1_m1_57600_211200 0 1.613080e-07
I1257 n1_m1_57600_216000 0 2.728708e-07
I1258 n1_m1_57600_220800 0 1.994199e-07
I1259 n1_m1_57600_225600 0 2.770154e-07
I1260 n1_m1_57600_230400 0 1.666420e-07
I1261 n1_m1_57600_235200 0 1.594942e-07
I1262 n1_m1_57600_240000 0 2.238784e-07
I1263 n1_m1_57600_244800 0 1.360354e-07
I1264 n1_m1_57600_249600 0 1.998628e-07
I1265 n1_m1_57600_254400 0 1.336532e-07
I1266 n1_m1_57600_259200 0 1.362859e-07
I1267 n1_m1_57600_264000 0 2.152277e-07
I1268 n1_m1_57600_268800 0 1.449589e-07
I1269 n1_m1_57600_273600 0 2.106469e-07
I1270 n1_m1_57600_278400 0 1.372109e-07
I1271 n1_m1_57600_283200 0 1.339335e-07
I1272 n1_m1_57600_288000 0 1.999417e-07
I1273 n1_m1_57600_292800 0 1.335839e-07
I1274 n1_m1_57600_297600 0 2.006143e-07
I1275 n1_m1_57600_302400 0 1.369095e-07
I1276 n1_m1_57600_307200 0 1.340012e-07
I1277 n1_m1_57600_312000 0 2.000491e-07
I1278 n1_m1_57600_316800 0 1.335860e-07
I1279 n1_m1_57600_321600 0 2.006997e-07
I1280 n1_m1_57600_326400 0 1.335021e-07
I1281 n1_m1_57600_331200 0 1.352515e-07
I1282 n1_m1_57600_336000 0 2.098560e-07
I1283 n1_m1_57600_340800 0 1.404203e-07
I1284 n1_m1_57600_345600 0 2.201197e-07
I1285 n1_m1_57600_350400 0 1.659686e-07
I1286 n1_m1_57600_355200 0 1.791877e-07
I1287 n1_m1_57600_360000 0 2.548760e-07
I1288 n1_m1_57600_364800 0 1.572474e-07
I1289 n1_m1_57600_369600 0 2.192356e-07
I1290 n1_m1_57600_374400 0 1.410686e-07
I1291 n1_m1_57600_379200 0 1.412755e-07
I1292 n1_m1_57600_384000 0 2.111566e-07
I1293 n1_m1_57600_388800 0 1.439506e-07
I1294 n1_m1_57600_393600 0 3.867208e-07
I1295 n1_m1_57600_398400 0 6.025716e-07
I1296 n1_m1_57600_403200 0 4.738971e-07
I1297 n1_m1_57600_408000 0 7.847217e-07
I1298 n1_m1_57600_412800 0 4.414234e-07
I1299 n1_m1_57600_417600 0 4.300694e-07
I1300 n1_m1_57600_422400 0 1.627106e-07
I1301 n1_m1_57600_427200 0 1.598376e-07
I1302 n1_m1_57600_432000 0 2.203857e-07
I1303 n1_m1_57600_436800 0 1.395599e-07
I1304 n1_m1_57600_441600 0 2.088842e-07
I1305 n1_m1_57600_446400 0 1.353582e-07
I1306 n1_m1_57600_451200 0 1.364035e-07
I1307 n1_m1_57600_456000 0 2.144113e-07
I1308 n1_m1_57600_460800 0 1.396694e-07
I1309 n1_m1_57600_465600 0 2.164604e-07
I1310 n1_m1_57600_470400 0 1.589353e-07
I1311 n1_m1_57600_475200 0 1.547698e-07
I1312 n1_m1_57600_480000 0 2.143570e-07
I1313 n1_m1_62400_0 0 1.332419e-07
I1314 n1_m1_62400_4800 0 1.332419e-07
I1315 n1_m1_62400_9600 0 2.024402e-07
I1316 n1_m1_62400_14400 0 1.370685e-07
I1317 n1_m1_62400_19200 0 1.341511e-07
I1318 n1_m1_62400_24000 0 1.998628e-07
I1319 n1_m1_62400_28800 0 1.332419e-07
I1320 n1_m1_62400_33600 0 1.998628e-07
I1321 n1_m1_62400_38400 0 1.332419e-07
I1322 n1_m1_62400_43200 0 1.332419e-07
I1323 n1_m1_62400_48000 0 2.019133e-07
I1324 n1_m1_62400_52800 0 1.389790e-07
I1325 n1_m1_62400_57600 0 2.098560e-07
I1326 n1_m1_62400_62400 0 1.423177e-07
I1327 n1_m1_62400_67200 0 1.455750e-07
I1328 n1_m1_62400_72000 0 2.079979e-07
I1329 n1_m1_62400_76800 0 1.334352e-07
I1330 n1_m1_62400_81600 0 1.998628e-07
I1331 n1_m1_62400_86400 0 1.332419e-07
I1332 n1_m1_62400_91200 0 1.332419e-07
I1333 n1_m1_62400_96000 0 1.998628e-07
I1334 n1_m1_62400_100800 0 1.332419e-07
I1335 n1_m1_62400_105600 0 1.998628e-07
I1336 n1_m1_62400_110400 0 1.332419e-07
I1337 n1_m1_62400_115200 0 1.332419e-07
I1338 n1_m1_62400_120000 0 2.019895e-07
I1339 n1_m1_62400_124800 0 1.364895e-07
I1340 n1_m1_62400_129600 0 2.208284e-07
I1341 n1_m1_62400_134400 0 1.591745e-07
I1342 n1_m1_62400_139200 0 1.592296e-07
I1343 n1_m1_62400_144000 0 2.268828e-07
I1344 n1_m1_62400_148800 0 1.479563e-07
I1345 n1_m1_62400_153600 0 2.170580e-07
I1346 n1_m1_62400_158400 0 1.443691e-07
I1347 n1_m1_62400_163200 0 1.437306e-07
I1348 n1_m1_62400_168000 0 2.168964e-07
I1349 n1_m1_62400_172800 0 1.500072e-07
I1350 n1_m1_62400_177600 0 2.345498e-07
I1351 n1_m1_62400_182400 0 1.464400e-07
I1352 n1_m1_62400_187200 0 1.428265e-07
I1353 n1_m1_62400_192000 0 2.110369e-07
I1354 n1_m1_62400_196800 0 1.364641e-07
I1355 n1_m1_62400_201600 0 2.033498e-07
I1356 n1_m1_62400_206400 0 1.399040e-07
I1357 n1_m1_62400_211200 0 1.501743e-07
I1358 n1_m1_62400_216000 0 2.491339e-07
I1359 n1_m1_62400_220800 0 1.724436e-07
I1360 n1_m1_62400_225600 0 2.513151e-07
I1361 n1_m1_62400_230400 0 1.673735e-07
I1362 n1_m1_62400_235200 0 1.639341e-07
I1363 n1_m1_62400_240000 0 2.205313e-07
I1364 n1_m1_62400_244800 0 1.360774e-07
I1365 n1_m1_62400_249600 0 2.009525e-07
I1366 n1_m1_62400_254400 0 1.347973e-07
I1367 n1_m1_62400_259200 0 1.398902e-07
I1368 n1_m1_62400_264000 0 2.129868e-07
I1369 n1_m1_62400_268800 0 1.434064e-07
I1370 n1_m1_62400_273600 0 2.104331e-07
I1371 n1_m1_62400_278400 0 1.414623e-07
I1372 n1_m1_62400_283200 0 1.386927e-07
I1373 n1_m1_62400_288000 0 2.056440e-07
I1374 n1_m1_62400_292800 0 1.434305e-07
I1375 n1_m1_62400_297600 0 2.157219e-07
I1376 n1_m1_62400_302400 0 1.370740e-07
I1377 n1_m1_62400_307200 0 1.336813e-07
I1378 n1_m1_62400_312000 0 2.019342e-07
I1379 n1_m1_62400_316800 0 1.387674e-07
I1380 n1_m1_62400_321600 0 2.127831e-07
I1381 n1_m1_62400_326400 0 1.361648e-07
I1382 n1_m1_62400_331200 0 1.343962e-07
I1383 n1_m1_62400_336000 0 2.078231e-07
I1384 n1_m1_62400_340800 0 1.375196e-07
I1385 n1_m1_62400_345600 0 2.091540e-07
I1386 n1_m1_62400_350400 0 1.516039e-07
I1387 n1_m1_62400_355200 0 1.570547e-07
I1388 n1_m1_62400_360000 0 2.258780e-07
I1389 n1_m1_62400_364800 0 1.426079e-07
I1390 n1_m1_62400_369600 0 2.095792e-07
I1391 n1_m1_62400_374400 0 1.370894e-07
I1392 n1_m1_62400_379200 0 1.397592e-07
I1393 n1_m1_62400_384000 0 2.138105e-07
I1394 n1_m1_62400_388800 0 1.427395e-07
I1395 n1_m1_62400_393600 0 2.300760e-07
I1396 n1_m1_62400_398400 0 1.826788e-07
I1397 n1_m1_62400_403200 0 1.867948e-07
I1398 n1_m1_62400_408000 0 2.554899e-07
I1399 n1_m1_62400_412800 0 1.572184e-07
I1400 n1_m1_62400_417600 0 2.236603e-07
I1401 n1_m1_62400_422400 0 1.412903e-07
I1402 n1_m1_62400_427200 0 1.370685e-07
I1403 n1_m1_62400_432000 0 2.045433e-07
I1404 n1_m1_62400_436800 0 1.332419e-07
I1405 n1_m1_62400_441600 0 2.001265e-07
I1406 n1_m1_62400_446400 0 1.356732e-07
I1407 n1_m1_62400_451200 0 1.366545e-07
I1408 n1_m1_62400_456000 0 2.095318e-07
I1409 n1_m1_62400_460800 0 1.372949e-07
I1410 n1_m1_62400_465600 0 2.199141e-07
I1411 n1_m1_62400_470400 0 1.579804e-07
I1412 n1_m1_62400_475200 0 1.558595e-07
I1413 n1_m1_62400_480000 0 2.162727e-07
I1414 n1_m1_67200_0 0 1.332419e-07
I1415 n1_m1_67200_4800 0 1.332419e-07
I1416 n1_m1_67200_9600 0 1.998628e-07
I1417 n1_m1_67200_14400 0 1.332419e-07
I1418 n1_m1_67200_19200 0 1.332419e-07
I1419 n1_m1_67200_24000 0 1.998628e-07
I1420 n1_m1_67200_28800 0 1.332419e-07
I1421 n1_m1_67200_33600 0 1.998628e-07
I1422 n1_m1_67200_38400 0 1.332419e-07
I1423 n1_m1_67200_43200 0 1.332419e-07
I1424 n1_m1_67200_48000 0 2.046805e-07
I1425 n1_m1_67200_52800 0 1.399040e-07
I1426 n1_m1_67200_57600 0 2.122251e-07
I1427 n1_m1_67200_62400 0 1.520169e-07
I1428 n1_m1_67200_67200 0 1.596700e-07
I1429 n1_m1_67200_72000 0 2.206223e-07
I1430 n1_m1_67200_76800 0 1.339157e-07
I1431 n1_m1_67200_81600 0 1.998628e-07
I1432 n1_m1_67200_86400 0 1.332419e-07
I1433 n1_m1_67200_91200 0 1.332419e-07
I1434 n1_m1_67200_96000 0 1.998628e-07
I1435 n1_m1_67200_100800 0 1.332419e-07
I1436 n1_m1_67200_105600 0 1.998628e-07
I1437 n1_m1_67200_110400 0 1.332419e-07
I1438 n1_m1_67200_115200 0 1.332419e-07
I1439 n1_m1_67200_120000 0 2.024437e-07
I1440 n1_m1_67200_124800 0 1.371214e-07
I1441 n1_m1_67200_129600 0 2.209635e-07
I1442 n1_m1_67200_134400 0 1.565592e-07
I1443 n1_m1_67200_139200 0 1.583046e-07
I1444 n1_m1_67200_144000 0 2.312784e-07
I1445 n1_m1_67200_148800 0 1.524816e-07
I1446 n1_m1_67200_153600 0 2.222733e-07
I1447 n1_m1_67200_158400 0 1.414043e-07
I1448 n1_m1_67200_163200 0 1.399040e-07
I1449 n1_m1_67200_168000 0 2.129117e-07
I1450 n1_m1_67200_172800 0 1.483435e-07
I1451 n1_m1_67200_177600 0 2.309029e-07
I1452 n1_m1_67200_182400 0 1.508279e-07
I1453 n1_m1_67200_187200 0 1.521561e-07
I1454 n1_m1_67200_192000 0 2.219443e-07
I1455 n1_m1_67200_196800 0 1.408124e-07
I1456 n1_m1_67200_201600 0 2.025552e-07
I1457 n1_m1_67200_206400 0 1.383201e-07
I1458 n1_m1_67200_211200 0 1.418521e-07
I1459 n1_m1_67200_216000 0 2.270915e-07
I1460 n1_m1_67200_220800 0 1.559795e-07
I1461 n1_m1_67200_225600 0 2.302724e-07
I1462 n1_m1_67200_230400 0 1.556113e-07
I1463 n1_m1_67200_235200 0 1.505853e-07
I1464 n1_m1_67200_240000 0 2.142744e-07
I1465 n1_m1_67200_244800 0 1.399040e-07
I1466 n1_m1_67200_249600 0 2.024230e-07
I1467 n1_m1_67200_254400 0 1.347973e-07
I1468 n1_m1_67200_259200 0 1.398902e-07
I1469 n1_m1_67200_264000 0 2.098560e-07
I1470 n1_m1_67200_268800 0 1.396311e-07
I1471 n1_m1_67200_273600 0 2.086781e-07
I1472 n1_m1_67200_278400 0 1.450161e-07
I1473 n1_m1_67200_283200 0 1.425193e-07
I1474 n1_m1_67200_288000 0 2.128612e-07
I1475 n1_m1_67200_292800 0 1.538154e-07
I1476 n1_m1_67200_297600 0 2.289338e-07
I1477 n1_m1_67200_302400 0 1.438131e-07
I1478 n1_m1_67200_307200 0 1.371425e-07
I1479 n1_m1_67200_312000 0 2.002688e-07
I1480 n1_m1_67200_316800 0 1.353037e-07
I1481 n1_m1_67200_321600 0 2.042496e-07
I1482 n1_m1_67200_326400 0 1.332774e-07
I1483 n1_m1_67200_331200 0 1.332419e-07
I1484 n1_m1_67200_336000 0 2.025575e-07
I1485 n1_m1_67200_340800 0 1.337893e-07
I1486 n1_m1_67200_345600 0 2.034141e-07
I1487 n1_m1_67200_350400 0 1.458741e-07
I1488 n1_m1_67200_355200 0 1.500072e-07
I1489 n1_m1_67200_360000 0 2.191932e-07
I1490 n1_m1_67200_364800 0 1.389590e-07
I1491 n1_m1_67200_369600 0 2.052575e-07
I1492 n1_m1_67200_374400 0 1.397043e-07
I1493 n1_m1_67200_379200 0 1.435595e-07
I1494 n1_m1_67200_384000 0 2.258552e-07
I1495 n1_m1_67200_388800 0 1.530079e-07
I1496 n1_m1_67200_393600 0 2.336340e-07
I1497 n1_m1_67200_398400 0 1.660370e-07
I1498 n1_m1_67200_403200 0 1.543844e-07
I1499 n1_m1_67200_408000 0 2.152626e-07
I1500 n1_m1_67200_412800 0 1.341641e-07
I1501 n1_m1_67200_417600 0 1.998628e-07
I1502 n1_m1_67200_422400 0 1.332419e-07
I1503 n1_m1_67200_427200 0 1.332419e-07
I1504 n1_m1_67200_432000 0 1.998628e-07
I1505 n1_m1_67200_436800 0 1.332419e-07
I1506 n1_m1_67200_441600 0 2.004822e-07
I1507 n1_m1_67200_446400 0 1.389542e-07
I1508 n1_m1_67200_451200 0 1.403898e-07
I1509 n1_m1_67200_456000 0 2.124048e-07
I1510 n1_m1_67200_460800 0 1.377079e-07
I1511 n1_m1_67200_465600 0 2.159241e-07
I1512 n1_m1_67200_470400 0 1.554030e-07
I1513 n1_m1_67200_475200 0 1.573300e-07
I1514 n1_m1_67200_480000 0 2.215133e-07
I1515 n1_m1_72000_0 0 1.998628e-07
I1516 n1_m1_72000_4800 0 1.998628e-07
I1517 n1_m1_72000_9600 0 3.005452e-07
I1518 n1_m1_72000_14400 0 2.009778e-07
I1519 n1_m1_72000_19200 0 2.001277e-07
I1520 n1_m1_72000_24000 0 2.997942e-07
I1521 n1_m1_72000_28800 0 1.998628e-07
I1522 n1_m1_72000_33600 0 2.997942e-07
I1523 n1_m1_72000_38400 0 1.998628e-07
I1524 n1_m1_72000_43200 0 1.998628e-07
I1525 n1_m1_72000_48000 0 3.020040e-07
I1526 n1_m1_72000_52800 0 2.081790e-07
I1527 n1_m1_72000_57600 0 3.217242e-07
I1528 n1_m1_72000_62400 0 2.367593e-07
I1529 n1_m1_72000_67200 0 2.475987e-07
I1530 n1_m1_72000_72000 0 3.381825e-07
I1531 n1_m1_72000_76800 0 2.022923e-07
I1532 n1_m1_72000_81600 0 3.041370e-07
I1533 n1_m1_72000_86400 0 1.998628e-07
I1534 n1_m1_72000_91200 0 1.998628e-07
I1535 n1_m1_72000_96000 0 2.997942e-07
I1536 n1_m1_72000_100800 0 1.998628e-07
I1537 n1_m1_72000_105600 0 2.997942e-07
I1538 n1_m1_72000_110400 0 1.998628e-07
I1539 n1_m1_72000_115200 0 1.998628e-07
I1540 n1_m1_72000_120000 0 2.998104e-07
I1541 n1_m1_72000_124800 0 2.009122e-07
I1542 n1_m1_72000_129600 0 3.096411e-07
I1543 n1_m1_72000_134400 0 2.132236e-07
I1544 n1_m1_72000_139200 0 2.221339e-07
I1545 n1_m1_72000_144000 0 3.505044e-07
I1546 n1_m1_72000_148800 0 2.311932e-07
I1547 n1_m1_72000_153600 0 3.450119e-07
I1548 n1_m1_72000_158400 0 2.177441e-07
I1549 n1_m1_72000_163200 0 2.122919e-07
I1550 n1_m1_72000_168000 0 3.256172e-07
I1551 n1_m1_72000_172800 0 2.186973e-07
I1552 n1_m1_72000_177600 0 3.307825e-07
I1553 n1_m1_72000_182400 0 2.270843e-07
I1554 n1_m1_72000_187200 0 2.298347e-07
I1555 n1_m1_72000_192000 0 3.340051e-07
I1556 n1_m1_72000_196800 0 2.067126e-07
I1557 n1_m1_72000_201600 0 3.005095e-07
I1558 n1_m1_72000_206400 0 2.014160e-07
I1559 n1_m1_72000_211200 0 2.029186e-07
I1560 n1_m1_72000_216000 0 3.168248e-07
I1561 n1_m1_72000_220800 0 2.169294e-07
I1562 n1_m1_72000_225600 0 3.190423e-07
I1563 n1_m1_72000_230400 0 2.249603e-07
I1564 n1_m1_72000_235200 0 2.205205e-07
I1565 n1_m1_72000_240000 0 3.162499e-07
I1566 n1_m1_72000_244800 0 2.098560e-07
I1567 n1_m1_72000_249600 0 3.101837e-07
I1568 n1_m1_72000_254400 0 2.029707e-07
I1569 n1_m1_72000_259200 0 2.087250e-07
I1570 n1_m1_72000_264000 0 3.127867e-07
I1571 n1_m1_72000_268800 0 2.037063e-07
I1572 n1_m1_72000_273600 0 3.095348e-07
I1573 n1_m1_72000_278400 0 2.155342e-07
I1574 n1_m1_72000_283200 0 2.068415e-07
I1575 n1_m1_72000_288000 0 3.180381e-07
I1576 n1_m1_72000_292800 0 2.382467e-07
I1577 n1_m1_72000_297600 0 3.393845e-07
I1578 n1_m1_72000_302400 0 2.230819e-07
I1579 n1_m1_72000_307200 0 2.161326e-07
I1580 n1_m1_72000_312000 0 3.097874e-07
I1581 n1_m1_72000_316800 0 2.063533e-07
I1582 n1_m1_72000_321600 0 3.102003e-07
I1583 n1_m1_72000_326400 0 2.053205e-07
I1584 n1_m1_72000_331200 0 2.027341e-07
I1585 n1_m1_72000_336000 0 3.102003e-07
I1586 n1_m1_72000_340800 0 2.060692e-07
I1587 n1_m1_72000_345600 0 3.060242e-07
I1588 n1_m1_72000_350400 0 2.198604e-07
I1589 n1_m1_72000_355200 0 2.267865e-07
I1590 n1_m1_72000_360000 0 3.293107e-07
I1591 n1_m1_72000_364800 0 2.069241e-07
I1592 n1_m1_72000_369600 0 3.005169e-07
I1593 n1_m1_72000_374400 0 2.092366e-07
I1594 n1_m1_72000_379200 0 2.196627e-07
I1595 n1_m1_72000_384000 0 3.479779e-07
I1596 n1_m1_72000_388800 0 2.387204e-07
I1597 n1_m1_72000_393600 0 3.977161e-07
I1598 n1_m1_72000_398400 0 3.028164e-07
I1599 n1_m1_72000_403200 0 2.400890e-07
I1600 n1_m1_72000_408000 0 3.198012e-07
I1601 n1_m1_72000_412800 0 2.012462e-07
I1602 n1_m1_72000_417600 0 3.064828e-07
I1603 n1_m1_72000_422400 0 2.041455e-07
I1604 n1_m1_72000_427200 0 1.998628e-07
I1605 n1_m1_72000_432000 0 2.997942e-07
I1606 n1_m1_72000_436800 0 1.998628e-07
I1607 n1_m1_72000_441600 0 3.007233e-07
I1608 n1_m1_72000_446400 0 2.084313e-07
I1609 n1_m1_72000_451200 0 2.113632e-07
I1610 n1_m1_72000_456000 0 3.226917e-07
I1611 n1_m1_72000_460800 0 2.030425e-07
I1612 n1_m1_72000_465600 0 3.156666e-07
I1613 n1_m1_72000_470400 0 2.284318e-07
I1614 n1_m1_72000_475200 0 2.359950e-07
I1615 n1_m1_72000_480000 0 3.365252e-07
I1616 n1_m1_76800_0 0 1.332419e-07
I1617 n1_m1_76800_4800 0 1.334715e-07
I1618 n1_m1_76800_9600 0 2.050465e-07
I1619 n1_m1_76800_14400 0 1.394497e-07
I1620 n1_m1_76800_19200 0 1.356787e-07
I1621 n1_m1_76800_24000 0 2.001357e-07
I1622 n1_m1_76800_28800 0 1.332419e-07
I1623 n1_m1_76800_33600 0 1.998628e-07
I1624 n1_m1_76800_38400 0 1.332419e-07
I1625 n1_m1_76800_43200 0 1.332419e-07
I1626 n1_m1_76800_48000 0 1.998628e-07
I1627 n1_m1_76800_52800 0 1.373317e-07
I1628 n1_m1_76800_57600 0 2.117139e-07
I1629 n1_m1_76800_62400 0 1.487415e-07
I1630 n1_m1_76800_67200 0 1.528290e-07
I1631 n1_m1_76800_72000 0 2.150664e-07
I1632 n1_m1_76800_76800 0 1.338162e-07
I1633 n1_m1_76800_81600 0 2.002016e-07
I1634 n1_m1_76800_86400 0 1.332419e-07
I1635 n1_m1_76800_91200 0 1.332419e-07
I1636 n1_m1_76800_96000 0 1.998628e-07
I1637 n1_m1_76800_100800 0 1.332419e-07
I1638 n1_m1_76800_105600 0 1.998628e-07
I1639 n1_m1_76800_110400 0 1.332419e-07
I1640 n1_m1_76800_115200 0 1.332419e-07
I1641 n1_m1_76800_120000 0 2.000093e-07
I1642 n1_m1_76800_124800 0 1.413456e-07
I1643 n1_m1_76800_129600 0 2.155045e-07
I1644 n1_m1_76800_134400 0 1.336961e-07
I1645 n1_m1_76800_139200 0 1.393161e-07
I1646 n1_m1_76800_144000 0 2.278728e-07
I1647 n1_m1_76800_148800 0 1.489410e-07
I1648 n1_m1_76800_153600 0 2.179393e-07
I1649 n1_m1_76800_158400 0 1.404310e-07
I1650 n1_m1_76800_163200 0 1.427440e-07
I1651 n1_m1_76800_168000 0 2.175928e-07
I1652 n1_m1_76800_172800 0 1.395208e-07
I1653 n1_m1_76800_177600 0 2.013090e-07
I1654 n1_m1_76800_182400 0 1.356239e-07
I1655 n1_m1_76800_187200 0 1.393934e-07
I1656 n1_m1_76800_192000 0 2.088724e-07
I1657 n1_m1_76800_196800 0 1.380103e-07
I1658 n1_m1_76800_201600 0 2.007031e-07
I1659 n1_m1_76800_206400 0 1.339065e-07
I1660 n1_m1_76800_211200 0 1.338092e-07
I1661 n1_m1_76800_216000 0 2.074456e-07
I1662 n1_m1_76800_220800 0 1.387631e-07
I1663 n1_m1_76800_225600 0 2.045310e-07
I1664 n1_m1_76800_230400 0 1.442298e-07
I1665 n1_m1_76800_235200 0 1.447463e-07
I1666 n1_m1_76800_240000 0 2.095256e-07
I1667 n1_m1_76800_244800 0 1.399040e-07
I1668 n1_m1_76800_249600 0 2.094956e-07
I1669 n1_m1_76800_254400 0 1.371587e-07
I1670 n1_m1_76800_259200 0 1.337053e-07
I1671 n1_m1_76800_264000 0 2.005188e-07
I1672 n1_m1_76800_268800 0 1.333235e-07
I1673 n1_m1_76800_273600 0 2.033622e-07
I1674 n1_m1_76800_278400 0 1.401086e-07
I1675 n1_m1_76800_283200 0 1.358572e-07
I1676 n1_m1_76800_288000 0 2.064995e-07
I1677 n1_m1_76800_292800 0 1.532629e-07
I1678 n1_m1_76800_297600 0 2.162827e-07
I1679 n1_m1_76800_302400 0 1.441077e-07
I1680 n1_m1_76800_307200 0 1.394966e-07
I1681 n1_m1_76800_312000 0 2.012190e-07
I1682 n1_m1_76800_316800 0 1.366322e-07
I1683 n1_m1_76800_321600 0 2.094075e-07
I1684 n1_m1_76800_326400 0 1.394562e-07
I1685 n1_m1_76800_331200 0 1.382791e-07
I1686 n1_m1_76800_336000 0 2.089185e-07
I1687 n1_m1_76800_340800 0 1.382402e-07
I1688 n1_m1_76800_345600 0 2.041111e-07
I1689 n1_m1_76800_350400 0 1.477774e-07
I1690 n1_m1_76800_355200 0 1.532282e-07
I1691 n1_m1_76800_360000 0 2.201382e-07
I1692 n1_m1_76800_364800 0 1.383330e-07
I1693 n1_m1_76800_369600 0 2.011929e-07
I1694 n1_m1_76800_374400 0 1.393587e-07
I1695 n1_m1_76800_379200 0 1.445985e-07
I1696 n1_m1_76800_384000 0 2.216409e-07
I1697 n1_m1_76800_388800 0 1.519047e-07
I1698 n1_m1_76800_393600 0 2.530265e-07
I1699 n1_m1_76800_398400 0 1.949117e-07
I1700 n1_m1_76800_403200 0 1.640747e-07
I1701 n1_m1_76800_408000 0 2.132008e-07
I1702 n1_m1_76800_412800 0 1.341641e-07
I1703 n1_m1_76800_417600 0 2.003846e-07
I1704 n1_m1_76800_422400 0 1.335760e-07
I1705 n1_m1_76800_427200 0 1.332419e-07
I1706 n1_m1_76800_432000 0 1.998628e-07
I1707 n1_m1_76800_436800 0 1.332419e-07
I1708 n1_m1_76800_441600 0 2.004822e-07
I1709 n1_m1_76800_446400 0 1.389542e-07
I1710 n1_m1_76800_451200 0 1.409088e-07
I1711 n1_m1_76800_456000 0 2.151278e-07
I1712 n1_m1_76800_460800 0 1.353616e-07
I1713 n1_m1_76800_465600 0 2.102485e-07
I1714 n1_m1_76800_470400 0 1.517965e-07
I1715 n1_m1_76800_475200 0 1.573300e-07
I1716 n1_m1_76800_480000 0 2.243501e-07
I1717 n1_m1_81600_0 0 1.998628e-07
I1718 n1_m1_81600_4800 0 2.007355e-07
I1719 n1_m1_81600_9600 0 3.071262e-07
I1720 n1_m1_81600_14400 0 2.050934e-07
I1721 n1_m1_81600_19200 0 2.047605e-07
I1722 n1_m1_81600_24000 0 3.008312e-07
I1723 n1_m1_81600_28800 0 1.998628e-07
I1724 n1_m1_81600_33600 0 2.997942e-07
I1725 n1_m1_81600_38400 0 1.998628e-07
I1726 n1_m1_81600_43200 0 1.998628e-07
I1727 n1_m1_81600_48000 0 2.997942e-07
I1728 n1_m1_81600_52800 0 2.002823e-07
I1729 n1_m1_81600_57600 0 3.128091e-07
I1730 n1_m1_81600_62400 0 2.143708e-07
I1731 n1_m1_81600_67200 0 2.201106e-07
I1732 n1_m1_81600_72000 0 3.136528e-07
I1733 n1_m1_81600_76800 0 2.002195e-07
I1734 n1_m1_81600_81600 0 2.997942e-07
I1735 n1_m1_81600_86400 0 1.998628e-07
I1736 n1_m1_81600_91200 0 1.998628e-07
I1737 n1_m1_81600_96000 0 2.997942e-07
I1738 n1_m1_81600_100800 0 1.998628e-07
I1739 n1_m1_81600_105600 0 2.997942e-07
I1740 n1_m1_81600_110400 0 1.998628e-07
I1741 n1_m1_81600_115200 0 1.998628e-07
I1742 n1_m1_81600_120000 0 3.038641e-07
I1743 n1_m1_81600_124800 0 2.314516e-07
I1744 n1_m1_81600_129600 0 3.447281e-07
I1745 n1_m1_81600_134400 0 2.024015e-07
I1746 n1_m1_81600_139200 0 2.026367e-07
I1747 n1_m1_81600_144000 0 3.126852e-07
I1748 n1_m1_81600_148800 0 2.087462e-07
I1749 n1_m1_81600_153600 0 3.183858e-07
I1750 n1_m1_81600_158400 0 2.049561e-07
I1751 n1_m1_81600_163200 0 2.054359e-07
I1752 n1_m1_81600_168000 0 3.143446e-07
I1753 n1_m1_81600_172800 0 2.072807e-07
I1754 n1_m1_81600_177600 0 3.060623e-07
I1755 n1_m1_81600_182400 0 2.001645e-07
I1756 n1_m1_81600_187200 0 2.001184e-07
I1757 n1_m1_81600_192000 0 3.001865e-07
I1758 n1_m1_81600_196800 0 2.001076e-07
I1759 n1_m1_81600_201600 0 2.998391e-07
I1760 n1_m1_81600_206400 0 2.048091e-07
I1761 n1_m1_81600_211200 0 2.040852e-07
I1762 n1_m1_81600_216000 0 3.110262e-07
I1763 n1_m1_81600_220800 0 2.074816e-07
I1764 n1_m1_81600_225600 0 3.001573e-07
I1765 n1_m1_81600_230400 0 2.045704e-07
I1766 n1_m1_81600_235200 0 2.083933e-07
I1767 n1_m1_81600_240000 0 3.041370e-07
I1768 n1_m1_81600_244800 0 2.077502e-07
I1769 n1_m1_81600_249600 0 3.084539e-07
I1770 n1_m1_81600_254400 0 2.002173e-07
I1771 n1_m1_81600_259200 0 1.998634e-07
I1772 n1_m1_81600_264000 0 3.036909e-07
I1773 n1_m1_81600_268800 0 2.042220e-07
I1774 n1_m1_81600_273600 0 3.054265e-07
I1775 n1_m1_81600_278400 0 2.098560e-07
I1776 n1_m1_81600_283200 0 2.037857e-07
I1777 n1_m1_81600_288000 0 3.212866e-07
I1778 n1_m1_81600_292800 0 2.510063e-07
I1779 n1_m1_81600_297600 0 3.423722e-07
I1780 n1_m1_81600_302400 0 2.175298e-07
I1781 n1_m1_81600_307200 0 2.066233e-07
I1782 n1_m1_81600_312000 0 3.004274e-07
I1783 n1_m1_81600_316800 0 2.000195e-07
I1784 n1_m1_81600_321600 0 3.114462e-07
I1785 n1_m1_81600_326400 0 2.085932e-07
I1786 n1_m1_81600_331200 0 2.034503e-07
I1787 n1_m1_81600_336000 0 3.078069e-07
I1788 n1_m1_81600_340800 0 2.021468e-07
I1789 n1_m1_81600_345600 0 3.116791e-07
I1790 n1_m1_81600_350400 0 2.264286e-07
I1791 n1_m1_81600_355200 0 2.376946e-07
I1792 n1_m1_81600_360000 0 3.387484e-07
I1793 n1_m1_81600_364800 0 2.131445e-07
I1794 n1_m1_81600_369600 0 3.105401e-07
I1795 n1_m1_81600_374400 0 2.090287e-07
I1796 n1_m1_81600_379200 0 2.100824e-07
I1797 n1_m1_81600_384000 0 3.153286e-07
I1798 n1_m1_81600_388800 0 2.135617e-07
I1799 n1_m1_81600_393600 0 3.407311e-07
I1800 n1_m1_81600_398400 0 2.643087e-07
I1801 n1_m1_81600_403200 0 2.461121e-07
I1802 n1_m1_81600_408000 0 3.236289e-07
I1803 n1_m1_81600_412800 0 2.019055e-07
I1804 n1_m1_81600_417600 0 2.997942e-07
I1805 n1_m1_81600_422400 0 1.998628e-07
I1806 n1_m1_81600_427200 0 1.998628e-07
I1807 n1_m1_81600_432000 0 2.997942e-07
I1808 n1_m1_81600_436800 0 1.998628e-07
I1809 n1_m1_81600_441600 0 3.007233e-07
I1810 n1_m1_81600_446400 0 2.084313e-07
I1811 n1_m1_81600_451200 0 2.106449e-07
I1812 n1_m1_81600_456000 0 3.189230e-07
I1813 n1_m1_81600_460800 0 2.062897e-07
I1814 n1_m1_81600_465600 0 3.233244e-07
I1815 n1_m1_81600_470400 0 2.329283e-07
I1816 n1_m1_81600_475200 0 2.359950e-07
I1817 n1_m1_81600_480000 0 3.325991e-07
I1818 n1_m1_86400_0 0 6.662094e-08
I1819 n1_m1_86400_4800 0 6.662094e-08
I1820 n1_m1_86400_9600 0 9.993141e-08
I1821 n1_m1_86400_14400 0 6.662094e-08
I1822 n1_m1_86400_19200 0 6.662094e-08
I1823 n1_m1_86400_24000 0 9.993141e-08
I1824 n1_m1_86400_28800 0 6.662094e-08
I1825 n1_m1_86400_33600 0 9.993141e-08
I1826 n1_m1_86400_38400 0 6.662094e-08
I1827 n1_m1_86400_43200 0 6.662094e-08
I1828 n1_m1_86400_48000 0 9.993141e-08
I1829 n1_m1_86400_52800 0 6.665817e-08
I1830 n1_m1_86400_57600 0 1.026625e-07
I1831 n1_m1_86400_62400 0 7.209034e-08
I1832 n1_m1_86400_67200 0 7.497609e-08
I1833 n1_m1_86400_72000 0 1.052434e-07
I1834 n1_m1_86400_76800 0 6.673638e-08
I1835 n1_m1_86400_81600 0 9.993141e-08
I1836 n1_m1_86400_86400 0 6.662094e-08
I1837 n1_m1_86400_91200 0 6.662094e-08
I1838 n1_m1_86400_96000 0 9.993141e-08
I1839 n1_m1_86400_100800 0 6.662094e-08
I1840 n1_m1_86400_105600 0 9.993141e-08
I1841 n1_m1_86400_110400 0 6.662094e-08
I1842 n1_m1_86400_115200 0 6.662094e-08
I1843 n1_m1_86400_120000 0 1.025987e-07
I1844 n1_m1_86400_124800 0 7.905466e-08
I1845 n1_m1_86400_129600 0 1.183692e-07
I1846 n1_m1_86400_134400 0 7.088019e-08
I1847 n1_m1_86400_139200 0 7.086666e-08
I1848 n1_m1_86400_144000 0 1.126482e-07
I1849 n1_m1_86400_148800 0 7.655689e-08
I1850 n1_m1_86400_153600 0 1.161492e-07
I1851 n1_m1_86400_158400 0 7.071456e-08
I1852 n1_m1_86400_163200 0 6.995199e-08
I1853 n1_m1_86400_168000 0 1.064811e-07
I1854 n1_m1_86400_172800 0 7.333809e-08
I1855 n1_m1_86400_177600 0 1.087720e-07
I1856 n1_m1_86400_182400 0 6.696790e-08
I1857 n1_m1_86400_187200 0 6.662094e-08
I1858 n1_m1_86400_192000 0 9.993141e-08
I1859 n1_m1_86400_196800 0 6.662094e-08
I1860 n1_m1_86400_201600 0 9.993141e-08
I1861 n1_m1_86400_206400 0 6.745348e-08
I1862 n1_m1_86400_211200 0 6.829010e-08
I1863 n1_m1_86400_216000 0 1.062150e-07
I1864 n1_m1_86400_220800 0 7.045130e-08
I1865 n1_m1_86400_225600 0 9.998388e-08
I1866 n1_m1_86400_230400 0 6.806583e-08
I1867 n1_m1_86400_235200 0 6.936838e-08
I1868 n1_m1_86400_240000 0 1.004201e-07
I1869 n1_m1_86400_244800 0 6.753470e-08
I1870 n1_m1_86400_249600 0 1.005609e-07
I1871 n1_m1_86400_254400 0 6.662094e-08
I1872 n1_m1_86400_259200 0 6.706519e-08
I1873 n1_m1_86400_264000 0 1.038112e-07
I1874 n1_m1_86400_268800 0 6.966981e-08
I1875 n1_m1_86400_273600 0 1.029043e-07
I1876 n1_m1_86400_278400 0 7.071456e-08
I1877 n1_m1_86400_283200 0 6.792858e-08
I1878 n1_m1_86400_288000 0 1.150604e-07
I1879 n1_m1_86400_292800 0 1.032436e-07
I1880 n1_m1_86400_297600 0 1.302997e-07
I1881 n1_m1_86400_302400 0 8.023257e-08
I1882 n1_m1_86400_307200 0 7.551334e-08
I1883 n1_m1_86400_312000 0 1.047273e-07
I1884 n1_m1_86400_316800 0 6.831399e-08
I1885 n1_m1_86400_321600 0 1.043662e-07
I1886 n1_m1_86400_326400 0 6.995199e-08
I1887 n1_m1_86400_331200 0 6.894717e-08
I1888 n1_m1_86400_336000 0 1.026692e-07
I1889 n1_m1_86400_340800 0 6.874718e-08
I1890 n1_m1_86400_345600 0 1.073929e-07
I1891 n1_m1_86400_350400 0 7.991322e-08
I1892 n1_m1_86400_355200 0 8.439390e-08
I1893 n1_m1_86400_360000 0 1.197789e-07
I1894 n1_m1_86400_364800 0 7.230574e-08
I1895 n1_m1_86400_369600 0 1.049280e-07
I1896 n1_m1_86400_374400 0 6.995199e-08
I1897 n1_m1_86400_379200 0 6.995199e-08
I1898 n1_m1_86400_384000 0 1.049280e-07
I1899 n1_m1_86400_388800 0 6.995199e-08
I1900 n1_m1_86400_393600 0 1.090230e-07
I1901 n1_m1_86400_398400 0 8.612449e-08
I1902 n1_m1_86400_403200 0 8.092498e-08
I1903 n1_m1_86400_408000 0 1.079169e-07
I1904 n1_m1_86400_412800 0 6.730880e-08
I1905 n1_m1_86400_417600 0 9.993141e-08
I1906 n1_m1_86400_422400 0 6.662094e-08
I1907 n1_m1_86400_427200 0 6.662094e-08
I1908 n1_m1_86400_432000 0 9.993141e-08
I1909 n1_m1_86400_436800 0 6.662094e-08
I1910 n1_m1_86400_441600 0 1.002411e-07
I1911 n1_m1_86400_446400 0 6.927072e-08
I1912 n1_m1_86400_451200 0 6.870668e-08
I1913 n1_m1_86400_456000 0 1.047846e-07
I1914 n1_m1_86400_460800 0 6.995199e-08
I1915 n1_m1_86400_465600 0 1.103999e-07
I1916 n1_m1_86400_470400 0 7.884185e-08
I1917 n1_m1_86400_475200 0 7.801438e-08
I1918 n1_m1_86400_480000 0 1.082852e-07
I1919 n1_m1_91200_0 0 1.331582e-07
I1920 n1_m1_91200_4800 0 1.330090e-07
I1921 n1_m1_91200_9600 0 2.031444e-07
I1922 n1_m1_91200_14400 0 1.386052e-07
I1923 n1_m1_91200_19200 0 1.350394e-07
I1924 n1_m1_91200_24000 0 2.026552e-07
I1925 n1_m1_91200_28800 0 1.363744e-07
I1926 n1_m1_91200_33600 0 1.998628e-07
I1927 n1_m1_91200_38400 0 1.332419e-07
I1928 n1_m1_91200_43200 0 1.332419e-07
I1929 n1_m1_91200_48000 0 1.998628e-07
I1930 n1_m1_91200_52800 0 1.333604e-07
I1931 n1_m1_91200_57600 0 2.069929e-07
I1932 n1_m1_91200_62400 0 1.408177e-07
I1933 n1_m1_91200_67200 0 1.401089e-07
I1934 n1_m1_91200_72000 0 2.031147e-07
I1935 n1_m1_91200_76800 0 1.333404e-07
I1936 n1_m1_91200_81600 0 1.998628e-07
I1937 n1_m1_91200_86400 0 1.332419e-07
I1938 n1_m1_91200_91200 0 1.332419e-07
I1939 n1_m1_91200_96000 0 1.998628e-07
I1940 n1_m1_91200_100800 0 1.332419e-07
I1941 n1_m1_91200_105600 0 1.998628e-07
I1942 n1_m1_91200_110400 0 1.331810e-07
I1943 n1_m1_91200_115200 0 1.330090e-07
I1944 n1_m1_91200_120000 0 2.050577e-07
I1945 n1_m1_91200_124800 0 1.623021e-07
I1946 n1_m1_91200_129600 0 2.353757e-07
I1947 n1_m1_91200_134400 0 1.674825e-07
I1948 n1_m1_91200_139200 0 1.540346e-07
I1949 n1_m1_91200_144000 0 2.266617e-07
I1950 n1_m1_91200_148800 0 1.573760e-07
I1951 n1_m1_91200_153600 0 2.255677e-07
I1952 n1_m1_91200_158400 0 1.420340e-07
I1953 n1_m1_91200_163200 0 1.396320e-07
I1954 n1_m1_91200_168000 0 2.068992e-07
I1955 n1_m1_91200_172800 0 1.483473e-07
I1956 n1_m1_91200_177600 0 2.412560e-07
I1957 n1_m1_91200_182400 0 1.402628e-07
I1958 n1_m1_91200_187200 0 1.372813e-07
I1959 n1_m1_91200_192000 0 2.000918e-07
I1960 n1_m1_91200_196800 0 1.332419e-07
I1961 n1_m1_91200_201600 0 1.998628e-07
I1962 n1_m1_91200_206400 0 1.334028e-07
I1963 n1_m1_91200_211200 0 1.343767e-07
I1964 n1_m1_91200_216000 0 2.099936e-07
I1965 n1_m1_91200_220800 0 1.409790e-07
I1966 n1_m1_91200_225600 0 2.080460e-07
I1967 n1_m1_91200_230400 0 1.357752e-07
I1968 n1_m1_91200_235200 0 1.348472e-07
I1969 n1_m1_91200_240000 0 2.001213e-07
I1970 n1_m1_91200_244800 0 1.361521e-07
I1971 n1_m1_91200_249600 0 2.018676e-07
I1972 n1_m1_91200_254400 0 1.332419e-07
I1973 n1_m1_91200_259200 0 1.336211e-07
I1974 n1_m1_91200_264000 0 2.020308e-07
I1975 n1_m1_91200_268800 0 1.345647e-07
I1976 n1_m1_91200_273600 0 2.015022e-07
I1977 n1_m1_91200_278400 0 1.353381e-07
I1978 n1_m1_91200_283200 0 1.369781e-07
I1979 n1_m1_91200_288000 0 2.193698e-07
I1980 n1_m1_91200_292800 0 1.757089e-07
I1981 n1_m1_91200_297600 0 3.469776e-07
I1982 n1_m1_91200_302400 0 1.834124e-07
I1983 n1_m1_91200_307200 0 1.556736e-07
I1984 n1_m1_91200_312000 0 2.149126e-07
I1985 n1_m1_91200_316800 0 1.436001e-07
I1986 n1_m1_91200_321600 0 2.272170e-07
I1987 n1_m1_91200_326400 0 1.426542e-07
I1988 n1_m1_91200_331200 0 1.361414e-07
I1989 n1_m1_91200_336000 0 2.091330e-07
I1990 n1_m1_91200_340800 0 1.404537e-07
I1991 n1_m1_91200_345600 0 2.190492e-07
I1992 n1_m1_91200_350400 0 1.535810e-07
I1993 n1_m1_91200_355200 0 1.678615e-07
I1994 n1_m1_91200_360000 0 2.685991e-07
I1995 n1_m1_91200_364800 0 1.587314e-07
I1996 n1_m1_91200_369600 0 2.162476e-07
I1997 n1_m1_91200_374400 0 1.360348e-07
I1998 n1_m1_91200_379200 0 1.389705e-07
I1999 n1_m1_91200_384000 0 2.098226e-07
I2000 n1_m1_91200_388800 0 1.399040e-07
I2001 n1_m1_91200_393600 0 2.154806e-07
I2002 n1_m1_91200_398400 0 1.653436e-07
I2003 n1_m1_91200_403200 0 1.667036e-07
I2004 n1_m1_91200_408000 0 2.152595e-07
I2005 n1_m1_91200_412800 0 1.334420e-07
I2006 n1_m1_91200_417600 0 1.998628e-07
I2007 n1_m1_91200_422400 0 1.332419e-07
I2008 n1_m1_91200_427200 0 1.332419e-07
I2009 n1_m1_91200_432000 0 1.998628e-07
I2010 n1_m1_91200_436800 0 1.332419e-07
I2011 n1_m1_91200_441600 0 2.004822e-07
I2012 n1_m1_91200_446400 0 1.387780e-07
I2013 n1_m1_91200_451200 0 1.388409e-07
I2014 n1_m1_91200_456000 0 2.097335e-07
I2015 n1_m1_91200_460800 0 1.399040e-07
I2016 n1_m1_91200_465600 0 2.138223e-07
I2017 n1_m1_91200_470400 0 1.545657e-07
I2018 n1_m1_91200_475200 0 1.619914e-07
I2019 n1_m1_91200_480000 0 2.257068e-07
I2020 n1_m1_96000_0 0 2.031122e-07
I2021 n1_m1_96000_4800 0 1.980181e-07
I2022 n1_m1_96000_9600 0 3.004474e-07
I2023 n1_m1_96000_14400 0 2.118675e-07
I2024 n1_m1_96000_19200 0 2.147864e-07
I2025 n1_m1_96000_24000 0 3.187258e-07
I2026 n1_m1_96000_28800 0 2.073201e-07
I2027 n1_m1_96000_33600 0 3.001906e-07
I2028 n1_m1_96000_38400 0 2.023848e-07
I2029 n1_m1_96000_43200 0 2.026433e-07
I2030 n1_m1_96000_48000 0 3.039649e-07
I2031 n1_m1_96000_52800 0 2.006989e-07
I2032 n1_m1_96000_57600 0 3.068864e-07
I2033 n1_m1_96000_62400 0 2.011154e-07
I2034 n1_m1_96000_67200 0 2.005098e-07
I2035 n1_m1_96000_72000 0 2.997942e-07
I2036 n1_m1_96000_76800 0 1.998628e-07
I2037 n1_m1_96000_81600 0 2.997942e-07
I2038 n1_m1_96000_86400 0 1.998628e-07
I2039 n1_m1_96000_91200 0 1.998628e-07
I2040 n1_m1_96000_96000 0 2.997942e-07
I2041 n1_m1_96000_100800 0 1.998628e-07
I2042 n1_m1_96000_105600 0 2.997942e-07
I2043 n1_m1_96000_110400 0 1.987176e-07
I2044 n1_m1_96000_115200 0 1.954789e-07
I2045 n1_m1_96000_120000 0 3.086022e-07
I2046 n1_m1_96000_124800 0 4.040334e-07
I2047 n1_m1_96000_129600 0 5.026569e-07
I2048 n1_m1_96000_134400 0 2.741842e-07
I2049 n1_m1_96000_139200 0 2.478191e-07
I2050 n1_m1_96000_144000 0 3.639558e-07
I2051 n1_m1_96000_148800 0 2.252840e-07
I2052 n1_m1_96000_153600 0 3.383619e-07
I2053 n1_m1_96000_158400 0 2.227674e-07
I2054 n1_m1_96000_163200 0 2.165013e-07
I2055 n1_m1_96000_168000 0 3.220306e-07
I2056 n1_m1_96000_172800 0 2.288189e-07
I2057 n1_m1_96000_177600 0 3.753181e-07
I2058 n1_m1_96000_182400 0 2.241395e-07
I2059 n1_m1_96000_187200 0 2.146406e-07
I2060 n1_m1_96000_192000 0 3.081255e-07
I2061 n1_m1_96000_196800 0 1.998628e-07
I2062 n1_m1_96000_201600 0 3.010466e-07
I2063 n1_m1_96000_206400 0 2.056726e-07
I2064 n1_m1_96000_211200 0 2.101774e-07
I2065 n1_m1_96000_216000 0 3.257628e-07
I2066 n1_m1_96000_220800 0 2.213023e-07
I2067 n1_m1_96000_225600 0 3.297049e-07
I2068 n1_m1_96000_230400 0 2.126926e-07
I2069 n1_m1_96000_235200 0 2.085622e-07
I2070 n1_m1_96000_240000 0 3.034490e-07
I2071 n1_m1_96000_244800 0 2.054375e-07
I2072 n1_m1_96000_249600 0 3.036346e-07
I2073 n1_m1_96000_254400 0 1.998628e-07
I2074 n1_m1_96000_259200 0 1.998628e-07
I2075 n1_m1_96000_264000 0 2.997942e-07
I2076 n1_m1_96000_268800 0 1.998628e-07
I2077 n1_m1_96000_273600 0 2.997942e-07
I2078 n1_m1_96000_278400 0 1.998628e-07
I2079 n1_m1_96000_283200 0 2.042441e-07
I2080 n1_m1_96000_288000 0 3.157947e-07
I2081 n1_m1_96000_292800 0 2.248987e-07
I2082 n1_m1_96000_297600 0 4.305477e-07
I2083 n1_m1_96000_302400 0 2.785642e-07
I2084 n1_m1_96000_307200 0 3.017815e-07
I2085 n1_m1_96000_312000 0 4.264024e-07
I2086 n1_m1_96000_316800 0 2.349345e-07
I2087 n1_m1_96000_321600 0 3.380687e-07
I2088 n1_m1_96000_326400 0 2.184631e-07
I2089 n1_m1_96000_331200 0 2.146626e-07
I2090 n1_m1_96000_336000 0 3.188139e-07
I2091 n1_m1_96000_340800 0 2.138330e-07
I2092 n1_m1_96000_345600 0 3.898103e-07
I2093 n1_m1_96000_350400 0 4.141028e-07
I2094 n1_m1_96000_355200 0 5.383527e-07
I2095 n1_m1_96000_360000 0 7.305324e-07
I2096 n1_m1_96000_364800 0 2.420001e-07
I2097 n1_m1_96000_369600 0 3.270276e-07
I2098 n1_m1_96000_374400 0 2.016207e-07
I2099 n1_m1_96000_379200 0 2.017230e-07
I2100 n1_m1_96000_384000 0 3.099852e-07
I2101 n1_m1_96000_388800 0 2.070755e-07
I2102 n1_m1_96000_393600 0 3.213162e-07
I2103 n1_m1_96000_398400 0 2.455340e-07
I2104 n1_m1_96000_403200 0 2.529669e-07
I2105 n1_m1_96000_408000 0 3.259794e-07
I2106 n1_m1_96000_412800 0 2.002477e-07
I2107 n1_m1_96000_417600 0 2.997942e-07
I2108 n1_m1_96000_422400 0 1.998628e-07
I2109 n1_m1_96000_427200 0 1.998628e-07
I2110 n1_m1_96000_432000 0 2.997942e-07
I2111 n1_m1_96000_436800 0 1.998628e-07
I2112 n1_m1_96000_441600 0 3.007233e-07
I2113 n1_m1_96000_446400 0 2.084313e-07
I2114 n1_m1_96000_451200 0 2.094366e-07
I2115 n1_m1_96000_456000 0 3.125837e-07
I2116 n1_m1_96000_460800 0 2.098560e-07
I2117 n1_m1_96000_465600 0 3.182149e-07
I2118 n1_m1_96000_470400 0 2.315086e-07
I2119 n1_m1_96000_475200 0 2.459882e-07
I2120 n1_m1_96000_480000 0 3.432768e-07
I2121 n1_m1_100800_0 0 1.456414e-07
I2122 n1_m1_100800_4800 0 1.427665e-07
I2123 n1_m1_100800_9600 0 2.053052e-07
I2124 n1_m1_100800_14400 0 1.357990e-07
I2125 n1_m1_100800_19200 0 1.390578e-07
I2126 n1_m1_100800_24000 0 2.041507e-07
I2127 n1_m1_100800_28800 0 1.332419e-07
I2128 n1_m1_100800_33600 0 2.008126e-07
I2129 n1_m1_100800_38400 0 1.392846e-07
I2130 n1_m1_100800_43200 0 1.399040e-07
I2131 n1_m1_100800_48000 0 2.098560e-07
I2132 n1_m1_100800_52800 0 1.348523e-07
I2133 n1_m1_100800_57600 0 2.010271e-07
I2134 n1_m1_100800_62400 0 1.364078e-07
I2135 n1_m1_100800_67200 0 1.348771e-07
I2136 n1_m1_100800_72000 0 1.998628e-07
I2137 n1_m1_100800_76800 0 1.338633e-07
I2138 n1_m1_100800_81600 0 2.044873e-07
I2139 n1_m1_100800_86400 0 1.363489e-07
I2140 n1_m1_100800_91200 0 1.339287e-07
I2141 n1_m1_100800_96000 0 1.998628e-07
I2142 n1_m1_100800_100800 0 1.332419e-07
I2143 n1_m1_100800_105600 0 1.998628e-07
I2144 n1_m1_100800_110400 0 1.332419e-07
I2145 n1_m1_100800_115200 0 1.332419e-07
I2146 n1_m1_100800_120000 0 2.204222e-07
I2147 n1_m1_100800_124800 0 4.578374e-07
I2148 n1_m1_100800_129600 0 5.568083e-07
I2149 n1_m1_100800_134400 0 2.445075e-07
I2150 n1_m1_100800_139200 0 2.153030e-07
I2151 n1_m1_100800_144000 0 2.972567e-07
I2152 n1_m1_100800_148800 0 1.546450e-07
I2153 n1_m1_100800_153600 0 2.322036e-07
I2154 n1_m1_100800_158400 0 1.563940e-07
I2155 n1_m1_100800_163200 0 1.563940e-07
I2156 n1_m1_100800_168000 0 2.360432e-07
I2157 n1_m1_100800_172800 0 1.648070e-07
I2158 n1_m1_100800_177600 0 2.564657e-07
I2159 n1_m1_100800_182400 0 1.621631e-07
I2160 n1_m1_100800_187200 0 1.541697e-07
I2161 n1_m1_100800_192000 0 2.118463e-07
I2162 n1_m1_100800_196800 0 1.338764e-07
I2163 n1_m1_100800_201600 0 2.014376e-07
I2164 n1_m1_100800_206400 0 1.383472e-07
I2165 n1_m1_100800_211200 0 1.436755e-07
I2166 n1_m1_100800_216000 0 2.212393e-07
I2167 n1_m1_100800_220800 0 1.530492e-07
I2168 n1_m1_100800_225600 0 2.247218e-07
I2169 n1_m1_100800_230400 0 1.461669e-07
I2170 n1_m1_100800_235200 0 1.410740e-07
I2171 n1_m1_100800_240000 0 2.081079e-07
I2172 n1_m1_100800_244800 0 1.383581e-07
I2173 n1_m1_100800_249600 0 2.024230e-07
I2174 n1_m1_100800_254400 0 1.332419e-07
I2175 n1_m1_100800_259200 0 1.332419e-07
I2176 n1_m1_100800_264000 0 1.998628e-07
I2177 n1_m1_100800_268800 0 1.335101e-07
I2178 n1_m1_100800_273600 0 2.025774e-07
I2179 n1_m1_100800_278400 0 1.332419e-07
I2180 n1_m1_100800_283200 0 1.332419e-07
I2181 n1_m1_100800_288000 0 2.076261e-07
I2182 n1_m1_100800_292800 0 1.416246e-07
I2183 n1_m1_100800_297600 0 2.422838e-07
I2184 n1_m1_100800_302400 0 1.949797e-07
I2185 n1_m1_100800_307200 0 2.793251e-07
I2186 n1_m1_100800_312000 0 3.970762e-07
I2187 n1_m1_100800_316800 0 1.639095e-07
I2188 n1_m1_100800_321600 0 2.152132e-07
I2189 n1_m1_100800_326400 0 1.450571e-07
I2190 n1_m1_100800_331200 0 1.469980e-07
I2191 n1_m1_100800_336000 0 2.133284e-07
I2192 n1_m1_100800_340800 0 1.527731e-07
I2193 n1_m1_100800_345600 0 3.354978e-07
I2194 n1_m1_100800_350400 0 4.530274e-07
I2195 n1_m1_100800_355200 0 4.252855e-07
I2196 n1_m1_100800_360000 0 3.171844e-07
I2197 n1_m1_100800_364800 0 1.570068e-07
I2198 n1_m1_100800_369600 0 2.134985e-07
I2199 n1_m1_100800_374400 0 1.338125e-07
I2200 n1_m1_100800_379200 0 1.332419e-07
I2201 n1_m1_100800_384000 0 1.998628e-07
I2202 n1_m1_100800_388800 0 1.352696e-07
I2203 n1_m1_100800_393600 0 2.099215e-07
I2204 n1_m1_100800_398400 0 1.605234e-07
I2205 n1_m1_100800_403200 0 1.643929e-07
I2206 n1_m1_100800_408000 0 2.148460e-07
I2207 n1_m1_100800_412800 0 1.337259e-07
I2208 n1_m1_100800_417600 0 1.998628e-07
I2209 n1_m1_100800_422400 0 1.332419e-07
I2210 n1_m1_100800_427200 0 1.332419e-07
I2211 n1_m1_100800_432000 0 1.998628e-07
I2212 n1_m1_100800_436800 0 1.332419e-07
I2213 n1_m1_100800_441600 0 2.004822e-07
I2214 n1_m1_100800_446400 0 1.389542e-07
I2215 n1_m1_100800_451200 0 1.388992e-07
I2216 n1_m1_100800_456000 0 2.045841e-07
I2217 n1_m1_100800_460800 0 1.399040e-07
I2218 n1_m1_100800_465600 0 2.134348e-07
I2219 n1_m1_100800_470400 0 1.575778e-07
I2220 n1_m1_100800_475200 0 1.639921e-07
I2221 n1_m1_100800_480000 0 2.288512e-07
I2222 n1_m1_105600_0 0 2.076170e-07
I2223 n1_m1_105600_4800 0 2.127642e-07
I2224 n1_m1_105600_9600 0 3.197375e-07
I2225 n1_m1_105600_14400 0 2.056577e-07
I2226 n1_m1_105600_19200 0 2.091697e-07
I2227 n1_m1_105600_24000 0 3.285804e-07
I2228 n1_m1_105600_28800 0 2.107920e-07
I2229 n1_m1_105600_33600 0 3.007904e-07
I2230 n1_m1_105600_38400 0 2.026844e-07
I2231 n1_m1_105600_43200 0 2.029736e-07
I2232 n1_m1_105600_48000 0 3.044605e-07
I2233 n1_m1_105600_52800 0 2.006148e-07
I2234 n1_m1_105600_57600 0 3.034694e-07
I2235 n1_m1_105600_62400 0 2.098560e-07
I2236 n1_m1_105600_67200 0 2.050246e-07
I2237 n1_m1_105600_72000 0 2.997942e-07
I2238 n1_m1_105600_76800 0 2.016108e-07
I2239 n1_m1_105600_81600 0 3.086606e-07
I2240 n1_m1_105600_86400 0 2.071984e-07
I2241 n1_m1_105600_91200 0 2.025947e-07
I2242 n1_m1_105600_96000 0 3.004525e-07
I2243 n1_m1_105600_100800 0 2.009502e-07
I2244 n1_m1_105600_105600 0 3.003020e-07
I2245 n1_m1_105600_110400 0 1.998628e-07
I2246 n1_m1_105600_115200 0 1.998628e-07
I2247 n1_m1_105600_120000 0 3.230405e-07
I2248 n1_m1_105600_124800 0 4.542653e-07
I2249 n1_m1_105600_129600 0 5.758356e-07
I2250 n1_m1_105600_134400 0 3.438103e-07
I2251 n1_m1_105600_139200 0 3.047616e-07
I2252 n1_m1_105600_144000 0 3.963438e-07
I2253 n1_m1_105600_148800 0 2.226511e-07
I2254 n1_m1_105600_153600 0 3.335181e-07
I2255 n1_m1_105600_158400 0 2.238959e-07
I2256 n1_m1_105600_163200 0 2.243652e-07
I2257 n1_m1_105600_168000 0 3.491004e-07
I2258 n1_m1_105600_172800 0 2.412908e-07
I2259 n1_m1_105600_177600 0 3.649884e-07
I2260 n1_m1_105600_182400 0 2.400681e-07
I2261 n1_m1_105600_187200 0 2.299878e-07
I2262 n1_m1_105600_192000 0 3.216976e-07
I2263 n1_m1_105600_196800 0 2.027351e-07
I2264 n1_m1_105600_201600 0 3.014253e-07
I2265 n1_m1_105600_206400 0 2.054767e-07
I2266 n1_m1_105600_211200 0 2.116170e-07
I2267 n1_m1_105600_216000 0 3.213086e-07
I2268 n1_m1_105600_220800 0 2.216333e-07
I2269 n1_m1_105600_225600 0 3.302382e-07
I2270 n1_m1_105600_230400 0 2.139657e-07
I2271 n1_m1_105600_235200 0 2.103057e-07
I2272 n1_m1_105600_240000 0 3.138561e-07
I2273 n1_m1_105600_244800 0 2.098560e-07
I2274 n1_m1_105600_249600 0 3.036346e-07
I2275 n1_m1_105600_254400 0 1.998628e-07
I2276 n1_m1_105600_259200 0 1.998628e-07
I2277 n1_m1_105600_264000 0 2.997942e-07
I2278 n1_m1_105600_268800 0 2.007093e-07
I2279 n1_m1_105600_273600 0 3.083627e-07
I2280 n1_m1_105600_278400 0 1.998628e-07
I2281 n1_m1_105600_283200 0 2.040434e-07
I2282 n1_m1_105600_288000 0 3.139921e-07
I2283 n1_m1_105600_292800 0 2.150141e-07
I2284 n1_m1_105600_297600 0 3.680905e-07
I2285 n1_m1_105600_302400 0 2.865054e-07
I2286 n1_m1_105600_307200 0 3.647539e-07
I2287 n1_m1_105600_312000 0 5.037432e-07
I2288 n1_m1_105600_316800 0 2.385461e-07
I2289 n1_m1_105600_321600 0 3.123285e-07
I2290 n1_m1_105600_326400 0 2.037754e-07
I2291 n1_m1_105600_331200 0 2.051461e-07
I2292 n1_m1_105600_336000 0 3.180630e-07
I2293 n1_m1_105600_340800 0 2.194483e-07
I2294 n1_m1_105600_345600 0 3.757033e-07
I2295 n1_m1_105600_350400 0 3.911628e-07
I2296 n1_m1_105600_355200 0 3.807158e-07
I2297 n1_m1_105600_360000 0 3.806730e-07
I2298 n1_m1_105600_364800 0 2.280211e-07
I2299 n1_m1_105600_369600 0 3.120551e-07
I2300 n1_m1_105600_374400 0 1.998628e-07
I2301 n1_m1_105600_379200 0 2.007587e-07
I2302 n1_m1_105600_384000 0 3.053826e-07
I2303 n1_m1_105600_388800 0 2.018553e-07
I2304 n1_m1_105600_393600 0 3.061441e-07
I2305 n1_m1_105600_398400 0 2.256088e-07
I2306 n1_m1_105600_403200 0 2.274277e-07
I2307 n1_m1_105600_408000 0 3.076458e-07
I2308 n1_m1_105600_412800 0 1.998628e-07
I2309 n1_m1_105600_417600 0 2.997942e-07
I2310 n1_m1_105600_422400 0 1.998628e-07
I2311 n1_m1_105600_427200 0 1.998628e-07
I2312 n1_m1_105600_432000 0 2.997942e-07
I2313 n1_m1_105600_436800 0 1.998628e-07
I2314 n1_m1_105600_441600 0 3.007233e-07
I2315 n1_m1_105600_446400 0 2.084313e-07
I2316 n1_m1_105600_451200 0 2.083487e-07
I2317 n1_m1_105600_456000 0 3.068761e-07
I2318 n1_m1_105600_460800 0 2.098560e-07
I2319 n1_m1_105600_465600 0 3.201522e-07
I2320 n1_m1_105600_470400 0 2.363667e-07
I2321 n1_m1_105600_475200 0 2.459882e-07
I2322 n1_m1_105600_480000 0 3.432768e-07
I2323 n1_m1_110400_0 0 1.337078e-07
I2324 n1_m1_110400_4800 0 1.366530e-07
I2325 n1_m1_110400_9600 0 2.103872e-07
I2326 n1_m1_110400_14400 0 1.368763e-07
I2327 n1_m1_110400_19200 0 1.441505e-07
I2328 n1_m1_110400_24000 0 2.147792e-07
I2329 n1_m1_110400_28800 0 1.407958e-07
I2330 n1_m1_110400_33600 0 2.049242e-07
I2331 n1_m1_110400_38400 0 1.343025e-07
I2332 n1_m1_110400_43200 0 1.333239e-07
I2333 n1_m1_110400_48000 0 2.007885e-07
I2334 n1_m1_110400_52800 0 1.345511e-07
I2335 n1_m1_110400_57600 0 2.058808e-07
I2336 n1_m1_110400_62400 0 1.419194e-07
I2337 n1_m1_110400_67200 0 1.379632e-07
I2338 n1_m1_110400_72000 0 2.015688e-07
I2339 n1_m1_110400_76800 0 1.334237e-07
I2340 n1_m1_110400_81600 0 2.002222e-07
I2341 n1_m1_110400_86400 0 1.337112e-07
I2342 n1_m1_110400_91200 0 1.379531e-07
I2343 n1_m1_110400_96000 0 2.047494e-07
I2344 n1_m1_110400_100800 0 1.394222e-07
I2345 n1_m1_110400_105600 0 2.038622e-07
I2346 n1_m1_110400_110400 0 1.333345e-07
I2347 n1_m1_110400_115200 0 1.332419e-07
I2348 n1_m1_110400_120000 0 2.057037e-07
I2349 n1_m1_110400_124800 0 1.650103e-07
I2350 n1_m1_110400_129600 0 2.387514e-07
I2351 n1_m1_110400_134400 0 1.857072e-07
I2352 n1_m1_110400_139200 0 1.706281e-07
I2353 n1_m1_110400_144000 0 2.201949e-07
I2354 n1_m1_110400_148800 0 1.402871e-07
I2355 n1_m1_110400_153600 0 2.023884e-07
I2356 n1_m1_110400_158400 0 1.342054e-07
I2357 n1_m1_110400_163200 0 1.345724e-07
I2358 n1_m1_110400_168000 0 2.092885e-07
I2359 n1_m1_110400_172800 0 1.413493e-07
I2360 n1_m1_110400_177600 0 2.184251e-07
I2361 n1_m1_110400_182400 0 1.520081e-07
I2362 n1_m1_110400_187200 0 1.509674e-07
I2363 n1_m1_110400_192000 0 2.175263e-07
I2364 n1_m1_110400_196800 0 1.410554e-07
I2365 n1_m1_110400_201600 0 2.110535e-07
I2366 n1_m1_110400_206400 0 1.402966e-07
I2367 n1_m1_110400_211200 0 1.399040e-07
I2368 n1_m1_110400_216000 0 2.099565e-07
I2369 n1_m1_110400_220800 0 1.403728e-07
I2370 n1_m1_110400_225600 0 2.105637e-07
I2371 n1_m1_110400_230400 0 1.400025e-07
I2372 n1_m1_110400_235200 0 1.393549e-07
I2373 n1_m1_110400_240000 0 2.045823e-07
I2374 n1_m1_110400_244800 0 1.399040e-07
I2375 n1_m1_110400_249600 0 2.035894e-07
I2376 n1_m1_110400_254400 0 1.332816e-07
I2377 n1_m1_110400_259200 0 1.332419e-07
I2378 n1_m1_110400_264000 0 2.008388e-07
I2379 n1_m1_110400_268800 0 1.340363e-07
I2380 n1_m1_110400_273600 0 2.055752e-07
I2381 n1_m1_110400_278400 0 1.332419e-07
I2382 n1_m1_110400_283200 0 1.372887e-07
I2383 n1_m1_110400_288000 0 2.124715e-07
I2384 n1_m1_110400_292800 0 1.478989e-07
I2385 n1_m1_110400_297600 0 2.457471e-07
I2386 n1_m1_110400_302400 0 1.848680e-07
I2387 n1_m1_110400_307200 0 1.962064e-07
I2388 n1_m1_110400_312000 0 2.746016e-07
I2389 n1_m1_110400_316800 0 1.552833e-07
I2390 n1_m1_110400_321600 0 2.101916e-07
I2391 n1_m1_110400_326400 0 1.333057e-07
I2392 n1_m1_110400_331200 0 1.332419e-07
I2393 n1_m1_110400_336000 0 2.062597e-07
I2394 n1_m1_110400_340800 0 1.432100e-07
I2395 n1_m1_110400_345600 0 2.147653e-07
I2396 n1_m1_110400_350400 0 1.500291e-07
I2397 n1_m1_110400_355200 0 1.586646e-07
I2398 n1_m1_110400_360000 0 2.280888e-07
I2399 n1_m1_110400_364800 0 1.441887e-07
I2400 n1_m1_110400_369600 0 2.044975e-07
I2401 n1_m1_110400_374400 0 1.332419e-07
I2402 n1_m1_110400_379200 0 1.341091e-07
I2403 n1_m1_110400_384000 0 2.052723e-07
I2404 n1_m1_110400_388800 0 1.332419e-07
I2405 n1_m1_110400_393600 0 2.016193e-07
I2406 n1_m1_110400_398400 0 1.422853e-07
I2407 n1_m1_110400_403200 0 1.445977e-07
I2408 n1_m1_110400_408000 0 2.038546e-07
I2409 n1_m1_110400_412800 0 1.334032e-07
I2410 n1_m1_110400_417600 0 2.009075e-07
I2411 n1_m1_110400_422400 0 1.332419e-07
I2412 n1_m1_110400_427200 0 1.332419e-07
I2413 n1_m1_110400_432000 0 1.998628e-07
I2414 n1_m1_110400_436800 0 1.332419e-07
I2415 n1_m1_110400_441600 0 2.004822e-07
I2416 n1_m1_110400_446400 0 1.389542e-07
I2417 n1_m1_110400_451200 0 1.390922e-07
I2418 n1_m1_110400_456000 0 2.055971e-07
I2419 n1_m1_110400_460800 0 1.399040e-07
I2420 n1_m1_110400_465600 0 2.130909e-07
I2421 n1_m1_110400_470400 0 1.567156e-07
I2422 n1_m1_110400_475200 0 1.639921e-07
I2423 n1_m1_110400_480000 0 2.288512e-07
I2424 n1_m1_115200_0 0 6.742543e-08
I2425 n1_m1_115200_4800 0 6.949420e-08
I2426 n1_m1_115200_9600 0 1.049375e-07
I2427 n1_m1_115200_14400 0 7.411278e-08
I2428 n1_m1_115200_19200 0 8.267977e-08
I2429 n1_m1_115200_24000 0 1.136706e-07
I2430 n1_m1_115200_28800 0 7.127186e-08
I2431 n1_m1_115200_33600 0 1.061874e-07
I2432 n1_m1_115200_38400 0 6.914127e-08
I2433 n1_m1_115200_43200 0 6.681578e-08
I2434 n1_m1_115200_48000 0 1.021312e-07
I2435 n1_m1_115200_52800 0 6.973207e-08
I2436 n1_m1_115200_57600 0 1.096351e-07
I2437 n1_m1_115200_62400 0 7.474124e-08
I2438 n1_m1_115200_67200 0 7.138351e-08
I2439 n1_m1_115200_72000 0 1.039853e-07
I2440 n1_m1_115200_76800 0 6.682835e-08
I2441 n1_m1_115200_81600 0 9.993141e-08
I2442 n1_m1_115200_86400 0 6.668288e-08
I2443 n1_m1_115200_91200 0 6.921561e-08
I2444 n1_m1_115200_96000 0 1.046694e-07
I2445 n1_m1_115200_100800 0 6.995199e-08
I2446 n1_m1_115200_105600 0 1.041328e-07
I2447 n1_m1_115200_110400 0 6.684092e-08
I2448 n1_m1_115200_115200 0 6.662094e-08
I2449 n1_m1_115200_120000 0 1.026224e-07
I2450 n1_m1_115200_124800 0 7.975242e-08
I2451 n1_m1_115200_129600 0 1.170271e-07
I2452 n1_m1_115200_134400 0 9.171391e-08
I2453 n1_m1_115200_139200 0 8.469394e-08
I2454 n1_m1_115200_144000 0 1.096706e-07
I2455 n1_m1_115200_148800 0 7.212678e-08
I2456 n1_m1_115200_153600 0 1.022874e-07
I2457 n1_m1_115200_158400 0 6.662094e-08
I2458 n1_m1_115200_163200 0 6.664065e-08
I2459 n1_m1_115200_168000 0 1.017119e-07
I2460 n1_m1_115200_172800 0 6.995199e-08
I2461 n1_m1_115200_177600 0 1.058511e-07
I2462 n1_m1_115200_182400 0 7.340003e-08
I2463 n1_m1_115200_187200 0 7.423757e-08
I2464 n1_m1_115200_192000 0 1.141561e-07
I2465 n1_m1_115200_196800 0 7.360363e-08
I2466 n1_m1_115200_201600 0 1.094910e-07
I2467 n1_m1_115200_206400 0 7.144784e-08
I2468 n1_m1_115200_211200 0 6.995199e-08
I2469 n1_m1_115200_216000 0 1.049280e-07
I2470 n1_m1_115200_220800 0 6.995199e-08
I2471 n1_m1_115200_225600 0 1.049280e-07
I2472 n1_m1_115200_230400 0 6.995199e-08
I2473 n1_m1_115200_235200 0 6.965605e-08
I2474 n1_m1_115200_240000 0 1.020856e-07
I2475 n1_m1_115200_244800 0 6.995199e-08
I2476 n1_m1_115200_249600 0 1.039833e-07
I2477 n1_m1_115200_254400 0 6.671522e-08
I2478 n1_m1_115200_259200 0 6.662094e-08
I2479 n1_m1_115200_264000 0 1.022506e-07
I2480 n1_m1_115200_268800 0 6.744992e-08
I2481 n1_m1_115200_273600 0 1.027876e-07
I2482 n1_m1_115200_278400 0 6.662094e-08
I2483 n1_m1_115200_283200 0 6.864435e-08
I2484 n1_m1_115200_288000 0 1.085391e-07
I2485 n1_m1_115200_292800 0 7.414153e-08
I2486 n1_m1_115200_297600 0 1.210522e-07
I2487 n1_m1_115200_302400 0 9.224354e-08
I2488 n1_m1_115200_307200 0 1.005275e-07
I2489 n1_m1_115200_312000 0 1.398607e-07
I2490 n1_m1_115200_316800 0 7.850786e-08
I2491 n1_m1_115200_321600 0 1.053203e-07
I2492 n1_m1_115200_326400 0 6.665535e-08
I2493 n1_m1_115200_331200 0 6.662094e-08
I2494 n1_m1_115200_336000 0 1.034921e-07
I2495 n1_m1_115200_340800 0 7.762610e-08
I2496 n1_m1_115200_345600 0 1.153738e-07
I2497 n1_m1_115200_350400 0 7.153805e-08
I2498 n1_m1_115200_355200 0 7.071763e-08
I2499 n1_m1_115200_360000 0 1.058077e-07
I2500 n1_m1_115200_364800 0 7.015624e-08
I2501 n1_m1_115200_369600 0 1.020925e-07
I2502 n1_m1_115200_374400 0 6.662094e-08
I2503 n1_m1_115200_379200 0 6.705453e-08
I2504 n1_m1_115200_384000 0 1.026362e-07
I2505 n1_m1_115200_388800 0 6.662094e-08
I2506 n1_m1_115200_393600 0 1.007504e-07
I2507 n1_m1_115200_398400 0 7.090175e-08
I2508 n1_m1_115200_403200 0 7.214057e-08
I2509 n1_m1_115200_408000 0 1.019273e-07
I2510 n1_m1_115200_412800 0 6.700433e-08
I2511 n1_m1_115200_417600 0 1.024140e-07
I2512 n1_m1_115200_422400 0 6.662094e-08
I2513 n1_m1_115200_427200 0 6.662094e-08
I2514 n1_m1_115200_432000 0 9.993141e-08
I2515 n1_m1_115200_436800 0 6.662094e-08
I2516 n1_m1_115200_441600 0 1.002411e-07
I2517 n1_m1_115200_446400 0 6.947711e-08
I2518 n1_m1_115200_451200 0 6.990839e-08
I2519 n1_m1_115200_456000 0 1.046992e-07
I2520 n1_m1_115200_460800 0 6.995199e-08
I2521 n1_m1_115200_465600 0 1.059003e-07
I2522 n1_m1_115200_470400 0 7.673995e-08
I2523 n1_m1_115200_475200 0 8.199606e-08
I2524 n1_m1_115200_480000 0 1.144256e-07
I2525 n1_m1_120000_0 0 1.333836e-07
I2526 n1_m1_120000_4800 0 1.344121e-07
I2527 n1_m1_120000_9600 0 2.293810e-07
I2528 n1_m1_120000_14400 0 2.731591e-07
I2529 n1_m1_120000_19200 0 5.197077e-07
I2530 n1_m1_120000_24000 0 6.470330e-07
I2531 n1_m1_120000_28800 0 1.786028e-07
I2532 n1_m1_120000_33600 0 2.495317e-07
I2533 n1_m1_120000_38400 0 1.409687e-07
I2534 n1_m1_120000_43200 0 1.353838e-07
I2535 n1_m1_120000_48000 0 3.065545e-07
I2536 n1_m1_120000_52800 0 2.541194e-07
I2537 n1_m1_120000_57600 0 4.741602e-07
I2538 n1_m1_120000_62400 0 3.146109e-07
I2539 n1_m1_120000_67200 0 2.487483e-07
I2540 n1_m1_120000_72000 0 3.964227e-07
I2541 n1_m1_120000_76800 0 2.040125e-07
I2542 n1_m1_120000_81600 0 2.795578e-07
I2543 n1_m1_120000_86400 0 1.855120e-07
I2544 n1_m1_120000_91200 0 1.885492e-07
I2545 n1_m1_120000_96000 0 2.406591e-07
I2546 n1_m1_120000_100800 0 1.448648e-07
I2547 n1_m1_120000_105600 0 2.210983e-07
I2548 n1_m1_120000_110400 0 1.390700e-07
I2549 n1_m1_120000_115200 0 1.392296e-07
I2550 n1_m1_120000_120000 0 2.127791e-07
I2551 n1_m1_120000_124800 0 1.727615e-07
I2552 n1_m1_120000_129600 0 2.333802e-07
I2553 n1_m1_120000_134400 0 1.707083e-07
I2554 n1_m1_120000_139200 0 1.672223e-07
I2555 n1_m1_120000_144000 0 2.152789e-07
I2556 n1_m1_120000_148800 0 1.374493e-07
I2557 n1_m1_120000_153600 0 2.145525e-07
I2558 n1_m1_120000_158400 0 1.411686e-07
I2559 n1_m1_120000_163200 0 1.359721e-07
I2560 n1_m1_120000_168000 0 2.079816e-07
I2561 n1_m1_120000_172800 0 1.484296e-07
I2562 n1_m1_120000_177600 0 2.146281e-07
I2563 n1_m1_120000_182400 0 1.435996e-07
I2564 n1_m1_120000_187200 0 1.528984e-07
I2565 n1_m1_120000_192000 0 2.385027e-07
I2566 n1_m1_120000_196800 0 1.520506e-07
I2567 n1_m1_120000_201600 0 2.197665e-07
I2568 n1_m1_120000_206400 0 1.456552e-07
I2569 n1_m1_120000_211200 0 1.442235e-07
I2570 n1_m1_120000_216000 0 2.063777e-07
I2571 n1_m1_120000_220800 0 1.461213e-07
I2572 n1_m1_120000_225600 0 2.183127e-07
I2573 n1_m1_120000_230400 0 1.407906e-07
I2574 n1_m1_120000_235200 0 1.512231e-07
I2575 n1_m1_120000_240000 0 2.211564e-07
I2576 n1_m1_120000_244800 0 1.442798e-07
I2577 n1_m1_120000_249600 0 2.084055e-07
I2578 n1_m1_120000_254400 0 1.338567e-07
I2579 n1_m1_120000_259200 0 1.358489e-07
I2580 n1_m1_120000_264000 0 2.086275e-07
I2581 n1_m1_120000_268800 0 1.388200e-07
I2582 n1_m1_120000_273600 0 2.102138e-07
I2583 n1_m1_120000_278400 0 1.382385e-07
I2584 n1_m1_120000_283200 0 1.392502e-07
I2585 n1_m1_120000_288000 0 2.114148e-07
I2586 n1_m1_120000_292800 0 1.403444e-07
I2587 n1_m1_120000_297600 0 2.189494e-07
I2588 n1_m1_120000_302400 0 1.711932e-07
I2589 n1_m1_120000_307200 0 2.206046e-07
I2590 n1_m1_120000_312000 0 3.633795e-07
I2591 n1_m1_120000_316800 0 1.669034e-07
I2592 n1_m1_120000_321600 0 2.220322e-07
I2593 n1_m1_120000_326400 0 1.453957e-07
I2594 n1_m1_120000_331200 0 1.445855e-07
I2595 n1_m1_120000_336000 0 2.085616e-07
I2596 n1_m1_120000_340800 0 1.384293e-07
I2597 n1_m1_120000_345600 0 2.096905e-07
I2598 n1_m1_120000_350400 0 1.399434e-07
I2599 n1_m1_120000_355200 0 1.367249e-07
I2600 n1_m1_120000_360000 0 2.084183e-07
I2601 n1_m1_120000_364800 0 1.379494e-07
I2602 n1_m1_120000_369600 0 1.998628e-07
I2603 n1_m1_120000_374400 0 1.339163e-07
I2604 n1_m1_120000_379200 0 1.396597e-07
I2605 n1_m1_120000_384000 0 2.158539e-07
I2606 n1_m1_120000_388800 0 1.400347e-07
I2607 n1_m1_120000_393600 0 2.139570e-07
I2608 n1_m1_120000_398400 0 1.598284e-07
I2609 n1_m1_120000_403200 0 1.443775e-07
I2610 n1_m1_120000_408000 0 2.042383e-07
I2611 n1_m1_120000_412800 0 1.372690e-07
I2612 n1_m1_120000_417600 0 2.242100e-07
I2613 n1_m1_120000_422400 0 1.406531e-07
I2614 n1_m1_120000_427200 0 1.382385e-07
I2615 n1_m1_120000_432000 0 2.025366e-07
I2616 n1_m1_120000_436800 0 1.382385e-07
I2617 n1_m1_120000_441600 0 2.115077e-07
I2618 n1_m1_120000_446400 0 1.403789e-07
I2619 n1_m1_120000_451200 0 1.406431e-07
I2620 n1_m1_120000_456000 0 2.167912e-07
I2621 n1_m1_120000_460800 0 1.448042e-07
I2622 n1_m1_120000_465600 0 2.352960e-07
I2623 n1_m1_120000_470400 0 1.974020e-07
I2624 n1_m1_120000_475200 0 2.153277e-07
I2625 n1_m1_120000_480000 0 2.430325e-07
I2626 n1_m1_124800_0 0 1.407992e-07
I2627 n1_m1_124800_4800 0 1.342100e-07
I2628 n1_m1_124800_9600 0 2.170230e-07
I2629 n1_m1_124800_14400 0 1.946607e-07
I2630 n1_m1_124800_19200 0 3.568333e-07
I2631 n1_m1_124800_24000 0 4.579708e-07
I2632 n1_m1_124800_28800 0 1.614271e-07
I2633 n1_m1_124800_33600 0 2.327530e-07
I2634 n1_m1_124800_38400 0 1.437622e-07
I2635 n1_m1_124800_43200 0 1.563403e-07
I2636 n1_m1_124800_48000 0 8.145510e-07
I2637 n1_m1_124800_52800 0 6.887085e-07
I2638 n1_m1_124800_57600 0 1.208940e-06
I2639 n1_m1_124800_62400 0 7.653876e-07
I2640 n1_m1_124800_67200 0 9.270608e-07
I2641 n1_m1_124800_72000 0 1.655590e-06
I2642 n1_m1_124800_76800 0 1.094752e-06
I2643 n1_m1_124800_81600 0 1.547168e-06
I2644 n1_m1_124800_86400 0 9.121720e-07
I2645 n1_m1_124800_91200 0 9.482650e-07
I2646 n1_m1_124800_96000 0 9.563037e-07
I2647 n1_m1_124800_100800 0 2.839051e-07
I2648 n1_m1_124800_105600 0 2.533346e-07
I2649 n1_m1_124800_110400 0 1.417811e-07
I2650 n1_m1_124800_115200 0 1.375194e-07
I2651 n1_m1_124800_120000 0 2.115659e-07
I2652 n1_m1_124800_124800 0 2.178207e-07
I2653 n1_m1_124800_129600 0 2.519962e-07
I2654 n1_m1_124800_134400 0 1.595330e-07
I2655 n1_m1_124800_139200 0 1.513128e-07
I2656 n1_m1_124800_144000 0 2.032538e-07
I2657 n1_m1_124800_148800 0 1.338625e-07
I2658 n1_m1_124800_153600 0 2.025342e-07
I2659 n1_m1_124800_158400 0 1.390319e-07
I2660 n1_m1_124800_163200 0 1.395387e-07
I2661 n1_m1_124800_168000 0 2.211431e-07
I2662 n1_m1_124800_172800 0 1.572670e-07
I2663 n1_m1_124800_177600 0 2.272017e-07
I2664 n1_m1_124800_182400 0 1.432212e-07
I2665 n1_m1_124800_187200 0 1.527073e-07
I2666 n1_m1_124800_192000 0 2.515638e-07
I2667 n1_m1_124800_196800 0 1.628869e-07
I2668 n1_m1_124800_201600 0 2.240252e-07
I2669 n1_m1_124800_206400 0 1.387636e-07
I2670 n1_m1_124800_211200 0 1.449696e-07
I2671 n1_m1_124800_216000 0 2.080769e-07
I2672 n1_m1_124800_220800 0 1.427412e-07
I2673 n1_m1_124800_225600 0 2.160460e-07
I2674 n1_m1_124800_230400 0 1.412459e-07
I2675 n1_m1_124800_235200 0 1.481815e-07
I2676 n1_m1_124800_240000 0 2.174992e-07
I2677 n1_m1_124800_244800 0 1.435008e-07
I2678 n1_m1_124800_249600 0 2.037650e-07
I2679 n1_m1_124800_254400 0 1.344991e-07
I2680 n1_m1_124800_259200 0 1.388827e-07
I2681 n1_m1_124800_264000 0 2.102896e-07
I2682 n1_m1_124800_268800 0 1.401685e-07
I2683 n1_m1_124800_273600 0 2.098996e-07
I2684 n1_m1_124800_278400 0 1.399040e-07
I2685 n1_m1_124800_283200 0 1.399040e-07
I2686 n1_m1_124800_288000 0 2.098560e-07
I2687 n1_m1_124800_292800 0 1.399040e-07
I2688 n1_m1_124800_297600 0 2.160011e-07
I2689 n1_m1_124800_302400 0 1.607676e-07
I2690 n1_m1_124800_307200 0 1.932342e-07
I2691 n1_m1_124800_312000 0 3.361227e-07
I2692 n1_m1_124800_316800 0 1.679013e-07
I2693 n1_m1_124800_321600 0 2.304231e-07
I2694 n1_m1_124800_326400 0 1.504366e-07
I2695 n1_m1_124800_331200 0 1.461218e-07
I2696 n1_m1_124800_336000 0 2.172653e-07
I2697 n1_m1_124800_340800 0 1.409726e-07
I2698 n1_m1_124800_345600 0 2.129016e-07
I2699 n1_m1_124800_350400 0 1.421977e-07
I2700 n1_m1_124800_355200 0 1.390500e-07
I2701 n1_m1_124800_360000 0 2.033273e-07
I2702 n1_m1_124800_364800 0 1.380342e-07
I2703 n1_m1_124800_369600 0 2.002964e-07
I2704 n1_m1_124800_374400 0 1.342054e-07
I2705 n1_m1_124800_379200 0 1.401279e-07
I2706 n1_m1_124800_384000 0 2.190091e-07
I2707 n1_m1_124800_388800 0 1.421951e-07
I2708 n1_m1_124800_393600 0 2.217258e-07
I2709 n1_m1_124800_398400 0 1.773247e-07
I2710 n1_m1_124800_403200 0 1.505275e-07
I2711 n1_m1_124800_408000 0 2.167934e-07
I2712 n1_m1_124800_412800 0 1.406261e-07
I2713 n1_m1_124800_417600 0 2.183817e-07
I2714 n1_m1_124800_422400 0 1.404456e-07
I2715 n1_m1_124800_427200 0 1.399040e-07
I2716 n1_m1_124800_432000 0 2.034279e-07
I2717 n1_m1_124800_436800 0 1.399040e-07
I2718 n1_m1_124800_441600 0 2.151829e-07
I2719 n1_m1_124800_446400 0 1.408537e-07
I2720 n1_m1_124800_451200 0 1.401261e-07
I2721 n1_m1_124800_456000 0 2.119404e-07
I2722 n1_m1_124800_460800 0 1.411797e-07
I2723 n1_m1_124800_465600 0 2.305309e-07
I2724 n1_m1_124800_470400 0 1.934172e-07
I2725 n1_m1_124800_475200 0 2.018061e-07
I2726 n1_m1_124800_480000 0 2.441451e-07
I2727 n1_m1_129600_0 0 2.095338e-07
I2728 n1_m1_129600_4800 0 1.925043e-07
I2729 n1_m1_129600_9600 0 3.036394e-07
I2730 n1_m1_129600_14400 0 2.325542e-07
I2731 n1_m1_129600_19200 0 2.934019e-07
I2732 n1_m1_129600_24000 0 4.182185e-07
I2733 n1_m1_129600_28800 0 2.413786e-07
I2734 n1_m1_129600_33600 0 3.499917e-07
I2735 n1_m1_129600_38400 0 2.273769e-07
I2736 n1_m1_129600_43200 0 2.630121e-07
I2737 n1_m1_129600_48000 0 1.409040e-06
I2738 n1_m1_129600_52800 0 1.072257e-06
I2739 n1_m1_129600_57600 0 1.996771e-06
I2740 n1_m1_129600_62400 0 1.300434e-06
I2741 n1_m1_129600_67200 0 1.432348e-06
I2742 n1_m1_129600_72000 0 2.267102e-06
I2743 n1_m1_129600_76800 0 1.391991e-06
I2744 n1_m1_129600_81600 0 1.991742e-06
I2745 n1_m1_129600_86400 0 1.085285e-06
I2746 n1_m1_129600_91200 0 1.423790e-06
I2747 n1_m1_129600_96000 0 1.515599e-06
I2748 n1_m1_129600_100800 0 4.778264e-07
I2749 n1_m1_129600_105600 0 4.447519e-07
I2750 n1_m1_129600_110400 0 2.531381e-07
I2751 n1_m1_129600_115200 0 2.604938e-07
I2752 n1_m1_129600_120000 0 3.953727e-07
I2753 n1_m1_129600_124800 0 5.044302e-07
I2754 n1_m1_129600_129600 0 4.891669e-07
I2755 n1_m1_129600_134400 0 2.545894e-07
I2756 n1_m1_129600_139200 0 2.343170e-07
I2757 n1_m1_129600_144000 0 3.173215e-07
I2758 n1_m1_129600_148800 0 2.214498e-07
I2759 n1_m1_129600_153600 0 3.171778e-07
I2760 n1_m1_129600_158400 0 2.113359e-07
I2761 n1_m1_129600_163200 0 2.338397e-07
I2762 n1_m1_129600_168000 0 3.652704e-07
I2763 n1_m1_129600_172800 0 2.348881e-07
I2764 n1_m1_129600_177600 0 4.187239e-07
I2765 n1_m1_129600_182400 0 2.963609e-07
I2766 n1_m1_129600_187200 0 2.670523e-07
I2767 n1_m1_129600_192000 0 3.859818e-07
I2768 n1_m1_129600_196800 0 2.408708e-07
I2769 n1_m1_129600_201600 0 3.348340e-07
I2770 n1_m1_129600_206400 0 2.061620e-07
I2771 n1_m1_129600_211200 0 2.198640e-07
I2772 n1_m1_129600_216000 0 3.174428e-07
I2773 n1_m1_129600_220800 0 2.159825e-07
I2774 n1_m1_129600_225600 0 3.495676e-07
I2775 n1_m1_129600_230400 0 2.952221e-07
I2776 n1_m1_129600_235200 0 3.446702e-07
I2777 n1_m1_129600_240000 0 4.270472e-07
I2778 n1_m1_129600_244800 0 2.182049e-07
I2779 n1_m1_129600_249600 0 3.071652e-07
I2780 n1_m1_129600_254400 0 2.022804e-07
I2781 n1_m1_129600_259200 0 2.121216e-07
I2782 n1_m1_129600_264000 0 3.256236e-07
I2783 n1_m1_129600_268800 0 2.153364e-07
I2784 n1_m1_129600_273600 0 3.156870e-07
I2785 n1_m1_129600_278400 0 2.098560e-07
I2786 n1_m1_129600_283200 0 2.098560e-07
I2787 n1_m1_129600_288000 0 3.147839e-07
I2788 n1_m1_129600_292800 0 2.098560e-07
I2789 n1_m1_129600_297600 0 3.233191e-07
I2790 n1_m1_129600_302400 0 2.291244e-07
I2791 n1_m1_129600_307200 0 2.564752e-07
I2792 n1_m1_129600_312000 0 4.210496e-07
I2793 n1_m1_129600_316800 0 2.523925e-07
I2794 n1_m1_129600_321600 0 3.485117e-07
I2795 n1_m1_129600_326400 0 2.252980e-07
I2796 n1_m1_129600_331200 0 2.198491e-07
I2797 n1_m1_129600_336000 0 3.275416e-07
I2798 n1_m1_129600_340800 0 2.183391e-07
I2799 n1_m1_129600_345600 0 3.285359e-07
I2800 n1_m1_129600_350400 0 2.190927e-07
I2801 n1_m1_129600_355200 0 2.146845e-07
I2802 n1_m1_129600_360000 0 3.143590e-07
I2803 n1_m1_129600_364800 0 2.094804e-07
I2804 n1_m1_129600_369600 0 3.151837e-07
I2805 n1_m1_129600_374400 0 2.123130e-07
I2806 n1_m1_129600_379200 0 2.197642e-07
I2807 n1_m1_129600_384000 0 3.248494e-07
I2808 n1_m1_129600_388800 0 2.103162e-07
I2809 n1_m1_129600_393600 0 3.732754e-07
I2810 n1_m1_129600_398400 0 3.654359e-07
I2811 n1_m1_129600_403200 0 2.637294e-07
I2812 n1_m1_129600_408000 0 3.661176e-07
I2813 n1_m1_129600_412800 0 2.156656e-07
I2814 n1_m1_129600_417600 0 3.245049e-07
I2815 n1_m1_129600_422400 0 2.108583e-07
I2816 n1_m1_129600_427200 0 2.098560e-07
I2817 n1_m1_129600_432000 0 3.051418e-07
I2818 n1_m1_129600_436800 0 2.098560e-07
I2819 n1_m1_129600_441600 0 3.227743e-07
I2820 n1_m1_129600_446400 0 2.112806e-07
I2821 n1_m1_129600_451200 0 2.098560e-07
I2822 n1_m1_129600_456000 0 3.147839e-07
I2823 n1_m1_129600_460800 0 2.057735e-07
I2824 n1_m1_129600_465600 0 3.359286e-07
I2825 n1_m1_129600_470400 0 2.657366e-07
I2826 n1_m1_129600_475200 0 2.705127e-07
I2827 n1_m1_129600_480000 0 3.587259e-07
I2828 n1_m1_134400_0 0 1.323302e-07
I2829 n1_m1_134400_4800 0 1.225870e-07
I2830 n1_m1_134400_9600 0 1.981484e-07
I2831 n1_m1_134400_14400 0 1.518063e-07
I2832 n1_m1_134400_19200 0 1.742839e-07
I2833 n1_m1_134400_24000 0 2.572890e-07
I2834 n1_m1_134400_28800 0 1.542703e-07
I2835 n1_m1_134400_33600 0 2.315157e-07
I2836 n1_m1_134400_38400 0 1.492913e-07
I2837 n1_m1_134400_43200 0 1.596848e-07
I2838 n1_m1_134400_48000 0 4.960368e-07
I2839 n1_m1_134400_52800 0 3.463347e-07
I2840 n1_m1_134400_57600 0 5.483309e-07
I2841 n1_m1_134400_62400 0 3.458901e-07
I2842 n1_m1_134400_67200 0 4.425920e-07
I2843 n1_m1_134400_72000 0 7.614711e-07
I2844 n1_m1_134400_76800 0 4.658070e-07
I2845 n1_m1_134400_81600 0 7.116304e-07
I2846 n1_m1_134400_86400 0 3.063463e-07
I2847 n1_m1_134400_91200 0 3.875287e-07
I2848 n1_m1_134400_96000 0 4.536346e-07
I2849 n1_m1_134400_100800 0 1.981472e-07
I2850 n1_m1_134400_105600 0 2.579733e-07
I2851 n1_m1_134400_110400 0 1.633574e-07
I2852 n1_m1_134400_115200 0 1.597780e-07
I2853 n1_m1_134400_120000 0 2.468655e-07
I2854 n1_m1_134400_124800 0 3.555698e-07
I2855 n1_m1_134400_129600 0 3.551560e-07
I2856 n1_m1_134400_134400 0 2.122444e-07
I2857 n1_m1_134400_139200 0 2.020424e-07
I2858 n1_m1_134400_144000 0 2.371879e-07
I2859 n1_m1_134400_148800 0 1.553132e-07
I2860 n1_m1_134400_153600 0 2.201033e-07
I2861 n1_m1_134400_158400 0 1.532377e-07
I2862 n1_m1_134400_163200 0 2.079408e-07
I2863 n1_m1_134400_168000 0 3.213555e-07
I2864 n1_m1_134400_172800 0 2.243170e-07
I2865 n1_m1_134400_177600 0 6.400873e-07
I2866 n1_m1_134400_182400 0 3.425409e-07
I2867 n1_m1_134400_187200 0 2.550605e-07
I2868 n1_m1_134400_192000 0 2.677766e-07
I2869 n1_m1_134400_196800 0 1.578709e-07
I2870 n1_m1_134400_201600 0 2.226571e-07
I2871 n1_m1_134400_206400 0 1.430148e-07
I2872 n1_m1_134400_211200 0 1.467863e-07
I2873 n1_m1_134400_216000 0 2.190667e-07
I2874 n1_m1_134400_220800 0 1.587523e-07
I2875 n1_m1_134400_225600 0 3.143120e-07
I2876 n1_m1_134400_230400 0 3.441731e-07
I2877 n1_m1_134400_235200 0 4.168698e-07
I2878 n1_m1_134400_240000 0 4.301127e-07
I2879 n1_m1_134400_244800 0 1.573035e-07
I2880 n1_m1_134400_249600 0 2.169152e-07
I2881 n1_m1_134400_254400 0 1.373883e-07
I2882 n1_m1_134400_259200 0 1.416447e-07
I2883 n1_m1_134400_264000 0 2.167700e-07
I2884 n1_m1_134400_268800 0 1.404632e-07
I2885 n1_m1_134400_273600 0 2.098560e-07
I2886 n1_m1_134400_278400 0 1.399040e-07
I2887 n1_m1_134400_283200 0 1.380143e-07
I2888 n1_m1_134400_288000 0 2.059032e-07
I2889 n1_m1_134400_292800 0 1.398847e-07
I2890 n1_m1_134400_297600 0 2.128929e-07
I2891 n1_m1_134400_302400 0 1.465664e-07
I2892 n1_m1_134400_307200 0 1.540271e-07
I2893 n1_m1_134400_312000 0 2.504939e-07
I2894 n1_m1_134400_316800 0 1.679758e-07
I2895 n1_m1_134400_321600 0 2.329118e-07
I2896 n1_m1_134400_326400 0 1.466349e-07
I2897 n1_m1_134400_331200 0 1.456277e-07
I2898 n1_m1_134400_336000 0 2.124020e-07
I2899 n1_m1_134400_340800 0 1.432181e-07
I2900 n1_m1_134400_345600 0 2.194442e-07
I2901 n1_m1_134400_350400 0 1.465661e-07
I2902 n1_m1_134400_355200 0 1.445479e-07
I2903 n1_m1_134400_360000 0 2.116756e-07
I2904 n1_m1_134400_364800 0 1.430148e-07
I2905 n1_m1_134400_369600 0 2.175452e-07
I2906 n1_m1_134400_374400 0 1.472405e-07
I2907 n1_m1_134400_379200 0 1.514663e-07
I2908 n1_m1_134400_384000 0 2.166695e-07
I2909 n1_m1_134400_388800 0 1.418964e-07
I2910 n1_m1_134400_393600 0 2.591896e-07
I2911 n1_m1_134400_398400 0 2.562515e-07
I2912 n1_m1_134400_403200 0 1.814323e-07
I2913 n1_m1_134400_408000 0 2.537144e-07
I2914 n1_m1_134400_412800 0 1.444935e-07
I2915 n1_m1_134400_417600 0 2.191196e-07
I2916 n1_m1_134400_422400 0 1.423541e-07
I2917 n1_m1_134400_427200 0 1.399040e-07
I2918 n1_m1_134400_432000 0 2.034279e-07
I2919 n1_m1_134400_436800 0 1.399040e-07
I2920 n1_m1_134400_441600 0 2.151829e-07
I2921 n1_m1_134400_446400 0 1.408537e-07
I2922 n1_m1_134400_451200 0 1.399040e-07
I2923 n1_m1_134400_456000 0 2.098560e-07
I2924 n1_m1_134400_460800 0 1.399040e-07
I2925 n1_m1_134400_465600 0 2.196193e-07
I2926 n1_m1_134400_470400 0 1.677912e-07
I2927 n1_m1_134400_475200 0 1.742055e-07
I2928 n1_m1_134400_480000 0 2.357515e-07
I2929 n1_m1_139200_0 0 1.332144e-07
I2930 n1_m1_139200_4800 0 1.257677e-07
I2931 n1_m1_139200_9600 0 2.058218e-07
I2932 n1_m1_139200_14400 0 1.537543e-07
I2933 n1_m1_139200_19200 0 1.689660e-07
I2934 n1_m1_139200_24000 0 2.494297e-07
I2935 n1_m1_139200_28800 0 1.450491e-07
I2936 n1_m1_139200_33600 0 2.202620e-07
I2937 n1_m1_139200_38400 0 1.436893e-07
I2938 n1_m1_139200_43200 0 1.464409e-07
I2939 n1_m1_139200_48000 0 2.362385e-07
I2940 n1_m1_139200_52800 0 1.948239e-07
I2941 n1_m1_139200_57600 0 2.662703e-07
I2942 n1_m1_139200_62400 0 1.752978e-07
I2943 n1_m1_139200_67200 0 2.227830e-07
I2944 n1_m1_139200_72000 0 4.227759e-07
I2945 n1_m1_139200_76800 0 2.679808e-07
I2946 n1_m1_139200_81600 0 4.140619e-07
I2947 n1_m1_139200_86400 0 1.871197e-07
I2948 n1_m1_139200_91200 0 1.645019e-07
I2949 n1_m1_139200_96000 0 2.373922e-07
I2950 n1_m1_139200_100800 0 1.545592e-07
I2951 n1_m1_139200_105600 0 2.382029e-07
I2952 n1_m1_139200_110400 0 1.599537e-07
I2953 n1_m1_139200_115200 0 1.587335e-07
I2954 n1_m1_139200_120000 0 2.318684e-07
I2955 n1_m1_139200_124800 0 2.522001e-07
I2956 n1_m1_139200_129600 0 2.926987e-07
I2957 n1_m1_139200_134400 0 2.456441e-07
I2958 n1_m1_139200_139200 0 2.396977e-07
I2959 n1_m1_139200_144000 0 2.397012e-07
I2960 n1_m1_139200_148800 0 1.483071e-07
I2961 n1_m1_139200_153600 0 2.251960e-07
I2962 n1_m1_139200_158400 0 1.659427e-07
I2963 n1_m1_139200_163200 0 2.402929e-07
I2964 n1_m1_139200_168000 0 3.394794e-07
I2965 n1_m1_139200_172800 0 2.522514e-07
I2966 n1_m1_139200_177600 0 8.087548e-07
I2967 n1_m1_139200_182400 0 3.214799e-07
I2968 n1_m1_139200_187200 0 2.879189e-07
I2969 n1_m1_139200_192000 0 3.450158e-07
I2970 n1_m1_139200_196800 0 1.745079e-07
I2971 n1_m1_139200_201600 0 2.322532e-07
I2972 n1_m1_139200_206400 0 1.465661e-07
I2973 n1_m1_139200_211200 0 1.503376e-07
I2974 n1_m1_139200_216000 0 2.258643e-07
I2975 n1_m1_139200_220800 0 1.691879e-07
I2976 n1_m1_139200_225600 0 3.204970e-07
I2977 n1_m1_139200_230400 0 2.832557e-07
I2978 n1_m1_139200_235200 0 3.039009e-07
I2979 n1_m1_139200_240000 0 3.406215e-07
I2980 n1_m1_139200_244800 0 1.643817e-07
I2981 n1_m1_139200_249600 0 2.243220e-07
I2982 n1_m1_139200_254400 0 1.434983e-07
I2983 n1_m1_139200_259200 0 1.451483e-07
I2984 n1_m1_139200_264000 0 2.247218e-07
I2985 n1_m1_139200_268800 0 1.443016e-07
I2986 n1_m1_139200_273600 0 2.103833e-07
I2987 n1_m1_139200_278400 0 1.399040e-07
I2988 n1_m1_139200_283200 0 1.379809e-07
I2989 n1_m1_139200_288000 0 2.058332e-07
I2990 n1_m1_139200_292800 0 1.398844e-07
I2991 n1_m1_139200_297600 0 2.102001e-07
I2992 n1_m1_139200_302400 0 1.450593e-07
I2993 n1_m1_139200_307200 0 1.446878e-07
I2994 n1_m1_139200_312000 0 2.317144e-07
I2995 n1_m1_139200_316800 0 1.616548e-07
I2996 n1_m1_139200_321600 0 2.317126e-07
I2997 n1_m1_139200_326400 0 1.466349e-07
I2998 n1_m1_139200_331200 0 1.435018e-07
I2999 n1_m1_139200_336000 0 2.076166e-07
I3000 n1_m1_139200_340800 0 1.402376e-07
I3001 n1_m1_139200_345600 0 2.160564e-07
I3002 n1_m1_139200_350400 0 1.465661e-07
I3003 n1_m1_139200_355200 0 1.445122e-07
I3004 n1_m1_139200_360000 0 2.158918e-07
I3005 n1_m1_139200_364800 0 1.465661e-07
I3006 n1_m1_139200_369600 0 2.228252e-07
I3007 n1_m1_139200_374400 0 1.500288e-07
I3008 n1_m1_139200_379200 0 1.493642e-07
I3009 n1_m1_139200_384000 0 2.163011e-07
I3010 n1_m1_139200_388800 0 1.441710e-07
I3011 n1_m1_139200_393600 0 2.429468e-07
I3012 n1_m1_139200_398400 0 2.008786e-07
I3013 n1_m1_139200_403200 0 1.650229e-07
I3014 n1_m1_139200_408000 0 2.364440e-07
I3015 n1_m1_139200_412800 0 1.400141e-07
I3016 n1_m1_139200_417600 0 2.158834e-07
I3017 n1_m1_139200_422400 0 1.423541e-07
I3018 n1_m1_139200_427200 0 1.399040e-07
I3019 n1_m1_139200_432000 0 2.034279e-07
I3020 n1_m1_139200_436800 0 1.399040e-07
I3021 n1_m1_139200_441600 0 2.151829e-07
I3022 n1_m1_139200_446400 0 1.408537e-07
I3023 n1_m1_139200_451200 0 1.399040e-07
I3024 n1_m1_139200_456000 0 2.076744e-07
I3025 n1_m1_139200_460800 0 1.364078e-07
I3026 n1_m1_139200_465600 0 2.099798e-07
I3027 n1_m1_139200_470400 0 1.596023e-07
I3028 n1_m1_139200_475200 0 1.650054e-07
I3029 n1_m1_139200_480000 0 2.309901e-07
I3030 n1_m1_144000_0 0 2.117830e-07
I3031 n1_m1_144000_4800 0 1.993463e-07
I3032 n1_m1_144000_9600 0 3.082313e-07
I3033 n1_m1_144000_14400 0 2.146701e-07
I3034 n1_m1_144000_19200 0 2.253492e-07
I3035 n1_m1_144000_24000 0 3.435096e-07
I3036 n1_m1_144000_28800 0 2.137696e-07
I3037 n1_m1_144000_33600 0 3.241161e-07
I3038 n1_m1_144000_38400 0 2.098613e-07
I3039 n1_m1_144000_43200 0 2.066196e-07
I3040 n1_m1_144000_48000 0 3.156748e-07
I3041 n1_m1_144000_52800 0 2.258174e-07
I3042 n1_m1_144000_57600 0 3.293415e-07
I3043 n1_m1_144000_62400 0 2.149956e-07
I3044 n1_m1_144000_67200 0 2.068599e-07
I3045 n1_m1_144000_72000 0 3.189732e-07
I3046 n1_m1_144000_76800 0 2.025638e-07
I3047 n1_m1_144000_81600 0 3.092299e-07
I3048 n1_m1_144000_86400 0 2.060978e-07
I3049 n1_m1_144000_91200 0 2.188104e-07
I3050 n1_m1_144000_96000 0 3.246490e-07
I3051 n1_m1_144000_100800 0 2.133004e-07
I3052 n1_m1_144000_105600 0 3.262022e-07
I3053 n1_m1_144000_110400 0 2.185077e-07
I3054 n1_m1_144000_115200 0 2.143184e-07
I3055 n1_m1_144000_120000 0 3.215002e-07
I3056 n1_m1_144000_124800 0 3.592620e-07
I3057 n1_m1_144000_129600 0 4.716096e-07
I3058 n1_m1_144000_134400 0 3.774280e-07
I3059 n1_m1_144000_139200 0 3.525674e-07
I3060 n1_m1_144000_144000 0 3.451344e-07
I3061 n1_m1_144000_148800 0 2.126890e-07
I3062 n1_m1_144000_153600 0 3.451991e-07
I3063 n1_m1_144000_158400 0 2.456375e-07
I3064 n1_m1_144000_163200 0 2.934447e-07
I3065 n1_m1_144000_168000 0 4.163239e-07
I3066 n1_m1_144000_172800 0 2.801575e-07
I3067 n1_m1_144000_177600 0 6.375205e-07
I3068 n1_m1_144000_182400 0 3.203565e-07
I3069 n1_m1_144000_187200 0 4.091693e-07
I3070 n1_m1_144000_192000 0 6.793884e-07
I3071 n1_m1_144000_196800 0 2.912383e-07
I3072 n1_m1_144000_201600 0 3.424248e-07
I3073 n1_m1_144000_206400 0 2.126571e-07
I3074 n1_m1_144000_211200 0 2.181281e-07
I3075 n1_m1_144000_216000 0 3.325448e-07
I3076 n1_m1_144000_220800 0 2.458300e-07
I3077 n1_m1_144000_225600 0 3.833539e-07
I3078 n1_m1_144000_230400 0 2.515686e-07
I3079 n1_m1_144000_235200 0 2.492029e-07
I3080 n1_m1_144000_240000 0 3.536021e-07
I3081 n1_m1_144000_244800 0 2.370180e-07
I3082 n1_m1_144000_249600 0 3.328036e-07
I3083 n1_m1_144000_254400 0 2.205729e-07
I3084 n1_m1_144000_259200 0 2.281026e-07
I3085 n1_m1_144000_264000 0 3.510311e-07
I3086 n1_m1_144000_268800 0 2.289329e-07
I3087 n1_m1_144000_273600 0 3.237524e-07
I3088 n1_m1_144000_278400 0 2.098560e-07
I3089 n1_m1_144000_283200 0 2.098560e-07
I3090 n1_m1_144000_288000 0 3.147839e-07
I3091 n1_m1_144000_292800 0 2.098560e-07
I3092 n1_m1_144000_297600 0 3.157374e-07
I3093 n1_m1_144000_302400 0 2.234328e-07
I3094 n1_m1_144000_307200 0 2.130207e-07
I3095 n1_m1_144000_312000 0 3.233357e-07
I3096 n1_m1_144000_316800 0 2.281151e-07
I3097 n1_m1_144000_321600 0 3.351212e-07
I3098 n1_m1_144000_326400 0 2.145726e-07
I3099 n1_m1_144000_331200 0 2.159959e-07
I3100 n1_m1_144000_336000 0 3.140797e-07
I3101 n1_m1_144000_340800 0 2.118686e-07
I3102 n1_m1_144000_345600 0 3.280251e-07
I3103 n1_m1_144000_350400 0 2.211017e-07
I3104 n1_m1_144000_355200 0 2.211017e-07
I3105 n1_m1_144000_360000 0 3.313394e-07
I3106 n1_m1_144000_364800 0 2.202166e-07
I3107 n1_m1_144000_369600 0 3.401591e-07
I3108 n1_m1_144000_374400 0 2.299563e-07
I3109 n1_m1_144000_379200 0 2.204205e-07
I3110 n1_m1_144000_384000 0 3.180946e-07
I3111 n1_m1_144000_388800 0 2.124391e-07
I3112 n1_m1_144000_393600 0 3.483136e-07
I3113 n1_m1_144000_398400 0 2.570062e-07
I3114 n1_m1_144000_403200 0 2.393114e-07
I3115 n1_m1_144000_408000 0 3.559847e-07
I3116 n1_m1_144000_412800 0 2.087915e-07
I3117 n1_m1_144000_417600 0 3.165833e-07
I3118 n1_m1_144000_422400 0 2.108785e-07
I3119 n1_m1_144000_427200 0 2.098560e-07
I3120 n1_m1_144000_432000 0 3.051418e-07
I3121 n1_m1_144000_436800 0 2.098560e-07
I3122 n1_m1_144000_441600 0 3.227743e-07
I3123 n1_m1_144000_446400 0 2.112806e-07
I3124 n1_m1_144000_451200 0 2.100449e-07
I3125 n1_m1_144000_456000 0 3.156034e-07
I3126 n1_m1_144000_460800 0 2.087266e-07
I3127 n1_m1_144000_465600 0 3.112816e-07
I3128 n1_m1_144000_470400 0 2.335134e-07
I3129 n1_m1_144000_475200 0 2.410880e-07
I3130 n1_m1_144000_480000 0 3.511017e-07
I3131 n1_m1_148800_0 0 1.409162e-07
I3132 n1_m1_148800_4800 0 1.344227e-07
I3133 n1_m1_148800_9600 0 2.054580e-07
I3134 n1_m1_148800_14400 0 1.409611e-07
I3135 n1_m1_148800_19200 0 1.454278e-07
I3136 n1_m1_148800_24000 0 2.226386e-07
I3137 n1_m1_148800_28800 0 1.490564e-07
I3138 n1_m1_148800_33600 0 2.175966e-07
I3139 n1_m1_148800_38400 0 1.404716e-07
I3140 n1_m1_148800_43200 0 1.408772e-07
I3141 n1_m1_148800_48000 0 2.214683e-07
I3142 n1_m1_148800_52800 0 1.410449e-07
I3143 n1_m1_148800_57600 0 2.183101e-07
I3144 n1_m1_148800_62400 0 1.473148e-07
I3145 n1_m1_148800_67200 0 1.332419e-07
I3146 n1_m1_148800_72000 0 2.056256e-07
I3147 n1_m1_148800_76800 0 1.318451e-07
I3148 n1_m1_148800_81600 0 1.995445e-07
I3149 n1_m1_148800_86400 0 1.383870e-07
I3150 n1_m1_148800_91200 0 1.364789e-07
I3151 n1_m1_148800_96000 0 2.035111e-07
I3152 n1_m1_148800_100800 0 1.387777e-07
I3153 n1_m1_148800_105600 0 2.128237e-07
I3154 n1_m1_148800_110400 0 1.446150e-07
I3155 n1_m1_148800_115200 0 1.384736e-07
I3156 n1_m1_148800_120000 0 2.147919e-07
I3157 n1_m1_148800_124800 0 3.029206e-07
I3158 n1_m1_148800_129600 0 4.421098e-07
I3159 n1_m1_148800_134400 0 3.023392e-07
I3160 n1_m1_148800_139200 0 2.250384e-07
I3161 n1_m1_148800_144000 0 2.238054e-07
I3162 n1_m1_148800_148800 0 1.424214e-07
I3163 n1_m1_148800_153600 0 2.100942e-07
I3164 n1_m1_148800_158400 0 1.470568e-07
I3165 n1_m1_148800_163200 0 1.724529e-07
I3166 n1_m1_148800_168000 0 2.961771e-07
I3167 n1_m1_148800_172800 0 1.860252e-07
I3168 n1_m1_148800_177600 0 2.865106e-07
I3169 n1_m1_148800_182400 0 2.107527e-07
I3170 n1_m1_148800_187200 0 2.782751e-07
I3171 n1_m1_148800_192000 0 4.097835e-07
I3172 n1_m1_148800_196800 0 1.767128e-07
I3173 n1_m1_148800_201600 0 2.148619e-07
I3174 n1_m1_148800_206400 0 1.414064e-07
I3175 n1_m1_148800_211200 0 1.438457e-07
I3176 n1_m1_148800_216000 0 2.091099e-07
I3177 n1_m1_148800_220800 0 1.519005e-07
I3178 n1_m1_148800_225600 0 2.296480e-07
I3179 n1_m1_148800_230400 0 1.516864e-07
I3180 n1_m1_148800_235200 0 1.552122e-07
I3181 n1_m1_148800_240000 0 2.255916e-07
I3182 n1_m1_148800_244800 0 1.504673e-07
I3183 n1_m1_148800_249600 0 2.128911e-07
I3184 n1_m1_148800_254400 0 1.429200e-07
I3185 n1_m1_148800_259200 0 1.530448e-07
I3186 n1_m1_148800_264000 0 2.366098e-07
I3187 n1_m1_148800_268800 0 1.593320e-07
I3188 n1_m1_148800_273600 0 2.194637e-07
I3189 n1_m1_148800_278400 0 1.413493e-07
I3190 n1_m1_148800_283200 0 1.404713e-07
I3191 n1_m1_148800_288000 0 2.098560e-07
I3192 n1_m1_148800_292800 0 1.399040e-07
I3193 n1_m1_148800_297600 0 2.118186e-07
I3194 n1_m1_148800_302400 0 1.526279e-07
I3195 n1_m1_148800_307200 0 1.437254e-07
I3196 n1_m1_148800_312000 0 2.114129e-07
I3197 n1_m1_148800_316800 0 1.462824e-07
I3198 n1_m1_148800_321600 0 2.182955e-07
I3199 n1_m1_148800_326400 0 1.416509e-07
I3200 n1_m1_148800_331200 0 1.449924e-07
I3201 n1_m1_148800_336000 0 2.153249e-07
I3202 n1_m1_148800_340800 0 1.485431e-07
I3203 n1_m1_148800_345600 0 2.256873e-07
I3204 n1_m1_148800_350400 0 1.540284e-07
I3205 n1_m1_148800_355200 0 1.539269e-07
I3206 n1_m1_148800_360000 0 2.343953e-07
I3207 n1_m1_148800_364800 0 1.506435e-07
I3208 n1_m1_148800_369600 0 2.294722e-07
I3209 n1_m1_148800_374400 0 1.545062e-07
I3210 n1_m1_148800_379200 0 1.490553e-07
I3211 n1_m1_148800_384000 0 2.185936e-07
I3212 n1_m1_148800_388800 0 1.444878e-07
I3213 n1_m1_148800_393600 0 2.374094e-07
I3214 n1_m1_148800_398400 0 1.840746e-07
I3215 n1_m1_148800_403200 0 1.644615e-07
I3216 n1_m1_148800_408000 0 2.546826e-07
I3217 n1_m1_148800_412800 0 1.474495e-07
I3218 n1_m1_148800_417600 0 2.146795e-07
I3219 n1_m1_148800_422400 0 1.418808e-07
I3220 n1_m1_148800_427200 0 1.413493e-07
I3221 n1_m1_148800_432000 0 2.047955e-07
I3222 n1_m1_148800_436800 0 1.389424e-07
I3223 n1_m1_148800_441600 0 2.140273e-07
I3224 n1_m1_148800_446400 0 1.408239e-07
I3225 n1_m1_148800_451200 0 1.417061e-07
I3226 n1_m1_148800_456000 0 2.199712e-07
I3227 n1_m1_148800_460800 0 1.463634e-07
I3228 n1_m1_148800_465600 0 2.165907e-07
I3229 n1_m1_148800_470400 0 1.608368e-07
I3230 n1_m1_148800_475200 0 1.689054e-07
I3231 n1_m1_148800_480000 0 2.414786e-07
I3232 n1_m1_153600_0 0 2.000451e-07
I3233 n1_m1_153600_4800 0 2.016181e-07
I3234 n1_m1_153600_9600 0 3.173908e-07
I3235 n1_m1_153600_14400 0 2.183906e-07
I3236 n1_m1_153600_19200 0 2.159030e-07
I3237 n1_m1_153600_24000 0 3.160798e-07
I3238 n1_m1_153600_28800 0 2.100185e-07
I3239 n1_m1_153600_33600 0 3.141808e-07
I3240 n1_m1_153600_38400 0 2.045859e-07
I3241 n1_m1_153600_43200 0 2.004357e-07
I3242 n1_m1_153600_48000 0 3.004437e-07
I3243 n1_m1_153600_52800 0 2.001170e-07
I3244 n1_m1_153600_57600 0 3.003531e-07
I3245 n1_m1_153600_62400 0 2.003167e-07
I3246 n1_m1_153600_67200 0 2.000005e-07
I3247 n1_m1_153600_72000 0 3.067594e-07
I3248 n1_m1_153600_76800 0 2.138571e-07
I3249 n1_m1_153600_81600 0 3.183481e-07
I3250 n1_m1_153600_86400 0 2.097321e-07
I3251 n1_m1_153600_91200 0 2.061579e-07
I3252 n1_m1_153600_96000 0 3.157835e-07
I3253 n1_m1_153600_100800 0 2.146912e-07
I3254 n1_m1_153600_105600 0 3.221545e-07
I3255 n1_m1_153600_110400 0 2.139057e-07
I3256 n1_m1_153600_115200 0 2.089633e-07
I3257 n1_m1_153600_120000 0 3.227060e-07
I3258 n1_m1_153600_124800 0 2.516911e-07
I3259 n1_m1_153600_129600 0 4.589356e-07
I3260 n1_m1_153600_134400 0 3.806617e-07
I3261 n1_m1_153600_139200 0 2.703050e-07
I3262 n1_m1_153600_144000 0 3.153401e-07
I3263 n1_m1_153600_148800 0 2.015684e-07
I3264 n1_m1_153600_153600 0 3.146020e-07
I3265 n1_m1_153600_158400 0 2.152079e-07
I3266 n1_m1_153600_163200 0 2.239095e-07
I3267 n1_m1_153600_168000 0 3.517937e-07
I3268 n1_m1_153600_172800 0 2.506818e-07
I3269 n1_m1_153600_177600 0 3.986725e-07
I3270 n1_m1_153600_182400 0 2.691303e-07
I3271 n1_m1_153600_187200 0 2.876654e-07
I3272 n1_m1_153600_192000 0 4.822582e-07
I3273 n1_m1_153600_196800 0 2.533752e-07
I3274 n1_m1_153600_201600 0 3.454465e-07
I3275 n1_m1_153600_206400 0 2.269633e-07
I3276 n1_m1_153600_211200 0 2.238490e-07
I3277 n1_m1_153600_216000 0 3.286155e-07
I3278 n1_m1_153600_220800 0 2.127880e-07
I3279 n1_m1_153600_225600 0 3.376073e-07
I3280 n1_m1_153600_230400 0 2.262789e-07
I3281 n1_m1_153600_235200 0 2.249185e-07
I3282 n1_m1_153600_240000 0 3.357723e-07
I3283 n1_m1_153600_244800 0 2.216716e-07
I3284 n1_m1_153600_249600 0 3.135132e-07
I3285 n1_m1_153600_254400 0 2.170855e-07
I3286 n1_m1_153600_259200 0 2.251601e-07
I3287 n1_m1_153600_264000 0 3.510337e-07
I3288 n1_m1_153600_268800 0 2.523268e-07
I3289 n1_m1_153600_273600 0 3.291963e-07
I3290 n1_m1_153600_278400 0 2.176247e-07
I3291 n1_m1_153600_283200 0 2.169699e-07
I3292 n1_m1_153600_288000 0 3.226504e-07
I3293 n1_m1_153600_292800 0 2.150825e-07
I3294 n1_m1_153600_297600 0 3.232736e-07
I3295 n1_m1_153600_302400 0 2.268892e-07
I3296 n1_m1_153600_307200 0 2.250465e-07
I3297 n1_m1_153600_312000 0 3.276275e-07
I3298 n1_m1_153600_316800 0 2.120374e-07
I3299 n1_m1_153600_321600 0 3.150080e-07
I3300 n1_m1_153600_326400 0 2.111515e-07
I3301 n1_m1_153600_331200 0 2.163897e-07
I3302 n1_m1_153600_336000 0 3.230952e-07
I3303 n1_m1_153600_340800 0 2.281156e-07
I3304 n1_m1_153600_345600 0 3.236075e-07
I3305 n1_m1_153600_350400 0 2.374685e-07
I3306 n1_m1_153600_355200 0 2.368198e-07
I3307 n1_m1_153600_360000 0 3.862750e-07
I3308 n1_m1_153600_364800 0 2.358982e-07
I3309 n1_m1_153600_369600 0 3.396678e-07
I3310 n1_m1_153600_374400 0 2.285713e-07
I3311 n1_m1_153600_379200 0 2.416137e-07
I3312 n1_m1_153600_384000 0 3.717479e-07
I3313 n1_m1_153600_388800 0 2.263269e-07
I3314 n1_m1_153600_393600 0 3.730454e-07
I3315 n1_m1_153600_398400 0 3.188306e-07
I3316 n1_m1_153600_403200 0 2.546690e-07
I3317 n1_m1_153600_408000 0 3.650900e-07
I3318 n1_m1_153600_412800 0 2.063973e-07
I3319 n1_m1_153600_417600 0 3.155192e-07
I3320 n1_m1_153600_422400 0 2.165583e-07
I3321 n1_m1_153600_427200 0 2.181377e-07
I3322 n1_m1_153600_432000 0 3.158388e-07
I3323 n1_m1_153600_436800 0 2.065959e-07
I3324 n1_m1_153600_441600 0 3.148830e-07
I3325 n1_m1_153600_446400 0 2.104710e-07
I3326 n1_m1_153600_451200 0 2.134789e-07
I3327 n1_m1_153600_456000 0 3.154517e-07
I3328 n1_m1_153600_460800 0 2.100193e-07
I3329 n1_m1_153600_465600 0 3.288815e-07
I3330 n1_m1_153600_470400 0 2.526670e-07
I3331 n1_m1_153600_475200 0 2.618968e-07
I3332 n1_m1_153600_480000 0 3.502893e-07
I3333 n1_m1_158400_0 0 1.332419e-07
I3334 n1_m1_158400_4800 0 1.343659e-07
I3335 n1_m1_158400_9600 0 2.100907e-07
I3336 n1_m1_158400_14400 0 1.449181e-07
I3337 n1_m1_158400_19200 0 1.414177e-07
I3338 n1_m1_158400_24000 0 2.076756e-07
I3339 n1_m1_158400_28800 0 1.347422e-07
I3340 n1_m1_158400_33600 0 2.025980e-07
I3341 n1_m1_158400_38400 0 1.378260e-07
I3342 n1_m1_158400_43200 0 1.381945e-07
I3343 n1_m1_158400_48000 0 2.075963e-07
I3344 n1_m1_158400_52800 0 1.386019e-07
I3345 n1_m1_158400_57600 0 2.079016e-07
I3346 n1_m1_158400_62400 0 1.406006e-07
I3347 n1_m1_158400_67200 0 1.435654e-07
I3348 n1_m1_158400_72000 0 2.102241e-07
I3349 n1_m1_158400_76800 0 1.398017e-07
I3350 n1_m1_158400_81600 0 2.100429e-07
I3351 n1_m1_158400_86400 0 1.401425e-07
I3352 n1_m1_158400_91200 0 1.394872e-07
I3353 n1_m1_158400_96000 0 2.143992e-07
I3354 n1_m1_158400_100800 0 1.401655e-07
I3355 n1_m1_158400_105600 0 2.102056e-07
I3356 n1_m1_158400_110400 0 1.399229e-07
I3357 n1_m1_158400_115200 0 1.399040e-07
I3358 n1_m1_158400_120000 0 2.102197e-07
I3359 n1_m1_158400_124800 0 1.591096e-07
I3360 n1_m1_158400_129600 0 2.515070e-07
I3361 n1_m1_158400_134400 0 1.905375e-07
I3362 n1_m1_158400_139200 0 1.649112e-07
I3363 n1_m1_158400_144000 0 2.139230e-07
I3364 n1_m1_158400_148800 0 1.304909e-07
I3365 n1_m1_158400_153600 0 2.067022e-07
I3366 n1_m1_158400_158400 0 1.361939e-07
I3367 n1_m1_158400_163200 0 1.353044e-07
I3368 n1_m1_158400_168000 0 2.130400e-07
I3369 n1_m1_158400_172800 0 1.603144e-07
I3370 n1_m1_158400_177600 0 2.724816e-07
I3371 n1_m1_158400_182400 0 1.725774e-07
I3372 n1_m1_158400_187200 0 1.901591e-07
I3373 n1_m1_158400_192000 0 3.141973e-07
I3374 n1_m1_158400_196800 0 1.720577e-07
I3375 n1_m1_158400_201600 0 2.687892e-07
I3376 n1_m1_158400_206400 0 1.610642e-07
I3377 n1_m1_158400_211200 0 1.477273e-07
I3378 n1_m1_158400_216000 0 2.294074e-07
I3379 n1_m1_158400_220800 0 1.607023e-07
I3380 n1_m1_158400_225600 0 2.467927e-07
I3381 n1_m1_158400_230400 0 1.834394e-07
I3382 n1_m1_158400_235200 0 1.787106e-07
I3383 n1_m1_158400_240000 0 2.412949e-07
I3384 n1_m1_158400_244800 0 1.585964e-07
I3385 n1_m1_158400_249600 0 2.290069e-07
I3386 n1_m1_158400_254400 0 1.635245e-07
I3387 n1_m1_158400_259200 0 1.691535e-07
I3388 n1_m1_158400_264000 0 2.561589e-07
I3389 n1_m1_158400_268800 0 1.759199e-07
I3390 n1_m1_158400_273600 0 2.301659e-07
I3391 n1_m1_158400_278400 0 1.541504e-07
I3392 n1_m1_158400_283200 0 1.632631e-07
I3393 n1_m1_158400_288000 0 2.513691e-07
I3394 n1_m1_158400_292800 0 1.661431e-07
I3395 n1_m1_158400_297600 0 2.387439e-07
I3396 n1_m1_158400_302400 0 1.626422e-07
I3397 n1_m1_158400_307200 0 1.586522e-07
I3398 n1_m1_158400_312000 0 2.256372e-07
I3399 n1_m1_158400_316800 0 1.455104e-07
I3400 n1_m1_158400_321600 0 2.115955e-07
I3401 n1_m1_158400_326400 0 1.414081e-07
I3402 n1_m1_158400_331200 0 1.455183e-07
I3403 n1_m1_158400_336000 0 2.151416e-07
I3404 n1_m1_158400_340800 0 1.497044e-07
I3405 n1_m1_158400_345600 0 2.152810e-07
I3406 n1_m1_158400_350400 0 1.586377e-07
I3407 n1_m1_158400_355200 0 1.616881e-07
I3408 n1_m1_158400_360000 0 2.656724e-07
I3409 n1_m1_158400_364800 0 1.592714e-07
I3410 n1_m1_158400_369600 0 2.981584e-07
I3411 n1_m1_158400_374400 0 1.883401e-07
I3412 n1_m1_158400_379200 0 1.730621e-07
I3413 n1_m1_158400_384000 0 2.484876e-07
I3414 n1_m1_158400_388800 0 1.669681e-07
I3415 n1_m1_158400_393600 0 2.722386e-07
I3416 n1_m1_158400_398400 0 2.482197e-07
I3417 n1_m1_158400_403200 0 1.703251e-07
I3418 n1_m1_158400_408000 0 2.393312e-07
I3419 n1_m1_158400_412800 0 1.462726e-07
I3420 n1_m1_158400_417600 0 2.149250e-07
I3421 n1_m1_158400_422400 0 1.399040e-07
I3422 n1_m1_158400_427200 0 1.409393e-07
I3423 n1_m1_158400_432000 0 2.102435e-07
I3424 n1_m1_158400_436800 0 1.399040e-07
I3425 n1_m1_158400_441600 0 2.098560e-07
I3426 n1_m1_158400_446400 0 1.399040e-07
I3427 n1_m1_158400_451200 0 1.399040e-07
I3428 n1_m1_158400_456000 0 2.098560e-07
I3429 n1_m1_158400_460800 0 1.399040e-07
I3430 n1_m1_158400_465600 0 2.138378e-07
I3431 n1_m1_158400_470400 0 1.589928e-07
I3432 n1_m1_158400_475200 0 1.672146e-07
I3433 n1_m1_158400_480000 0 2.376464e-07
I3434 n1_m1_163200_0 0 1.331218e-07
I3435 n1_m1_163200_4800 0 1.331374e-07
I3436 n1_m1_163200_9600 0 2.017187e-07
I3437 n1_m1_163200_14400 0 1.390900e-07
I3438 n1_m1_163200_19200 0 1.396288e-07
I3439 n1_m1_163200_24000 0 2.023551e-07
I3440 n1_m1_163200_28800 0 1.334390e-07
I3441 n1_m1_163200_33600 0 2.007306e-07
I3442 n1_m1_163200_38400 0 1.348822e-07
I3443 n1_m1_163200_43200 0 1.359858e-07
I3444 n1_m1_163200_48000 0 2.096838e-07
I3445 n1_m1_163200_52800 0 1.439641e-07
I3446 n1_m1_163200_57600 0 2.157514e-07
I3447 n1_m1_163200_62400 0 1.420919e-07
I3448 n1_m1_163200_67200 0 1.456576e-07
I3449 n1_m1_163200_72000 0 2.120220e-07
I3450 n1_m1_163200_76800 0 1.395389e-07
I3451 n1_m1_163200_81600 0 2.133412e-07
I3452 n1_m1_163200_86400 0 1.449122e-07
I3453 n1_m1_163200_91200 0 1.491604e-07
I3454 n1_m1_163200_96000 0 2.200642e-07
I3455 n1_m1_163200_100800 0 1.452584e-07
I3456 n1_m1_163200_105600 0 2.165444e-07
I3457 n1_m1_163200_110400 0 1.398369e-07
I3458 n1_m1_163200_115200 0 1.395502e-07
I3459 n1_m1_163200_120000 0 2.102282e-07
I3460 n1_m1_163200_124800 0 1.597489e-07
I3461 n1_m1_163200_129600 0 2.455706e-07
I3462 n1_m1_163200_134400 0 1.854181e-07
I3463 n1_m1_163200_139200 0 1.674853e-07
I3464 n1_m1_163200_144000 0 2.327012e-07
I3465 n1_m1_163200_148800 0 1.337319e-07
I3466 n1_m1_163200_153600 0 2.011344e-07
I3467 n1_m1_163200_158400 0 1.338357e-07
I3468 n1_m1_163200_163200 0 1.397630e-07
I3469 n1_m1_163200_168000 0 2.397214e-07
I3470 n1_m1_163200_172800 0 1.819971e-07
I3471 n1_m1_163200_177600 0 2.825201e-07
I3472 n1_m1_163200_182400 0 1.970308e-07
I3473 n1_m1_163200_187200 0 1.698625e-07
I3474 n1_m1_163200_192000 0 3.482823e-07
I3475 n1_m1_163200_196800 0 2.438290e-07
I3476 n1_m1_163200_201600 0 2.758419e-07
I3477 n1_m1_163200_206400 0 1.553740e-07
I3478 n1_m1_163200_211200 0 1.495406e-07
I3479 n1_m1_163200_216000 0 2.803609e-07
I3480 n1_m1_163200_220800 0 2.772420e-07
I3481 n1_m1_163200_225600 0 3.668380e-07
I3482 n1_m1_163200_230400 0 2.583771e-07
I3483 n1_m1_163200_235200 0 1.979879e-07
I3484 n1_m1_163200_240000 0 2.491653e-07
I3485 n1_m1_163200_244800 0 1.679370e-07
I3486 n1_m1_163200_249600 0 2.469431e-07
I3487 n1_m1_163200_254400 0 1.738910e-07
I3488 n1_m1_163200_259200 0 1.817052e-07
I3489 n1_m1_163200_264000 0 2.635090e-07
I3490 n1_m1_163200_268800 0 1.765026e-07
I3491 n1_m1_163200_273600 0 2.401809e-07
I3492 n1_m1_163200_278400 0 1.610859e-07
I3493 n1_m1_163200_283200 0 1.684472e-07
I3494 n1_m1_163200_288000 0 2.684514e-07
I3495 n1_m1_163200_292800 0 1.755160e-07
I3496 n1_m1_163200_297600 0 2.539740e-07
I3497 n1_m1_163200_302400 0 1.620799e-07
I3498 n1_m1_163200_307200 0 1.585750e-07
I3499 n1_m1_163200_312000 0 2.263370e-07
I3500 n1_m1_163200_316800 0 1.431758e-07
I3501 n1_m1_163200_321600 0 2.115103e-07
I3502 n1_m1_163200_326400 0 1.455354e-07
I3503 n1_m1_163200_331200 0 1.467031e-07
I3504 n1_m1_163200_336000 0 2.158229e-07
I3505 n1_m1_163200_340800 0 1.502065e-07
I3506 n1_m1_163200_345600 0 2.190573e-07
I3507 n1_m1_163200_350400 0 1.644532e-07
I3508 n1_m1_163200_355200 0 1.719669e-07
I3509 n1_m1_163200_360000 0 3.159449e-07
I3510 n1_m1_163200_364800 0 1.654324e-07
I3511 n1_m1_163200_369600 0 3.132137e-07
I3512 n1_m1_163200_374400 0 1.897194e-07
I3513 n1_m1_163200_379200 0 1.698293e-07
I3514 n1_m1_163200_384000 0 2.506844e-07
I3515 n1_m1_163200_388800 0 1.719304e-07
I3516 n1_m1_163200_393600 0 3.142246e-07
I3517 n1_m1_163200_398400 0 3.675439e-07
I3518 n1_m1_163200_403200 0 2.186791e-07
I3519 n1_m1_163200_408000 0 2.427699e-07
I3520 n1_m1_163200_412800 0 1.533645e-07
I3521 n1_m1_163200_417600 0 2.252988e-07
I3522 n1_m1_163200_422400 0 1.399040e-07
I3523 n1_m1_163200_427200 0 1.399040e-07
I3524 n1_m1_163200_432000 0 2.098560e-07
I3525 n1_m1_163200_436800 0 1.399040e-07
I3526 n1_m1_163200_441600 0 2.098560e-07
I3527 n1_m1_163200_446400 0 1.399040e-07
I3528 n1_m1_163200_451200 0 1.399040e-07
I3529 n1_m1_163200_456000 0 2.098560e-07
I3530 n1_m1_163200_460800 0 1.399040e-07
I3531 n1_m1_163200_465600 0 2.134348e-07
I3532 n1_m1_163200_470400 0 1.558299e-07
I3533 n1_m1_163200_475200 0 1.611979e-07
I3534 n1_m1_163200_480000 0 2.396409e-07
I3535 n1_m1_168000_0 0 1.983230e-07
I3536 n1_m1_168000_4800 0 1.955802e-07
I3537 n1_m1_168000_9600 0 2.994454e-07
I3538 n1_m1_168000_14400 0 2.006783e-07
I3539 n1_m1_168000_19200 0 2.009478e-07
I3540 n1_m1_168000_24000 0 3.000269e-07
I3541 n1_m1_168000_28800 0 2.037149e-07
I3542 n1_m1_168000_33600 0 3.131115e-07
I3543 n1_m1_168000_38400 0 2.087410e-07
I3544 n1_m1_168000_43200 0 2.083521e-07
I3545 n1_m1_168000_48000 0 3.124782e-07
I3546 n1_m1_168000_52800 0 2.151163e-07
I3547 n1_m1_168000_57600 0 3.193735e-07
I3548 n1_m1_168000_62400 0 2.027529e-07
I3549 n1_m1_168000_67200 0 2.051485e-07
I3550 n1_m1_168000_72000 0 3.038910e-07
I3551 n1_m1_168000_76800 0 2.061676e-07
I3552 n1_m1_168000_81600 0 3.264643e-07
I3553 n1_m1_168000_86400 0 2.159938e-07
I3554 n1_m1_168000_91200 0 2.329696e-07
I3555 n1_m1_168000_96000 0 3.413943e-07
I3556 n1_m1_168000_100800 0 2.288648e-07
I3557 n1_m1_168000_105600 0 3.394646e-07
I3558 n1_m1_168000_110400 0 2.107225e-07
I3559 n1_m1_168000_115200 0 2.091846e-07
I3560 n1_m1_168000_120000 0 3.197773e-07
I3561 n1_m1_168000_124800 0 2.383546e-07
I3562 n1_m1_168000_129600 0 3.679915e-07
I3563 n1_m1_168000_134400 0 2.595348e-07
I3564 n1_m1_168000_139200 0 2.362701e-07
I3565 n1_m1_168000_144000 0 3.346825e-07
I3566 n1_m1_168000_148800 0 2.031743e-07
I3567 n1_m1_168000_153600 0 3.063561e-07
I3568 n1_m1_168000_158400 0 2.046052e-07
I3569 n1_m1_168000_163200 0 2.510108e-07
I3570 n1_m1_168000_168000 0 5.854327e-07
I3571 n1_m1_168000_172800 0 4.852417e-07
I3572 n1_m1_168000_177600 0 5.051161e-07
I3573 n1_m1_168000_182400 0 3.210294e-07
I3574 n1_m1_168000_187200 0 2.977294e-07
I3575 n1_m1_168000_192000 0 7.074267e-07
I3576 n1_m1_168000_196800 0 3.249027e-07
I3577 n1_m1_168000_201600 0 4.160065e-07
I3578 n1_m1_168000_206400 0 2.344005e-07
I3579 n1_m1_168000_211200 0 2.359935e-07
I3580 n1_m1_168000_216000 0 6.248586e-07
I3581 n1_m1_168000_220800 0 6.389902e-07
I3582 n1_m1_168000_225600 0 6.094504e-07
I3583 n1_m1_168000_230400 0 2.950096e-07
I3584 n1_m1_168000_235200 0 2.634422e-07
I3585 n1_m1_168000_240000 0 4.156266e-07
I3586 n1_m1_168000_244800 0 2.956483e-07
I3587 n1_m1_168000_249600 0 3.696045e-07
I3588 n1_m1_168000_254400 0 2.532361e-07
I3589 n1_m1_168000_259200 0 2.609342e-07
I3590 n1_m1_168000_264000 0 3.833006e-07
I3591 n1_m1_168000_268800 0 2.503552e-07
I3592 n1_m1_168000_273600 0 3.452091e-07
I3593 n1_m1_168000_278400 0 2.210123e-07
I3594 n1_m1_168000_283200 0 2.226716e-07
I3595 n1_m1_168000_288000 0 3.559365e-07
I3596 n1_m1_168000_292800 0 2.375505e-07
I3597 n1_m1_168000_297600 0 3.406668e-07
I3598 n1_m1_168000_302400 0 2.267716e-07
I3599 n1_m1_168000_307200 0 2.228591e-07
I3600 n1_m1_168000_312000 0 3.261771e-07
I3601 n1_m1_168000_316800 0 2.103029e-07
I3602 n1_m1_168000_321600 0 3.170345e-07
I3603 n1_m1_168000_326400 0 2.197459e-07
I3604 n1_m1_168000_331200 0 2.225272e-07
I3605 n1_m1_168000_336000 0 3.362633e-07
I3606 n1_m1_168000_340800 0 2.366180e-07
I3607 n1_m1_168000_345600 0 3.491834e-07
I3608 n1_m1_168000_350400 0 2.634874e-07
I3609 n1_m1_168000_355200 0 2.845987e-07
I3610 n1_m1_168000_360000 0 6.163670e-07
I3611 n1_m1_168000_364800 0 2.556564e-07
I3612 n1_m1_168000_369600 0 3.886416e-07
I3613 n1_m1_168000_374400 0 2.460585e-07
I3614 n1_m1_168000_379200 0 2.432958e-07
I3615 n1_m1_168000_384000 0 3.743187e-07
I3616 n1_m1_168000_388800 0 2.502949e-07
I3617 n1_m1_168000_393600 0 5.101630e-07
I3618 n1_m1_168000_398400 0 6.909599e-07
I3619 n1_m1_168000_403200 0 4.380500e-07
I3620 n1_m1_168000_408000 0 3.739539e-07
I3621 n1_m1_168000_412800 0 2.206893e-07
I3622 n1_m1_168000_417600 0 3.348101e-07
I3623 n1_m1_168000_422400 0 2.098560e-07
I3624 n1_m1_168000_427200 0 2.098560e-07
I3625 n1_m1_168000_432000 0 3.147839e-07
I3626 n1_m1_168000_436800 0 2.098560e-07
I3627 n1_m1_168000_441600 0 3.147839e-07
I3628 n1_m1_168000_446400 0 2.098560e-07
I3629 n1_m1_168000_451200 0 2.098560e-07
I3630 n1_m1_168000_456000 0 3.147839e-07
I3631 n1_m1_168000_460800 0 2.098560e-07
I3632 n1_m1_168000_465600 0 3.201522e-07
I3633 n1_m1_168000_470400 0 2.341020e-07
I3634 n1_m1_168000_475200 0 2.428911e-07
I3635 n1_m1_168000_480000 0 3.592985e-07
I3636 n1_m1_172800_0 0 7.044797e-08
I3637 n1_m1_172800_4800 0 6.708319e-08
I3638 n1_m1_172800_9600 0 9.993141e-08
I3639 n1_m1_172800_14400 0 6.662094e-08
I3640 n1_m1_172800_19200 0 6.860433e-08
I3641 n1_m1_172800_24000 0 1.048119e-07
I3642 n1_m1_172800_28800 0 7.101175e-08
I3643 n1_m1_172800_33600 0 1.052989e-07
I3644 n1_m1_172800_38400 0 7.186550e-08
I3645 n1_m1_172800_43200 0 6.997241e-08
I3646 n1_m1_172800_48000 0 1.025056e-07
I3647 n1_m1_172800_52800 0 6.735047e-08
I3648 n1_m1_172800_57600 0 1.026709e-07
I3649 n1_m1_172800_62400 0 7.324174e-08
I3650 n1_m1_172800_67200 0 7.389727e-08
I3651 n1_m1_172800_72000 0 1.063544e-07
I3652 n1_m1_172800_76800 0 7.707944e-08
I3653 n1_m1_172800_81600 0 1.305860e-07
I3654 n1_m1_172800_86400 0 7.948495e-08
I3655 n1_m1_172800_91200 0 1.034705e-07
I3656 n1_m1_172800_96000 0 1.373868e-07
I3657 n1_m1_172800_100800 0 1.034072e-07
I3658 n1_m1_172800_105600 0 1.550206e-07
I3659 n1_m1_172800_110400 0 8.196421e-08
I3660 n1_m1_172800_115200 0 7.745350e-08
I3661 n1_m1_172800_120000 0 1.182604e-07
I3662 n1_m1_172800_124800 0 1.083605e-07
I3663 n1_m1_172800_129600 0 1.785095e-07
I3664 n1_m1_172800_134400 0 1.072849e-07
I3665 n1_m1_172800_139200 0 8.186962e-08
I3666 n1_m1_172800_144000 0 1.149016e-07
I3667 n1_m1_172800_148800 0 6.982094e-08
I3668 n1_m1_172800_153600 0 1.024643e-07
I3669 n1_m1_172800_158400 0 7.014580e-08
I3670 n1_m1_172800_163200 0 8.905179e-08
I3671 n1_m1_172800_168000 0 2.993601e-07
I3672 n1_m1_172800_172800 0 3.466627e-07
I3673 n1_m1_172800_177600 0 5.672185e-07
I3674 n1_m1_172800_182400 0 3.355423e-07
I3675 n1_m1_172800_187200 0 1.253482e-07
I3676 n1_m1_172800_192000 0 1.705601e-07
I3677 n1_m1_172800_196800 0 1.131502e-07
I3678 n1_m1_172800_201600 0 2.997772e-07
I3679 n1_m1_172800_206400 0 8.208986e-08
I3680 n1_m1_172800_211200 0 7.849984e-08
I3681 n1_m1_172800_216000 0 1.393451e-07
I3682 n1_m1_172800_220800 0 1.080493e-07
I3683 n1_m1_172800_225600 0 1.422156e-07
I3684 n1_m1_172800_230400 0 9.263336e-08
I3685 n1_m1_172800_235200 0 1.042257e-07
I3686 n1_m1_172800_240000 0 2.644968e-07
I3687 n1_m1_172800_244800 0 2.359766e-07
I3688 n1_m1_172800_249600 0 1.762368e-07
I3689 n1_m1_172800_254400 0 8.822602e-08
I3690 n1_m1_172800_259200 0 8.573704e-08
I3691 n1_m1_172800_264000 0 1.221482e-07
I3692 n1_m1_172800_268800 0 7.934674e-08
I3693 n1_m1_172800_273600 0 1.171854e-07
I3694 n1_m1_172800_278400 0 7.548362e-08
I3695 n1_m1_172800_283200 0 7.717843e-08
I3696 n1_m1_172800_288000 0 1.252389e-07
I3697 n1_m1_172800_292800 0 8.547187e-08
I3698 n1_m1_172800_297600 0 1.174174e-07
I3699 n1_m1_172800_302400 0 7.588456e-08
I3700 n1_m1_172800_307200 0 7.559968e-08
I3701 n1_m1_172800_312000 0 1.098575e-07
I3702 n1_m1_172800_316800 0 7.099475e-08
I3703 n1_m1_172800_321600 0 1.056782e-07
I3704 n1_m1_172800_326400 0 7.324862e-08
I3705 n1_m1_172800_331200 0 7.428785e-08
I3706 n1_m1_172800_336000 0 1.126231e-07
I3707 n1_m1_172800_340800 0 7.907085e-08
I3708 n1_m1_172800_345600 0 1.186121e-07
I3709 n1_m1_172800_350400 0 9.392564e-08
I3710 n1_m1_172800_355200 0 1.061255e-07
I3711 n1_m1_172800_360000 0 2.458932e-07
I3712 n1_m1_172800_364800 0 8.624314e-08
I3713 n1_m1_172800_369600 0 1.205837e-07
I3714 n1_m1_172800_374400 0 7.777535e-08
I3715 n1_m1_172800_379200 0 7.845144e-08
I3716 n1_m1_172800_384000 0 1.231123e-07
I3717 n1_m1_172800_388800 0 8.088113e-08
I3718 n1_m1_172800_393600 0 1.498508e-07
I3719 n1_m1_172800_398400 0 1.611857e-07
I3720 n1_m1_172800_403200 0 1.017796e-07
I3721 n1_m1_172800_408000 0 1.251436e-07
I3722 n1_m1_172800_412800 0 6.933730e-08
I3723 n1_m1_172800_417600 0 1.051586e-07
I3724 n1_m1_172800_422400 0 6.995199e-08
I3725 n1_m1_172800_427200 0 6.995199e-08
I3726 n1_m1_172800_432000 0 1.049280e-07
I3727 n1_m1_172800_436800 0 6.995199e-08
I3728 n1_m1_172800_441600 0 1.049280e-07
I3729 n1_m1_172800_446400 0 6.995199e-08
I3730 n1_m1_172800_451200 0 6.995199e-08
I3731 n1_m1_172800_456000 0 1.049280e-07
I3732 n1_m1_172800_460800 0 6.995199e-08
I3733 n1_m1_172800_465600 0 1.074161e-07
I3734 n1_m1_172800_470400 0 8.139042e-08
I3735 n1_m1_172800_475200 0 8.487794e-08
I3736 n1_m1_172800_480000 0 1.172775e-07
I3737 n1_m1_177600_0 0 2.158793e-07
I3738 n1_m1_177600_4800 0 2.091676e-07
I3739 n1_m1_177600_9600 0 3.115431e-07
I3740 n1_m1_177600_14400 0 2.079165e-07
I3741 n1_m1_177600_19200 0 2.133028e-07
I3742 n1_m1_177600_24000 0 3.263155e-07
I3743 n1_m1_177600_28800 0 2.141262e-07
I3744 n1_m1_177600_33600 0 3.202260e-07
I3745 n1_m1_177600_38400 0 2.124932e-07
I3746 n1_m1_177600_43200 0 2.100376e-07
I3747 n1_m1_177600_48000 0 3.084434e-07
I3748 n1_m1_177600_52800 0 2.010600e-07
I3749 n1_m1_177600_57600 0 3.095871e-07
I3750 n1_m1_177600_62400 0 2.295135e-07
I3751 n1_m1_177600_67200 0 2.274424e-07
I3752 n1_m1_177600_72000 0 3.235002e-07
I3753 n1_m1_177600_76800 0 2.460533e-07
I3754 n1_m1_177600_81600 0 4.414830e-07
I3755 n1_m1_177600_86400 0 2.494338e-07
I3756 n1_m1_177600_91200 0 2.863860e-07
I3757 n1_m1_177600_96000 0 3.988999e-07
I3758 n1_m1_177600_100800 0 3.065367e-07
I3759 n1_m1_177600_105600 0 4.472669e-07
I3760 n1_m1_177600_110400 0 2.332461e-07
I3761 n1_m1_177600_115200 0 2.191240e-07
I3762 n1_m1_177600_120000 0 3.516771e-07
I3763 n1_m1_177600_124800 0 3.910039e-07
I3764 n1_m1_177600_129600 0 6.764191e-07
I3765 n1_m1_177600_134400 0 3.774287e-07
I3766 n1_m1_177600_139200 0 2.571699e-07
I3767 n1_m1_177600_144000 0 3.539598e-07
I3768 n1_m1_177600_148800 0 2.154983e-07
I3769 n1_m1_177600_153600 0 3.179959e-07
I3770 n1_m1_177600_158400 0 2.091947e-07
I3771 n1_m1_177600_163200 0 2.431549e-07
I3772 n1_m1_177600_168000 0 8.014704e-07
I3773 n1_m1_177600_172800 0 1.037168e-06
I3774 n1_m1_177600_177600 0 2.228446e-06
I3775 n1_m1_177600_182400 0 1.301485e-06
I3776 n1_m1_177600_187200 0 3.502767e-07
I3777 n1_m1_177600_192000 0 4.355019e-07
I3778 n1_m1_177600_196800 0 3.317795e-07
I3779 n1_m1_177600_201600 0 7.030718e-07
I3780 n1_m1_177600_206400 0 2.715075e-07
I3781 n1_m1_177600_211200 0 2.737358e-07
I3782 n1_m1_177600_216000 0 3.876687e-07
I3783 n1_m1_177600_220800 0 2.684348e-07
I3784 n1_m1_177600_225600 0 4.634553e-07
I3785 n1_m1_177600_230400 0 2.943760e-07
I3786 n1_m1_177600_235200 0 2.874283e-07
I3787 n1_m1_177600_240000 0 7.110923e-07
I3788 n1_m1_177600_244800 0 6.359707e-07
I3789 n1_m1_177600_249600 0 4.928314e-07
I3790 n1_m1_177600_254400 0 2.577811e-07
I3791 n1_m1_177600_259200 0 2.572058e-07
I3792 n1_m1_177600_264000 0 3.856333e-07
I3793 n1_m1_177600_268800 0 2.592308e-07
I3794 n1_m1_177600_273600 0 3.495583e-07
I3795 n1_m1_177600_278400 0 2.318777e-07
I3796 n1_m1_177600_283200 0 2.442236e-07
I3797 n1_m1_177600_288000 0 4.220785e-07
I3798 n1_m1_177600_292800 0 2.873583e-07
I3799 n1_m1_177600_297600 0 3.714132e-07
I3800 n1_m1_177600_302400 0 2.400397e-07
I3801 n1_m1_177600_307200 0 2.343748e-07
I3802 n1_m1_177600_312000 0 3.348830e-07
I3803 n1_m1_177600_316800 0 2.169251e-07
I3804 n1_m1_177600_321600 0 3.190692e-07
I3805 n1_m1_177600_326400 0 2.203685e-07
I3806 n1_m1_177600_331200 0 2.245746e-07
I3807 n1_m1_177600_336000 0 3.385677e-07
I3808 n1_m1_177600_340800 0 2.350257e-07
I3809 n1_m1_177600_345600 0 3.550742e-07
I3810 n1_m1_177600_350400 0 2.775418e-07
I3811 n1_m1_177600_355200 0 3.129532e-07
I3812 n1_m1_177600_360000 0 7.294764e-07
I3813 n1_m1_177600_364800 0 2.539046e-07
I3814 n1_m1_177600_369600 0 3.752343e-07
I3815 n1_m1_177600_374400 0 2.444449e-07
I3816 n1_m1_177600_379200 0 2.384816e-07
I3817 n1_m1_177600_384000 0 3.641562e-07
I3818 n1_m1_177600_388800 0 2.390647e-07
I3819 n1_m1_177600_393600 0 4.063690e-07
I3820 n1_m1_177600_398400 0 3.516224e-07
I3821 n1_m1_177600_403200 0 2.635477e-07
I3822 n1_m1_177600_408000 0 3.869237e-07
I3823 n1_m1_177600_412800 0 2.220141e-07
I3824 n1_m1_177600_417600 0 3.246404e-07
I3825 n1_m1_177600_422400 0 2.120378e-07
I3826 n1_m1_177600_427200 0 2.098560e-07
I3827 n1_m1_177600_432000 0 3.164264e-07
I3828 n1_m1_177600_436800 0 2.157885e-07
I3829 n1_m1_177600_441600 0 3.194810e-07
I3830 n1_m1_177600_446400 0 2.110810e-07
I3831 n1_m1_177600_451200 0 2.108962e-07
I3832 n1_m1_177600_456000 0 3.156521e-07
I3833 n1_m1_177600_460800 0 2.110810e-07
I3834 n1_m1_177600_465600 0 3.313579e-07
I3835 n1_m1_177600_470400 0 2.530040e-07
I3836 n1_m1_177600_475200 0 2.625325e-07
I3837 n1_m1_177600_480000 0 3.520482e-07
I3838 n1_m1_182400_0 0 1.436207e-07
I3839 n1_m1_182400_4800 0 1.481518e-07
I3840 n1_m1_182400_9600 0 2.172890e-07
I3841 n1_m1_182400_14400 0 1.449058e-07
I3842 n1_m1_182400_19200 0 1.603422e-07
I3843 n1_m1_182400_24000 0 2.247638e-07
I3844 n1_m1_182400_28800 0 1.365221e-07
I3845 n1_m1_182400_33600 0 2.101482e-07
I3846 n1_m1_182400_38400 0 1.399360e-07
I3847 n1_m1_182400_43200 0 1.399040e-07
I3848 n1_m1_182400_48000 0 2.096071e-07
I3849 n1_m1_182400_52800 0 1.394163e-07
I3850 n1_m1_182400_57600 0 2.051913e-07
I3851 n1_m1_182400_62400 0 1.448246e-07
I3852 n1_m1_182400_67200 0 1.448184e-07
I3853 n1_m1_182400_72000 0 2.113649e-07
I3854 n1_m1_182400_76800 0 1.481452e-07
I3855 n1_m1_182400_81600 0 2.391737e-07
I3856 n1_m1_182400_86400 0 1.494012e-07
I3857 n1_m1_182400_91200 0 1.543434e-07
I3858 n1_m1_182400_96000 0 2.219675e-07
I3859 n1_m1_182400_100800 0 1.529979e-07
I3860 n1_m1_182400_105600 0 2.296315e-07
I3861 n1_m1_182400_110400 0 1.399779e-07
I3862 n1_m1_182400_115200 0 1.399889e-07
I3863 n1_m1_182400_120000 0 2.268699e-07
I3864 n1_m1_182400_124800 0 1.749661e-07
I3865 n1_m1_182400_129600 0 3.014999e-07
I3866 n1_m1_182400_134400 0 2.214978e-07
I3867 n1_m1_182400_139200 0 1.998950e-07
I3868 n1_m1_182400_144000 0 2.243598e-07
I3869 n1_m1_182400_148800 0 1.452214e-07
I3870 n1_m1_182400_153600 0 2.138479e-07
I3871 n1_m1_182400_158400 0 1.403766e-07
I3872 n1_m1_182400_163200 0 1.385277e-07
I3873 n1_m1_182400_168000 0 2.894649e-07
I3874 n1_m1_182400_172800 0 3.300826e-07
I3875 n1_m1_182400_177600 0 1.468649e-06
I3876 n1_m1_182400_182400 0 7.650314e-07
I3877 n1_m1_182400_187200 0 3.129279e-07
I3878 n1_m1_182400_192000 0 3.695121e-07
I3879 n1_m1_182400_196800 0 2.012880e-07
I3880 n1_m1_182400_201600 0 3.163198e-07
I3881 n1_m1_182400_206400 0 2.503864e-07
I3882 n1_m1_182400_211200 0 2.296395e-07
I3883 n1_m1_182400_216000 0 2.886886e-07
I3884 n1_m1_182400_220800 0 1.838995e-07
I3885 n1_m1_182400_225600 0 3.040248e-07
I3886 n1_m1_182400_230400 0 1.841339e-07
I3887 n1_m1_182400_235200 0 1.765244e-07
I3888 n1_m1_182400_240000 0 2.970925e-07
I3889 n1_m1_182400_244800 0 1.935239e-07
I3890 n1_m1_182400_249600 0 2.674254e-07
I3891 n1_m1_182400_254400 0 1.690530e-07
I3892 n1_m1_182400_259200 0 1.615017e-07
I3893 n1_m1_182400_264000 0 2.451401e-07
I3894 n1_m1_182400_268800 0 1.605126e-07
I3895 n1_m1_182400_273600 0 2.452571e-07
I3896 n1_m1_182400_278400 0 1.536901e-07
I3897 n1_m1_182400_283200 0 1.557107e-07
I3898 n1_m1_182400_288000 0 2.507065e-07
I3899 n1_m1_182400_292800 0 1.865880e-07
I3900 n1_m1_182400_297600 0 2.511722e-07
I3901 n1_m1_182400_302400 0 1.522735e-07
I3902 n1_m1_182400_307200 0 1.468886e-07
I3903 n1_m1_182400_312000 0 2.162051e-07
I3904 n1_m1_182400_316800 0 1.436519e-07
I3905 n1_m1_182400_321600 0 2.140872e-07
I3906 n1_m1_182400_326400 0 1.504056e-07
I3907 n1_m1_182400_331200 0 1.572652e-07
I3908 n1_m1_182400_336000 0 2.335272e-07
I3909 n1_m1_182400_340800 0 1.536499e-07
I3910 n1_m1_182400_345600 0 2.472183e-07
I3911 n1_m1_182400_350400 0 1.675184e-07
I3912 n1_m1_182400_355200 0 1.661954e-07
I3913 n1_m1_182400_360000 0 3.810578e-07
I3914 n1_m1_182400_364800 0 1.644051e-07
I3915 n1_m1_182400_369600 0 2.467684e-07
I3916 n1_m1_182400_374400 0 1.554052e-07
I3917 n1_m1_182400_379200 0 1.495084e-07
I3918 n1_m1_182400_384000 0 2.330034e-07
I3919 n1_m1_182400_388800 0 1.712322e-07
I3920 n1_m1_182400_393600 0 2.511988e-07
I3921 n1_m1_182400_398400 0 1.721714e-07
I3922 n1_m1_182400_403200 0 1.732144e-07
I3923 n1_m1_182400_408000 0 2.517690e-07
I3924 n1_m1_182400_412800 0 1.526574e-07
I3925 n1_m1_182400_417600 0 2.155997e-07
I3926 n1_m1_182400_422400 0 1.400305e-07
I3927 n1_m1_182400_427200 0 1.399040e-07
I3928 n1_m1_182400_432000 0 2.099512e-07
I3929 n1_m1_182400_436800 0 1.407226e-07
I3930 n1_m1_182400_441600 0 2.165654e-07
I3931 n1_m1_182400_446400 0 1.462220e-07
I3932 n1_m1_182400_451200 0 1.450552e-07
I3933 n1_m1_182400_456000 0 2.132115e-07
I3934 n1_m1_182400_460800 0 1.462220e-07
I3935 n1_m1_182400_465600 0 2.213523e-07
I3936 n1_m1_182400_470400 0 1.569606e-07
I3937 n1_m1_182400_475200 0 1.657702e-07
I3938 n1_m1_182400_480000 0 2.416424e-07
I3939 n1_m1_187200_0 0 1.515088e-07
I3940 n1_m1_187200_4800 0 1.591670e-07
I3941 n1_m1_187200_9600 0 2.280834e-07
I3942 n1_m1_187200_14400 0 1.465254e-07
I3943 n1_m1_187200_19200 0 1.602611e-07
I3944 n1_m1_187200_24000 0 2.253767e-07
I3945 n1_m1_187200_28800 0 1.370442e-07
I3946 n1_m1_187200_33600 0 2.098560e-07
I3947 n1_m1_187200_38400 0 1.396278e-07
I3948 n1_m1_187200_43200 0 1.383967e-07
I3949 n1_m1_187200_48000 0 2.086049e-07
I3950 n1_m1_187200_52800 0 1.397892e-07
I3951 n1_m1_187200_57600 0 2.028726e-07
I3952 n1_m1_187200_62400 0 1.356303e-07
I3953 n1_m1_187200_67200 0 1.360758e-07
I3954 n1_m1_187200_72000 0 2.010048e-07
I3955 n1_m1_187200_76800 0 1.397540e-07
I3956 n1_m1_187200_81600 0 2.188214e-07
I3957 n1_m1_187200_86400 0 1.401557e-07
I3958 n1_m1_187200_91200 0 1.398522e-07
I3959 n1_m1_187200_96000 0 2.080271e-07
I3960 n1_m1_187200_100800 0 1.385888e-07
I3961 n1_m1_187200_105600 0 2.071159e-07
I3962 n1_m1_187200_110400 0 1.337695e-07
I3963 n1_m1_187200_115200 0 1.352221e-07
I3964 n1_m1_187200_120000 0 2.241730e-07
I3965 n1_m1_187200_124800 0 3.144527e-07
I3966 n1_m1_187200_129600 0 4.005021e-07
I3967 n1_m1_187200_134400 0 1.908152e-07
I3968 n1_m1_187200_139200 0 1.716259e-07
I3969 n1_m1_187200_144000 0 2.214801e-07
I3970 n1_m1_187200_148800 0 1.390284e-07
I3971 n1_m1_187200_153600 0 2.123972e-07
I3972 n1_m1_187200_158400 0 1.480118e-07
I3973 n1_m1_187200_163200 0 1.440893e-07
I3974 n1_m1_187200_168000 0 3.968683e-07
I3975 n1_m1_187200_172800 0 5.308584e-07
I3976 n1_m1_187200_177600 0 1.313665e-06
I3977 n1_m1_187200_182400 0 6.539665e-07
I3978 n1_m1_187200_187200 0 3.847396e-07
I3979 n1_m1_187200_192000 0 4.346178e-07
I3980 n1_m1_187200_196800 0 3.062546e-07
I3981 n1_m1_187200_201600 0 4.867310e-07
I3982 n1_m1_187200_206400 0 2.769445e-07
I3983 n1_m1_187200_211200 0 1.661353e-07
I3984 n1_m1_187200_216000 0 4.557749e-07
I3985 n1_m1_187200_220800 0 1.860111e-07
I3986 n1_m1_187200_225600 0 2.647165e-07
I3987 n1_m1_187200_230400 0 1.755956e-07
I3988 n1_m1_187200_235200 0 1.815925e-07
I3989 n1_m1_187200_240000 0 3.227833e-07
I3990 n1_m1_187200_244800 0 2.173061e-07
I3991 n1_m1_187200_249600 0 2.717620e-07
I3992 n1_m1_187200_254400 0 1.638321e-07
I3993 n1_m1_187200_259200 0 1.591418e-07
I3994 n1_m1_187200_264000 0 2.474668e-07
I3995 n1_m1_187200_268800 0 1.663848e-07
I3996 n1_m1_187200_273600 0 2.639127e-07
I3997 n1_m1_187200_278400 0 1.944613e-07
I3998 n1_m1_187200_283200 0 1.813424e-07
I3999 n1_m1_187200_288000 0 2.305518e-07
I4000 n1_m1_187200_292800 0 1.588893e-07
I4001 n1_m1_187200_297600 0 2.425800e-07
I4002 n1_m1_187200_302400 0 1.546771e-07
I4003 n1_m1_187200_307200 0 1.503802e-07
I4004 n1_m1_187200_312000 0 2.316451e-07
I4005 n1_m1_187200_316800 0 1.548895e-07
I4006 n1_m1_187200_321600 0 2.248560e-07
I4007 n1_m1_187200_326400 0 1.543293e-07
I4008 n1_m1_187200_331200 0 1.596642e-07
I4009 n1_m1_187200_336000 0 2.472024e-07
I4010 n1_m1_187200_340800 0 1.535094e-07
I4011 n1_m1_187200_345600 0 2.539822e-07
I4012 n1_m1_187200_350400 0 1.934059e-07
I4013 n1_m1_187200_355200 0 1.758705e-07
I4014 n1_m1_187200_360000 0 2.631586e-07
I4015 n1_m1_187200_364800 0 1.899169e-07
I4016 n1_m1_187200_369600 0 2.588026e-07
I4017 n1_m1_187200_374400 0 1.547105e-07
I4018 n1_m1_187200_379200 0 1.479058e-07
I4019 n1_m1_187200_384000 0 2.254698e-07
I4020 n1_m1_187200_388800 0 1.597566e-07
I4021 n1_m1_187200_393600 0 2.514429e-07
I4022 n1_m1_187200_398400 0 1.731062e-07
I4023 n1_m1_187200_403200 0 1.732144e-07
I4024 n1_m1_187200_408000 0 2.466614e-07
I4025 n1_m1_187200_412800 0 1.477223e-07
I4026 n1_m1_187200_417600 0 2.107256e-07
I4027 n1_m1_187200_422400 0 1.399040e-07
I4028 n1_m1_187200_427200 0 1.410153e-07
I4029 n1_m1_187200_432000 0 2.102719e-07
I4030 n1_m1_187200_436800 0 1.420832e-07
I4031 n1_m1_187200_441600 0 2.197571e-07
I4032 n1_m1_187200_446400 0 1.465661e-07
I4033 n1_m1_187200_451200 0 1.448222e-07
I4034 n1_m1_187200_456000 0 2.096947e-07
I4035 n1_m1_187200_460800 0 1.460536e-07
I4036 n1_m1_187200_465600 0 2.187618e-07
I4037 n1_m1_187200_470400 0 1.526776e-07
I4038 n1_m1_187200_475200 0 1.610332e-07
I4039 n1_m1_187200_480000 0 2.345704e-07
I4040 n1_m1_192000_0 0 2.407095e-07
I4041 n1_m1_192000_4800 0 2.534421e-07
I4042 n1_m1_192000_9600 0 3.624849e-07
I4043 n1_m1_192000_14400 0 2.249163e-07
I4044 n1_m1_192000_19200 0 2.358202e-07
I4045 n1_m1_192000_24000 0 3.392844e-07
I4046 n1_m1_192000_28800 0 2.098560e-07
I4047 n1_m1_192000_33600 0 3.140461e-07
I4048 n1_m1_192000_38400 0 2.043355e-07
I4049 n1_m1_192000_43200 0 2.012086e-07
I4050 n1_m1_192000_48000 0 3.108595e-07
I4051 n1_m1_192000_52800 0 2.098560e-07
I4052 n1_m1_192000_57600 0 3.130122e-07
I4053 n1_m1_192000_62400 0 2.051379e-07
I4054 n1_m1_192000_67200 0 2.051592e-07
I4055 n1_m1_192000_72000 0 3.075575e-07
I4056 n1_m1_192000_76800 0 2.090072e-07
I4057 n1_m1_192000_81600 0 3.336501e-07
I4058 n1_m1_192000_86400 0 2.128180e-07
I4059 n1_m1_192000_91200 0 2.132766e-07
I4060 n1_m1_192000_96000 0 3.028555e-07
I4061 n1_m1_192000_100800 0 2.023223e-07
I4062 n1_m1_192000_105600 0 3.075575e-07
I4063 n1_m1_192000_110400 0 2.050833e-07
I4064 n1_m1_192000_115200 0 2.096806e-07
I4065 n1_m1_192000_120000 0 3.828114e-07
I4066 n1_m1_192000_124800 0 1.100157e-06
I4067 n1_m1_192000_129600 0 9.772880e-07
I4068 n1_m1_192000_134400 0 3.141624e-07
I4069 n1_m1_192000_139200 0 2.703202e-07
I4070 n1_m1_192000_144000 0 3.592237e-07
I4071 n1_m1_192000_148800 0 2.205563e-07
I4072 n1_m1_192000_153600 0 3.259941e-07
I4073 n1_m1_192000_158400 0 2.124175e-07
I4074 n1_m1_192000_163200 0 2.269664e-07
I4075 n1_m1_192000_168000 0 1.060700e-06
I4076 n1_m1_192000_172800 0 1.283107e-06
I4077 n1_m1_192000_177600 0 1.486766e-06
I4078 n1_m1_192000_182400 0 1.094769e-06
I4079 n1_m1_192000_187200 0 7.147872e-07
I4080 n1_m1_192000_192000 0 1.217014e-06
I4081 n1_m1_192000_196800 0 1.053541e-06
I4082 n1_m1_192000_201600 0 1.918555e-06
I4083 n1_m1_192000_206400 0 1.165123e-06
I4084 n1_m1_192000_211200 0 6.006747e-07
I4085 n1_m1_192000_216000 0 7.865886e-07
I4086 n1_m1_192000_220800 0 3.825721e-07
I4087 n1_m1_192000_225600 0 9.556057e-07
I4088 n1_m1_192000_230400 0 4.326365e-07
I4089 n1_m1_192000_235200 0 6.428649e-07
I4090 n1_m1_192000_240000 0 1.370732e-06
I4091 n1_m1_192000_244800 0 1.009217e-06
I4092 n1_m1_192000_249600 0 1.139127e-06
I4093 n1_m1_192000_254400 0 6.462135e-07
I4094 n1_m1_192000_259200 0 7.357928e-07
I4095 n1_m1_192000_264000 0 1.251624e-06
I4096 n1_m1_192000_268800 0 8.992080e-07
I4097 n1_m1_192000_273600 0 1.677743e-06
I4098 n1_m1_192000_278400 0 1.069595e-06
I4099 n1_m1_192000_283200 0 7.204797e-07
I4100 n1_m1_192000_288000 0 5.986528e-07
I4101 n1_m1_192000_292800 0 3.923364e-07
I4102 n1_m1_192000_297600 0 4.163475e-07
I4103 n1_m1_192000_302400 0 2.598375e-07
I4104 n1_m1_192000_307200 0 2.506916e-07
I4105 n1_m1_192000_312000 0 3.720065e-07
I4106 n1_m1_192000_316800 0 2.428494e-07
I4107 n1_m1_192000_321600 0 3.575532e-07
I4108 n1_m1_192000_326400 0 2.452624e-07
I4109 n1_m1_192000_331200 0 2.607503e-07
I4110 n1_m1_192000_336000 0 6.874050e-07
I4111 n1_m1_192000_340800 0 4.751960e-07
I4112 n1_m1_192000_345600 0 6.637253e-07
I4113 n1_m1_192000_350400 0 4.405297e-07
I4114 n1_m1_192000_355200 0 3.631485e-07
I4115 n1_m1_192000_360000 0 4.594462e-07
I4116 n1_m1_192000_364800 0 3.882115e-07
I4117 n1_m1_192000_369600 0 4.356872e-07
I4118 n1_m1_192000_374400 0 2.529634e-07
I4119 n1_m1_192000_379200 0 2.294786e-07
I4120 n1_m1_192000_384000 0 3.470035e-07
I4121 n1_m1_192000_388800 0 2.233139e-07
I4122 n1_m1_192000_393600 0 3.630253e-07
I4123 n1_m1_192000_398400 0 2.542449e-07
I4124 n1_m1_192000_403200 0 2.544122e-07
I4125 n1_m1_192000_408000 0 3.623866e-07
I4126 n1_m1_192000_412800 0 2.206694e-07
I4127 n1_m1_192000_417600 0 3.162036e-07
I4128 n1_m1_192000_422400 0 2.099420e-07
I4129 n1_m1_192000_427200 0 2.167521e-07
I4130 n1_m1_192000_432000 0 3.173648e-07
I4131 n1_m1_192000_436800 0 2.114685e-07
I4132 n1_m1_192000_441600 0 3.266299e-07
I4133 n1_m1_192000_446400 0 2.198491e-07
I4134 n1_m1_192000_451200 0 2.183772e-07
I4135 n1_m1_192000_456000 0 3.190450e-07
I4136 n1_m1_192000_460800 0 2.183162e-07
I4137 n1_m1_192000_465600 0 3.294692e-07
I4138 n1_m1_192000_470400 0 2.417762e-07
I4139 n1_m1_192000_475200 0 2.513977e-07
I4140 n1_m1_192000_480000 0 3.551697e-07
I4141 n1_m1_196800_0 0 1.726591e-07
I4142 n1_m1_196800_4800 0 1.769703e-07
I4143 n1_m1_196800_9600 0 2.505941e-07
I4144 n1_m1_196800_14400 0 1.507628e-07
I4145 n1_m1_196800_19200 0 1.529445e-07
I4146 n1_m1_196800_24000 0 2.251105e-07
I4147 n1_m1_196800_28800 0 1.399040e-07
I4148 n1_m1_196800_33600 0 2.085439e-07
I4149 n1_m1_196800_38400 0 1.338216e-07
I4150 n1_m1_196800_43200 0 1.344915e-07
I4151 n1_m1_196800_48000 0 2.089969e-07
I4152 n1_m1_196800_52800 0 1.397911e-07
I4153 n1_m1_196800_57600 0 2.094636e-07
I4154 n1_m1_196800_62400 0 1.419896e-07
I4155 n1_m1_196800_67200 0 1.424351e-07
I4156 n1_m1_196800_72000 0 2.098560e-07
I4157 n1_m1_196800_76800 0 1.434811e-07
I4158 n1_m1_196800_81600 0 2.364772e-07
I4159 n1_m1_196800_86400 0 1.490950e-07
I4160 n1_m1_196800_91200 0 1.460935e-07
I4161 n1_m1_196800_96000 0 2.073117e-07
I4162 n1_m1_196800_100800 0 1.366317e-07
I4163 n1_m1_196800_105600 0 2.098560e-07
I4164 n1_m1_196800_110400 0 1.408455e-07
I4165 n1_m1_196800_115200 0 1.474429e-07
I4166 n1_m1_196800_120000 0 2.442395e-07
I4167 n1_m1_196800_124800 0 5.133337e-07
I4168 n1_m1_196800_129600 0 4.465454e-07
I4169 n1_m1_196800_134400 0 2.995564e-07
I4170 n1_m1_196800_139200 0 2.308999e-07
I4171 n1_m1_196800_144000 0 2.280300e-07
I4172 n1_m1_196800_148800 0 1.425393e-07
I4173 n1_m1_196800_153600 0 2.191212e-07
I4174 n1_m1_196800_158400 0 1.494121e-07
I4175 n1_m1_196800_163200 0 1.450024e-07
I4176 n1_m1_196800_168000 0 7.052906e-07
I4177 n1_m1_196800_172800 0 8.776757e-07
I4178 n1_m1_196800_177600 0 1.564096e-06
I4179 n1_m1_196800_182400 0 1.068733e-06
I4180 n1_m1_196800_187200 0 6.752292e-07
I4181 n1_m1_196800_192000 0 9.082366e-07
I4182 n1_m1_196800_196800 0 4.899568e-07
I4183 n1_m1_196800_201600 0 1.588147e-06
I4184 n1_m1_196800_206400 0 6.255736e-07
I4185 n1_m1_196800_211200 0 3.265606e-07
I4186 n1_m1_196800_216000 0 3.981008e-07
I4187 n1_m1_196800_220800 0 5.297507e-07
I4188 n1_m1_196800_225600 0 1.105271e-06
I4189 n1_m1_196800_230400 0 3.410286e-07
I4190 n1_m1_196800_235200 0 5.714044e-07
I4191 n1_m1_196800_240000 0 1.272962e-06
I4192 n1_m1_196800_244800 0 1.125470e-06
I4193 n1_m1_196800_249600 0 1.062765e-06
I4194 n1_m1_196800_254400 0 5.642159e-07
I4195 n1_m1_196800_259200 0 7.296880e-07
I4196 n1_m1_196800_264000 0 1.480135e-06
I4197 n1_m1_196800_268800 0 1.099150e-06
I4198 n1_m1_196800_273600 0 1.564423e-06
I4199 n1_m1_196800_278400 0 8.907383e-07
I4200 n1_m1_196800_283200 0 6.031665e-07
I4201 n1_m1_196800_288000 0 6.462788e-07
I4202 n1_m1_196800_292800 0 5.352957e-07
I4203 n1_m1_196800_297600 0 5.186318e-07
I4204 n1_m1_196800_302400 0 1.904553e-07
I4205 n1_m1_196800_307200 0 1.796154e-07
I4206 n1_m1_196800_312000 0 3.864147e-07
I4207 n1_m1_196800_316800 0 2.844023e-07
I4208 n1_m1_196800_321600 0 3.240134e-07
I4209 n1_m1_196800_326400 0 1.718490e-07
I4210 n1_m1_196800_331200 0 2.231871e-07
I4211 n1_m1_196800_336000 0 8.787882e-07
I4212 n1_m1_196800_340800 0 5.602337e-07
I4213 n1_m1_196800_345600 0 6.457916e-07
I4214 n1_m1_196800_350400 0 3.776759e-07
I4215 n1_m1_196800_355200 0 3.021575e-07
I4216 n1_m1_196800_360000 0 3.505052e-07
I4217 n1_m1_196800_364800 0 1.892244e-07
I4218 n1_m1_196800_369600 0 2.554133e-07
I4219 n1_m1_196800_374400 0 1.586318e-07
I4220 n1_m1_196800_379200 0 1.524120e-07
I4221 n1_m1_196800_384000 0 2.402422e-07
I4222 n1_m1_196800_388800 0 1.539717e-07
I4223 n1_m1_196800_393600 0 2.280700e-07
I4224 n1_m1_196800_398400 0 1.569906e-07
I4225 n1_m1_196800_403200 0 1.607987e-07
I4226 n1_m1_196800_408000 0 2.333884e-07
I4227 n1_m1_196800_412800 0 1.472610e-07
I4228 n1_m1_196800_417600 0 2.182376e-07
I4229 n1_m1_196800_422400 0 1.420200e-07
I4230 n1_m1_196800_427200 0 1.445014e-07
I4231 n1_m1_196800_432000 0 2.115765e-07
I4232 n1_m1_196800_436800 0 1.399040e-07
I4233 n1_m1_196800_441600 0 2.158023e-07
I4234 n1_m1_196800_446400 0 1.465661e-07
I4235 n1_m1_196800_451200 0 1.464290e-07
I4236 n1_m1_196800_456000 0 2.193965e-07
I4237 n1_m1_196800_460800 0 1.469928e-07
I4238 n1_m1_196800_465600 0 2.302471e-07
I4239 n1_m1_196800_470400 0 1.699935e-07
I4240 n1_m1_196800_475200 0 1.762439e-07
I4241 n1_m1_196800_480000 0 2.424433e-07
I4242 n1_m1_201600_0 0 1.727692e-07
I4243 n1_m1_201600_4800 0 1.790181e-07
I4244 n1_m1_201600_9600 0 2.543318e-07
I4245 n1_m1_201600_14400 0 1.471442e-07
I4246 n1_m1_201600_19200 0 1.487251e-07
I4247 n1_m1_201600_24000 0 2.242057e-07
I4248 n1_m1_201600_28800 0 1.399040e-07
I4249 n1_m1_201600_33600 0 2.032489e-07
I4250 n1_m1_201600_38400 0 1.332419e-07
I4251 n1_m1_201600_43200 0 1.332419e-07
I4252 n1_m1_201600_48000 0 1.998628e-07
I4253 n1_m1_201600_52800 0 1.360032e-07
I4254 n1_m1_201600_57600 0 2.058510e-07
I4255 n1_m1_201600_62400 0 1.399040e-07
I4256 n1_m1_201600_67200 0 1.399040e-07
I4257 n1_m1_201600_72000 0 2.098560e-07
I4258 n1_m1_201600_76800 0 1.425193e-07
I4259 n1_m1_201600_81600 0 2.293192e-07
I4260 n1_m1_201600_86400 0 1.455110e-07
I4261 n1_m1_201600_91200 0 1.454552e-07
I4262 n1_m1_201600_96000 0 2.111085e-07
I4263 n1_m1_201600_100800 0 1.399040e-07
I4264 n1_m1_201600_105600 0 2.093662e-07
I4265 n1_m1_201600_110400 0 1.371203e-07
I4266 n1_m1_201600_115200 0 1.383761e-07
I4267 n1_m1_201600_120000 0 2.277167e-07
I4268 n1_m1_201600_124800 0 1.718283e-07
I4269 n1_m1_201600_129600 0 3.036033e-07
I4270 n1_m1_201600_134400 0 2.441232e-07
I4271 n1_m1_201600_139200 0 1.766288e-07
I4272 n1_m1_201600_144000 0 2.349898e-07
I4273 n1_m1_201600_148800 0 1.573737e-07
I4274 n1_m1_201600_153600 0 2.249405e-07
I4275 n1_m1_201600_158400 0 1.432891e-07
I4276 n1_m1_201600_163200 0 1.456809e-07
I4277 n1_m1_201600_168000 0 4.412455e-07
I4278 n1_m1_201600_172800 0 5.052338e-07
I4279 n1_m1_201600_177600 0 1.567612e-06
I4280 n1_m1_201600_182400 0 1.191580e-06
I4281 n1_m1_201600_187200 0 1.212433e-06
I4282 n1_m1_201600_192000 0 1.132876e-06
I4283 n1_m1_201600_196800 0 4.367860e-07
I4284 n1_m1_201600_201600 0 6.292163e-07
I4285 n1_m1_201600_206400 0 3.754625e-07
I4286 n1_m1_201600_211200 0 3.259037e-07
I4287 n1_m1_201600_216000 0 3.280358e-07
I4288 n1_m1_201600_220800 0 2.134619e-07
I4289 n1_m1_201600_225600 0 4.478372e-07
I4290 n1_m1_201600_230400 0 6.434713e-07
I4291 n1_m1_201600_235200 0 6.306936e-07
I4292 n1_m1_201600_240000 0 8.535965e-07
I4293 n1_m1_201600_244800 0 5.791898e-07
I4294 n1_m1_201600_249600 0 5.522647e-07
I4295 n1_m1_201600_254400 0 4.445096e-07
I4296 n1_m1_201600_259200 0 5.585971e-07
I4297 n1_m1_201600_264000 0 7.815541e-07
I4298 n1_m1_201600_268800 0 4.633561e-07
I4299 n1_m1_201600_273600 0 5.356825e-07
I4300 n1_m1_201600_278400 0 3.955556e-07
I4301 n1_m1_201600_283200 0 3.369676e-07
I4302 n1_m1_201600_288000 0 3.075461e-07
I4303 n1_m1_201600_292800 0 1.791698e-07
I4304 n1_m1_201600_297600 0 2.524480e-07
I4305 n1_m1_201600_302400 0 1.728362e-07
I4306 n1_m1_201600_307200 0 1.767094e-07
I4307 n1_m1_201600_312000 0 2.687201e-07
I4308 n1_m1_201600_316800 0 1.735448e-07
I4309 n1_m1_201600_321600 0 2.646070e-07
I4310 n1_m1_201600_326400 0 1.898463e-07
I4311 n1_m1_201600_331200 0 2.014925e-07
I4312 n1_m1_201600_336000 0 3.635958e-07
I4313 n1_m1_201600_340800 0 1.923419e-07
I4314 n1_m1_201600_345600 0 2.929678e-07
I4315 n1_m1_201600_350400 0 4.001523e-07
I4316 n1_m1_201600_355200 0 4.072691e-07
I4317 n1_m1_201600_360000 0 5.051606e-07
I4318 n1_m1_201600_364800 0 2.028124e-07
I4319 n1_m1_201600_369600 0 3.100180e-07
I4320 n1_m1_201600_374400 0 1.757084e-07
I4321 n1_m1_201600_379200 0 1.558820e-07
I4322 n1_m1_201600_384000 0 2.301583e-07
I4323 n1_m1_201600_388800 0 1.478324e-07
I4324 n1_m1_201600_393600 0 2.216914e-07
I4325 n1_m1_201600_398400 0 1.506107e-07
I4326 n1_m1_201600_403200 0 1.532282e-07
I4327 n1_m1_201600_408000 0 2.238409e-07
I4328 n1_m1_201600_412800 0 1.465661e-07
I4329 n1_m1_201600_417600 0 2.219521e-07
I4330 n1_m1_201600_422400 0 1.437006e-07
I4331 n1_m1_201600_427200 0 1.445014e-07
I4332 n1_m1_201600_432000 0 2.115765e-07
I4333 n1_m1_201600_436800 0 1.409083e-07
I4334 n1_m1_201600_441600 0 2.176250e-07
I4335 n1_m1_201600_446400 0 1.465661e-07
I4336 n1_m1_201600_451200 0 1.471183e-07
I4337 n1_m1_201600_456000 0 2.269034e-07
I4338 n1_m1_201600_460800 0 1.511822e-07
I4339 n1_m1_201600_465600 0 2.344231e-07
I4340 n1_m1_201600_470400 0 1.775641e-07
I4341 n1_m1_201600_475200 0 1.814182e-07
I4342 n1_m1_201600_480000 0 2.433454e-07
I4343 n1_m1_206400_0 0 1.700761e-07
I4344 n1_m1_206400_4800 0 1.780981e-07
I4345 n1_m1_206400_9600 0 2.492701e-07
I4346 n1_m1_206400_14400 0 1.434828e-07
I4347 n1_m1_206400_19200 0 1.450711e-07
I4348 n1_m1_206400_24000 0 2.203424e-07
I4349 n1_m1_206400_28800 0 1.399040e-07
I4350 n1_m1_206400_33600 0 2.066070e-07
I4351 n1_m1_206400_38400 0 1.366280e-07
I4352 n1_m1_206400_43200 0 1.366280e-07
I4353 n1_m1_206400_48000 0 2.049420e-07
I4354 n1_m1_206400_52800 0 1.391930e-07
I4355 n1_m1_206400_57600 0 2.123700e-07
I4356 n1_m1_206400_62400 0 1.466762e-07
I4357 n1_m1_206400_67200 0 1.450391e-07
I4358 n1_m1_206400_72000 0 2.119758e-07
I4359 n1_m1_206400_76800 0 1.456745e-07
I4360 n1_m1_206400_81600 0 2.343983e-07
I4361 n1_m1_206400_86400 0 1.515272e-07
I4362 n1_m1_206400_91200 0 1.471450e-07
I4363 n1_m1_206400_96000 0 2.155511e-07
I4364 n1_m1_206400_100800 0 1.448992e-07
I4365 n1_m1_206400_105600 0 2.154288e-07
I4366 n1_m1_206400_110400 0 1.371098e-07
I4367 n1_m1_206400_115200 0 1.381008e-07
I4368 n1_m1_206400_120000 0 2.248489e-07
I4369 n1_m1_206400_124800 0 1.774144e-07
I4370 n1_m1_206400_129600 0 7.698114e-07
I4371 n1_m1_206400_134400 0 5.063302e-07
I4372 n1_m1_206400_139200 0 2.668434e-07
I4373 n1_m1_206400_144000 0 2.603142e-07
I4374 n1_m1_206400_148800 0 1.479951e-07
I4375 n1_m1_206400_153600 0 2.198721e-07
I4376 n1_m1_206400_158400 0 1.541495e-07
I4377 n1_m1_206400_163200 0 1.636601e-07
I4378 n1_m1_206400_168000 0 2.923656e-07
I4379 n1_m1_206400_172800 0 3.946799e-07
I4380 n1_m1_206400_177600 0 1.548339e-06
I4381 n1_m1_206400_182400 0 1.188842e-06
I4382 n1_m1_206400_187200 0 1.263550e-06
I4383 n1_m1_206400_192000 0 1.337904e-06
I4384 n1_m1_206400_196800 0 6.381708e-07
I4385 n1_m1_206400_201600 0 5.022874e-07
I4386 n1_m1_206400_206400 0 2.896955e-07
I4387 n1_m1_206400_211200 0 3.243845e-07
I4388 n1_m1_206400_216000 0 3.422905e-07
I4389 n1_m1_206400_220800 0 2.371388e-07
I4390 n1_m1_206400_225600 0 5.341995e-07
I4391 n1_m1_206400_230400 0 8.295043e-07
I4392 n1_m1_206400_235200 0 5.403400e-07
I4393 n1_m1_206400_240000 0 1.149322e-06
I4394 n1_m1_206400_244800 0 6.388745e-07
I4395 n1_m1_206400_249600 0 6.025157e-07
I4396 n1_m1_206400_254400 0 5.030707e-07
I4397 n1_m1_206400_259200 0 5.650330e-07
I4398 n1_m1_206400_264000 0 6.160963e-07
I4399 n1_m1_206400_268800 0 2.974956e-07
I4400 n1_m1_206400_273600 0 4.787037e-07
I4401 n1_m1_206400_278400 0 2.579831e-07
I4402 n1_m1_206400_283200 0 2.396194e-07
I4403 n1_m1_206400_288000 0 2.939675e-07
I4404 n1_m1_206400_292800 0 1.988921e-07
I4405 n1_m1_206400_297600 0 2.548745e-07
I4406 n1_m1_206400_302400 0 1.682332e-07
I4407 n1_m1_206400_307200 0 1.740190e-07
I4408 n1_m1_206400_312000 0 3.106379e-07
I4409 n1_m1_206400_316800 0 2.390838e-07
I4410 n1_m1_206400_321600 0 3.157533e-07
I4411 n1_m1_206400_326400 0 1.891994e-07
I4412 n1_m1_206400_331200 0 1.950708e-07
I4413 n1_m1_206400_336000 0 2.683538e-07
I4414 n1_m1_206400_340800 0 1.779058e-07
I4415 n1_m1_206400_345600 0 2.883348e-07
I4416 n1_m1_206400_350400 0 3.032829e-07
I4417 n1_m1_206400_355200 0 3.379764e-07
I4418 n1_m1_206400_360000 0 5.794168e-07
I4419 n1_m1_206400_364800 0 2.062687e-07
I4420 n1_m1_206400_369600 0 3.410562e-07
I4421 n1_m1_206400_374400 0 1.865348e-07
I4422 n1_m1_206400_379200 0 1.534217e-07
I4423 n1_m1_206400_384000 0 2.217222e-07
I4424 n1_m1_206400_388800 0 1.485086e-07
I4425 n1_m1_206400_393600 0 2.267552e-07
I4426 n1_m1_206400_398400 0 1.532282e-07
I4427 n1_m1_206400_403200 0 1.532282e-07
I4428 n1_m1_206400_408000 0 2.235120e-07
I4429 n1_m1_206400_412800 0 1.440755e-07
I4430 n1_m1_206400_417600 0 2.175334e-07
I4431 n1_m1_206400_422400 0 1.411088e-07
I4432 n1_m1_206400_427200 0 1.445014e-07
I4433 n1_m1_206400_432000 0 2.157812e-07
I4434 n1_m1_206400_436800 0 1.432532e-07
I4435 n1_m1_206400_441600 0 2.177923e-07
I4436 n1_m1_206400_446400 0 1.465661e-07
I4437 n1_m1_206400_451200 0 1.465661e-07
I4438 n1_m1_206400_456000 0 2.218932e-07
I4439 n1_m1_206400_460800 0 1.476084e-07
I4440 n1_m1_206400_465600 0 2.334624e-07
I4441 n1_m1_206400_470400 0 1.775641e-07
I4442 n1_m1_206400_475200 0 1.814182e-07
I4443 n1_m1_206400_480000 0 2.433454e-07
I4444 n1_m1_211200_0 0 1.627513e-07
I4445 n1_m1_211200_4800 0 1.806164e-07
I4446 n1_m1_211200_9600 0 2.527669e-07
I4447 n1_m1_211200_14400 0 1.434828e-07
I4448 n1_m1_211200_19200 0 1.421077e-07
I4449 n1_m1_211200_24000 0 2.131049e-07
I4450 n1_m1_211200_28800 0 1.399040e-07
I4451 n1_m1_211200_33600 0 2.237420e-07
I4452 n1_m1_211200_38400 0 1.481483e-07
I4453 n1_m1_211200_43200 0 1.451794e-07
I4454 n1_m1_211200_48000 0 2.100508e-07
I4455 n1_m1_211200_52800 0 1.433704e-07
I4456 n1_m1_211200_57600 0 2.410317e-07
I4457 n1_m1_211200_62400 0 1.614102e-07
I4458 n1_m1_211200_67200 0 1.514566e-07
I4459 n1_m1_211200_72000 0 2.374272e-07
I4460 n1_m1_211200_76800 0 1.477920e-07
I4461 n1_m1_211200_81600 0 2.362655e-07
I4462 n1_m1_211200_86400 0 1.539630e-07
I4463 n1_m1_211200_91200 0 1.527413e-07
I4464 n1_m1_211200_96000 0 2.196933e-07
I4465 n1_m1_211200_100800 0 1.459604e-07
I4466 n1_m1_211200_105600 0 2.207270e-07
I4467 n1_m1_211200_110400 0 1.446092e-07
I4468 n1_m1_211200_115200 0 1.495900e-07
I4469 n1_m1_211200_120000 0 2.398595e-07
I4470 n1_m1_211200_124800 0 6.582950e-07
I4471 n1_m1_211200_129600 0 1.054044e-06
I4472 n1_m1_211200_134400 0 5.278468e-07
I4473 n1_m1_211200_139200 0 3.267435e-07
I4474 n1_m1_211200_144000 0 2.681807e-07
I4475 n1_m1_211200_148800 0 1.626703e-07
I4476 n1_m1_211200_153600 0 2.292747e-07
I4477 n1_m1_211200_158400 0 1.583533e-07
I4478 n1_m1_211200_163200 0 1.713629e-07
I4479 n1_m1_211200_168000 0 5.055176e-07
I4480 n1_m1_211200_172800 0 6.327948e-07
I4481 n1_m1_211200_177600 0 1.300210e-06
I4482 n1_m1_211200_182400 0 1.057189e-06
I4483 n1_m1_211200_187200 0 1.000117e-06
I4484 n1_m1_211200_192000 0 1.414612e-06
I4485 n1_m1_211200_196800 0 8.973630e-07
I4486 n1_m1_211200_201600 0 4.246553e-07
I4487 n1_m1_211200_206400 0 2.280189e-07
I4488 n1_m1_211200_211200 0 1.932723e-07
I4489 n1_m1_211200_216000 0 7.069539e-07
I4490 n1_m1_211200_220800 0 2.741777e-07
I4491 n1_m1_211200_225600 0 5.677411e-07
I4492 n1_m1_211200_230400 0 6.016856e-07
I4493 n1_m1_211200_235200 0 4.053153e-07
I4494 n1_m1_211200_240000 0 1.506500e-06
I4495 n1_m1_211200_244800 0 7.334154e-07
I4496 n1_m1_211200_249600 0 5.465972e-07
I4497 n1_m1_211200_254400 0 4.936635e-07
I4498 n1_m1_211200_259200 0 3.968173e-07
I4499 n1_m1_211200_264000 0 7.138313e-07
I4500 n1_m1_211200_268800 0 2.458577e-07
I4501 n1_m1_211200_273600 0 4.820912e-07
I4502 n1_m1_211200_278400 0 1.827444e-07
I4503 n1_m1_211200_283200 0 1.853179e-07
I4504 n1_m1_211200_288000 0 2.905635e-07
I4505 n1_m1_211200_292800 0 2.057575e-07
I4506 n1_m1_211200_297600 0 2.555023e-07
I4507 n1_m1_211200_302400 0 2.563928e-07
I4508 n1_m1_211200_307200 0 2.250661e-07
I4509 n1_m1_211200_312000 0 4.116735e-07
I4510 n1_m1_211200_316800 0 2.361764e-07
I4511 n1_m1_211200_321600 0 3.060061e-07
I4512 n1_m1_211200_326400 0 1.775172e-07
I4513 n1_m1_211200_331200 0 1.764725e-07
I4514 n1_m1_211200_336000 0 2.605236e-07
I4515 n1_m1_211200_340800 0 1.783864e-07
I4516 n1_m1_211200_345600 0 2.616454e-07
I4517 n1_m1_211200_350400 0 1.774527e-07
I4518 n1_m1_211200_355200 0 1.870683e-07
I4519 n1_m1_211200_360000 0 3.751808e-07
I4520 n1_m1_211200_364800 0 1.741504e-07
I4521 n1_m1_211200_369600 0 2.766798e-07
I4522 n1_m1_211200_374400 0 1.726086e-07
I4523 n1_m1_211200_379200 0 1.555628e-07
I4524 n1_m1_211200_384000 0 2.191094e-07
I4525 n1_m1_211200_388800 0 1.478738e-07
I4526 n1_m1_211200_393600 0 2.295765e-07
I4527 n1_m1_211200_398400 0 1.553789e-07
I4528 n1_m1_211200_403200 0 1.568906e-07
I4529 n1_m1_211200_408000 0 2.216666e-07
I4530 n1_m1_211200_412800 0 1.472140e-07
I4531 n1_m1_211200_417600 0 2.161190e-07
I4532 n1_m1_211200_422400 0 1.399040e-07
I4533 n1_m1_211200_427200 0 1.471040e-07
I4534 n1_m1_211200_432000 0 2.156334e-07
I4535 n1_m1_211200_436800 0 1.531416e-07
I4536 n1_m1_211200_441600 0 2.230258e-07
I4537 n1_m1_211200_446400 0 1.493402e-07
I4538 n1_m1_211200_451200 0 1.464258e-07
I4539 n1_m1_211200_456000 0 2.145113e-07
I4540 n1_m1_211200_460800 0 1.427946e-07
I4541 n1_m1_211200_465600 0 2.278051e-07
I4542 n1_m1_211200_470400 0 1.762550e-07
I4543 n1_m1_211200_475200 0 1.866391e-07
I4544 n1_m1_211200_480000 0 2.546599e-07
I4545 n1_m1_216000_0 0 3.080459e-07
I4546 n1_m1_216000_4800 0 4.362741e-07
I4547 n1_m1_216000_9600 0 5.296168e-07
I4548 n1_m1_216000_14400 0 2.522065e-07
I4549 n1_m1_216000_19200 0 2.455966e-07
I4550 n1_m1_216000_24000 0 3.672708e-07
I4551 n1_m1_216000_28800 0 2.345550e-07
I4552 n1_m1_216000_33600 0 3.321507e-07
I4553 n1_m1_216000_38400 0 2.203473e-07
I4554 n1_m1_216000_43200 0 2.226564e-07
I4555 n1_m1_216000_48000 0 7.428404e-07
I4556 n1_m1_216000_52800 0 6.105847e-07
I4557 n1_m1_216000_57600 0 1.421873e-06
I4558 n1_m1_216000_62400 0 9.275298e-07
I4559 n1_m1_216000_67200 0 1.084941e-06
I4560 n1_m1_216000_72000 0 1.935987e-06
I4561 n1_m1_216000_76800 0 8.258975e-07
I4562 n1_m1_216000_81600 0 5.091395e-07
I4563 n1_m1_216000_86400 0 2.753720e-07
I4564 n1_m1_216000_91200 0 4.207269e-07
I4565 n1_m1_216000_96000 0 8.202965e-07
I4566 n1_m1_216000_100800 0 8.493267e-07
I4567 n1_m1_216000_105600 0 1.516386e-06
I4568 n1_m1_216000_110400 0 8.996950e-07
I4569 n1_m1_216000_115200 0 9.075084e-07
I4570 n1_m1_216000_120000 0 1.173608e-06
I4571 n1_m1_216000_124800 0 1.574817e-06
I4572 n1_m1_216000_129600 0 1.370061e-06
I4573 n1_m1_216000_134400 0 1.114390e-06
I4574 n1_m1_216000_139200 0 1.467715e-06
I4575 n1_m1_216000_144000 0 2.138696e-06
I4576 n1_m1_216000_148800 0 1.255274e-06
I4577 n1_m1_216000_153600 0 1.448555e-06
I4578 n1_m1_216000_158400 0 7.080847e-07
I4579 n1_m1_216000_163200 0 5.023799e-07
I4580 n1_m1_216000_168000 0 1.351202e-06
I4581 n1_m1_216000_172800 0 1.442971e-06
I4582 n1_m1_216000_177600 0 1.647356e-06
I4583 n1_m1_216000_182400 0 1.585179e-06
I4584 n1_m1_216000_187200 0 1.633266e-06
I4585 n1_m1_216000_192000 0 2.024288e-06
I4586 n1_m1_216000_196800 0 9.405657e-07
I4587 n1_m1_216000_201600 0 8.580338e-07
I4588 n1_m1_216000_206400 0 2.882631e-07
I4589 n1_m1_216000_211200 0 2.829200e-07
I4590 n1_m1_216000_216000 0 7.558181e-07
I4591 n1_m1_216000_220800 0 3.461584e-07
I4592 n1_m1_216000_225600 0 5.978725e-07
I4593 n1_m1_216000_230400 0 5.444810e-07
I4594 n1_m1_216000_235200 0 8.253444e-07
I4595 n1_m1_216000_240000 0 1.771979e-06
I4596 n1_m1_216000_244800 0 1.609000e-06
I4597 n1_m1_216000_249600 0 1.328272e-06
I4598 n1_m1_216000_254400 0 8.461896e-07
I4599 n1_m1_216000_259200 0 1.084579e-06
I4600 n1_m1_216000_264000 0 1.076661e-06
I4601 n1_m1_216000_268800 0 2.945573e-07
I4602 n1_m1_216000_273600 0 4.851708e-07
I4603 n1_m1_216000_278400 0 2.822970e-07
I4604 n1_m1_216000_283200 0 2.976857e-07
I4605 n1_m1_216000_288000 0 4.810533e-07
I4606 n1_m1_216000_292800 0 5.154706e-07
I4607 n1_m1_216000_297600 0 6.547000e-07
I4608 n1_m1_216000_302400 0 5.506435e-07
I4609 n1_m1_216000_307200 0 3.488170e-07
I4610 n1_m1_216000_312000 0 5.089018e-07
I4611 n1_m1_216000_316800 0 2.637416e-07
I4612 n1_m1_216000_321600 0 3.938449e-07
I4613 n1_m1_216000_326400 0 2.509468e-07
I4614 n1_m1_216000_331200 0 2.506286e-07
I4615 n1_m1_216000_336000 0 3.892301e-07
I4616 n1_m1_216000_340800 0 2.523559e-07
I4617 n1_m1_216000_345600 0 3.758209e-07
I4618 n1_m1_216000_350400 0 2.557336e-07
I4619 n1_m1_216000_355200 0 2.605450e-07
I4620 n1_m1_216000_360000 0 3.986870e-07
I4621 n1_m1_216000_364800 0 2.523203e-07
I4622 n1_m1_216000_369600 0 3.562348e-07
I4623 n1_m1_216000_374400 0 2.345990e-07
I4624 n1_m1_216000_379200 0 2.300823e-07
I4625 n1_m1_216000_384000 0 3.191881e-07
I4626 n1_m1_216000_388800 0 2.171470e-07
I4627 n1_m1_216000_393600 0 3.372107e-07
I4628 n1_m1_216000_398400 0 2.306860e-07
I4629 n1_m1_216000_403200 0 2.320104e-07
I4630 n1_m1_216000_408000 0 3.308499e-07
I4631 n1_m1_216000_412800 0 2.216917e-07
I4632 n1_m1_216000_417600 0 3.278105e-07
I4633 n1_m1_216000_422400 0 2.224457e-07
I4634 n1_m1_216000_427200 0 2.296797e-07
I4635 n1_m1_216000_432000 0 3.135131e-07
I4636 n1_m1_216000_436800 0 2.231236e-07
I4637 n1_m1_216000_441600 0 3.365382e-07
I4638 n1_m1_216000_446400 0 2.292446e-07
I4639 n1_m1_216000_451200 0 2.200031e-07
I4640 n1_m1_216000_456000 0 3.214028e-07
I4641 n1_m1_216000_460800 0 2.192397e-07
I4642 n1_m1_216000_465600 0 4.162290e-07
I4643 n1_m1_216000_470400 0 4.286292e-07
I4644 n1_m1_216000_475200 0 4.139206e-07
I4645 n1_m1_216000_480000 0 3.895892e-07
I4646 n1_m1_220800_0 0 1.746859e-07
I4647 n1_m1_220800_4800 0 2.062583e-07
I4648 n1_m1_220800_9600 0 2.676384e-07
I4649 n1_m1_220800_14400 0 1.555749e-07
I4650 n1_m1_220800_19200 0 1.601165e-07
I4651 n1_m1_220800_24000 0 2.318027e-07
I4652 n1_m1_220800_28800 0 1.561474e-07
I4653 n1_m1_220800_33600 0 2.416101e-07
I4654 n1_m1_220800_38400 0 1.656431e-07
I4655 n1_m1_220800_43200 0 1.849975e-07
I4656 n1_m1_220800_48000 0 9.091264e-07
I4657 n1_m1_220800_52800 0 5.133312e-07
I4658 n1_m1_220800_57600 0 7.927688e-07
I4659 n1_m1_220800_62400 0 4.494192e-07
I4660 n1_m1_220800_67200 0 5.714446e-07
I4661 n1_m1_220800_72000 0 9.708384e-07
I4662 n1_m1_220800_76800 0 5.325940e-07
I4663 n1_m1_220800_81600 0 4.028503e-07
I4664 n1_m1_220800_86400 0 2.375890e-07
I4665 n1_m1_220800_91200 0 3.446813e-07
I4666 n1_m1_220800_96000 0 7.566176e-07
I4667 n1_m1_220800_100800 0 8.231873e-07
I4668 n1_m1_220800_105600 0 1.241182e-06
I4669 n1_m1_220800_110400 0 4.957364e-07
I4670 n1_m1_220800_115200 0 4.415802e-07
I4671 n1_m1_220800_120000 0 7.701536e-07
I4672 n1_m1_220800_124800 0 1.136013e-06
I4673 n1_m1_220800_129600 0 1.336194e-06
I4674 n1_m1_220800_134400 0 9.029149e-07
I4675 n1_m1_220800_139200 0 8.034170e-07
I4676 n1_m1_220800_144000 0 1.255070e-06
I4677 n1_m1_220800_148800 0 7.967933e-07
I4678 n1_m1_220800_153600 0 1.096260e-06
I4679 n1_m1_220800_158400 0 5.955080e-07
I4680 n1_m1_220800_163200 0 3.924018e-07
I4681 n1_m1_220800_168000 0 9.750008e-07
I4682 n1_m1_220800_172800 0 1.136495e-06
I4683 n1_m1_220800_177600 0 1.714093e-06
I4684 n1_m1_220800_182400 0 1.195453e-06
I4685 n1_m1_220800_187200 0 1.175352e-06
I4686 n1_m1_220800_192000 0 9.384800e-07
I4687 n1_m1_220800_196800 0 5.434288e-07
I4688 n1_m1_220800_201600 0 1.088471e-06
I4689 n1_m1_220800_206400 0 2.087517e-07
I4690 n1_m1_220800_211200 0 1.928323e-07
I4691 n1_m1_220800_216000 0 4.074689e-07
I4692 n1_m1_220800_220800 0 3.064538e-07
I4693 n1_m1_220800_225600 0 4.292762e-07
I4694 n1_m1_220800_230400 0 2.288730e-07
I4695 n1_m1_220800_235200 0 3.493489e-07
I4696 n1_m1_220800_240000 0 7.641754e-07
I4697 n1_m1_220800_244800 0 1.006207e-06
I4698 n1_m1_220800_249600 0 9.131533e-07
I4699 n1_m1_220800_254400 0 4.022424e-07
I4700 n1_m1_220800_259200 0 4.725472e-07
I4701 n1_m1_220800_264000 0 7.948358e-07
I4702 n1_m1_220800_268800 0 2.453144e-07
I4703 n1_m1_220800_273600 0 3.541850e-07
I4704 n1_m1_220800_278400 0 2.370304e-07
I4705 n1_m1_220800_283200 0 4.043225e-07
I4706 n1_m1_220800_288000 0 5.785221e-07
I4707 n1_m1_220800_292800 0 5.898097e-07
I4708 n1_m1_220800_297600 0 3.896876e-07
I4709 n1_m1_220800_302400 0 3.178359e-07
I4710 n1_m1_220800_307200 0 2.726336e-07
I4711 n1_m1_220800_312000 0 4.943771e-07
I4712 n1_m1_220800_316800 0 1.751889e-07
I4713 n1_m1_220800_321600 0 2.468851e-07
I4714 n1_m1_220800_326400 0 1.776578e-07
I4715 n1_m1_220800_331200 0 2.004426e-07
I4716 n1_m1_220800_336000 0 2.696170e-07
I4717 n1_m1_220800_340800 0 1.649077e-07
I4718 n1_m1_220800_345600 0 2.461401e-07
I4719 n1_m1_220800_350400 0 1.711366e-07
I4720 n1_m1_220800_355200 0 1.700354e-07
I4721 n1_m1_220800_360000 0 2.442530e-07
I4722 n1_m1_220800_364800 0 1.577766e-07
I4723 n1_m1_220800_369600 0 2.276984e-07
I4724 n1_m1_220800_374400 0 1.531300e-07
I4725 n1_m1_220800_379200 0 1.528642e-07
I4726 n1_m1_220800_384000 0 2.145567e-07
I4727 n1_m1_220800_388800 0 1.504755e-07
I4728 n1_m1_220800_393600 0 2.413976e-07
I4729 n1_m1_220800_398400 0 1.722841e-07
I4730 n1_m1_220800_403200 0 1.638118e-07
I4731 n1_m1_220800_408000 0 2.269028e-07
I4732 n1_m1_220800_412800 0 1.471842e-07
I4733 n1_m1_220800_417600 0 2.196182e-07
I4734 n1_m1_220800_422400 0 1.510732e-07
I4735 n1_m1_220800_427200 0 1.576378e-07
I4736 n1_m1_220800_432000 0 2.204764e-07
I4737 n1_m1_220800_436800 0 1.852659e-07
I4738 n1_m1_220800_441600 0 2.671912e-07
I4739 n1_m1_220800_446400 0 1.635218e-07
I4740 n1_m1_220800_451200 0 1.487107e-07
I4741 n1_m1_220800_456000 0 2.184549e-07
I4742 n1_m1_220800_460800 0 1.564860e-07
I4743 n1_m1_220800_465600 0 3.609871e-07
I4744 n1_m1_220800_470400 0 4.347649e-07
I4745 n1_m1_220800_475200 0 3.634401e-07
I4746 n1_m1_220800_480000 0 2.634699e-07
I4747 n1_m1_225600_0 0 1.851082e-07
I4748 n1_m1_225600_4800 0 2.413155e-07
I4749 n1_m1_225600_9600 0 3.134175e-07
I4750 n1_m1_225600_14400 0 1.652585e-07
I4751 n1_m1_225600_19200 0 1.685194e-07
I4752 n1_m1_225600_24000 0 2.308644e-07
I4753 n1_m1_225600_28800 0 1.457897e-07
I4754 n1_m1_225600_33600 0 2.195041e-07
I4755 n1_m1_225600_38400 0 1.666504e-07
I4756 n1_m1_225600_43200 0 1.944609e-07
I4757 n1_m1_225600_48000 0 9.845723e-07
I4758 n1_m1_225600_52800 0 4.902885e-07
I4759 n1_m1_225600_57600 0 6.856443e-07
I4760 n1_m1_225600_62400 0 3.705076e-07
I4761 n1_m1_225600_67200 0 2.929716e-07
I4762 n1_m1_225600_72000 0 3.958630e-07
I4763 n1_m1_225600_76800 0 4.784045e-07
I4764 n1_m1_225600_81600 0 4.737726e-07
I4765 n1_m1_225600_86400 0 2.218060e-07
I4766 n1_m1_225600_91200 0 2.620477e-07
I4767 n1_m1_225600_96000 0 5.611037e-07
I4768 n1_m1_225600_100800 0 6.631905e-07
I4769 n1_m1_225600_105600 0 1.005299e-06
I4770 n1_m1_225600_110400 0 4.130379e-07
I4771 n1_m1_225600_115200 0 4.504485e-07
I4772 n1_m1_225600_120000 0 9.198564e-07
I4773 n1_m1_225600_124800 0 1.191222e-06
I4774 n1_m1_225600_129600 0 1.635762e-06
I4775 n1_m1_225600_134400 0 1.047803e-06
I4776 n1_m1_225600_139200 0 7.307504e-07
I4777 n1_m1_225600_144000 0 9.693714e-07
I4778 n1_m1_225600_148800 0 5.504417e-07
I4779 n1_m1_225600_153600 0 6.772156e-07
I4780 n1_m1_225600_158400 0 2.446613e-07
I4781 n1_m1_225600_163200 0 2.989805e-07
I4782 n1_m1_225600_168000 0 1.236073e-06
I4783 n1_m1_225600_172800 0 1.238639e-06
I4784 n1_m1_225600_177600 0 1.914421e-06
I4785 n1_m1_225600_182400 0 1.231279e-06
I4786 n1_m1_225600_187200 0 9.853279e-07
I4787 n1_m1_225600_192000 0 9.876196e-07
I4788 n1_m1_225600_196800 0 7.484813e-07
I4789 n1_m1_225600_201600 0 3.706963e-07
I4790 n1_m1_225600_206400 0 3.471491e-07
I4791 n1_m1_225600_211200 0 3.578688e-07
I4792 n1_m1_225600_216000 0 7.209823e-07
I4793 n1_m1_225600_220800 0 3.560000e-07
I4794 n1_m1_225600_225600 0 2.793310e-07
I4795 n1_m1_225600_230400 0 3.035110e-07
I4796 n1_m1_225600_235200 0 5.296128e-07
I4797 n1_m1_225600_240000 0 6.956194e-07
I4798 n1_m1_225600_244800 0 4.743433e-07
I4799 n1_m1_225600_249600 0 6.037873e-07
I4800 n1_m1_225600_254400 0 8.172986e-07
I4801 n1_m1_225600_259200 0 8.318061e-07
I4802 n1_m1_225600_264000 0 1.471102e-06
I4803 n1_m1_225600_268800 0 3.110908e-07
I4804 n1_m1_225600_273600 0 3.705253e-07
I4805 n1_m1_225600_278400 0 4.152987e-07
I4806 n1_m1_225600_283200 0 8.153802e-07
I4807 n1_m1_225600_288000 0 7.248867e-07
I4808 n1_m1_225600_292800 0 3.702272e-07
I4809 n1_m1_225600_297600 0 5.473908e-07
I4810 n1_m1_225600_302400 0 4.904968e-07
I4811 n1_m1_225600_307200 0 4.118352e-07
I4812 n1_m1_225600_312000 0 6.308407e-07
I4813 n1_m1_225600_316800 0 1.822902e-07
I4814 n1_m1_225600_321600 0 2.546523e-07
I4815 n1_m1_225600_326400 0 2.013624e-07
I4816 n1_m1_225600_331200 0 2.515827e-07
I4817 n1_m1_225600_336000 0 2.731369e-07
I4818 n1_m1_225600_340800 0 1.747924e-07
I4819 n1_m1_225600_345600 0 2.550234e-07
I4820 n1_m1_225600_350400 0 1.703677e-07
I4821 n1_m1_225600_355200 0 1.707965e-07
I4822 n1_m1_225600_360000 0 2.508570e-07
I4823 n1_m1_225600_364800 0 1.547167e-07
I4824 n1_m1_225600_369600 0 2.203309e-07
I4825 n1_m1_225600_374400 0 1.526341e-07
I4826 n1_m1_225600_379200 0 1.559450e-07
I4827 n1_m1_225600_384000 0 2.249462e-07
I4828 n1_m1_225600_388800 0 1.586413e-07
I4829 n1_m1_225600_393600 0 2.414404e-07
I4830 n1_m1_225600_398400 0 1.756774e-07
I4831 n1_m1_225600_403200 0 1.685781e-07
I4832 n1_m1_225600_408000 0 2.371788e-07
I4833 n1_m1_225600_412800 0 1.496186e-07
I4834 n1_m1_225600_417600 0 2.336439e-07
I4835 n1_m1_225600_422400 0 1.454348e-07
I4836 n1_m1_225600_427200 0 1.506089e-07
I4837 n1_m1_225600_432000 0 2.545683e-07
I4838 n1_m1_225600_436800 0 2.969936e-07
I4839 n1_m1_225600_441600 0 3.980638e-07
I4840 n1_m1_225600_446400 0 1.731410e-07
I4841 n1_m1_225600_451200 0 1.485895e-07
I4842 n1_m1_225600_456000 0 2.145772e-07
I4843 n1_m1_225600_460800 0 1.577530e-07
I4844 n1_m1_225600_465600 0 3.106184e-07
I4845 n1_m1_225600_470400 0 3.347565e-07
I4846 n1_m1_225600_475200 0 2.900329e-07
I4847 n1_m1_225600_480000 0 2.559057e-07
I4848 n1_m1_230400_0 0 2.251272e-07
I4849 n1_m1_230400_4800 0 3.667759e-07
I4850 n1_m1_230400_9600 0 4.607084e-07
I4851 n1_m1_230400_14400 0 1.782817e-07
I4852 n1_m1_230400_19200 0 1.699742e-07
I4853 n1_m1_230400_24000 0 2.243585e-07
I4854 n1_m1_230400_28800 0 1.492327e-07
I4855 n1_m1_230400_33600 0 2.367570e-07
I4856 n1_m1_230400_38400 0 1.474469e-07
I4857 n1_m1_230400_43200 0 1.483240e-07
I4858 n1_m1_230400_48000 0 6.631407e-07
I4859 n1_m1_230400_52800 0 3.456680e-07
I4860 n1_m1_230400_57600 0 6.742972e-07
I4861 n1_m1_230400_62400 0 3.055381e-07
I4862 n1_m1_230400_67200 0 2.945576e-07
I4863 n1_m1_230400_72000 0 4.085086e-07
I4864 n1_m1_230400_76800 0 5.248850e-07
I4865 n1_m1_230400_81600 0 5.426630e-07
I4866 n1_m1_230400_86400 0 2.887761e-07
I4867 n1_m1_230400_91200 0 3.134984e-07
I4868 n1_m1_230400_96000 0 4.519070e-07
I4869 n1_m1_230400_100800 0 3.354976e-07
I4870 n1_m1_230400_105600 0 4.364176e-07
I4871 n1_m1_230400_110400 0 2.285812e-07
I4872 n1_m1_230400_115200 0 2.987224e-07
I4873 n1_m1_230400_120000 0 8.228742e-07
I4874 n1_m1_230400_124800 0 1.150679e-06
I4875 n1_m1_230400_129600 0 1.853816e-06
I4876 n1_m1_230400_134400 0 1.188579e-06
I4877 n1_m1_230400_139200 0 7.582440e-07
I4878 n1_m1_230400_144000 0 8.030268e-07
I4879 n1_m1_230400_148800 0 3.751371e-07
I4880 n1_m1_230400_153600 0 3.789424e-07
I4881 n1_m1_230400_158400 0 3.773800e-07
I4882 n1_m1_230400_163200 0 3.562142e-07
I4883 n1_m1_230400_168000 0 1.169546e-06
I4884 n1_m1_230400_172800 0 1.166705e-06
I4885 n1_m1_230400_177600 0 1.922511e-06
I4886 n1_m1_230400_182400 0 1.308397e-06
I4887 n1_m1_230400_187200 0 1.198554e-06
I4888 n1_m1_230400_192000 0 1.192730e-06
I4889 n1_m1_230400_196800 0 3.421440e-07
I4890 n1_m1_230400_201600 0 5.992882e-07
I4891 n1_m1_230400_206400 0 4.288811e-07
I4892 n1_m1_230400_211200 0 2.840723e-07
I4893 n1_m1_230400_216000 0 6.611115e-07
I4894 n1_m1_230400_220800 0 2.952665e-07
I4895 n1_m1_230400_225600 0 5.896620e-07
I4896 n1_m1_230400_230400 0 3.246759e-07
I4897 n1_m1_230400_235200 0 2.670508e-07
I4898 n1_m1_230400_240000 0 4.632922e-07
I4899 n1_m1_230400_244800 0 3.604777e-07
I4900 n1_m1_230400_249600 0 1.003617e-06
I4901 n1_m1_230400_254400 0 8.374225e-07
I4902 n1_m1_230400_259200 0 6.178088e-07
I4903 n1_m1_230400_264000 0 9.841954e-07
I4904 n1_m1_230400_268800 0 4.793670e-07
I4905 n1_m1_230400_273600 0 8.040081e-07
I4906 n1_m1_230400_278400 0 2.569007e-07
I4907 n1_m1_230400_283200 0 2.914939e-07
I4908 n1_m1_230400_288000 0 5.072289e-07
I4909 n1_m1_230400_292800 0 6.466327e-07
I4910 n1_m1_230400_297600 0 5.615732e-07
I4911 n1_m1_230400_302400 0 4.897526e-07
I4912 n1_m1_230400_307200 0 3.372243e-07
I4913 n1_m1_230400_312000 0 4.512296e-07
I4914 n1_m1_230400_316800 0 1.677620e-07
I4915 n1_m1_230400_321600 0 2.429562e-07
I4916 n1_m1_230400_326400 0 1.663721e-07
I4917 n1_m1_230400_331200 0 1.702016e-07
I4918 n1_m1_230400_336000 0 2.404408e-07
I4919 n1_m1_230400_340800 0 1.705446e-07
I4920 n1_m1_230400_345600 0 2.449409e-07
I4921 n1_m1_230400_350400 0 1.547492e-07
I4922 n1_m1_230400_355200 0 1.582548e-07
I4923 n1_m1_230400_360000 0 2.486111e-07
I4924 n1_m1_230400_364800 0 1.458571e-07
I4925 n1_m1_230400_369600 0 2.114287e-07
I4926 n1_m1_230400_374400 0 1.428379e-07
I4927 n1_m1_230400_379200 0 1.460563e-07
I4928 n1_m1_230400_384000 0 2.164416e-07
I4929 n1_m1_230400_388800 0 1.564629e-07
I4930 n1_m1_230400_393600 0 2.642219e-07
I4931 n1_m1_230400_398400 0 2.363172e-07
I4932 n1_m1_230400_403200 0 1.762758e-07
I4933 n1_m1_230400_408000 0 2.557195e-07
I4934 n1_m1_230400_412800 0 1.481474e-07
I4935 n1_m1_230400_417600 0 2.340177e-07
I4936 n1_m1_230400_422400 0 1.440079e-07
I4937 n1_m1_230400_427200 0 1.508649e-07
I4938 n1_m1_230400_432000 0 2.355642e-07
I4939 n1_m1_230400_436800 0 2.327542e-07
I4940 n1_m1_230400_441600 0 3.248133e-07
I4941 n1_m1_230400_446400 0 1.698124e-07
I4942 n1_m1_230400_451200 0 1.484988e-07
I4943 n1_m1_230400_456000 0 2.143282e-07
I4944 n1_m1_230400_460800 0 1.470960e-07
I4945 n1_m1_230400_465600 0 2.274240e-07
I4946 n1_m1_230400_470400 0 1.643175e-07
I4947 n1_m1_230400_475200 0 1.749161e-07
I4948 n1_m1_230400_480000 0 2.537978e-07
I4949 n1_m1_235200_0 0 2.857503e-07
I4950 n1_m1_235200_4800 0 5.061139e-07
I4951 n1_m1_235200_9600 0 6.124960e-07
I4952 n1_m1_235200_14400 0 1.854321e-07
I4953 n1_m1_235200_19200 0 1.653944e-07
I4954 n1_m1_235200_24000 0 2.260423e-07
I4955 n1_m1_235200_28800 0 1.425042e-07
I4956 n1_m1_235200_33600 0 2.102469e-07
I4957 n1_m1_235200_38400 0 1.386958e-07
I4958 n1_m1_235200_43200 0 1.520963e-07
I4959 n1_m1_235200_48000 0 5.109551e-07
I4960 n1_m1_235200_52800 0 2.861929e-07
I4961 n1_m1_235200_57600 0 5.798387e-07
I4962 n1_m1_235200_62400 0 3.016347e-07
I4963 n1_m1_235200_67200 0 2.780487e-07
I4964 n1_m1_235200_72000 0 3.177088e-07
I4965 n1_m1_235200_76800 0 2.258372e-07
I4966 n1_m1_235200_81600 0 2.785274e-07
I4967 n1_m1_235200_86400 0 1.891239e-07
I4968 n1_m1_235200_91200 0 1.826253e-07
I4969 n1_m1_235200_96000 0 2.578855e-07
I4970 n1_m1_235200_100800 0 1.685949e-07
I4971 n1_m1_235200_105600 0 2.367881e-07
I4972 n1_m1_235200_110400 0 1.594593e-07
I4973 n1_m1_235200_115200 0 1.828449e-07
I4974 n1_m1_235200_120000 0 4.768853e-07
I4975 n1_m1_235200_124800 0 6.931672e-07
I4976 n1_m1_235200_129600 0 1.075637e-06
I4977 n1_m1_235200_134400 0 7.239219e-07
I4978 n1_m1_235200_139200 0 4.543358e-07
I4979 n1_m1_235200_144000 0 3.653765e-07
I4980 n1_m1_235200_148800 0 1.992048e-07
I4981 n1_m1_235200_153600 0 3.079405e-07
I4982 n1_m1_235200_158400 0 2.184513e-07
I4983 n1_m1_235200_163200 0 2.038569e-07
I4984 n1_m1_235200_168000 0 9.712050e-07
I4985 n1_m1_235200_172800 0 1.102493e-06
I4986 n1_m1_235200_177600 0 1.923072e-06
I4987 n1_m1_235200_182400 0 1.359234e-06
I4988 n1_m1_235200_187200 0 1.277043e-06
I4989 n1_m1_235200_192000 0 1.490244e-06
I4990 n1_m1_235200_196800 0 6.439109e-07
I4991 n1_m1_235200_201600 0 4.445139e-07
I4992 n1_m1_235200_206400 0 2.537784e-07
I4993 n1_m1_235200_211200 0 2.002636e-07
I4994 n1_m1_235200_216000 0 1.305630e-06
I4995 n1_m1_235200_220800 0 8.111728e-07
I4996 n1_m1_235200_225600 0 4.522243e-07
I4997 n1_m1_235200_230400 0 3.316082e-07
I4998 n1_m1_235200_235200 0 3.294281e-07
I4999 n1_m1_235200_240000 0 5.985657e-07
I5000 n1_m1_235200_244800 0 2.760278e-07
I5001 n1_m1_235200_249600 0 5.518299e-07
I5002 n1_m1_235200_254400 0 5.478786e-07
I5003 n1_m1_235200_259200 0 6.943749e-07
I5004 n1_m1_235200_264000 0 1.757900e-06
I5005 n1_m1_235200_268800 0 7.414294e-07
I5006 n1_m1_235200_273600 0 9.405822e-07
I5007 n1_m1_235200_278400 0 2.969761e-07
I5008 n1_m1_235200_283200 0 2.290242e-07
I5009 n1_m1_235200_288000 0 3.752062e-07
I5010 n1_m1_235200_292800 0 4.459900e-07
I5011 n1_m1_235200_297600 0 3.183893e-07
I5012 n1_m1_235200_302400 0 2.390023e-07
I5013 n1_m1_235200_307200 0 2.180835e-07
I5014 n1_m1_235200_312000 0 3.907846e-07
I5015 n1_m1_235200_316800 0 1.578900e-07
I5016 n1_m1_235200_321600 0 2.268174e-07
I5017 n1_m1_235200_326400 0 1.543378e-07
I5018 n1_m1_235200_331200 0 1.636407e-07
I5019 n1_m1_235200_336000 0 2.231224e-07
I5020 n1_m1_235200_340800 0 1.502528e-07
I5021 n1_m1_235200_345600 0 2.237622e-07
I5022 n1_m1_235200_350400 0 1.483279e-07
I5023 n1_m1_235200_355200 0 1.483190e-07
I5024 n1_m1_235200_360000 0 2.286901e-07
I5025 n1_m1_235200_364800 0 1.440103e-07
I5026 n1_m1_235200_369600 0 2.029028e-07
I5027 n1_m1_235200_374400 0 1.397179e-07
I5028 n1_m1_235200_379200 0 1.412794e-07
I5029 n1_m1_235200_384000 0 2.142681e-07
I5030 n1_m1_235200_388800 0 1.556920e-07
I5031 n1_m1_235200_393600 0 3.310292e-07
I5032 n1_m1_235200_398400 0 3.810253e-07
I5033 n1_m1_235200_403200 0 2.211267e-07
I5034 n1_m1_235200_408000 0 3.122350e-07
I5035 n1_m1_235200_412800 0 1.528985e-07
I5036 n1_m1_235200_417600 0 2.394429e-07
I5037 n1_m1_235200_422400 0 1.474317e-07
I5038 n1_m1_235200_427200 0 1.526821e-07
I5039 n1_m1_235200_432000 0 2.201262e-07
I5040 n1_m1_235200_436800 0 1.693433e-07
I5041 n1_m1_235200_441600 0 2.431823e-07
I5042 n1_m1_235200_446400 0 1.579962e-07
I5043 n1_m1_235200_451200 0 1.469279e-07
I5044 n1_m1_235200_456000 0 2.119379e-07
I5045 n1_m1_235200_460800 0 1.412623e-07
I5046 n1_m1_235200_465600 0 2.219905e-07
I5047 n1_m1_235200_470400 0 1.644469e-07
I5048 n1_m1_235200_475200 0 1.735873e-07
I5049 n1_m1_235200_480000 0 2.493141e-07
I5050 n1_m1_240000_0 0 4.101118e-07
I5051 n1_m1_240000_4800 0 7.159993e-07
I5052 n1_m1_240000_9600 0 7.905374e-07
I5053 n1_m1_240000_14400 0 2.415746e-07
I5054 n1_m1_240000_19200 0 2.274072e-07
I5055 n1_m1_240000_24000 0 3.149920e-07
I5056 n1_m1_240000_28800 0 2.059024e-07
I5057 n1_m1_240000_33600 0 3.200552e-07
I5058 n1_m1_240000_38400 0 2.034973e-07
I5059 n1_m1_240000_43200 0 2.143832e-07
I5060 n1_m1_240000_48000 0 4.220923e-07
I5061 n1_m1_240000_52800 0 2.768315e-07
I5062 n1_m1_240000_57600 0 4.600254e-07
I5063 n1_m1_240000_62400 0 2.553748e-07
I5064 n1_m1_240000_67200 0 2.458820e-07
I5065 n1_m1_240000_72000 0 3.394273e-07
I5066 n1_m1_240000_76800 0 2.229914e-07
I5067 n1_m1_240000_81600 0 3.194374e-07
I5068 n1_m1_240000_86400 0 2.103775e-07
I5069 n1_m1_240000_91200 0 2.086204e-07
I5070 n1_m1_240000_96000 0 3.163391e-07
I5071 n1_m1_240000_100800 0 2.048008e-07
I5072 n1_m1_240000_105600 0 3.047414e-07
I5073 n1_m1_240000_110400 0 2.138348e-07
I5074 n1_m1_240000_115200 0 2.161443e-07
I5075 n1_m1_240000_120000 0 3.590532e-07
I5076 n1_m1_240000_124800 0 3.145067e-07
I5077 n1_m1_240000_129600 0 5.170304e-07
I5078 n1_m1_240000_134400 0 3.593222e-07
I5079 n1_m1_240000_139200 0 2.763283e-07
I5080 n1_m1_240000_144000 0 3.459448e-07
I5081 n1_m1_240000_148800 0 2.290891e-07
I5082 n1_m1_240000_153600 0 3.470198e-07
I5083 n1_m1_240000_158400 0 2.423804e-07
I5084 n1_m1_240000_163200 0 2.394732e-07
I5085 n1_m1_240000_168000 0 6.851544e-07
I5086 n1_m1_240000_172800 0 7.980273e-07
I5087 n1_m1_240000_177600 0 2.399378e-06
I5088 n1_m1_240000_182400 0 1.693038e-06
I5089 n1_m1_240000_187200 0 1.546010e-06
I5090 n1_m1_240000_192000 0 1.507092e-06
I5091 n1_m1_240000_196800 0 4.496968e-07
I5092 n1_m1_240000_201600 0 1.139860e-06
I5093 n1_m1_240000_206400 0 4.000029e-07
I5094 n1_m1_240000_211200 0 3.885092e-07
I5095 n1_m1_240000_216000 0 1.190263e-06
I5096 n1_m1_240000_220800 0 1.236805e-06
I5097 n1_m1_240000_225600 0 1.750847e-06
I5098 n1_m1_240000_230400 0 4.345155e-07
I5099 n1_m1_240000_235200 0 4.024391e-07
I5100 n1_m1_240000_240000 0 5.267651e-07
I5101 n1_m1_240000_244800 0 4.668568e-07
I5102 n1_m1_240000_249600 0 5.738916e-07
I5103 n1_m1_240000_254400 0 5.799026e-07
I5104 n1_m1_240000_259200 0 8.629068e-07
I5105 n1_m1_240000_264000 0 2.313539e-06
I5106 n1_m1_240000_268800 0 1.635590e-06
I5107 n1_m1_240000_273600 0 1.796384e-06
I5108 n1_m1_240000_278400 0 4.268730e-07
I5109 n1_m1_240000_283200 0 3.388629e-07
I5110 n1_m1_240000_288000 0 5.645178e-07
I5111 n1_m1_240000_292800 0 5.820129e-07
I5112 n1_m1_240000_297600 0 3.862018e-07
I5113 n1_m1_240000_302400 0 2.767904e-07
I5114 n1_m1_240000_307200 0 2.531570e-07
I5115 n1_m1_240000_312000 0 3.862194e-07
I5116 n1_m1_240000_316800 0 2.395091e-07
I5117 n1_m1_240000_321600 0 3.580458e-07
I5118 n1_m1_240000_326400 0 2.187619e-07
I5119 n1_m1_240000_331200 0 2.179977e-07
I5120 n1_m1_240000_336000 0 3.329802e-07
I5121 n1_m1_240000_340800 0 2.147177e-07
I5122 n1_m1_240000_345600 0 3.227441e-07
I5123 n1_m1_240000_350400 0 2.222029e-07
I5124 n1_m1_240000_355200 0 2.148267e-07
I5125 n1_m1_240000_360000 0 3.151775e-07
I5126 n1_m1_240000_364800 0 2.189796e-07
I5127 n1_m1_240000_369600 0 3.088032e-07
I5128 n1_m1_240000_374400 0 2.114595e-07
I5129 n1_m1_240000_379200 0 2.143535e-07
I5130 n1_m1_240000_384000 0 3.245176e-07
I5131 n1_m1_240000_388800 0 2.362015e-07
I5132 n1_m1_240000_393600 0 4.304119e-07
I5133 n1_m1_240000_398400 0 4.302567e-07
I5134 n1_m1_240000_403200 0 2.971693e-07
I5135 n1_m1_240000_408000 0 4.503804e-07
I5136 n1_m1_240000_412800 0 2.351407e-07
I5137 n1_m1_240000_417600 0 3.698907e-07
I5138 n1_m1_240000_422400 0 2.167765e-07
I5139 n1_m1_240000_427200 0 2.329118e-07
I5140 n1_m1_240000_432000 0 3.299044e-07
I5141 n1_m1_240000_436800 0 2.379464e-07
I5142 n1_m1_240000_441600 0 3.363188e-07
I5143 n1_m1_240000_446400 0 2.259400e-07
I5144 n1_m1_240000_451200 0 2.172694e-07
I5145 n1_m1_240000_456000 0 3.305449e-07
I5146 n1_m1_240000_460800 0 2.127246e-07
I5147 n1_m1_240000_465600 0 3.414854e-07
I5148 n1_m1_240000_470400 0 2.717532e-07
I5149 n1_m1_240000_475200 0 2.805768e-07
I5150 n1_m1_240000_480000 0 3.658237e-07
I5151 n1_m1_244800_0 0 2.040311e-07
I5152 n1_m1_244800_4800 0 2.859021e-07
I5153 n1_m1_244800_9600 0 3.260238e-07
I5154 n1_m1_244800_14400 0 1.468138e-07
I5155 n1_m1_244800_19200 0 1.470328e-07
I5156 n1_m1_244800_24000 0 2.083285e-07
I5157 n1_m1_244800_28800 0 1.332419e-07
I5158 n1_m1_244800_33600 0 1.998628e-07
I5159 n1_m1_244800_38400 0 1.343843e-07
I5160 n1_m1_244800_43200 0 1.400676e-07
I5161 n1_m1_244800_48000 0 2.168585e-07
I5162 n1_m1_244800_52800 0 1.487996e-07
I5163 n1_m1_244800_57600 0 2.231842e-07
I5164 n1_m1_244800_62400 0 1.437306e-07
I5165 n1_m1_244800_67200 0 1.399040e-07
I5166 n1_m1_244800_72000 0 2.098560e-07
I5167 n1_m1_244800_76800 0 1.399040e-07
I5168 n1_m1_244800_81600 0 2.050934e-07
I5169 n1_m1_244800_86400 0 1.332419e-07
I5170 n1_m1_244800_91200 0 1.332419e-07
I5171 n1_m1_244800_96000 0 1.998628e-07
I5172 n1_m1_244800_100800 0 1.332419e-07
I5173 n1_m1_244800_105600 0 1.998628e-07
I5174 n1_m1_244800_110400 0 1.332419e-07
I5175 n1_m1_244800_115200 0 1.340635e-07
I5176 n1_m1_244800_120000 0 2.103266e-07
I5177 n1_m1_244800_124800 0 1.408534e-07
I5178 n1_m1_244800_129600 0 2.137084e-07
I5179 n1_m1_244800_134400 0 1.414742e-07
I5180 n1_m1_244800_139200 0 1.399040e-07
I5181 n1_m1_244800_144000 0 2.104098e-07
I5182 n1_m1_244800_148800 0 1.428769e-07
I5183 n1_m1_244800_153600 0 2.203470e-07
I5184 n1_m1_244800_158400 0 1.475187e-07
I5185 n1_m1_244800_163200 0 1.493352e-07
I5186 n1_m1_244800_168000 0 2.513875e-07
I5187 n1_m1_244800_172800 0 2.512769e-07
I5188 n1_m1_244800_177600 0 1.398069e-06
I5189 n1_m1_244800_182400 0 9.871737e-07
I5190 n1_m1_244800_187200 0 1.033993e-06
I5191 n1_m1_244800_192000 0 9.790783e-07
I5192 n1_m1_244800_196800 0 4.579985e-07
I5193 n1_m1_244800_201600 0 7.393542e-07
I5194 n1_m1_244800_206400 0 2.043057e-07
I5195 n1_m1_244800_211200 0 2.523999e-07
I5196 n1_m1_244800_216000 0 7.582898e-07
I5197 n1_m1_244800_220800 0 7.381283e-07
I5198 n1_m1_244800_225600 0 1.298043e-06
I5199 n1_m1_244800_230400 0 5.113297e-07
I5200 n1_m1_244800_235200 0 5.957741e-07
I5201 n1_m1_244800_240000 0 6.805782e-07
I5202 n1_m1_244800_244800 0 2.654011e-07
I5203 n1_m1_244800_249600 0 3.302095e-07
I5204 n1_m1_244800_254400 0 2.017270e-07
I5205 n1_m1_244800_259200 0 3.939815e-07
I5206 n1_m1_244800_264000 0 1.409213e-06
I5207 n1_m1_244800_268800 0 9.982576e-07
I5208 n1_m1_244800_273600 0 1.377537e-06
I5209 n1_m1_244800_278400 0 7.873737e-07
I5210 n1_m1_244800_283200 0 8.322997e-07
I5211 n1_m1_244800_288000 0 6.287843e-07
I5212 n1_m1_244800_292800 0 4.156740e-07
I5213 n1_m1_244800_297600 0 2.364854e-07
I5214 n1_m1_244800_302400 0 1.592069e-07
I5215 n1_m1_244800_307200 0 1.598903e-07
I5216 n1_m1_244800_312000 0 2.378236e-07
I5217 n1_m1_244800_316800 0 1.544089e-07
I5218 n1_m1_244800_321600 0 2.248788e-07
I5219 n1_m1_244800_326400 0 1.458479e-07
I5220 n1_m1_244800_331200 0 1.433879e-07
I5221 n1_m1_244800_336000 0 2.142744e-07
I5222 n1_m1_244800_340800 0 1.425392e-07
I5223 n1_m1_244800_345600 0 2.102394e-07
I5224 n1_m1_244800_350400 0 1.399040e-07
I5225 n1_m1_244800_355200 0 1.399040e-07
I5226 n1_m1_244800_360000 0 2.081904e-07
I5227 n1_m1_244800_364800 0 1.343322e-07
I5228 n1_m1_244800_369600 0 2.025427e-07
I5229 n1_m1_244800_374400 0 1.366499e-07
I5230 n1_m1_244800_379200 0 1.395084e-07
I5231 n1_m1_244800_384000 0 2.137376e-07
I5232 n1_m1_244800_388800 0 1.484527e-07
I5233 n1_m1_244800_393600 0 2.329653e-07
I5234 n1_m1_244800_398400 0 1.620651e-07
I5235 n1_m1_244800_403200 0 1.643500e-07
I5236 n1_m1_244800_408000 0 2.458703e-07
I5237 n1_m1_244800_412800 0 1.505070e-07
I5238 n1_m1_244800_417600 0 2.139411e-07
I5239 n1_m1_244800_422400 0 1.399040e-07
I5240 n1_m1_244800_427200 0 1.577616e-07
I5241 n1_m1_244800_432000 0 2.217562e-07
I5242 n1_m1_244800_436800 0 1.492691e-07
I5243 n1_m1_244800_441600 0 2.202866e-07
I5244 n1_m1_244800_446400 0 1.450493e-07
I5245 n1_m1_244800_451200 0 1.469228e-07
I5246 n1_m1_244800_456000 0 2.221801e-07
I5247 n1_m1_244800_460800 0 1.420237e-07
I5248 n1_m1_244800_465600 0 2.289041e-07
I5249 n1_m1_244800_470400 0 1.860726e-07
I5250 n1_m1_244800_475200 0 1.951520e-07
I5251 n1_m1_244800_480000 0 2.489201e-07
I5252 n1_m1_249600_0 0 2.553442e-07
I5253 n1_m1_249600_4800 0 2.919358e-07
I5254 n1_m1_249600_9600 0 3.976956e-07
I5255 n1_m1_249600_14400 0 2.190432e-07
I5256 n1_m1_249600_19200 0 2.078599e-07
I5257 n1_m1_249600_24000 0 3.084212e-07
I5258 n1_m1_249600_28800 0 2.115349e-07
I5259 n1_m1_249600_33600 0 3.018383e-07
I5260 n1_m1_249600_38400 0 2.016646e-07
I5261 n1_m1_249600_43200 0 2.036218e-07
I5262 n1_m1_249600_48000 0 3.075300e-07
I5263 n1_m1_249600_52800 0 2.064839e-07
I5264 n1_m1_249600_57600 0 3.173325e-07
I5265 n1_m1_249600_62400 0 2.113265e-07
I5266 n1_m1_249600_67200 0 2.062624e-07
I5267 n1_m1_249600_72000 0 3.060695e-07
I5268 n1_m1_249600_76800 0 2.094421e-07
I5269 n1_m1_249600_81600 0 3.129537e-07
I5270 n1_m1_249600_86400 0 2.018286e-07
I5271 n1_m1_249600_91200 0 2.056832e-07
I5272 n1_m1_249600_96000 0 3.078414e-07
I5273 n1_m1_249600_100800 0 1.998628e-07
I5274 n1_m1_249600_105600 0 2.997942e-07
I5275 n1_m1_249600_110400 0 1.998628e-07
I5276 n1_m1_249600_115200 0 2.020720e-07
I5277 n1_m1_249600_120000 0 3.175446e-07
I5278 n1_m1_249600_124800 0 2.117847e-07
I5279 n1_m1_249600_129600 0 3.168280e-07
I5280 n1_m1_249600_134400 0 2.112187e-07
I5281 n1_m1_249600_139200 0 2.112187e-07
I5282 n1_m1_249600_144000 0 3.248752e-07
I5283 n1_m1_249600_148800 0 2.189114e-07
I5284 n1_m1_249600_153600 0 3.306322e-07
I5285 n1_m1_249600_158400 0 2.202258e-07
I5286 n1_m1_249600_163200 0 2.214399e-07
I5287 n1_m1_249600_168000 0 3.301333e-07
I5288 n1_m1_249600_172800 0 3.639599e-07
I5289 n1_m1_249600_177600 0 2.284934e-06
I5290 n1_m1_249600_182400 0 1.697253e-06
I5291 n1_m1_249600_187200 0 1.989512e-06
I5292 n1_m1_249600_192000 0 1.961185e-06
I5293 n1_m1_249600_196800 0 8.355734e-07
I5294 n1_m1_249600_201600 0 5.134738e-07
I5295 n1_m1_249600_206400 0 4.145283e-07
I5296 n1_m1_249600_211200 0 7.116037e-07
I5297 n1_m1_249600_216000 0 1.507273e-06
I5298 n1_m1_249600_220800 0 1.438192e-06
I5299 n1_m1_249600_225600 0 1.429065e-06
I5300 n1_m1_249600_230400 0 1.502208e-06
I5301 n1_m1_249600_235200 0 1.558080e-06
I5302 n1_m1_249600_240000 0 1.049079e-06
I5303 n1_m1_249600_244800 0 3.334985e-07
I5304 n1_m1_249600_249600 0 5.036325e-07
I5305 n1_m1_249600_254400 0 6.277256e-07
I5306 n1_m1_249600_259200 0 1.002540e-06
I5307 n1_m1_249600_264000 0 2.662297e-06
I5308 n1_m1_249600_268800 0 1.152989e-06
I5309 n1_m1_249600_273600 0 2.359296e-06
I5310 n1_m1_249600_278400 0 1.530160e-06
I5311 n1_m1_249600_283200 0 1.549235e-06
I5312 n1_m1_249600_288000 0 1.056311e-06
I5313 n1_m1_249600_292800 0 3.811147e-07
I5314 n1_m1_249600_297600 0 4.081138e-07
I5315 n1_m1_249600_302400 0 2.379978e-07
I5316 n1_m1_249600_307200 0 2.390215e-07
I5317 n1_m1_249600_312000 0 3.481546e-07
I5318 n1_m1_249600_316800 0 2.290258e-07
I5319 n1_m1_249600_321600 0 3.327337e-07
I5320 n1_m1_249600_326400 0 2.198491e-07
I5321 n1_m1_249600_331200 0 2.168346e-07
I5322 n1_m1_249600_336000 0 3.147839e-07
I5323 n1_m1_249600_340800 0 2.098560e-07
I5324 n1_m1_249600_345600 0 3.147839e-07
I5325 n1_m1_249600_350400 0 2.098560e-07
I5326 n1_m1_249600_355200 0 2.098560e-07
I5327 n1_m1_249600_360000 0 3.126263e-07
I5328 n1_m1_249600_364800 0 2.037576e-07
I5329 n1_m1_249600_369600 0 3.139497e-07
I5330 n1_m1_249600_374400 0 2.108008e-07
I5331 n1_m1_249600_379200 0 2.110413e-07
I5332 n1_m1_249600_384000 0 3.164192e-07
I5333 n1_m1_249600_388800 0 2.124162e-07
I5334 n1_m1_249600_393600 0 3.192538e-07
I5335 n1_m1_249600_398400 0 2.149764e-07
I5336 n1_m1_249600_403200 0 2.158545e-07
I5337 n1_m1_249600_408000 0 3.238824e-07
I5338 n1_m1_249600_412800 0 2.139447e-07
I5339 n1_m1_249600_417600 0 3.226844e-07
I5340 n1_m1_249600_422400 0 2.219882e-07
I5341 n1_m1_249600_427200 0 2.300221e-07
I5342 n1_m1_249600_432000 0 3.391130e-07
I5343 n1_m1_249600_436800 0 2.149643e-07
I5344 n1_m1_249600_441600 0 3.336048e-07
I5345 n1_m1_249600_446400 0 2.084662e-07
I5346 n1_m1_249600_451200 0 2.245759e-07
I5347 n1_m1_249600_456000 0 3.513273e-07
I5348 n1_m1_249600_460800 0 2.237626e-07
I5349 n1_m1_249600_465600 0 3.395199e-07
I5350 n1_m1_249600_470400 0 2.634021e-07
I5351 n1_m1_249600_475200 0 2.798576e-07
I5352 n1_m1_249600_480000 0 3.911395e-07
I5353 n1_m1_254400_0 0 8.822918e-08
I5354 n1_m1_254400_4800 0 9.210765e-08
I5355 n1_m1_254400_9600 0 1.245466e-07
I5356 n1_m1_254400_14400 0 7.423319e-08
I5357 n1_m1_254400_19200 0 6.835574e-08
I5358 n1_m1_254400_24000 0 1.013824e-07
I5359 n1_m1_254400_28800 0 7.009618e-08
I5360 n1_m1_254400_33600 0 1.046183e-07
I5361 n1_m1_254400_38400 0 6.974552e-08
I5362 n1_m1_254400_43200 0 6.974552e-08
I5363 n1_m1_254400_48000 0 1.046183e-07
I5364 n1_m1_254400_52800 0 6.975021e-08
I5365 n1_m1_254400_57600 0 1.048840e-07
I5366 n1_m1_254400_62400 0 6.995199e-08
I5367 n1_m1_254400_67200 0 6.834152e-08
I5368 n1_m1_254400_72000 0 1.032197e-07
I5369 n1_m1_254400_76800 0 6.993791e-08
I5370 n1_m1_254400_81600 0 1.049280e-07
I5371 n1_m1_254400_86400 0 6.750188e-08
I5372 n1_m1_254400_91200 0 6.922934e-08
I5373 n1_m1_254400_96000 0 1.035378e-07
I5374 n1_m1_254400_100800 0 6.662094e-08
I5375 n1_m1_254400_105600 0 9.993141e-08
I5376 n1_m1_254400_110400 0 6.662094e-08
I5377 n1_m1_254400_115200 0 6.735735e-08
I5378 n1_m1_254400_120000 0 1.072232e-07
I5379 n1_m1_254400_124800 0 7.307657e-08
I5380 n1_m1_254400_129600 0 1.096148e-07
I5381 n1_m1_254400_134400 0 7.307657e-08
I5382 n1_m1_254400_139200 0 7.307657e-08
I5383 n1_m1_254400_144000 0 1.132212e-07
I5384 n1_m1_254400_148800 0 7.572976e-08
I5385 n1_m1_254400_153600 0 1.076844e-07
I5386 n1_m1_254400_158400 0 7.282468e-08
I5387 n1_m1_254400_163200 0 7.786544e-08
I5388 n1_m1_254400_168000 0 1.137510e-07
I5389 n1_m1_254400_172800 0 1.393191e-07
I5390 n1_m1_254400_177600 0 8.218315e-07
I5391 n1_m1_254400_182400 0 6.186934e-07
I5392 n1_m1_254400_187200 0 5.824758e-07
I5393 n1_m1_254400_192000 0 5.608600e-07
I5394 n1_m1_254400_196800 0 4.080646e-07
I5395 n1_m1_254400_201600 0 2.165174e-07
I5396 n1_m1_254400_206400 0 1.577393e-07
I5397 n1_m1_254400_211200 0 1.432945e-07
I5398 n1_m1_254400_216000 0 6.352502e-07
I5399 n1_m1_254400_220800 0 2.774141e-07
I5400 n1_m1_254400_225600 0 5.379197e-07
I5401 n1_m1_254400_230400 0 2.177425e-07
I5402 n1_m1_254400_235200 0 4.248396e-07
I5403 n1_m1_254400_240000 0 3.559858e-07
I5404 n1_m1_254400_244800 0 1.864952e-07
I5405 n1_m1_254400_249600 0 1.548267e-07
I5406 n1_m1_254400_254400 0 1.855396e-07
I5407 n1_m1_254400_259200 0 3.477877e-07
I5408 n1_m1_254400_264000 0 7.185303e-07
I5409 n1_m1_254400_268800 0 3.524023e-07
I5410 n1_m1_254400_273600 0 4.620634e-07
I5411 n1_m1_254400_278400 0 2.991787e-07
I5412 n1_m1_254400_283200 0 2.985085e-07
I5413 n1_m1_254400_288000 0 3.124740e-07
I5414 n1_m1_254400_292800 0 1.936525e-07
I5415 n1_m1_254400_297600 0 1.172304e-07
I5416 n1_m1_254400_302400 0 7.933260e-08
I5417 n1_m1_254400_307200 0 7.958037e-08
I5418 n1_m1_254400_312000 0 1.153409e-07
I5419 n1_m1_254400_316800 0 7.474192e-08
I5420 n1_m1_254400_321600 0 1.099954e-07
I5421 n1_m1_254400_326400 0 7.328303e-08
I5422 n1_m1_254400_331200 0 7.227821e-08
I5423 n1_m1_254400_336000 0 1.049280e-07
I5424 n1_m1_254400_340800 0 6.995199e-08
I5425 n1_m1_254400_345600 0 1.049280e-07
I5426 n1_m1_254400_350400 0 6.995199e-08
I5427 n1_m1_254400_355200 0 6.995199e-08
I5428 n1_m1_254400_360000 0 1.048764e-07
I5429 n1_m1_254400_364800 0 6.980609e-08
I5430 n1_m1_254400_369600 0 1.075877e-07
I5431 n1_m1_254400_374400 0 7.307657e-08
I5432 n1_m1_254400_379200 0 7.266985e-08
I5433 n1_m1_254400_384000 0 1.052572e-07
I5434 n1_m1_254400_388800 0 6.995199e-08
I5435 n1_m1_254400_393600 0 1.049280e-07
I5436 n1_m1_254400_398400 0 6.995199e-08
I5437 n1_m1_254400_403200 0 6.995199e-08
I5438 n1_m1_254400_408000 0 1.052314e-07
I5439 n1_m1_254400_412800 0 7.264403e-08
I5440 n1_m1_254400_417600 0 1.097334e-07
I5441 n1_m1_254400_422400 0 7.538903e-08
I5442 n1_m1_254400_427200 0 7.661408e-08
I5443 n1_m1_254400_432000 0 1.169566e-07
I5444 n1_m1_254400_436800 0 7.314567e-08
I5445 n1_m1_254400_441600 0 1.119686e-07
I5446 n1_m1_254400_446400 0 6.888287e-08
I5447 n1_m1_254400_451200 0 7.368266e-08
I5448 n1_m1_254400_456000 0 1.193708e-07
I5449 n1_m1_254400_460800 0 7.753319e-08
I5450 n1_m1_254400_465600 0 1.164563e-07
I5451 n1_m1_254400_470400 0 8.551839e-08
I5452 n1_m1_254400_475200 0 9.006539e-08
I5453 n1_m1_254400_480000 0 1.295855e-07
I5454 n1_m1_259200_0 0 1.569013e-07
I5455 n1_m1_259200_4800 0 1.594554e-07
I5456 n1_m1_259200_9600 0 2.152356e-07
I5457 n1_m1_259200_14400 0 1.443145e-07
I5458 n1_m1_259200_19200 0 1.439164e-07
I5459 n1_m1_259200_24000 0 2.067423e-07
I5460 n1_m1_259200_28800 0 1.408936e-07
I5461 n1_m1_259200_33600 0 2.098560e-07
I5462 n1_m1_259200_38400 0 1.410441e-07
I5463 n1_m1_259200_43200 0 1.461265e-07
I5464 n1_m1_259200_48000 0 2.198285e-07
I5465 n1_m1_259200_52800 0 1.465523e-07
I5466 n1_m1_259200_57600 0 2.198285e-07
I5467 n1_m1_259200_62400 0 1.437226e-07
I5468 n1_m1_259200_67200 0 1.398973e-07
I5469 n1_m1_259200_72000 0 2.101422e-07
I5470 n1_m1_259200_76800 0 1.424947e-07
I5471 n1_m1_259200_81600 0 2.161330e-07
I5472 n1_m1_259200_86400 0 1.367194e-07
I5473 n1_m1_259200_91200 0 1.388379e-07
I5474 n1_m1_259200_96000 0 2.098502e-07
I5475 n1_m1_259200_100800 0 1.375616e-07
I5476 n1_m1_259200_105600 0 2.006791e-07
I5477 n1_m1_259200_110400 0 1.345193e-07
I5478 n1_m1_259200_115200 0 1.396048e-07
I5479 n1_m1_259200_120000 0 2.135413e-07
I5480 n1_m1_259200_124800 0 1.448938e-07
I5481 n1_m1_259200_129600 0 2.195132e-07
I5482 n1_m1_259200_134400 0 1.465661e-07
I5483 n1_m1_259200_139200 0 1.465661e-07
I5484 n1_m1_259200_144000 0 2.270618e-07
I5485 n1_m1_259200_148800 0 1.546675e-07
I5486 n1_m1_259200_153600 0 2.298298e-07
I5487 n1_m1_259200_158400 0 1.532619e-07
I5488 n1_m1_259200_163200 0 1.580146e-07
I5489 n1_m1_259200_168000 0 2.220916e-07
I5490 n1_m1_259200_172800 0 1.681720e-07
I5491 n1_m1_259200_177600 0 1.402200e-06
I5492 n1_m1_259200_182400 0 1.089273e-06
I5493 n1_m1_259200_187200 0 1.126075e-06
I5494 n1_m1_259200_192000 0 1.436741e-06
I5495 n1_m1_259200_196800 0 6.679220e-07
I5496 n1_m1_259200_201600 0 3.351497e-07
I5497 n1_m1_259200_206400 0 1.802073e-07
I5498 n1_m1_259200_211200 0 1.894015e-07
I5499 n1_m1_259200_216000 0 9.486234e-07
I5500 n1_m1_259200_220800 0 3.993789e-07
I5501 n1_m1_259200_225600 0 5.809142e-07
I5502 n1_m1_259200_230400 0 4.066730e-07
I5503 n1_m1_259200_235200 0 3.263164e-07
I5504 n1_m1_259200_240000 0 1.101139e-06
I5505 n1_m1_259200_244800 0 3.464004e-07
I5506 n1_m1_259200_249600 0 3.658069e-07
I5507 n1_m1_259200_254400 0 2.770677e-07
I5508 n1_m1_259200_259200 0 4.939011e-07
I5509 n1_m1_259200_264000 0 8.526997e-07
I5510 n1_m1_259200_268800 0 3.237291e-07
I5511 n1_m1_259200_273600 0 4.678985e-07
I5512 n1_m1_259200_278400 0 2.819575e-07
I5513 n1_m1_259200_283200 0 3.441644e-07
I5514 n1_m1_259200_288000 0 5.628792e-07
I5515 n1_m1_259200_292800 0 1.696278e-07
I5516 n1_m1_259200_297600 0 2.495403e-07
I5517 n1_m1_259200_302400 0 1.613684e-07
I5518 n1_m1_259200_307200 0 1.591607e-07
I5519 n1_m1_259200_312000 0 2.297356e-07
I5520 n1_m1_259200_316800 0 1.485357e-07
I5521 n1_m1_259200_321600 0 2.167229e-07
I5522 n1_m1_259200_326400 0 1.399684e-07
I5523 n1_m1_259200_331200 0 1.404409e-07
I5524 n1_m1_259200_336000 0 2.124781e-07
I5525 n1_m1_259200_340800 0 1.416521e-07
I5526 n1_m1_259200_345600 0 2.124781e-07
I5527 n1_m1_259200_350400 0 1.406191e-07
I5528 n1_m1_259200_355200 0 1.399040e-07
I5529 n1_m1_259200_360000 0 2.098560e-07
I5530 n1_m1_259200_364800 0 1.399040e-07
I5531 n1_m1_259200_369600 0 2.155270e-07
I5532 n1_m1_259200_374400 0 1.465661e-07
I5533 n1_m1_259200_379200 0 1.465643e-07
I5534 n1_m1_259200_384000 0 2.169748e-07
I5535 n1_m1_259200_388800 0 1.416521e-07
I5536 n1_m1_259200_393600 0 2.242225e-07
I5537 n1_m1_259200_398400 0 1.514525e-07
I5538 n1_m1_259200_403200 0 1.520521e-07
I5539 n1_m1_259200_408000 0 2.282275e-07
I5540 n1_m1_259200_412800 0 1.506265e-07
I5541 n1_m1_259200_417600 0 2.151404e-07
I5542 n1_m1_259200_422400 0 1.472278e-07
I5543 n1_m1_259200_427200 0 1.584806e-07
I5544 n1_m1_259200_432000 0 2.355456e-07
I5545 n1_m1_259200_436800 0 1.616383e-07
I5546 n1_m1_259200_441600 0 2.538505e-07
I5547 n1_m1_259200_446400 0 1.484675e-07
I5548 n1_m1_259200_451200 0 1.544202e-07
I5549 n1_m1_259200_456000 0 2.301276e-07
I5550 n1_m1_259200_460800 0 1.486996e-07
I5551 n1_m1_259200_465600 0 2.435684e-07
I5552 n1_m1_259200_470400 0 1.980391e-07
I5553 n1_m1_259200_475200 0 2.066280e-07
I5554 n1_m1_259200_480000 0 2.571531e-07
I5555 n1_m1_264000_0 0 2.310916e-07
I5556 n1_m1_264000_4800 0 2.664460e-07
I5557 n1_m1_264000_9600 0 3.572390e-07
I5558 n1_m1_264000_14400 0 2.082213e-07
I5559 n1_m1_264000_19200 0 2.129882e-07
I5560 n1_m1_264000_24000 0 3.108466e-07
I5561 n1_m1_264000_28800 0 2.093908e-07
I5562 n1_m1_264000_33600 0 3.142265e-07
I5563 n1_m1_264000_38400 0 2.093923e-07
I5564 n1_m1_264000_43200 0 2.099998e-07
I5565 n1_m1_264000_48000 0 3.208616e-07
I5566 n1_m1_264000_52800 0 2.181598e-07
I5567 n1_m1_264000_57600 0 3.293529e-07
I5568 n1_m1_264000_62400 0 2.179158e-07
I5569 n1_m1_264000_67200 0 2.151271e-07
I5570 n1_m1_264000_72000 0 3.232251e-07
I5571 n1_m1_264000_76800 0 2.205110e-07
I5572 n1_m1_264000_81600 0 3.335620e-07
I5573 n1_m1_264000_86400 0 2.161433e-07
I5574 n1_m1_264000_91200 0 2.146938e-07
I5575 n1_m1_264000_96000 0 3.157389e-07
I5576 n1_m1_264000_100800 0 2.096794e-07
I5577 n1_m1_264000_105600 0 3.099179e-07
I5578 n1_m1_264000_110400 0 2.061864e-07
I5579 n1_m1_264000_115200 0 2.108639e-07
I5580 n1_m1_264000_120000 0 3.225345e-07
I5581 n1_m1_264000_124800 0 2.116858e-07
I5582 n1_m1_264000_129600 0 3.277729e-07
I5583 n1_m1_264000_134400 0 2.171058e-07
I5584 n1_m1_264000_139200 0 2.170638e-07
I5585 n1_m1_264000_144000 0 3.400352e-07
I5586 n1_m1_264000_148800 0 2.281716e-07
I5587 n1_m1_264000_153600 0 3.331091e-07
I5588 n1_m1_264000_158400 0 2.354482e-07
I5589 n1_m1_264000_163200 0 2.343360e-07
I5590 n1_m1_264000_168000 0 3.438509e-07
I5591 n1_m1_264000_172800 0 2.538533e-07
I5592 n1_m1_264000_177600 0 1.993032e-06
I5593 n1_m1_264000_182400 0 1.453586e-06
I5594 n1_m1_264000_187200 0 1.879992e-06
I5595 n1_m1_264000_192000 0 1.769193e-06
I5596 n1_m1_264000_196800 0 4.677797e-07
I5597 n1_m1_264000_201600 0 1.012195e-06
I5598 n1_m1_264000_206400 0 2.684625e-07
I5599 n1_m1_264000_211200 0 2.476154e-07
I5600 n1_m1_264000_216000 0 3.749022e-07
I5601 n1_m1_264000_220800 0 3.723661e-07
I5602 n1_m1_264000_225600 0 7.304782e-07
I5603 n1_m1_264000_230400 0 3.828521e-07
I5604 n1_m1_264000_235200 0 6.449455e-07
I5605 n1_m1_264000_240000 0 4.667031e-07
I5606 n1_m1_264000_244800 0 5.044381e-07
I5607 n1_m1_264000_249600 0 6.284865e-07
I5608 n1_m1_264000_254400 0 5.823083e-07
I5609 n1_m1_264000_259200 0 3.695791e-07
I5610 n1_m1_264000_264000 0 6.775862e-07
I5611 n1_m1_264000_268800 0 1.171246e-06
I5612 n1_m1_264000_273600 0 9.026839e-07
I5613 n1_m1_264000_278400 0 4.003258e-07
I5614 n1_m1_264000_283200 0 3.358152e-07
I5615 n1_m1_264000_288000 0 6.883240e-07
I5616 n1_m1_264000_292800 0 7.712560e-07
I5617 n1_m1_264000_297600 0 4.275898e-07
I5618 n1_m1_264000_302400 0 2.514915e-07
I5619 n1_m1_264000_307200 0 2.357229e-07
I5620 n1_m1_264000_312000 0 3.363015e-07
I5621 n1_m1_264000_316800 0 2.202208e-07
I5622 n1_m1_264000_321600 0 3.250755e-07
I5623 n1_m1_264000_326400 0 2.170636e-07
I5624 n1_m1_264000_331200 0 2.226115e-07
I5625 n1_m1_264000_336000 0 3.387454e-07
I5626 n1_m1_264000_340800 0 2.256324e-07
I5627 n1_m1_264000_345600 0 3.350926e-07
I5628 n1_m1_264000_350400 0 2.171650e-07
I5629 n1_m1_264000_355200 0 2.117705e-07
I5630 n1_m1_264000_360000 0 3.147839e-07
I5631 n1_m1_264000_364800 0 2.098560e-07
I5632 n1_m1_264000_369600 0 3.186506e-07
I5633 n1_m1_264000_374400 0 2.149501e-07
I5634 n1_m1_264000_379200 0 2.191171e-07
I5635 n1_m1_264000_384000 0 3.329495e-07
I5636 n1_m1_264000_388800 0 2.255379e-07
I5637 n1_m1_264000_393600 0 3.332201e-07
I5638 n1_m1_264000_398400 0 2.208581e-07
I5639 n1_m1_264000_403200 0 2.221503e-07
I5640 n1_m1_264000_408000 0 3.344743e-07
I5641 n1_m1_264000_412800 0 2.254157e-07
I5642 n1_m1_264000_417600 0 3.453199e-07
I5643 n1_m1_264000_422400 0 2.822998e-07
I5644 n1_m1_264000_427200 0 4.797790e-07
I5645 n1_m1_264000_432000 0 5.615694e-07
I5646 n1_m1_264000_436800 0 5.037679e-07
I5647 n1_m1_264000_441600 0 6.102753e-07
I5648 n1_m1_264000_446400 0 3.500888e-07
I5649 n1_m1_264000_451200 0 2.763033e-07
I5650 n1_m1_264000_456000 0 3.886190e-07
I5651 n1_m1_264000_460800 0 2.332828e-07
I5652 n1_m1_264000_465600 0 3.904531e-07
I5653 n1_m1_264000_470400 0 3.971729e-07
I5654 n1_m1_264000_475200 0 4.262582e-07
I5655 n1_m1_264000_480000 0 4.106755e-07
I5656 n1_m1_268800_0 0 3.115910e-07
I5657 n1_m1_268800_4800 0 4.983669e-07
I5658 n1_m1_268800_9600 0 5.338836e-07
I5659 n1_m1_268800_14400 0 1.589225e-07
I5660 n1_m1_268800_19200 0 1.465400e-07
I5661 n1_m1_268800_24000 0 2.087068e-07
I5662 n1_m1_268800_28800 0 1.365356e-07
I5663 n1_m1_268800_33600 0 2.030968e-07
I5664 n1_m1_268800_38400 0 1.344882e-07
I5665 n1_m1_268800_43200 0 1.343130e-07
I5666 n1_m1_268800_48000 0 2.028927e-07
I5667 n1_m1_268800_52800 0 1.390631e-07
I5668 n1_m1_268800_57600 0 2.126079e-07
I5669 n1_m1_268800_62400 0 1.459178e-07
I5670 n1_m1_268800_67200 0 1.436513e-07
I5671 n1_m1_268800_72000 0 2.123079e-07
I5672 n1_m1_268800_76800 0 1.464285e-07
I5673 n1_m1_268800_81600 0 2.211457e-07
I5674 n1_m1_268800_86400 0 1.425943e-07
I5675 n1_m1_268800_91200 0 1.414329e-07
I5676 n1_m1_268800_96000 0 2.099179e-07
I5677 n1_m1_268800_100800 0 1.378715e-07
I5678 n1_m1_268800_105600 0 2.076600e-07
I5679 n1_m1_268800_110400 0 1.402106e-07
I5680 n1_m1_268800_115200 0 1.411109e-07
I5681 n1_m1_268800_120000 0 2.165381e-07
I5682 n1_m1_268800_124800 0 1.446019e-07
I5683 n1_m1_268800_129600 0 2.176144e-07
I5684 n1_m1_268800_134400 0 1.413702e-07
I5685 n1_m1_268800_139200 0 1.413650e-07
I5686 n1_m1_268800_144000 0 2.185151e-07
I5687 n1_m1_268800_148800 0 1.475428e-07
I5688 n1_m1_268800_153600 0 2.187940e-07
I5689 n1_m1_268800_158400 0 1.602037e-07
I5690 n1_m1_268800_163200 0 1.470186e-07
I5691 n1_m1_268800_168000 0 2.290741e-07
I5692 n1_m1_268800_172800 0 1.742152e-07
I5693 n1_m1_268800_177600 0 1.358305e-06
I5694 n1_m1_268800_182400 0 1.000929e-06
I5695 n1_m1_268800_187200 0 1.049887e-06
I5696 n1_m1_268800_192000 0 6.445566e-07
I5697 n1_m1_268800_196800 0 6.625366e-07
I5698 n1_m1_268800_201600 0 5.088134e-07
I5699 n1_m1_268800_206400 0 2.049580e-07
I5700 n1_m1_268800_211200 0 1.941472e-07
I5701 n1_m1_268800_216000 0 3.686047e-07
I5702 n1_m1_268800_220800 0 2.114790e-07
I5703 n1_m1_268800_225600 0 4.089512e-07
I5704 n1_m1_268800_230400 0 3.440105e-07
I5705 n1_m1_268800_235200 0 2.819323e-07
I5706 n1_m1_268800_240000 0 4.644532e-07
I5707 n1_m1_268800_244800 0 3.258339e-07
I5708 n1_m1_268800_249600 0 6.403665e-07
I5709 n1_m1_268800_254400 0 4.926530e-07
I5710 n1_m1_268800_259200 0 4.166085e-07
I5711 n1_m1_268800_264000 0 1.382987e-06
I5712 n1_m1_268800_268800 0 8.776719e-07
I5713 n1_m1_268800_273600 0 1.612132e-06
I5714 n1_m1_268800_278400 0 5.559540e-07
I5715 n1_m1_268800_283200 0 5.181662e-07
I5716 n1_m1_268800_288000 0 1.310395e-06
I5717 n1_m1_268800_292800 0 4.919479e-07
I5718 n1_m1_268800_297600 0 1.168488e-06
I5719 n1_m1_268800_302400 0 2.970553e-07
I5720 n1_m1_268800_307200 0 1.685194e-07
I5721 n1_m1_268800_312000 0 2.362873e-07
I5722 n1_m1_268800_316800 0 1.528212e-07
I5723 n1_m1_268800_321600 0 2.301984e-07
I5724 n1_m1_268800_326400 0 1.582851e-07
I5725 n1_m1_268800_331200 0 1.704272e-07
I5726 n1_m1_268800_336000 0 2.448075e-07
I5727 n1_m1_268800_340800 0 1.603720e-07
I5728 n1_m1_268800_345600 0 2.285729e-07
I5729 n1_m1_268800_350400 0 1.474896e-07
I5730 n1_m1_268800_355200 0 1.429762e-07
I5731 n1_m1_268800_360000 0 2.104693e-07
I5732 n1_m1_268800_364800 0 1.407015e-07
I5733 n1_m1_268800_369600 0 2.094164e-07
I5734 n1_m1_268800_374400 0 1.404863e-07
I5735 n1_m1_268800_379200 0 1.459652e-07
I5736 n1_m1_268800_384000 0 2.272078e-07
I5737 n1_m1_268800_388800 0 1.620802e-07
I5738 n1_m1_268800_393600 0 2.513366e-07
I5739 n1_m1_268800_398400 0 1.613201e-07
I5740 n1_m1_268800_403200 0 1.590110e-07
I5741 n1_m1_268800_408000 0 2.436185e-07
I5742 n1_m1_268800_412800 0 1.774396e-07
I5743 n1_m1_268800_417600 0 4.152942e-07
I5744 n1_m1_268800_422400 0 7.171771e-07
I5745 n1_m1_268800_427200 0 1.087148e-06
I5746 n1_m1_268800_432000 0 1.395693e-06
I5747 n1_m1_268800_436800 0 1.093485e-06
I5748 n1_m1_268800_441600 0 1.385472e-06
I5749 n1_m1_268800_446400 0 9.174239e-07
I5750 n1_m1_268800_451200 0 6.017883e-07
I5751 n1_m1_268800_456000 0 4.393620e-07
I5752 n1_m1_268800_460800 0 1.784919e-07
I5753 n1_m1_268800_465600 0 2.695496e-07
I5754 n1_m1_268800_470400 0 2.791579e-07
I5755 n1_m1_268800_475200 0 2.891626e-07
I5756 n1_m1_268800_480000 0 2.603094e-07
I5757 n1_m1_273600_0 0 3.588403e-07
I5758 n1_m1_273600_4800 0 4.029534e-07
I5759 n1_m1_273600_9600 0 4.427547e-07
I5760 n1_m1_273600_14400 0 2.407378e-07
I5761 n1_m1_273600_19200 0 2.278128e-07
I5762 n1_m1_273600_24000 0 3.062793e-07
I5763 n1_m1_273600_28800 0 2.089601e-07
I5764 n1_m1_273600_33600 0 3.410282e-07
I5765 n1_m1_273600_38400 0 2.042632e-07
I5766 n1_m1_273600_43200 0 2.094686e-07
I5767 n1_m1_273600_48000 0 3.223647e-07
I5768 n1_m1_273600_52800 0 2.038263e-07
I5769 n1_m1_273600_57600 0 3.023682e-07
I5770 n1_m1_273600_62400 0 2.081294e-07
I5771 n1_m1_273600_67200 0 2.089800e-07
I5772 n1_m1_273600_72000 0 3.123336e-07
I5773 n1_m1_273600_76800 0 2.191678e-07
I5774 n1_m1_273600_81600 0 3.361992e-07
I5775 n1_m1_273600_86400 0 2.170387e-07
I5776 n1_m1_273600_91200 0 2.144968e-07
I5777 n1_m1_273600_96000 0 3.144989e-07
I5778 n1_m1_273600_100800 0 2.172090e-07
I5779 n1_m1_273600_105600 0 3.211561e-07
I5780 n1_m1_273600_110400 0 2.125674e-07
I5781 n1_m1_273600_115200 0 2.062404e-07
I5782 n1_m1_273600_120000 0 3.330564e-07
I5783 n1_m1_273600_124800 0 2.253126e-07
I5784 n1_m1_273600_129600 0 3.335659e-07
I5785 n1_m1_273600_134400 0 2.245710e-07
I5786 n1_m1_273600_139200 0 2.263916e-07
I5787 n1_m1_273600_144000 0 3.189352e-07
I5788 n1_m1_273600_148800 0 2.316835e-07
I5789 n1_m1_273600_153600 0 3.188331e-07
I5790 n1_m1_273600_158400 0 2.248586e-07
I5791 n1_m1_273600_163200 0 2.161848e-07
I5792 n1_m1_273600_168000 0 3.713106e-07
I5793 n1_m1_273600_172800 0 2.518328e-07
I5794 n1_m1_273600_177600 0 1.613983e-06
I5795 n1_m1_273600_182400 0 1.082554e-06
I5796 n1_m1_273600_187200 0 1.051305e-06
I5797 n1_m1_273600_192000 0 1.578260e-06
I5798 n1_m1_273600_196800 0 7.741476e-07
I5799 n1_m1_273600_201600 0 6.465739e-07
I5800 n1_m1_273600_206400 0 3.217375e-07
I5801 n1_m1_273600_211200 0 2.493507e-07
I5802 n1_m1_273600_216000 0 1.076110e-06
I5803 n1_m1_273600_220800 0 3.178353e-07
I5804 n1_m1_273600_225600 0 4.907481e-07
I5805 n1_m1_273600_230400 0 4.447459e-07
I5806 n1_m1_273600_235200 0 4.861257e-07
I5807 n1_m1_273600_240000 0 1.098939e-06
I5808 n1_m1_273600_244800 0 6.005293e-07
I5809 n1_m1_273600_249600 0 1.087352e-06
I5810 n1_m1_273600_254400 0 1.138547e-06
I5811 n1_m1_273600_259200 0 8.051156e-07
I5812 n1_m1_273600_264000 0 1.976931e-06
I5813 n1_m1_273600_268800 0 8.264484e-07
I5814 n1_m1_273600_273600 0 2.079132e-06
I5815 n1_m1_273600_278400 0 1.019809e-06
I5816 n1_m1_273600_283200 0 1.117511e-06
I5817 n1_m1_273600_288000 0 1.511149e-06
I5818 n1_m1_273600_292800 0 9.690504e-07
I5819 n1_m1_273600_297600 0 2.137232e-06
I5820 n1_m1_273600_302400 0 6.927129e-07
I5821 n1_m1_273600_307200 0 4.594751e-07
I5822 n1_m1_273600_312000 0 8.524741e-07
I5823 n1_m1_273600_316800 0 5.949270e-07
I5824 n1_m1_273600_321600 0 8.677293e-07
I5825 n1_m1_273600_326400 0 5.778114e-07
I5826 n1_m1_273600_331200 0 6.159401e-07
I5827 n1_m1_273600_336000 0 5.390404e-07
I5828 n1_m1_273600_340800 0 4.311744e-07
I5829 n1_m1_273600_345600 0 3.916217e-07
I5830 n1_m1_273600_350400 0 2.357485e-07
I5831 n1_m1_273600_355200 0 2.485831e-07
I5832 n1_m1_273600_360000 0 3.442420e-07
I5833 n1_m1_273600_364800 0 2.146528e-07
I5834 n1_m1_273600_369600 0 3.089198e-07
I5835 n1_m1_273600_374400 0 2.184908e-07
I5836 n1_m1_273600_379200 0 2.349981e-07
I5837 n1_m1_273600_384000 0 3.995842e-07
I5838 n1_m1_273600_388800 0 3.058750e-07
I5839 n1_m1_273600_393600 0 4.145490e-07
I5840 n1_m1_273600_398400 0 2.456793e-07
I5841 n1_m1_273600_403200 0 2.628540e-07
I5842 n1_m1_273600_408000 0 3.932598e-07
I5843 n1_m1_273600_412800 0 3.091220e-07
I5844 n1_m1_273600_417600 0 1.427014e-06
I5845 n1_m1_273600_422400 0 1.444258e-06
I5846 n1_m1_273600_427200 0 1.665366e-06
I5847 n1_m1_273600_432000 0 2.219688e-06
I5848 n1_m1_273600_436800 0 1.567083e-06
I5849 n1_m1_273600_441600 0 1.763021e-06
I5850 n1_m1_273600_446400 0 1.003963e-06
I5851 n1_m1_273600_451200 0 5.105150e-07
I5852 n1_m1_273600_456000 0 5.879762e-07
I5853 n1_m1_273600_460800 0 2.595076e-07
I5854 n1_m1_273600_465600 0 3.623865e-07
I5855 n1_m1_273600_470400 0 2.896600e-07
I5856 n1_m1_273600_475200 0 3.041347e-07
I5857 n1_m1_273600_480000 0 3.682134e-07
I5858 n1_m1_278400_0 0 1.823565e-07
I5859 n1_m1_278400_4800 0 2.148857e-07
I5860 n1_m1_278400_9600 0 2.740094e-07
I5861 n1_m1_278400_14400 0 1.508056e-07
I5862 n1_m1_278400_19200 0 1.392578e-07
I5863 n1_m1_278400_24000 0 2.061341e-07
I5864 n1_m1_278400_28800 0 1.477561e-07
I5865 n1_m1_278400_33600 0 2.193322e-07
I5866 n1_m1_278400_38400 0 1.345754e-07
I5867 n1_m1_278400_43200 0 1.357798e-07
I5868 n1_m1_278400_48000 0 2.220165e-07
I5869 n1_m1_278400_52800 0 1.424910e-07
I5870 n1_m1_278400_57600 0 2.073400e-07
I5871 n1_m1_278400_62400 0 1.402835e-07
I5872 n1_m1_278400_67200 0 1.384532e-07
I5873 n1_m1_278400_72000 0 2.095945e-07
I5874 n1_m1_278400_76800 0 1.468305e-07
I5875 n1_m1_278400_81600 0 2.247251e-07
I5876 n1_m1_278400_86400 0 1.472480e-07
I5877 n1_m1_278400_91200 0 1.440424e-07
I5878 n1_m1_278400_96000 0 2.117967e-07
I5879 n1_m1_278400_100800 0 1.460705e-07
I5880 n1_m1_278400_105600 0 2.201628e-07
I5881 n1_m1_278400_110400 0 1.426233e-07
I5882 n1_m1_278400_115200 0 1.525164e-07
I5883 n1_m1_278400_120000 0 2.418175e-07
I5884 n1_m1_278400_124800 0 1.689537e-07
I5885 n1_m1_278400_129600 0 2.370890e-07
I5886 n1_m1_278400_134400 0 1.527877e-07
I5887 n1_m1_278400_139200 0 1.544726e-07
I5888 n1_m1_278400_144000 0 2.117685e-07
I5889 n1_m1_278400_148800 0 1.444948e-07
I5890 n1_m1_278400_153600 0 2.185768e-07
I5891 n1_m1_278400_158400 0 1.471550e-07
I5892 n1_m1_278400_163200 0 1.467649e-07
I5893 n1_m1_278400_168000 0 2.521070e-07
I5894 n1_m1_278400_172800 0 1.751192e-07
I5895 n1_m1_278400_177600 0 7.779777e-07
I5896 n1_m1_278400_182400 0 4.875463e-07
I5897 n1_m1_278400_187200 0 6.076545e-07
I5898 n1_m1_278400_192000 0 6.101855e-07
I5899 n1_m1_278400_196800 0 2.543362e-07
I5900 n1_m1_278400_201600 0 5.980506e-07
I5901 n1_m1_278400_206400 0 1.813909e-07
I5902 n1_m1_278400_211200 0 1.739625e-07
I5903 n1_m1_278400_216000 0 3.749320e-07
I5904 n1_m1_278400_220800 0 2.833066e-07
I5905 n1_m1_278400_225600 0 4.850634e-07
I5906 n1_m1_278400_230400 0 2.766710e-07
I5907 n1_m1_278400_235200 0 3.904773e-07
I5908 n1_m1_278400_240000 0 5.310511e-07
I5909 n1_m1_278400_244800 0 5.238106e-07
I5910 n1_m1_278400_249600 0 6.593869e-07
I5911 n1_m1_278400_254400 0 7.942752e-07
I5912 n1_m1_278400_259200 0 4.734526e-07
I5913 n1_m1_278400_264000 0 8.251143e-07
I5914 n1_m1_278400_268800 0 3.565920e-07
I5915 n1_m1_278400_273600 0 7.250047e-07
I5916 n1_m1_278400_278400 0 3.326955e-07
I5917 n1_m1_278400_283200 0 4.128179e-07
I5918 n1_m1_278400_288000 0 5.250957e-07
I5919 n1_m1_278400_292800 0 6.228831e-07
I5920 n1_m1_278400_297600 0 6.827748e-07
I5921 n1_m1_278400_302400 0 5.024609e-07
I5922 n1_m1_278400_307200 0 5.450874e-07
I5923 n1_m1_278400_312000 0 1.072829e-06
I5924 n1_m1_278400_316800 0 7.402784e-07
I5925 n1_m1_278400_321600 0 1.086568e-06
I5926 n1_m1_278400_326400 0 7.281852e-07
I5927 n1_m1_278400_331200 0 7.078954e-07
I5928 n1_m1_278400_336000 0 4.035078e-07
I5929 n1_m1_278400_340800 0 3.276076e-07
I5930 n1_m1_278400_345600 0 2.669664e-07
I5931 n1_m1_278400_350400 0 1.635517e-07
I5932 n1_m1_278400_355200 0 1.834476e-07
I5933 n1_m1_278400_360000 0 2.365233e-07
I5934 n1_m1_278400_364800 0 1.369033e-07
I5935 n1_m1_278400_369600 0 2.090897e-07
I5936 n1_m1_278400_374400 0 1.545425e-07
I5937 n1_m1_278400_379200 0 1.658517e-07
I5938 n1_m1_278400_384000 0 2.619285e-07
I5939 n1_m1_278400_388800 0 1.706267e-07
I5940 n1_m1_278400_393600 0 2.489680e-07
I5941 n1_m1_278400_398400 0 1.663067e-07
I5942 n1_m1_278400_403200 0 1.742436e-07
I5943 n1_m1_278400_408000 0 2.516730e-07
I5944 n1_m1_278400_412800 0 1.679069e-07
I5945 n1_m1_278400_417600 0 4.881729e-07
I5946 n1_m1_278400_422400 0 4.715122e-07
I5947 n1_m1_278400_427200 0 7.968316e-07
I5948 n1_m1_278400_432000 0 1.274566e-06
I5949 n1_m1_278400_436800 0 1.050453e-06
I5950 n1_m1_278400_441600 0 1.189043e-06
I5951 n1_m1_278400_446400 0 5.705602e-07
I5952 n1_m1_278400_451200 0 2.259958e-07
I5953 n1_m1_278400_456000 0 2.948994e-07
I5954 n1_m1_278400_460800 0 1.614231e-07
I5955 n1_m1_278400_465600 0 2.324499e-07
I5956 n1_m1_278400_470400 0 1.797389e-07
I5957 n1_m1_278400_475200 0 1.855200e-07
I5958 n1_m1_278400_480000 0 2.378533e-07
I5959 n1_m1_283200_0 0 9.531468e-08
I5960 n1_m1_283200_4800 0 1.133147e-07
I5961 n1_m1_283200_9600 0 1.381990e-07
I5962 n1_m1_283200_14400 0 7.581169e-08
I5963 n1_m1_283200_19200 0 7.090255e-08
I5964 n1_m1_283200_24000 0 1.039184e-07
I5965 n1_m1_283200_28800 0 7.310580e-08
I5966 n1_m1_283200_33600 0 1.019742e-07
I5967 n1_m1_283200_38400 0 7.299372e-08
I5968 n1_m1_283200_43200 0 7.032173e-08
I5969 n1_m1_283200_48000 0 1.105055e-07
I5970 n1_m1_283200_52800 0 7.186727e-08
I5971 n1_m1_283200_57600 0 1.082539e-07
I5972 n1_m1_283200_62400 0 7.186528e-08
I5973 n1_m1_283200_67200 0 6.995199e-08
I5974 n1_m1_283200_72000 0 1.052943e-07
I5975 n1_m1_283200_76800 0 7.242092e-08
I5976 n1_m1_283200_81600 0 1.098432e-07
I5977 n1_m1_283200_86400 0 7.298089e-08
I5978 n1_m1_283200_91200 0 7.228441e-08
I5979 n1_m1_283200_96000 0 1.048627e-07
I5980 n1_m1_283200_100800 0 7.039246e-08
I5981 n1_m1_283200_105600 0 1.076671e-07
I5982 n1_m1_283200_110400 0 7.161063e-08
I5983 n1_m1_283200_115200 0 8.254457e-08
I5984 n1_m1_283200_120000 0 1.318724e-07
I5985 n1_m1_283200_124800 0 1.047421e-07
I5986 n1_m1_283200_129600 0 1.306323e-07
I5987 n1_m1_283200_134400 0 7.700285e-08
I5988 n1_m1_283200_139200 0 7.584935e-08
I5989 n1_m1_283200_144000 0 1.068635e-07
I5990 n1_m1_283200_148800 0 7.264901e-08
I5991 n1_m1_283200_153600 0 1.139815e-07
I5992 n1_m1_283200_158400 0 7.691389e-08
I5993 n1_m1_283200_163200 0 7.859614e-08
I5994 n1_m1_283200_168000 0 1.258752e-07
I5995 n1_m1_283200_172800 0 9.060250e-08
I5996 n1_m1_283200_177600 0 3.793458e-07
I5997 n1_m1_283200_182400 0 2.808765e-07
I5998 n1_m1_283200_187200 0 3.512435e-07
I5999 n1_m1_283200_192000 0 4.563956e-07
I6000 n1_m1_283200_196800 0 2.597904e-07
I6001 n1_m1_283200_201600 0 2.861657e-07
I6002 n1_m1_283200_206400 0 1.333622e-07
I6003 n1_m1_283200_211200 0 1.572461e-07
I6004 n1_m1_283200_216000 0 3.456442e-07
I6005 n1_m1_283200_220800 0 2.087737e-07
I6006 n1_m1_283200_225600 0 3.729844e-07
I6007 n1_m1_283200_230400 0 3.241676e-07
I6008 n1_m1_283200_235200 0 3.629235e-07
I6009 n1_m1_283200_240000 0 3.954106e-07
I6010 n1_m1_283200_244800 0 2.116519e-07
I6011 n1_m1_283200_249600 0 3.791420e-07
I6012 n1_m1_283200_254400 0 5.181922e-07
I6013 n1_m1_283200_259200 0 3.448941e-07
I6014 n1_m1_283200_264000 0 4.983664e-07
I6015 n1_m1_283200_268800 0 1.782082e-07
I6016 n1_m1_283200_273600 0 3.614741e-07
I6017 n1_m1_283200_278400 0 1.701356e-07
I6018 n1_m1_283200_283200 0 2.704491e-07
I6019 n1_m1_283200_288000 0 3.157247e-07
I6020 n1_m1_283200_292800 0 1.758846e-07
I6021 n1_m1_283200_297600 0 2.063732e-07
I6022 n1_m1_283200_302400 0 3.150445e-07
I6023 n1_m1_283200_307200 0 2.911935e-07
I6024 n1_m1_283200_312000 0 4.265278e-07
I6025 n1_m1_283200_316800 0 2.532707e-07
I6026 n1_m1_283200_321600 0 3.849366e-07
I6027 n1_m1_283200_326400 0 2.904501e-07
I6028 n1_m1_283200_331200 0 3.122152e-07
I6029 n1_m1_283200_336000 0 1.539612e-07
I6030 n1_m1_283200_340800 0 8.778714e-08
I6031 n1_m1_283200_345600 0 1.424015e-07
I6032 n1_m1_283200_350400 0 9.755701e-08
I6033 n1_m1_283200_355200 0 8.281239e-08
I6034 n1_m1_283200_360000 0 1.104730e-07
I6035 n1_m1_283200_364800 0 7.156655e-08
I6036 n1_m1_283200_369600 0 1.043546e-07
I6037 n1_m1_283200_374400 0 7.364979e-08
I6038 n1_m1_283200_379200 0 7.665740e-08
I6039 n1_m1_283200_384000 0 1.188127e-07
I6040 n1_m1_283200_388800 0 7.740089e-08
I6041 n1_m1_283200_393600 0 1.200128e-07
I6042 n1_m1_283200_398400 0 8.504266e-08
I6043 n1_m1_283200_403200 0 8.582355e-08
I6044 n1_m1_283200_408000 0 1.214096e-07
I6045 n1_m1_283200_412800 0 7.830904e-08
I6046 n1_m1_283200_417600 0 1.349605e-07
I6047 n1_m1_283200_422400 0 1.430866e-07
I6048 n1_m1_283200_427200 0 2.986419e-07
I6049 n1_m1_283200_432000 0 5.064879e-07
I6050 n1_m1_283200_436800 0 4.584061e-07
I6051 n1_m1_283200_441600 0 5.317796e-07
I6052 n1_m1_283200_446400 0 2.660327e-07
I6053 n1_m1_283200_451200 0 1.100779e-07
I6054 n1_m1_283200_456000 0 1.279310e-07
I6055 n1_m1_283200_460800 0 7.759137e-08
I6056 n1_m1_283200_465600 0 1.151847e-07
I6057 n1_m1_283200_470400 0 8.986945e-08
I6058 n1_m1_283200_475200 0 9.276002e-08
I6059 n1_m1_283200_480000 0 1.198685e-07
I6060 n1_m1_288000_0 0 2.196251e-07
I6061 n1_m1_288000_4800 0 3.396068e-07
I6062 n1_m1_288000_9600 0 4.634380e-07
I6063 n1_m1_288000_14400 0 1.887058e-07
I6064 n1_m1_288000_19200 0 1.534678e-07
I6065 n1_m1_288000_24000 0 2.095953e-07
I6066 n1_m1_288000_28800 0 1.397814e-07
I6067 n1_m1_288000_33600 0 2.086531e-07
I6068 n1_m1_288000_38400 0 1.788630e-07
I6069 n1_m1_288000_43200 0 2.923106e-07
I6070 n1_m1_288000_48000 0 4.902590e-07
I6071 n1_m1_288000_52800 0 3.438279e-07
I6072 n1_m1_288000_57600 0 3.396879e-07
I6073 n1_m1_288000_62400 0 1.565622e-07
I6074 n1_m1_288000_67200 0 1.461196e-07
I6075 n1_m1_288000_72000 0 2.216756e-07
I6076 n1_m1_288000_76800 0 1.524935e-07
I6077 n1_m1_288000_81600 0 2.364248e-07
I6078 n1_m1_288000_86400 0 1.676654e-07
I6079 n1_m1_288000_91200 0 1.643893e-07
I6080 n1_m1_288000_96000 0 2.337512e-07
I6081 n1_m1_288000_100800 0 1.612269e-07
I6082 n1_m1_288000_105600 0 2.375495e-07
I6083 n1_m1_288000_110400 0 1.474084e-07
I6084 n1_m1_288000_115200 0 1.841016e-07
I6085 n1_m1_288000_120000 0 5.308330e-07
I6086 n1_m1_288000_124800 0 5.123259e-07
I6087 n1_m1_288000_129600 0 7.654123e-07
I6088 n1_m1_288000_134400 0 4.598390e-07
I6089 n1_m1_288000_139200 0 3.275481e-07
I6090 n1_m1_288000_144000 0 2.815018e-07
I6091 n1_m1_288000_148800 0 1.642709e-07
I6092 n1_m1_288000_153600 0 2.593698e-07
I6093 n1_m1_288000_158400 0 2.650655e-07
I6094 n1_m1_288000_163200 0 2.704550e-07
I6095 n1_m1_288000_168000 0 3.846279e-07
I6096 n1_m1_288000_172800 0 4.028391e-07
I6097 n1_m1_288000_177600 0 1.201668e-06
I6098 n1_m1_288000_182400 0 7.410504e-07
I6099 n1_m1_288000_187200 0 1.048538e-06
I6100 n1_m1_288000_192000 0 8.043277e-07
I6101 n1_m1_288000_196800 0 5.137319e-07
I6102 n1_m1_288000_201600 0 5.674159e-07
I6103 n1_m1_288000_206400 0 7.918900e-07
I6104 n1_m1_288000_211200 0 1.120313e-06
I6105 n1_m1_288000_216000 0 1.047368e-06
I6106 n1_m1_288000_220800 0 1.018293e-06
I6107 n1_m1_288000_225600 0 1.813258e-06
I6108 n1_m1_288000_230400 0 8.595547e-07
I6109 n1_m1_288000_235200 0 1.070269e-06
I6110 n1_m1_288000_240000 0 1.267186e-06
I6111 n1_m1_288000_244800 0 7.992019e-07
I6112 n1_m1_288000_249600 0 1.087987e-06
I6113 n1_m1_288000_254400 0 1.261217e-06
I6114 n1_m1_288000_259200 0 1.187882e-06
I6115 n1_m1_288000_264000 0 1.377624e-06
I6116 n1_m1_288000_268800 0 6.539610e-07
I6117 n1_m1_288000_273600 0 1.219349e-06
I6118 n1_m1_288000_278400 0 6.656521e-07
I6119 n1_m1_288000_283200 0 1.003361e-06
I6120 n1_m1_288000_288000 0 1.160817e-06
I6121 n1_m1_288000_292800 0 1.078917e-06
I6122 n1_m1_288000_297600 0 1.205563e-06
I6123 n1_m1_288000_302400 0 9.749290e-07
I6124 n1_m1_288000_307200 0 7.615007e-07
I6125 n1_m1_288000_312000 0 7.846611e-07
I6126 n1_m1_288000_316800 0 3.987444e-07
I6127 n1_m1_288000_321600 0 5.399980e-07
I6128 n1_m1_288000_326400 0 2.713876e-07
I6129 n1_m1_288000_331200 0 3.037028e-07
I6130 n1_m1_288000_336000 0 3.105220e-07
I6131 n1_m1_288000_340800 0 2.510410e-07
I6132 n1_m1_288000_345600 0 2.995090e-07
I6133 n1_m1_288000_350400 0 1.657534e-07
I6134 n1_m1_288000_355200 0 1.555541e-07
I6135 n1_m1_288000_360000 0 2.796036e-07
I6136 n1_m1_288000_364800 0 1.447768e-07
I6137 n1_m1_288000_369600 0 2.097842e-07
I6138 n1_m1_288000_374400 0 1.416404e-07
I6139 n1_m1_288000_379200 0 1.463423e-07
I6140 n1_m1_288000_384000 0 2.325049e-07
I6141 n1_m1_288000_388800 0 1.646393e-07
I6142 n1_m1_288000_393600 0 2.350405e-07
I6143 n1_m1_288000_398400 0 1.573025e-07
I6144 n1_m1_288000_403200 0 1.537807e-07
I6145 n1_m1_288000_408000 0 2.202351e-07
I6146 n1_m1_288000_412800 0 1.557107e-07
I6147 n1_m1_288000_417600 0 2.217732e-07
I6148 n1_m1_288000_422400 0 1.402240e-07
I6149 n1_m1_288000_427200 0 1.627925e-07
I6150 n1_m1_288000_432000 0 2.269979e-07
I6151 n1_m1_288000_436800 0 1.696780e-07
I6152 n1_m1_288000_441600 0 2.463822e-07
I6153 n1_m1_288000_446400 0 1.802900e-07
I6154 n1_m1_288000_451200 0 1.548058e-07
I6155 n1_m1_288000_456000 0 2.390213e-07
I6156 n1_m1_288000_460800 0 1.551884e-07
I6157 n1_m1_288000_465600 0 2.351491e-07
I6158 n1_m1_288000_470400 0 1.792401e-07
I6159 n1_m1_288000_475200 0 1.845793e-07
I6160 n1_m1_288000_480000 0 2.499041e-07
I6161 n1_m1_292800_0 0 3.243581e-07
I6162 n1_m1_292800_4800 0 6.453727e-07
I6163 n1_m1_292800_9600 0 9.455056e-07
I6164 n1_m1_292800_14400 0 2.722922e-07
I6165 n1_m1_292800_19200 0 1.673611e-07
I6166 n1_m1_292800_24000 0 2.220709e-07
I6167 n1_m1_292800_28800 0 1.486479e-07
I6168 n1_m1_292800_33600 0 2.721183e-07
I6169 n1_m1_292800_38400 0 3.544724e-07
I6170 n1_m1_292800_43200 0 8.453126e-07
I6171 n1_m1_292800_48000 0 1.339294e-06
I6172 n1_m1_292800_52800 0 9.244787e-07
I6173 n1_m1_292800_57600 0 6.959885e-07
I6174 n1_m1_292800_62400 0 2.787846e-07
I6175 n1_m1_292800_67200 0 2.379135e-07
I6176 n1_m1_292800_72000 0 3.354628e-07
I6177 n1_m1_292800_76800 0 2.099723e-07
I6178 n1_m1_292800_81600 0 3.021691e-07
I6179 n1_m1_292800_86400 0 2.327854e-07
I6180 n1_m1_292800_91200 0 2.756613e-07
I6181 n1_m1_292800_96000 0 3.525877e-07
I6182 n1_m1_292800_100800 0 2.663008e-07
I6183 n1_m1_292800_105600 0 3.496949e-07
I6184 n1_m1_292800_110400 0 3.016783e-07
I6185 n1_m1_292800_115200 0 4.422196e-07
I6186 n1_m1_292800_120000 0 1.579445e-06
I6187 n1_m1_292800_124800 0 1.328056e-06
I6188 n1_m1_292800_129600 0 1.958715e-06
I6189 n1_m1_292800_134400 0 1.255200e-06
I6190 n1_m1_292800_139200 0 7.721613e-07
I6191 n1_m1_292800_144000 0 4.834345e-07
I6192 n1_m1_292800_148800 0 2.031672e-07
I6193 n1_m1_292800_153600 0 4.562180e-07
I6194 n1_m1_292800_158400 0 6.858614e-07
I6195 n1_m1_292800_163200 0 7.342291e-07
I6196 n1_m1_292800_168000 0 1.087995e-06
I6197 n1_m1_292800_172800 0 9.322559e-07
I6198 n1_m1_292800_177600 0 1.920092e-06
I6199 n1_m1_292800_182400 0 1.191512e-06
I6200 n1_m1_292800_187200 0 1.138114e-06
I6201 n1_m1_292800_192000 0 7.983534e-07
I6202 n1_m1_292800_196800 0 7.227378e-07
I6203 n1_m1_292800_201600 0 9.403325e-07
I6204 n1_m1_292800_206400 0 8.921704e-07
I6205 n1_m1_292800_211200 0 8.664645e-07
I6206 n1_m1_292800_216000 0 1.730485e-06
I6207 n1_m1_292800_220800 0 1.277037e-06
I6208 n1_m1_292800_225600 0 1.452709e-06
I6209 n1_m1_292800_230400 0 8.293665e-07
I6210 n1_m1_292800_235200 0 7.476464e-07
I6211 n1_m1_292800_240000 0 8.440361e-07
I6212 n1_m1_292800_244800 0 6.794940e-07
I6213 n1_m1_292800_249600 0 9.117849e-07
I6214 n1_m1_292800_254400 0 1.196778e-06
I6215 n1_m1_292800_259200 0 1.251192e-06
I6216 n1_m1_292800_264000 0 1.844771e-06
I6217 n1_m1_292800_268800 0 7.900542e-07
I6218 n1_m1_292800_273600 0 1.356799e-06
I6219 n1_m1_292800_278400 0 6.186279e-07
I6220 n1_m1_292800_283200 0 7.492915e-07
I6221 n1_m1_292800_288000 0 1.103028e-06
I6222 n1_m1_292800_292800 0 8.675791e-07
I6223 n1_m1_292800_297600 0 9.522179e-07
I6224 n1_m1_292800_302400 0 8.311600e-07
I6225 n1_m1_292800_307200 0 6.068274e-07
I6226 n1_m1_292800_312000 0 6.665853e-07
I6227 n1_m1_292800_316800 0 3.821072e-07
I6228 n1_m1_292800_321600 0 6.127399e-07
I6229 n1_m1_292800_326400 0 3.739056e-07
I6230 n1_m1_292800_331200 0 4.383659e-07
I6231 n1_m1_292800_336000 0 5.216219e-07
I6232 n1_m1_292800_340800 0 3.652862e-07
I6233 n1_m1_292800_345600 0 2.759546e-07
I6234 n1_m1_292800_350400 0 1.792703e-07
I6235 n1_m1_292800_355200 0 2.048066e-07
I6236 n1_m1_292800_360000 0 2.545970e-07
I6237 n1_m1_292800_364800 0 1.468369e-07
I6238 n1_m1_292800_369600 0 2.139074e-07
I6239 n1_m1_292800_374400 0 1.459033e-07
I6240 n1_m1_292800_379200 0 1.482794e-07
I6241 n1_m1_292800_384000 0 2.249353e-07
I6242 n1_m1_292800_388800 0 1.501576e-07
I6243 n1_m1_292800_393600 0 2.289416e-07
I6244 n1_m1_292800_398400 0 1.461581e-07
I6245 n1_m1_292800_403200 0 1.448997e-07
I6246 n1_m1_292800_408000 0 2.151966e-07
I6247 n1_m1_292800_412800 0 1.480756e-07
I6248 n1_m1_292800_417600 0 2.150093e-07
I6249 n1_m1_292800_422400 0 1.388162e-07
I6250 n1_m1_292800_427200 0 1.508452e-07
I6251 n1_m1_292800_432000 0 2.178507e-07
I6252 n1_m1_292800_436800 0 1.532971e-07
I6253 n1_m1_292800_441600 0 2.207195e-07
I6254 n1_m1_292800_446400 0 1.621208e-07
I6255 n1_m1_292800_451200 0 1.543762e-07
I6256 n1_m1_292800_456000 0 2.366867e-07
I6257 n1_m1_292800_460800 0 1.536273e-07
I6258 n1_m1_292800_465600 0 2.321674e-07
I6259 n1_m1_292800_470400 0 1.741364e-07
I6260 n1_m1_292800_475200 0 1.793249e-07
I6261 n1_m1_292800_480000 0 2.528771e-07
I6262 n1_m1_297600_0 0 3.429223e-07
I6263 n1_m1_297600_4800 0 5.237857e-07
I6264 n1_m1_297600_9600 0 6.459331e-07
I6265 n1_m1_297600_14400 0 2.418090e-07
I6266 n1_m1_297600_19200 0 2.368483e-07
I6267 n1_m1_297600_24000 0 3.612166e-07
I6268 n1_m1_297600_28800 0 2.448826e-07
I6269 n1_m1_297600_33600 0 6.590415e-07
I6270 n1_m1_297600_38400 0 6.112423e-07
I6271 n1_m1_297600_43200 0 1.158671e-06
I6272 n1_m1_297600_48000 0 1.184434e-06
I6273 n1_m1_297600_52800 0 1.248992e-06
I6274 n1_m1_297600_57600 0 1.679123e-06
I6275 n1_m1_297600_62400 0 1.552521e-06
I6276 n1_m1_297600_67200 0 1.426587e-06
I6277 n1_m1_297600_72000 0 2.045284e-06
I6278 n1_m1_297600_76800 0 1.276859e-06
I6279 n1_m1_297600_81600 0 1.733648e-06
I6280 n1_m1_297600_86400 0 1.235149e-06
I6281 n1_m1_297600_91200 0 1.438488e-06
I6282 n1_m1_297600_96000 0 2.074999e-06
I6283 n1_m1_297600_100800 0 1.551783e-06
I6284 n1_m1_297600_105600 0 2.144743e-06
I6285 n1_m1_297600_110400 0 1.604567e-06
I6286 n1_m1_297600_115200 0 1.678491e-06
I6287 n1_m1_297600_120000 0 2.747935e-06
I6288 n1_m1_297600_124800 0 1.679283e-06
I6289 n1_m1_297600_129600 0 2.307705e-06
I6290 n1_m1_297600_134400 0 1.626326e-06
I6291 n1_m1_297600_139200 0 1.108284e-06
I6292 n1_m1_297600_144000 0 9.963423e-07
I6293 n1_m1_297600_148800 0 4.215674e-07
I6294 n1_m1_297600_153600 0 1.064555e-06
I6295 n1_m1_297600_158400 0 1.338564e-06
I6296 n1_m1_297600_163200 0 1.243571e-06
I6297 n1_m1_297600_168000 0 1.679049e-06
I6298 n1_m1_297600_172800 0 1.194852e-06
I6299 n1_m1_297600_177600 0 2.654709e-06
I6300 n1_m1_297600_182400 0 1.547662e-06
I6301 n1_m1_297600_187200 0 1.789803e-06
I6302 n1_m1_297600_192000 0 1.903634e-06
I6303 n1_m1_297600_196800 0 1.310319e-06
I6304 n1_m1_297600_201600 0 1.512012e-06
I6305 n1_m1_297600_206400 0 1.277236e-06
I6306 n1_m1_297600_211200 0 1.347108e-06
I6307 n1_m1_297600_216000 0 2.250005e-06
I6308 n1_m1_297600_220800 0 1.669862e-06
I6309 n1_m1_297600_225600 0 2.182588e-06
I6310 n1_m1_297600_230400 0 1.119923e-06
I6311 n1_m1_297600_235200 0 8.585841e-07
I6312 n1_m1_297600_240000 0 8.927633e-07
I6313 n1_m1_297600_244800 0 5.257630e-07
I6314 n1_m1_297600_249600 0 9.251727e-07
I6315 n1_m1_297600_254400 0 1.117785e-06
I6316 n1_m1_297600_259200 0 1.247968e-06
I6317 n1_m1_297600_264000 0 2.429086e-06
I6318 n1_m1_297600_268800 0 1.102346e-06
I6319 n1_m1_297600_273600 0 1.764802e-06
I6320 n1_m1_297600_278400 0 7.917995e-07
I6321 n1_m1_297600_283200 0 5.773395e-07
I6322 n1_m1_297600_288000 0 9.748957e-07
I6323 n1_m1_297600_292800 0 7.654815e-07
I6324 n1_m1_297600_297600 0 7.389381e-07
I6325 n1_m1_297600_302400 0 5.700887e-07
I6326 n1_m1_297600_307200 0 4.091898e-07
I6327 n1_m1_297600_312000 0 5.371971e-07
I6328 n1_m1_297600_316800 0 3.314168e-07
I6329 n1_m1_297600_321600 0 5.888322e-07
I6330 n1_m1_297600_326400 0 5.107636e-07
I6331 n1_m1_297600_331200 0 7.257594e-07
I6332 n1_m1_297600_336000 0 8.573040e-07
I6333 n1_m1_297600_340800 0 5.626604e-07
I6334 n1_m1_297600_345600 0 4.893044e-07
I6335 n1_m1_297600_350400 0 3.384110e-07
I6336 n1_m1_297600_355200 0 3.449771e-07
I6337 n1_m1_297600_360000 0 3.738547e-07
I6338 n1_m1_297600_364800 0 2.362931e-07
I6339 n1_m1_297600_369600 0 3.327159e-07
I6340 n1_m1_297600_374400 0 2.284586e-07
I6341 n1_m1_297600_379200 0 2.668146e-07
I6342 n1_m1_297600_384000 0 6.064094e-07
I6343 n1_m1_297600_388800 0 5.213349e-07
I6344 n1_m1_297600_393600 0 4.671251e-07
I6345 n1_m1_297600_398400 0 2.289574e-07
I6346 n1_m1_297600_403200 0 2.183508e-07
I6347 n1_m1_297600_408000 0 3.335479e-07
I6348 n1_m1_297600_412800 0 2.113453e-07
I6349 n1_m1_297600_417600 0 3.111397e-07
I6350 n1_m1_297600_422400 0 2.070759e-07
I6351 n1_m1_297600_427200 0 2.150898e-07
I6352 n1_m1_297600_432000 0 3.226188e-07
I6353 n1_m1_297600_436800 0 2.291540e-07
I6354 n1_m1_297600_441600 0 3.283006e-07
I6355 n1_m1_297600_446400 0 2.252266e-07
I6356 n1_m1_297600_451200 0 2.213468e-07
I6357 n1_m1_297600_456000 0 3.364659e-07
I6358 n1_m1_297600_460800 0 2.182117e-07
I6359 n1_m1_297600_465600 0 3.271364e-07
I6360 n1_m1_297600_470400 0 2.422691e-07
I6361 n1_m1_297600_475200 0 2.571921e-07
I6362 n1_m1_297600_480000 0 3.649301e-07
I6363 n1_m1_302400_0 0 2.053355e-07
I6364 n1_m1_302400_4800 0 2.907682e-07
I6365 n1_m1_302400_9600 0 3.421571e-07
I6366 n1_m1_302400_14400 0 1.547724e-07
I6367 n1_m1_302400_19200 0 1.597207e-07
I6368 n1_m1_302400_24000 0 2.387603e-07
I6369 n1_m1_302400_28800 0 1.643245e-07
I6370 n1_m1_302400_33600 0 2.945389e-07
I6371 n1_m1_302400_38400 0 2.497775e-07
I6372 n1_m1_302400_43200 0 4.079948e-07
I6373 n1_m1_302400_48000 0 4.565630e-07
I6374 n1_m1_302400_52800 0 6.547989e-07
I6375 n1_m1_302400_57600 0 1.284077e-06
I6376 n1_m1_302400_62400 0 1.241433e-06
I6377 n1_m1_302400_67200 0 1.187389e-06
I6378 n1_m1_302400_72000 0 1.791242e-06
I6379 n1_m1_302400_76800 0 1.084769e-06
I6380 n1_m1_302400_81600 0 1.555619e-06
I6381 n1_m1_302400_86400 0 9.859216e-07
I6382 n1_m1_302400_91200 0 1.006381e-06
I6383 n1_m1_302400_96000 0 1.536210e-06
I6384 n1_m1_302400_100800 0 1.279779e-06
I6385 n1_m1_302400_105600 0 1.917542e-06
I6386 n1_m1_302400_110400 0 1.311263e-06
I6387 n1_m1_302400_115200 0 1.278165e-06
I6388 n1_m1_302400_120000 0 1.864550e-06
I6389 n1_m1_302400_124800 0 1.124996e-06
I6390 n1_m1_302400_129600 0 1.488620e-06
I6391 n1_m1_302400_134400 0 8.335178e-07
I6392 n1_m1_302400_139200 0 6.139179e-07
I6393 n1_m1_302400_144000 0 5.241182e-07
I6394 n1_m1_302400_148800 0 2.142299e-07
I6395 n1_m1_302400_153600 0 3.548264e-07
I6396 n1_m1_302400_158400 0 3.218391e-07
I6397 n1_m1_302400_163200 0 2.903622e-07
I6398 n1_m1_302400_168000 0 4.224631e-07
I6399 n1_m1_302400_172800 0 5.163202e-07
I6400 n1_m1_302400_177600 0 1.609840e-06
I6401 n1_m1_302400_182400 0 1.064235e-06
I6402 n1_m1_302400_187200 0 1.288340e-06
I6403 n1_m1_302400_192000 0 1.252645e-06
I6404 n1_m1_302400_196800 0 6.282020e-07
I6405 n1_m1_302400_201600 0 9.035359e-07
I6406 n1_m1_302400_206400 0 3.622031e-07
I6407 n1_m1_302400_211200 0 3.783917e-07
I6408 n1_m1_302400_216000 0 8.347380e-07
I6409 n1_m1_302400_220800 0 5.888606e-07
I6410 n1_m1_302400_225600 0 7.847161e-07
I6411 n1_m1_302400_230400 0 2.573478e-07
I6412 n1_m1_302400_235200 0 2.133299e-07
I6413 n1_m1_302400_240000 0 2.762407e-07
I6414 n1_m1_302400_244800 0 1.837586e-07
I6415 n1_m1_302400_249600 0 2.974297e-07
I6416 n1_m1_302400_254400 0 2.230934e-07
I6417 n1_m1_302400_259200 0 2.441670e-07
I6418 n1_m1_302400_264000 0 5.335739e-07
I6419 n1_m1_302400_268800 0 3.672386e-07
I6420 n1_m1_302400_273600 0 3.959839e-07
I6421 n1_m1_302400_278400 0 1.626629e-07
I6422 n1_m1_302400_283200 0 1.598799e-07
I6423 n1_m1_302400_288000 0 2.727380e-07
I6424 n1_m1_302400_292800 0 2.009236e-07
I6425 n1_m1_302400_297600 0 2.498112e-07
I6426 n1_m1_302400_302400 0 1.611126e-07
I6427 n1_m1_302400_307200 0 1.590171e-07
I6428 n1_m1_302400_312000 0 2.392989e-07
I6429 n1_m1_302400_316800 0 1.563665e-07
I6430 n1_m1_302400_321600 0 2.516010e-07
I6431 n1_m1_302400_326400 0 2.073824e-07
I6432 n1_m1_302400_331200 0 2.699387e-07
I6433 n1_m1_302400_336000 0 3.969295e-07
I6434 n1_m1_302400_340800 0 2.851095e-07
I6435 n1_m1_302400_345600 0 3.608986e-07
I6436 n1_m1_302400_350400 0 1.945784e-07
I6437 n1_m1_302400_355200 0 1.722886e-07
I6438 n1_m1_302400_360000 0 2.359045e-07
I6439 n1_m1_302400_364800 0 1.444647e-07
I6440 n1_m1_302400_369600 0 2.282846e-07
I6441 n1_m1_302400_374400 0 2.472405e-07
I6442 n1_m1_302400_379200 0 3.856507e-07
I6443 n1_m1_302400_384000 0 1.059393e-06
I6444 n1_m1_302400_388800 0 3.812255e-07
I6445 n1_m1_302400_393600 0 4.289812e-07
I6446 n1_m1_302400_398400 0 2.013569e-07
I6447 n1_m1_302400_403200 0 1.680403e-07
I6448 n1_m1_302400_408000 0 2.272189e-07
I6449 n1_m1_302400_412800 0 1.423840e-07
I6450 n1_m1_302400_417600 0 2.169720e-07
I6451 n1_m1_302400_422400 0 1.419035e-07
I6452 n1_m1_302400_427200 0 1.407494e-07
I6453 n1_m1_302400_432000 0 2.108507e-07
I6454 n1_m1_302400_436800 0 1.423541e-07
I6455 n1_m1_302400_441600 0 2.115721e-07
I6456 n1_m1_302400_446400 0 1.418555e-07
I6457 n1_m1_302400_451200 0 1.420883e-07
I6458 n1_m1_302400_456000 0 2.227811e-07
I6459 n1_m1_302400_460800 0 1.508018e-07
I6460 n1_m1_302400_465600 0 2.146869e-07
I6461 n1_m1_302400_470400 0 1.525407e-07
I6462 n1_m1_302400_475200 0 1.618696e-07
I6463 n1_m1_302400_480000 0 2.351710e-07
I6464 n1_m1_307200_0 0 2.231615e-07
I6465 n1_m1_307200_4800 0 3.482258e-07
I6466 n1_m1_307200_9600 0 4.321958e-07
I6467 n1_m1_307200_14400 0 1.703093e-07
I6468 n1_m1_307200_19200 0 1.620919e-07
I6469 n1_m1_307200_24000 0 2.253231e-07
I6470 n1_m1_307200_28800 0 1.575832e-07
I6471 n1_m1_307200_33600 0 2.557536e-07
I6472 n1_m1_307200_38400 0 2.455122e-07
I6473 n1_m1_307200_43200 0 4.705215e-07
I6474 n1_m1_307200_48000 0 6.227914e-07
I6475 n1_m1_307200_52800 0 7.210477e-07
I6476 n1_m1_307200_57600 0 1.292650e-06
I6477 n1_m1_307200_62400 0 9.869859e-07
I6478 n1_m1_307200_67200 0 9.855251e-07
I6479 n1_m1_307200_72000 0 1.626181e-06
I6480 n1_m1_307200_76800 0 9.817939e-07
I6481 n1_m1_307200_81600 0 1.389668e-06
I6482 n1_m1_307200_86400 0 8.240956e-07
I6483 n1_m1_307200_91200 0 9.122943e-07
I6484 n1_m1_307200_96000 0 1.393955e-06
I6485 n1_m1_307200_100800 0 1.133656e-06
I6486 n1_m1_307200_105600 0 1.683664e-06
I6487 n1_m1_307200_110400 0 1.191228e-06
I6488 n1_m1_307200_115200 0 1.166885e-06
I6489 n1_m1_307200_120000 0 1.816156e-06
I6490 n1_m1_307200_124800 0 1.166283e-06
I6491 n1_m1_307200_129600 0 1.577181e-06
I6492 n1_m1_307200_134400 0 8.456813e-07
I6493 n1_m1_307200_139200 0 6.366058e-07
I6494 n1_m1_307200_144000 0 5.928417e-07
I6495 n1_m1_307200_148800 0 2.584002e-07
I6496 n1_m1_307200_153600 0 2.707926e-07
I6497 n1_m1_307200_158400 0 2.334602e-07
I6498 n1_m1_307200_163200 0 2.224996e-07
I6499 n1_m1_307200_168000 0 2.911656e-07
I6500 n1_m1_307200_172800 0 2.906791e-07
I6501 n1_m1_307200_177600 0 1.170238e-06
I6502 n1_m1_307200_182400 0 8.495971e-07
I6503 n1_m1_307200_187200 0 1.298810e-06
I6504 n1_m1_307200_192000 0 1.339441e-06
I6505 n1_m1_307200_196800 0 5.014689e-07
I6506 n1_m1_307200_201600 0 4.281482e-07
I6507 n1_m1_307200_206400 0 3.234664e-07
I6508 n1_m1_307200_211200 0 3.513272e-07
I6509 n1_m1_307200_216000 0 4.889856e-07
I6510 n1_m1_307200_220800 0 2.201916e-07
I6511 n1_m1_307200_225600 0 3.252732e-07
I6512 n1_m1_307200_230400 0 1.836652e-07
I6513 n1_m1_307200_235200 0 1.806139e-07
I6514 n1_m1_307200_240000 0 2.556908e-07
I6515 n1_m1_307200_244800 0 1.626845e-07
I6516 n1_m1_307200_249600 0 2.507949e-07
I6517 n1_m1_307200_254400 0 1.681799e-07
I6518 n1_m1_307200_259200 0 1.648068e-07
I6519 n1_m1_307200_264000 0 2.643874e-07
I6520 n1_m1_307200_268800 0 1.894525e-07
I6521 n1_m1_307200_273600 0 2.536997e-07
I6522 n1_m1_307200_278400 0 1.566938e-07
I6523 n1_m1_307200_283200 0 1.538553e-07
I6524 n1_m1_307200_288000 0 2.534539e-07
I6525 n1_m1_307200_292800 0 1.713203e-07
I6526 n1_m1_307200_297600 0 2.359063e-07
I6527 n1_m1_307200_302400 0 1.500608e-07
I6528 n1_m1_307200_307200 0 1.527717e-07
I6529 n1_m1_307200_312000 0 2.270850e-07
I6530 n1_m1_307200_316800 0 1.475984e-07
I6531 n1_m1_307200_321600 0 2.336287e-07
I6532 n1_m1_307200_326400 0 1.781987e-07
I6533 n1_m1_307200_331200 0 1.899123e-07
I6534 n1_m1_307200_336000 0 2.777973e-07
I6535 n1_m1_307200_340800 0 1.888629e-07
I6536 n1_m1_307200_345600 0 2.732513e-07
I6537 n1_m1_307200_350400 0 1.675259e-07
I6538 n1_m1_307200_355200 0 1.586652e-07
I6539 n1_m1_307200_360000 0 2.242470e-07
I6540 n1_m1_307200_364800 0 1.433665e-07
I6541 n1_m1_307200_369600 0 2.191083e-07
I6542 n1_m1_307200_374400 0 1.862066e-07
I6543 n1_m1_307200_379200 0 2.917113e-07
I6544 n1_m1_307200_384000 0 8.999288e-07
I6545 n1_m1_307200_388800 0 2.622704e-07
I6546 n1_m1_307200_393600 0 5.082453e-07
I6547 n1_m1_307200_398400 0 2.337677e-07
I6548 n1_m1_307200_403200 0 1.666625e-07
I6549 n1_m1_307200_408000 0 2.244687e-07
I6550 n1_m1_307200_412800 0 1.506572e-07
I6551 n1_m1_307200_417600 0 2.249471e-07
I6552 n1_m1_307200_422400 0 1.423541e-07
I6553 n1_m1_307200_427200 0 1.399040e-07
I6554 n1_m1_307200_432000 0 2.098560e-07
I6555 n1_m1_307200_436800 0 1.399040e-07
I6556 n1_m1_307200_441600 0 2.098560e-07
I6557 n1_m1_307200_446400 0 1.399040e-07
I6558 n1_m1_307200_451200 0 1.407988e-07
I6559 n1_m1_307200_456000 0 2.224092e-07
I6560 n1_m1_307200_460800 0 1.491576e-07
I6561 n1_m1_307200_465600 0 2.145672e-07
I6562 n1_m1_307200_470400 0 1.516452e-07
I6563 n1_m1_307200_475200 0 1.606198e-07
I6564 n1_m1_307200_480000 0 2.348362e-07
I6565 n1_m1_312000_0 0 3.645522e-07
I6566 n1_m1_312000_4800 0 5.937883e-07
I6567 n1_m1_312000_9600 0 7.503483e-07
I6568 n1_m1_312000_14400 0 2.859758e-07
I6569 n1_m1_312000_19200 0 2.605910e-07
I6570 n1_m1_312000_24000 0 3.461427e-07
I6571 n1_m1_312000_28800 0 2.213063e-07
I6572 n1_m1_312000_33600 0 3.495104e-07
I6573 n1_m1_312000_38400 0 3.673626e-07
I6574 n1_m1_312000_43200 0 8.440967e-07
I6575 n1_m1_312000_48000 0 1.531260e-06
I6576 n1_m1_312000_52800 0 1.596791e-06
I6577 n1_m1_312000_57600 0 2.540340e-06
I6578 n1_m1_312000_62400 0 1.661654e-06
I6579 n1_m1_312000_67200 0 1.668339e-06
I6580 n1_m1_312000_72000 0 2.637305e-06
I6581 n1_m1_312000_76800 0 1.715900e-06
I6582 n1_m1_312000_81600 0 2.596775e-06
I6583 n1_m1_312000_86400 0 1.682889e-06
I6584 n1_m1_312000_91200 0 1.681514e-06
I6585 n1_m1_312000_96000 0 2.396221e-06
I6586 n1_m1_312000_100800 0 1.643937e-06
I6587 n1_m1_312000_105600 0 2.407230e-06
I6588 n1_m1_312000_110400 0 1.716200e-06
I6589 n1_m1_312000_115200 0 1.762973e-06
I6590 n1_m1_312000_120000 0 2.907194e-06
I6591 n1_m1_312000_124800 0 1.885276e-06
I6592 n1_m1_312000_129600 0 2.500871e-06
I6593 n1_m1_312000_134400 0 1.278953e-06
I6594 n1_m1_312000_139200 0 9.066774e-07
I6595 n1_m1_312000_144000 0 8.330501e-07
I6596 n1_m1_312000_148800 0 4.264818e-07
I6597 n1_m1_312000_153600 0 3.813580e-07
I6598 n1_m1_312000_158400 0 2.629260e-07
I6599 n1_m1_312000_163200 0 2.577329e-07
I6600 n1_m1_312000_168000 0 3.795223e-07
I6601 n1_m1_312000_172800 0 2.841207e-07
I6602 n1_m1_312000_177600 0 1.212587e-06
I6603 n1_m1_312000_182400 0 9.390447e-07
I6604 n1_m1_312000_187200 0 1.794070e-06
I6605 n1_m1_312000_192000 0 1.820340e-06
I6606 n1_m1_312000_196800 0 1.228320e-06
I6607 n1_m1_312000_201600 0 8.463753e-07
I6608 n1_m1_312000_206400 0 4.391170e-07
I6609 n1_m1_312000_211200 0 3.336838e-07
I6610 n1_m1_312000_216000 0 5.754315e-07
I6611 n1_m1_312000_220800 0 3.363466e-07
I6612 n1_m1_312000_225600 0 4.140866e-07
I6613 n1_m1_312000_230400 0 2.500373e-07
I6614 n1_m1_312000_235200 0 3.157159e-07
I6615 n1_m1_312000_240000 0 3.916511e-07
I6616 n1_m1_312000_244800 0 2.505834e-07
I6617 n1_m1_312000_249600 0 3.762924e-07
I6618 n1_m1_312000_254400 0 2.593443e-07
I6619 n1_m1_312000_259200 0 2.602874e-07
I6620 n1_m1_312000_264000 0 3.740388e-07
I6621 n1_m1_312000_268800 0 2.377130e-07
I6622 n1_m1_312000_273600 0 3.662927e-07
I6623 n1_m1_312000_278400 0 2.399316e-07
I6624 n1_m1_312000_283200 0 2.370549e-07
I6625 n1_m1_312000_288000 0 3.599522e-07
I6626 n1_m1_312000_292800 0 2.360644e-07
I6627 n1_m1_312000_297600 0 3.448266e-07
I6628 n1_m1_312000_302400 0 2.217543e-07
I6629 n1_m1_312000_307200 0 2.205586e-07
I6630 n1_m1_312000_312000 0 3.286264e-07
I6631 n1_m1_312000_316800 0 2.162428e-07
I6632 n1_m1_312000_321600 0 3.279643e-07
I6633 n1_m1_312000_326400 0 2.304707e-07
I6634 n1_m1_312000_331200 0 2.335481e-07
I6635 n1_m1_312000_336000 0 3.461182e-07
I6636 n1_m1_312000_340800 0 2.374058e-07
I6637 n1_m1_312000_345600 0 3.613550e-07
I6638 n1_m1_312000_350400 0 2.401789e-07
I6639 n1_m1_312000_355200 0 2.333522e-07
I6640 n1_m1_312000_360000 0 3.322203e-07
I6641 n1_m1_312000_364800 0 2.166039e-07
I6642 n1_m1_312000_369600 0 3.236783e-07
I6643 n1_m1_312000_374400 0 2.471145e-07
I6644 n1_m1_312000_379200 0 3.630608e-07
I6645 n1_m1_312000_384000 0 1.171406e-06
I6646 n1_m1_312000_388800 0 5.772031e-07
I6647 n1_m1_312000_393600 0 8.246311e-07
I6648 n1_m1_312000_398400 0 3.183577e-07
I6649 n1_m1_312000_403200 0 2.403860e-07
I6650 n1_m1_312000_408000 0 3.308970e-07
I6651 n1_m1_312000_412800 0 2.253518e-07
I6652 n1_m1_312000_417600 0 3.356854e-07
I6653 n1_m1_312000_422400 0 2.135311e-07
I6654 n1_m1_312000_427200 0 2.098560e-07
I6655 n1_m1_312000_432000 0 3.147839e-07
I6656 n1_m1_312000_436800 0 2.098560e-07
I6657 n1_m1_312000_441600 0 3.147839e-07
I6658 n1_m1_312000_446400 0 2.098560e-07
I6659 n1_m1_312000_451200 0 2.099826e-07
I6660 n1_m1_312000_456000 0 3.222077e-07
I6661 n1_m1_312000_460800 0 2.201163e-07
I6662 n1_m1_312000_465600 0 3.314186e-07
I6663 n1_m1_312000_470400 0 2.367043e-07
I6664 n1_m1_312000_475200 0 2.512093e-07
I6665 n1_m1_312000_480000 0 3.576992e-07
I6666 n1_m1_316800_0 0 2.198063e-07
I6667 n1_m1_316800_4800 0 3.157712e-07
I6668 n1_m1_316800_9600 0 3.843172e-07
I6669 n1_m1_316800_14400 0 1.792218e-07
I6670 n1_m1_316800_19200 0 1.639755e-07
I6671 n1_m1_316800_24000 0 2.217016e-07
I6672 n1_m1_316800_28800 0 1.482980e-07
I6673 n1_m1_316800_33600 0 2.250953e-07
I6674 n1_m1_316800_38400 0 1.771226e-07
I6675 n1_m1_316800_43200 0 2.704106e-07
I6676 n1_m1_316800_48000 0 5.072487e-07
I6677 n1_m1_316800_52800 0 5.048379e-07
I6678 n1_m1_316800_57600 0 7.726760e-07
I6679 n1_m1_316800_62400 0 4.372008e-07
I6680 n1_m1_316800_67200 0 4.162765e-07
I6681 n1_m1_316800_72000 0 6.577213e-07
I6682 n1_m1_316800_76800 0 4.402979e-07
I6683 n1_m1_316800_81600 0 7.498517e-07
I6684 n1_m1_316800_86400 0 5.229790e-07
I6685 n1_m1_316800_91200 0 4.710950e-07
I6686 n1_m1_316800_96000 0 6.106944e-07
I6687 n1_m1_316800_100800 0 4.115778e-07
I6688 n1_m1_316800_105600 0 6.110743e-07
I6689 n1_m1_316800_110400 0 5.130874e-07
I6690 n1_m1_316800_115200 0 5.873560e-07
I6691 n1_m1_316800_120000 0 1.367521e-06
I6692 n1_m1_316800_124800 0 1.013144e-06
I6693 n1_m1_316800_129600 0 1.240076e-06
I6694 n1_m1_316800_134400 0 5.185080e-07
I6695 n1_m1_316800_139200 0 3.533516e-07
I6696 n1_m1_316800_144000 0 2.962157e-07
I6697 n1_m1_316800_148800 0 1.896694e-07
I6698 n1_m1_316800_153600 0 2.561195e-07
I6699 n1_m1_316800_158400 0 1.624081e-07
I6700 n1_m1_316800_163200 0 1.525653e-07
I6701 n1_m1_316800_168000 0 2.357886e-07
I6702 n1_m1_316800_172800 0 1.749602e-07
I6703 n1_m1_316800_177600 0 6.531901e-07
I6704 n1_m1_316800_182400 0 4.956048e-07
I6705 n1_m1_316800_187200 0 9.113149e-07
I6706 n1_m1_316800_192000 0 1.336229e-06
I6707 n1_m1_316800_196800 0 1.051720e-06
I6708 n1_m1_316800_201600 0 5.483287e-07
I6709 n1_m1_316800_206400 0 2.719895e-07
I6710 n1_m1_316800_211200 0 1.958316e-07
I6711 n1_m1_316800_216000 0 7.420102e-07
I6712 n1_m1_316800_220800 0 2.402727e-07
I6713 n1_m1_316800_225600 0 3.491980e-07
I6714 n1_m1_316800_230400 0 1.966150e-07
I6715 n1_m1_316800_235200 0 1.774552e-07
I6716 n1_m1_316800_240000 0 3.308549e-07
I6717 n1_m1_316800_244800 0 1.655062e-07
I6718 n1_m1_316800_249600 0 2.443871e-07
I6719 n1_m1_316800_254400 0 1.657716e-07
I6720 n1_m1_316800_259200 0 1.699906e-07
I6721 n1_m1_316800_264000 0 2.558199e-07
I6722 n1_m1_316800_268800 0 1.610878e-07
I6723 n1_m1_316800_273600 0 2.411485e-07
I6724 n1_m1_316800_278400 0 1.647544e-07
I6725 n1_m1_316800_283200 0 1.665524e-07
I6726 n1_m1_316800_288000 0 2.368013e-07
I6727 n1_m1_316800_292800 0 1.532447e-07
I6728 n1_m1_316800_297600 0 2.294981e-07
I6729 n1_m1_316800_302400 0 1.477911e-07
I6730 n1_m1_316800_307200 0 1.465661e-07
I6731 n1_m1_316800_312000 0 2.162428e-07
I6732 n1_m1_316800_316800 0 1.399040e-07
I6733 n1_m1_316800_321600 0 2.104573e-07
I6734 n1_m1_316800_326400 0 1.425467e-07
I6735 n1_m1_316800_331200 0 1.425743e-07
I6736 n1_m1_316800_336000 0 2.195876e-07
I6737 n1_m1_316800_340800 0 1.495178e-07
I6738 n1_m1_316800_345600 0 2.253847e-07
I6739 n1_m1_316800_350400 0 1.479150e-07
I6740 n1_m1_316800_355200 0 1.461826e-07
I6741 n1_m1_316800_360000 0 2.114940e-07
I6742 n1_m1_316800_364800 0 1.444612e-07
I6743 n1_m1_316800_369600 0 2.145363e-07
I6744 n1_m1_316800_374400 0 1.501131e-07
I6745 n1_m1_316800_379200 0 1.648817e-07
I6746 n1_m1_316800_384000 0 3.254374e-07
I6747 n1_m1_316800_388800 0 1.804243e-07
I6748 n1_m1_316800_393600 0 3.103237e-07
I6749 n1_m1_316800_398400 0 1.711411e-07
I6750 n1_m1_316800_403200 0 1.584439e-07
I6751 n1_m1_316800_408000 0 2.186450e-07
I6752 n1_m1_316800_412800 0 1.425743e-07
I6753 n1_m1_316800_417600 0 2.161543e-07
I6754 n1_m1_316800_422400 0 1.423541e-07
I6755 n1_m1_316800_427200 0 1.399040e-07
I6756 n1_m1_316800_432000 0 2.098560e-07
I6757 n1_m1_316800_436800 0 1.399040e-07
I6758 n1_m1_316800_441600 0 2.098560e-07
I6759 n1_m1_316800_446400 0 1.399040e-07
I6760 n1_m1_316800_451200 0 1.399040e-07
I6761 n1_m1_316800_456000 0 2.115222e-07
I6762 n1_m1_316800_460800 0 1.452960e-07
I6763 n1_m1_316800_465600 0 2.227107e-07
I6764 n1_m1_316800_470400 0 1.624413e-07
I6765 n1_m1_316800_475200 0 1.706542e-07
I6766 n1_m1_316800_480000 0 2.388443e-07
I6767 n1_m1_321600_0 0 2.607936e-07
I6768 n1_m1_321600_4800 0 2.964421e-07
I6769 n1_m1_321600_9600 0 3.881188e-07
I6770 n1_m1_321600_14400 0 2.262203e-07
I6771 n1_m1_321600_19200 0 2.109872e-07
I6772 n1_m1_321600_24000 0 3.073688e-07
I6773 n1_m1_321600_28800 0 2.089385e-07
I6774 n1_m1_321600_33600 0 3.113941e-07
I6775 n1_m1_321600_38400 0 2.187287e-07
I6776 n1_m1_321600_43200 0 2.249764e-07
I6777 n1_m1_321600_48000 0 3.777524e-07
I6778 n1_m1_321600_52800 0 2.806395e-07
I6779 n1_m1_321600_57600 0 3.986834e-07
I6780 n1_m1_321600_62400 0 2.384152e-07
I6781 n1_m1_321600_67200 0 2.288022e-07
I6782 n1_m1_321600_72000 0 3.466997e-07
I6783 n1_m1_321600_76800 0 2.442189e-07
I6784 n1_m1_321600_81600 0 4.089134e-07
I6785 n1_m1_321600_86400 0 2.777528e-07
I6786 n1_m1_321600_91200 0 2.546983e-07
I6787 n1_m1_321600_96000 0 3.605786e-07
I6788 n1_m1_321600_100800 0 2.430154e-07
I6789 n1_m1_321600_105600 0 3.586138e-07
I6790 n1_m1_321600_110400 0 2.818262e-07
I6791 n1_m1_321600_115200 0 3.438306e-07
I6792 n1_m1_321600_120000 0 8.791165e-07
I6793 n1_m1_321600_124800 0 7.524955e-07
I6794 n1_m1_321600_129600 0 9.367168e-07
I6795 n1_m1_321600_134400 0 3.922772e-07
I6796 n1_m1_321600_139200 0 3.333737e-07
I6797 n1_m1_321600_144000 0 3.545770e-07
I6798 n1_m1_321600_148800 0 2.437896e-07
I6799 n1_m1_321600_153600 0 3.530524e-07
I6800 n1_m1_321600_158400 0 2.386576e-07
I6801 n1_m1_321600_163200 0 2.249019e-07
I6802 n1_m1_321600_168000 0 3.441390e-07
I6803 n1_m1_321600_172800 0 2.344876e-07
I6804 n1_m1_321600_177600 0 6.683308e-07
I6805 n1_m1_321600_182400 0 6.175414e-07
I6806 n1_m1_321600_187200 0 1.027436e-06
I6807 n1_m1_321600_192000 0 1.407662e-06
I6808 n1_m1_321600_196800 0 7.832887e-07
I6809 n1_m1_321600_201600 0 8.514651e-07
I6810 n1_m1_321600_206400 0 2.742572e-07
I6811 n1_m1_321600_211200 0 2.761740e-07
I6812 n1_m1_321600_216000 0 6.543291e-07
I6813 n1_m1_321600_220800 0 3.102800e-07
I6814 n1_m1_321600_225600 0 4.539905e-07
I6815 n1_m1_321600_230400 0 2.692568e-07
I6816 n1_m1_321600_235200 0 3.639763e-07
I6817 n1_m1_321600_240000 0 4.357014e-07
I6818 n1_m1_321600_244800 0 2.527990e-07
I6819 n1_m1_321600_249600 0 3.646590e-07
I6820 n1_m1_321600_254400 0 2.395316e-07
I6821 n1_m1_321600_259200 0 2.395373e-07
I6822 n1_m1_321600_264000 0 3.641017e-07
I6823 n1_m1_321600_268800 0 2.463664e-07
I6824 n1_m1_321600_273600 0 3.537949e-07
I6825 n1_m1_321600_278400 0 2.395908e-07
I6826 n1_m1_321600_283200 0 2.415313e-07
I6827 n1_m1_321600_288000 0 3.506213e-07
I6828 n1_m1_321600_292800 0 2.309551e-07
I6829 n1_m1_321600_297600 0 3.400156e-07
I6830 n1_m1_321600_302400 0 2.273184e-07
I6831 n1_m1_321600_307200 0 2.211118e-07
I6832 n1_m1_321600_312000 0 3.264753e-07
I6833 n1_m1_321600_316800 0 2.169628e-07
I6834 n1_m1_321600_321600 0 3.263463e-07
I6835 n1_m1_321600_326400 0 2.110547e-07
I6836 n1_m1_321600_331200 0 2.103085e-07
I6837 n1_m1_321600_336000 0 3.189984e-07
I6838 n1_m1_321600_340800 0 2.136412e-07
I6839 n1_m1_321600_345600 0 3.184441e-07
I6840 n1_m1_321600_350400 0 2.098560e-07
I6841 n1_m1_321600_355200 0 2.058285e-07
I6842 n1_m1_321600_360000 0 3.040365e-07
I6843 n1_m1_321600_364800 0 2.084701e-07
I6844 n1_m1_321600_369600 0 3.189624e-07
I6845 n1_m1_321600_374400 0 2.224020e-07
I6846 n1_m1_321600_379200 0 2.281704e-07
I6847 n1_m1_321600_384000 0 3.702292e-07
I6848 n1_m1_321600_388800 0 2.461072e-07
I6849 n1_m1_321600_393600 0 3.390626e-07
I6850 n1_m1_321600_398400 0 2.295924e-07
I6851 n1_m1_321600_403200 0 2.339219e-07
I6852 n1_m1_321600_408000 0 3.251117e-07
I6853 n1_m1_321600_412800 0 2.041863e-07
I6854 n1_m1_321600_417600 0 3.196797e-07
I6855 n1_m1_321600_422400 0 2.135311e-07
I6856 n1_m1_321600_427200 0 2.098560e-07
I6857 n1_m1_321600_432000 0 3.147839e-07
I6858 n1_m1_321600_436800 0 2.098560e-07
I6859 n1_m1_321600_441600 0 3.147839e-07
I6860 n1_m1_321600_446400 0 2.098560e-07
I6861 n1_m1_321600_451200 0 2.098560e-07
I6862 n1_m1_321600_456000 0 3.147839e-07
I6863 n1_m1_321600_460800 0 2.166695e-07
I6864 n1_m1_321600_465600 0 3.355449e-07
I6865 n1_m1_321600_470400 0 2.498867e-07
I6866 n1_m1_321600_475200 0 2.607273e-07
I6867 n1_m1_321600_480000 0 3.582665e-07
I6868 n1_m1_326400_0 0 1.681142e-07
I6869 n1_m1_326400_4800 0 1.776165e-07
I6870 n1_m1_326400_9600 0 2.397574e-07
I6871 n1_m1_326400_14400 0 1.459134e-07
I6872 n1_m1_326400_19200 0 1.385386e-07
I6873 n1_m1_326400_24000 0 2.012320e-07
I6874 n1_m1_326400_28800 0 1.342393e-07
I6875 n1_m1_326400_33600 0 2.104929e-07
I6876 n1_m1_326400_38400 0 1.389155e-07
I6877 n1_m1_326400_43200 0 1.397373e-07
I6878 n1_m1_326400_48000 0 2.127969e-07
I6879 n1_m1_326400_52800 0 1.351212e-07
I6880 n1_m1_326400_57600 0 2.078821e-07
I6881 n1_m1_326400_62400 0 1.352951e-07
I6882 n1_m1_326400_67200 0 1.413564e-07
I6883 n1_m1_326400_72000 0 2.090576e-07
I6884 n1_m1_326400_76800 0 1.450373e-07
I6885 n1_m1_326400_81600 0 2.274572e-07
I6886 n1_m1_326400_86400 0 1.416876e-07
I6887 n1_m1_326400_91200 0 1.406237e-07
I6888 n1_m1_326400_96000 0 2.124884e-07
I6889 n1_m1_326400_100800 0 1.447688e-07
I6890 n1_m1_326400_105600 0 2.161984e-07
I6891 n1_m1_326400_110400 0 1.484984e-07
I6892 n1_m1_326400_115200 0 1.450665e-07
I6893 n1_m1_326400_120000 0 2.548282e-07
I6894 n1_m1_326400_124800 0 2.589000e-07
I6895 n1_m1_326400_129600 0 4.200500e-07
I6896 n1_m1_326400_134400 0 3.203768e-07
I6897 n1_m1_326400_139200 0 3.280721e-07
I6898 n1_m1_326400_144000 0 4.022668e-07
I6899 n1_m1_326400_148800 0 2.374126e-07
I6900 n1_m1_326400_153600 0 2.371612e-07
I6901 n1_m1_326400_158400 0 1.620243e-07
I6902 n1_m1_326400_163200 0 1.504017e-07
I6903 n1_m1_326400_168000 0 2.242148e-07
I6904 n1_m1_326400_172800 0 1.515911e-07
I6905 n1_m1_326400_177600 0 4.343359e-07
I6906 n1_m1_326400_182400 0 5.019993e-07
I6907 n1_m1_326400_187200 0 1.026326e-06
I6908 n1_m1_326400_192000 0 8.988610e-07
I6909 n1_m1_326400_196800 0 5.971343e-07
I6910 n1_m1_326400_201600 0 8.468117e-07
I6911 n1_m1_326400_206400 0 1.944494e-07
I6912 n1_m1_326400_211200 0 2.589291e-07
I6913 n1_m1_326400_216000 0 5.359221e-07
I6914 n1_m1_326400_220800 0 3.153372e-07
I6915 n1_m1_326400_225600 0 4.466425e-07
I6916 n1_m1_326400_230400 0 2.439109e-07
I6917 n1_m1_326400_235200 0 3.537500e-07
I6918 n1_m1_326400_240000 0 2.839558e-07
I6919 n1_m1_326400_244800 0 1.697899e-07
I6920 n1_m1_326400_249600 0 2.492893e-07
I6921 n1_m1_326400_254400 0 1.573100e-07
I6922 n1_m1_326400_259200 0 1.533071e-07
I6923 n1_m1_326400_264000 0 2.360794e-07
I6924 n1_m1_326400_268800 0 1.692191e-07
I6925 n1_m1_326400_273600 0 2.351644e-07
I6926 n1_m1_326400_278400 0 1.549900e-07
I6927 n1_m1_326400_283200 0 1.579666e-07
I6928 n1_m1_326400_288000 0 2.421164e-07
I6929 n1_m1_326400_292800 0 1.614942e-07
I6930 n1_m1_326400_297600 0 2.337511e-07
I6931 n1_m1_326400_302400 0 1.579760e-07
I6932 n1_m1_326400_307200 0 1.493288e-07
I6933 n1_m1_326400_312000 0 2.124133e-07
I6934 n1_m1_326400_316800 0 1.439233e-07
I6935 n1_m1_326400_321600 0 2.259773e-07
I6936 n1_m1_326400_326400 0 1.453208e-07
I6937 n1_m1_326400_331200 0 1.425645e-07
I6938 n1_m1_326400_336000 0 2.172063e-07
I6939 n1_m1_326400_340800 0 1.448042e-07
I6940 n1_m1_326400_345600 0 2.145942e-07
I6941 n1_m1_326400_350400 0 1.399040e-07
I6942 n1_m1_326400_355200 0 1.398593e-07
I6943 n1_m1_326400_360000 0 2.117796e-07
I6944 n1_m1_326400_364800 0 1.484594e-07
I6945 n1_m1_326400_369600 0 2.200410e-07
I6946 n1_m1_326400_374400 0 1.413332e-07
I6947 n1_m1_326400_379200 0 1.440248e-07
I6948 n1_m1_326400_384000 0 2.171926e-07
I6949 n1_m1_326400_388800 0 1.465446e-07
I6950 n1_m1_326400_393600 0 2.199966e-07
I6951 n1_m1_326400_398400 0 1.473329e-07
I6952 n1_m1_326400_403200 0 1.449871e-07
I6953 n1_m1_326400_408000 0 2.125564e-07
I6954 n1_m1_326400_412800 0 1.374944e-07
I6955 n1_m1_326400_417600 0 2.123513e-07
I6956 n1_m1_326400_422400 0 1.417314e-07
I6957 n1_m1_326400_427200 0 1.399040e-07
I6958 n1_m1_326400_432000 0 2.098560e-07
I6959 n1_m1_326400_436800 0 1.399040e-07
I6960 n1_m1_326400_441600 0 2.098560e-07
I6961 n1_m1_326400_446400 0 1.399040e-07
I6962 n1_m1_326400_451200 0 1.399040e-07
I6963 n1_m1_326400_456000 0 2.098560e-07
I6964 n1_m1_326400_460800 0 1.432920e-07
I6965 n1_m1_326400_465600 0 2.247546e-07
I6966 n1_m1_326400_470400 0 1.708556e-07
I6967 n1_m1_326400_475200 0 1.747561e-07
I6968 n1_m1_326400_480000 0 2.374486e-07
I6969 n1_m1_331200_0 0 1.737819e-07
I6970 n1_m1_331200_4800 0 1.823049e-07
I6971 n1_m1_331200_9600 0 2.429105e-07
I6972 n1_m1_331200_14400 0 1.526117e-07
I6973 n1_m1_331200_19200 0 1.464634e-07
I6974 n1_m1_331200_24000 0 2.047291e-07
I6975 n1_m1_331200_28800 0 1.378853e-07
I6976 n1_m1_331200_33600 0 2.186802e-07
I6977 n1_m1_331200_38400 0 1.393753e-07
I6978 n1_m1_331200_43200 0 1.460473e-07
I6979 n1_m1_331200_48000 0 2.154209e-07
I6980 n1_m1_331200_52800 0 1.390485e-07
I6981 n1_m1_331200_57600 0 2.234096e-07
I6982 n1_m1_331200_62400 0 1.405961e-07
I6983 n1_m1_331200_67200 0 1.442488e-07
I6984 n1_m1_331200_72000 0 2.136431e-07
I6985 n1_m1_331200_76800 0 1.515902e-07
I6986 n1_m1_331200_81600 0 2.420806e-07
I6987 n1_m1_331200_86400 0 1.499341e-07
I6988 n1_m1_331200_91200 0 1.438011e-07
I6989 n1_m1_331200_96000 0 2.192531e-07
I6990 n1_m1_331200_100800 0 1.483155e-07
I6991 n1_m1_331200_105600 0 2.169560e-07
I6992 n1_m1_331200_110400 0 1.462900e-07
I6993 n1_m1_331200_115200 0 1.482346e-07
I6994 n1_m1_331200_120000 0 2.617440e-07
I6995 n1_m1_331200_124800 0 4.799596e-07
I6996 n1_m1_331200_129600 0 6.997775e-07
I6997 n1_m1_331200_134400 0 5.845397e-07
I6998 n1_m1_331200_139200 0 5.848017e-07
I6999 n1_m1_331200_144000 0 7.320813e-07
I7000 n1_m1_331200_148800 0 5.123587e-07
I7001 n1_m1_331200_153600 0 3.286374e-07
I7002 n1_m1_331200_158400 0 1.778215e-07
I7003 n1_m1_331200_163200 0 1.561545e-07
I7004 n1_m1_331200_168000 0 2.186690e-07
I7005 n1_m1_331200_172800 0 1.499004e-07
I7006 n1_m1_331200_177600 0 7.281790e-07
I7007 n1_m1_331200_182400 0 5.480617e-07
I7008 n1_m1_331200_187200 0 1.157375e-06
I7009 n1_m1_331200_192000 0 1.330370e-06
I7010 n1_m1_331200_196800 0 8.586132e-07
I7011 n1_m1_331200_201600 0 4.081657e-07
I7012 n1_m1_331200_206400 0 4.037425e-07
I7013 n1_m1_331200_211200 0 6.075043e-07
I7014 n1_m1_331200_216000 0 9.873739e-07
I7015 n1_m1_331200_220800 0 2.543206e-07
I7016 n1_m1_331200_225600 0 5.586373e-07
I7017 n1_m1_331200_230400 0 3.708556e-07
I7018 n1_m1_331200_235200 0 2.277697e-07
I7019 n1_m1_331200_240000 0 2.710044e-07
I7020 n1_m1_331200_244800 0 1.598903e-07
I7021 n1_m1_331200_249600 0 2.408807e-07
I7022 n1_m1_331200_254400 0 1.535165e-07
I7023 n1_m1_331200_259200 0 1.532282e-07
I7024 n1_m1_331200_264000 0 2.341679e-07
I7025 n1_m1_331200_268800 0 1.650652e-07
I7026 n1_m1_331200_273600 0 2.406824e-07
I7027 n1_m1_331200_278400 0 1.569754e-07
I7028 n1_m1_331200_283200 0 1.700879e-07
I7029 n1_m1_331200_288000 0 2.500359e-07
I7030 n1_m1_331200_292800 0 1.654361e-07
I7031 n1_m1_331200_297600 0 2.615023e-07
I7032 n1_m1_331200_302400 0 1.630488e-07
I7033 n1_m1_331200_307200 0 1.534396e-07
I7034 n1_m1_331200_312000 0 2.198436e-07
I7035 n1_m1_331200_316800 0 1.434971e-07
I7036 n1_m1_331200_321600 0 2.216225e-07
I7037 n1_m1_331200_326400 0 1.465934e-07
I7038 n1_m1_331200_331200 0 1.445564e-07
I7039 n1_m1_331200_336000 0 2.098560e-07
I7040 n1_m1_331200_340800 0 1.399040e-07
I7041 n1_m1_331200_345600 0 2.098560e-07
I7042 n1_m1_331200_350400 0 1.399040e-07
I7043 n1_m1_331200_355200 0 1.399040e-07
I7044 n1_m1_331200_360000 0 2.091953e-07
I7045 n1_m1_331200_364800 0 1.380365e-07
I7046 n1_m1_331200_369600 0 2.100013e-07
I7047 n1_m1_331200_374400 0 1.432021e-07
I7048 n1_m1_331200_379200 0 1.542635e-07
I7049 n1_m1_331200_384000 0 2.330552e-07
I7050 n1_m1_331200_388800 0 1.663744e-07
I7051 n1_m1_331200_393600 0 2.401250e-07
I7052 n1_m1_331200_398400 0 1.485655e-07
I7053 n1_m1_331200_403200 0 1.419136e-07
I7054 n1_m1_331200_408000 0 2.153277e-07
I7055 n1_m1_331200_412800 0 1.488235e-07
I7056 n1_m1_331200_417600 0 2.143058e-07
I7057 n1_m1_331200_422400 0 1.399040e-07
I7058 n1_m1_331200_427200 0 1.399040e-07
I7059 n1_m1_331200_432000 0 2.098560e-07
I7060 n1_m1_331200_436800 0 1.399040e-07
I7061 n1_m1_331200_441600 0 2.098560e-07
I7062 n1_m1_331200_446400 0 1.399040e-07
I7063 n1_m1_331200_451200 0 1.405102e-07
I7064 n1_m1_331200_456000 0 2.142905e-07
I7065 n1_m1_331200_460800 0 1.419136e-07
I7066 n1_m1_331200_465600 0 2.209696e-07
I7067 n1_m1_331200_470400 0 1.675387e-07
I7068 n1_m1_331200_475200 0 1.735187e-07
I7069 n1_m1_331200_480000 0 2.333522e-07
I7070 n1_m1_336000_0 0 2.508107e-07
I7071 n1_m1_336000_4800 0 2.722049e-07
I7072 n1_m1_336000_9600 0 3.500973e-07
I7073 n1_m1_336000_14400 0 2.094835e-07
I7074 n1_m1_336000_19200 0 2.052548e-07
I7075 n1_m1_336000_24000 0 3.022892e-07
I7076 n1_m1_336000_28800 0 2.066143e-07
I7077 n1_m1_336000_33600 0 3.147839e-07
I7078 n1_m1_336000_38400 0 2.098560e-07
I7079 n1_m1_336000_43200 0 2.088987e-07
I7080 n1_m1_336000_48000 0 3.071004e-07
I7081 n1_m1_336000_52800 0 2.080856e-07
I7082 n1_m1_336000_57600 0 3.121014e-07
I7083 n1_m1_336000_62400 0 2.065670e-07
I7084 n1_m1_336000_67200 0 2.096097e-07
I7085 n1_m1_336000_72000 0 3.178952e-07
I7086 n1_m1_336000_76800 0 2.342640e-07
I7087 n1_m1_336000_81600 0 3.878117e-07
I7088 n1_m1_336000_86400 0 2.368927e-07
I7089 n1_m1_336000_91200 0 2.213461e-07
I7090 n1_m1_336000_96000 0 3.238870e-07
I7091 n1_m1_336000_100800 0 2.195818e-07
I7092 n1_m1_336000_105600 0 3.193670e-07
I7093 n1_m1_336000_110400 0 2.132238e-07
I7094 n1_m1_336000_115200 0 2.350935e-07
I7095 n1_m1_336000_120000 0 4.040559e-07
I7096 n1_m1_336000_124800 0 1.066862e-06
I7097 n1_m1_336000_129600 0 1.121039e-06
I7098 n1_m1_336000_134400 0 6.669932e-07
I7099 n1_m1_336000_139200 0 4.685335e-07
I7100 n1_m1_336000_144000 0 4.713238e-07
I7101 n1_m1_336000_148800 0 5.991716e-07
I7102 n1_m1_336000_153600 0 5.125159e-07
I7103 n1_m1_336000_158400 0 2.632927e-07
I7104 n1_m1_336000_163200 0 2.366528e-07
I7105 n1_m1_336000_168000 0 3.446950e-07
I7106 n1_m1_336000_172800 0 2.322378e-07
I7107 n1_m1_336000_177600 0 1.800484e-06
I7108 n1_m1_336000_182400 0 7.482729e-07
I7109 n1_m1_336000_187200 0 1.304060e-06
I7110 n1_m1_336000_192000 0 1.466936e-06
I7111 n1_m1_336000_196800 0 1.145352e-06
I7112 n1_m1_336000_201600 0 5.985336e-07
I7113 n1_m1_336000_206400 0 6.731203e-07
I7114 n1_m1_336000_211200 0 8.070352e-07
I7115 n1_m1_336000_216000 0 1.248171e-06
I7116 n1_m1_336000_220800 0 4.658195e-07
I7117 n1_m1_336000_225600 0 7.414298e-07
I7118 n1_m1_336000_230400 0 3.325516e-07
I7119 n1_m1_336000_235200 0 2.950638e-07
I7120 n1_m1_336000_240000 0 4.156805e-07
I7121 n1_m1_336000_244800 0 2.480933e-07
I7122 n1_m1_336000_249600 0 3.566246e-07
I7123 n1_m1_336000_254400 0 2.378517e-07
I7124 n1_m1_336000_259200 0 2.510699e-07
I7125 n1_m1_336000_264000 0 3.856488e-07
I7126 n1_m1_336000_268800 0 2.394949e-07
I7127 n1_m1_336000_273600 0 3.541754e-07
I7128 n1_m1_336000_278400 0 2.307793e-07
I7129 n1_m1_336000_283200 0 2.562712e-07
I7130 n1_m1_336000_288000 0 3.869871e-07
I7131 n1_m1_336000_292800 0 3.361295e-07
I7132 n1_m1_336000_297600 0 4.041995e-07
I7133 n1_m1_336000_302400 0 2.489711e-07
I7134 n1_m1_336000_307200 0 2.354969e-07
I7135 n1_m1_336000_312000 0 3.397157e-07
I7136 n1_m1_336000_316800 0 2.141666e-07
I7137 n1_m1_336000_321600 0 3.225448e-07
I7138 n1_m1_336000_326400 0 2.198050e-07
I7139 n1_m1_336000_331200 0 2.168346e-07
I7140 n1_m1_336000_336000 0 3.152217e-07
I7141 n1_m1_336000_340800 0 2.103653e-07
I7142 n1_m1_336000_345600 0 3.155479e-07
I7143 n1_m1_336000_350400 0 2.103653e-07
I7144 n1_m1_336000_355200 0 2.137497e-07
I7145 n1_m1_336000_360000 0 3.230083e-07
I7146 n1_m1_336000_364800 0 2.128711e-07
I7147 n1_m1_336000_369600 0 3.155066e-07
I7148 n1_m1_336000_374400 0 2.186500e-07
I7149 n1_m1_336000_379200 0 2.229877e-07
I7150 n1_m1_336000_384000 0 3.363425e-07
I7151 n1_m1_336000_388800 0 2.559538e-07
I7152 n1_m1_336000_393600 0 3.751229e-07
I7153 n1_m1_336000_398400 0 2.403616e-07
I7154 n1_m1_336000_403200 0 2.277081e-07
I7155 n1_m1_336000_408000 0 3.345385e-07
I7156 n1_m1_336000_412800 0 2.317494e-07
I7157 n1_m1_336000_417600 0 3.332795e-07
I7158 n1_m1_336000_422400 0 2.134762e-07
I7159 n1_m1_336000_427200 0 2.119820e-07
I7160 n1_m1_336000_432000 0 3.149155e-07
I7161 n1_m1_336000_436800 0 2.098560e-07
I7162 n1_m1_336000_441600 0 3.148313e-07
I7163 n1_m1_336000_446400 0 2.109286e-07
I7164 n1_m1_336000_451200 0 2.161996e-07
I7165 n1_m1_336000_456000 0 3.323858e-07
I7166 n1_m1_336000_460800 0 2.230588e-07
I7167 n1_m1_336000_465600 0 3.370590e-07
I7168 n1_m1_336000_470400 0 2.487026e-07
I7169 n1_m1_336000_475200 0 2.591933e-07
I7170 n1_m1_336000_480000 0 3.500284e-07
I7171 n1_m1_340800_0 0 8.611170e-08
I7172 n1_m1_340800_4800 0 9.826589e-08
I7173 n1_m1_340800_9600 0 1.196906e-07
I7174 n1_m1_340800_14400 0 6.802909e-08
I7175 n1_m1_340800_19200 0 6.730408e-08
I7176 n1_m1_340800_24000 0 1.000779e-07
I7177 n1_m1_340800_28800 0 6.776164e-08
I7178 n1_m1_340800_33600 0 1.038750e-07
I7179 n1_m1_340800_38400 0 6.924999e-08
I7180 n1_m1_340800_43200 0 6.872309e-08
I7181 n1_m1_340800_48000 0 1.000238e-07
I7182 n1_m1_340800_52800 0 6.662094e-08
I7183 n1_m1_340800_57600 0 9.993141e-08
I7184 n1_m1_340800_62400 0 6.773992e-08
I7185 n1_m1_340800_67200 0 6.797892e-08
I7186 n1_m1_340800_72000 0 1.039015e-07
I7187 n1_m1_340800_76800 0 7.741963e-08
I7188 n1_m1_340800_81600 0 1.246527e-07
I7189 n1_m1_340800_86400 0 7.812819e-08
I7190 n1_m1_340800_91200 0 7.123898e-08
I7191 n1_m1_340800_96000 0 1.019479e-07
I7192 n1_m1_340800_100800 0 7.153492e-08
I7193 n1_m1_340800_105600 0 1.059397e-07
I7194 n1_m1_340800_110400 0 6.800705e-08
I7195 n1_m1_340800_115200 0 7.453167e-08
I7196 n1_m1_340800_120000 0 1.248659e-07
I7197 n1_m1_340800_124800 0 1.681543e-07
I7198 n1_m1_340800_129600 0 1.943818e-07
I7199 n1_m1_340800_134400 0 1.374382e-07
I7200 n1_m1_340800_139200 0 9.952086e-08
I7201 n1_m1_340800_144000 0 1.218716e-07
I7202 n1_m1_340800_148800 0 7.936986e-08
I7203 n1_m1_340800_153600 0 1.222716e-07
I7204 n1_m1_340800_158400 0 8.437069e-08
I7205 n1_m1_340800_163200 0 7.308331e-08
I7206 n1_m1_340800_168000 0 1.079837e-07
I7207 n1_m1_340800_172800 0 7.489350e-08
I7208 n1_m1_340800_177600 0 2.675569e-07
I7209 n1_m1_340800_182400 0 2.569656e-07
I7210 n1_m1_340800_187200 0 4.752142e-07
I7211 n1_m1_340800_192000 0 5.590526e-07
I7212 n1_m1_340800_196800 0 4.772524e-07
I7213 n1_m1_340800_201600 0 2.386590e-07
I7214 n1_m1_340800_206400 0 1.295702e-07
I7215 n1_m1_340800_211200 0 9.518966e-08
I7216 n1_m1_340800_216000 0 5.506006e-07
I7217 n1_m1_340800_220800 0 1.611329e-07
I7218 n1_m1_340800_225600 0 1.489009e-07
I7219 n1_m1_340800_230400 0 1.579896e-07
I7220 n1_m1_340800_235200 0 1.019827e-07
I7221 n1_m1_340800_240000 0 1.659760e-07
I7222 n1_m1_340800_244800 0 8.474899e-08
I7223 n1_m1_340800_249600 0 1.174813e-07
I7224 n1_m1_340800_254400 0 7.878330e-08
I7225 n1_m1_340800_259200 0 9.333717e-08
I7226 n1_m1_340800_264000 0 1.557303e-07
I7227 n1_m1_340800_268800 0 8.577921e-08
I7228 n1_m1_340800_273600 0 1.201808e-07
I7229 n1_m1_340800_278400 0 8.001475e-08
I7230 n1_m1_340800_283200 0 8.192639e-08
I7231 n1_m1_340800_288000 0 1.197507e-07
I7232 n1_m1_340800_292800 0 8.587605e-08
I7233 n1_m1_340800_297600 0 1.452582e-07
I7234 n1_m1_340800_302400 0 9.695173e-08
I7235 n1_m1_340800_307200 0 8.386692e-08
I7236 n1_m1_340800_312000 0 1.111840e-07
I7237 n1_m1_340800_316800 0 7.328303e-08
I7238 n1_m1_340800_321600 0 1.099246e-07
I7239 n1_m1_340800_326400 0 7.328303e-08
I7240 n1_m1_340800_331200 0 7.248997e-08
I7241 n1_m1_340800_336000 0 1.082407e-07
I7242 n1_m1_340800_340800 0 7.328303e-08
I7243 n1_m1_340800_345600 0 1.099246e-07
I7244 n1_m1_340800_350400 0 7.328303e-08
I7245 n1_m1_340800_355200 0 7.328303e-08
I7246 n1_m1_340800_360000 0 1.084203e-07
I7247 n1_m1_340800_364800 0 6.995199e-08
I7248 n1_m1_340800_369600 0 1.057157e-07
I7249 n1_m1_340800_374400 0 7.285391e-08
I7250 n1_m1_340800_379200 0 7.328303e-08
I7251 n1_m1_340800_384000 0 1.146242e-07
I7252 n1_m1_340800_388800 0 9.258097e-08
I7253 n1_m1_340800_393600 0 1.497790e-07
I7254 n1_m1_340800_398400 0 9.042003e-08
I7255 n1_m1_340800_403200 0 8.008954e-08
I7256 n1_m1_340800_408000 0 1.103452e-07
I7257 n1_m1_340800_412800 0 7.337151e-08
I7258 n1_m1_340800_417600 0 1.089874e-07
I7259 n1_m1_340800_422400 0 7.231615e-08
I7260 n1_m1_340800_427200 0 7.328303e-08
I7261 n1_m1_340800_432000 0 1.057883e-07
I7262 n1_m1_340800_436800 0 6.995199e-08
I7263 n1_m1_340800_441600 0 1.052377e-07
I7264 n1_m1_340800_446400 0 7.280815e-08
I7265 n1_m1_340800_451200 0 7.288650e-08
I7266 n1_m1_340800_456000 0 1.078441e-07
I7267 n1_m1_340800_460800 0 7.101187e-08
I7268 n1_m1_340800_465600 0 1.072350e-07
I7269 n1_m1_340800_470400 0 8.048679e-08
I7270 n1_m1_340800_475200 0 8.376067e-08
I7271 n1_m1_340800_480000 0 1.167805e-07
I7272 n1_m1_345600_0 0 2.493542e-07
I7273 n1_m1_345600_4800 0 2.830946e-07
I7274 n1_m1_345600_9600 0 3.531065e-07
I7275 n1_m1_345600_14400 0 2.082679e-07
I7276 n1_m1_345600_19200 0 2.087437e-07
I7277 n1_m1_345600_24000 0 3.016986e-07
I7278 n1_m1_345600_28800 0 2.002391e-07
I7279 n1_m1_345600_33600 0 3.010950e-07
I7280 n1_m1_345600_38400 0 2.007300e-07
I7281 n1_m1_345600_43200 0 2.005562e-07
I7282 n1_m1_345600_48000 0 2.998247e-07
I7283 n1_m1_345600_52800 0 1.998628e-07
I7284 n1_m1_345600_57600 0 2.997942e-07
I7285 n1_m1_345600_62400 0 2.017434e-07
I7286 n1_m1_345600_67200 0 2.038620e-07
I7287 n1_m1_345600_72000 0 3.097076e-07
I7288 n1_m1_345600_76800 0 2.294103e-07
I7289 n1_m1_345600_81600 0 3.738188e-07
I7290 n1_m1_345600_86400 0 2.344506e-07
I7291 n1_m1_345600_91200 0 2.164978e-07
I7292 n1_m1_345600_96000 0 3.096886e-07
I7293 n1_m1_345600_100800 0 2.146048e-07
I7294 n1_m1_345600_105600 0 3.183987e-07
I7295 n1_m1_345600_110400 0 2.052844e-07
I7296 n1_m1_345600_115200 0 2.154635e-07
I7297 n1_m1_345600_120000 0 3.495161e-07
I7298 n1_m1_345600_124800 0 2.836806e-07
I7299 n1_m1_345600_129600 0 5.109566e-07
I7300 n1_m1_345600_134400 0 3.714092e-07
I7301 n1_m1_345600_139200 0 2.568437e-07
I7302 n1_m1_345600_144000 0 3.692552e-07
I7303 n1_m1_345600_148800 0 2.235475e-07
I7304 n1_m1_345600_153600 0 3.379419e-07
I7305 n1_m1_345600_158400 0 2.362901e-07
I7306 n1_m1_345600_163200 0 2.183930e-07
I7307 n1_m1_345600_168000 0 3.212877e-07
I7308 n1_m1_345600_172800 0 2.249153e-07
I7309 n1_m1_345600_177600 0 6.110746e-07
I7310 n1_m1_345600_182400 0 5.241623e-07
I7311 n1_m1_345600_187200 0 8.969236e-07
I7312 n1_m1_345600_192000 0 8.253601e-07
I7313 n1_m1_345600_196800 0 4.814103e-07
I7314 n1_m1_345600_201600 0 5.635446e-07
I7315 n1_m1_345600_206400 0 2.608129e-07
I7316 n1_m1_345600_211200 0 2.611117e-07
I7317 n1_m1_345600_216000 0 6.763854e-07
I7318 n1_m1_345600_220800 0 3.461245e-07
I7319 n1_m1_345600_225600 0 4.561913e-07
I7320 n1_m1_345600_230400 0 2.614368e-07
I7321 n1_m1_345600_235200 0 2.677563e-07
I7322 n1_m1_345600_240000 0 3.834640e-07
I7323 n1_m1_345600_244800 0 2.546579e-07
I7324 n1_m1_345600_249600 0 3.642425e-07
I7325 n1_m1_345600_254400 0 2.359950e-07
I7326 n1_m1_345600_259200 0 2.520995e-07
I7327 n1_m1_345600_264000 0 4.112608e-07
I7328 n1_m1_345600_268800 0 2.596617e-07
I7329 n1_m1_345600_273600 0 3.603431e-07
I7330 n1_m1_345600_278400 0 2.416356e-07
I7331 n1_m1_345600_283200 0 2.520176e-07
I7332 n1_m1_345600_288000 0 4.687930e-07
I7333 n1_m1_345600_292800 0 6.093837e-07
I7334 n1_m1_345600_297600 0 6.427952e-07
I7335 n1_m1_345600_302400 0 3.361897e-07
I7336 n1_m1_345600_307200 0 2.555155e-07
I7337 n1_m1_345600_312000 0 3.331045e-07
I7338 n1_m1_345600_316800 0 2.198491e-07
I7339 n1_m1_345600_321600 0 3.297737e-07
I7340 n1_m1_345600_326400 0 2.198491e-07
I7341 n1_m1_345600_331200 0 2.195875e-07
I7342 n1_m1_345600_336000 0 3.292182e-07
I7343 n1_m1_345600_340800 0 2.198491e-07
I7344 n1_m1_345600_345600 0 3.297737e-07
I7345 n1_m1_345600_350400 0 2.177506e-07
I7346 n1_m1_345600_355200 0 2.162978e-07
I7347 n1_m1_345600_360000 0 3.175035e-07
I7348 n1_m1_345600_364800 0 2.108979e-07
I7349 n1_m1_345600_369600 0 3.249190e-07
I7350 n1_m1_345600_374400 0 2.197076e-07
I7351 n1_m1_345600_379200 0 2.207736e-07
I7352 n1_m1_345600_384000 0 3.619584e-07
I7353 n1_m1_345600_388800 0 3.372359e-07
I7354 n1_m1_345600_393600 0 4.578945e-07
I7355 n1_m1_345600_398400 0 2.758239e-07
I7356 n1_m1_345600_403200 0 2.485609e-07
I7357 n1_m1_345600_408000 0 3.405686e-07
I7358 n1_m1_345600_412800 0 2.241030e-07
I7359 n1_m1_345600_417600 0 3.371123e-07
I7360 n1_m1_345600_422400 0 2.195302e-07
I7361 n1_m1_345600_427200 0 2.198491e-07
I7362 n1_m1_345600_432000 0 3.173648e-07
I7363 n1_m1_345600_436800 0 2.098560e-07
I7364 n1_m1_345600_441600 0 3.157131e-07
I7365 n1_m1_345600_446400 0 2.184245e-07
I7366 n1_m1_345600_451200 0 2.191827e-07
I7367 n1_m1_345600_456000 0 3.262772e-07
I7368 n1_m1_345600_460800 0 2.154569e-07
I7369 n1_m1_345600_465600 0 3.223070e-07
I7370 n1_m1_345600_470400 0 2.262881e-07
I7371 n1_m1_345600_475200 0 2.378041e-07
I7372 n1_m1_345600_480000 0 3.513859e-07
I7373 n1_m1_350400_0 0 1.503976e-07
I7374 n1_m1_350400_4800 0 1.670535e-07
I7375 n1_m1_350400_9600 0 2.216836e-07
I7376 n1_m1_350400_14400 0 1.352353e-07
I7377 n1_m1_350400_19200 0 1.387897e-07
I7378 n1_m1_350400_24000 0 2.012531e-07
I7379 n1_m1_350400_28800 0 1.332419e-07
I7380 n1_m1_350400_33600 0 1.998628e-07
I7381 n1_m1_350400_38400 0 1.332419e-07
I7382 n1_m1_350400_43200 0 1.332419e-07
I7383 n1_m1_350400_48000 0 1.998628e-07
I7384 n1_m1_350400_52800 0 1.332419e-07
I7385 n1_m1_350400_57600 0 1.998628e-07
I7386 n1_m1_350400_62400 0 1.360774e-07
I7387 n1_m1_350400_67200 0 1.399040e-07
I7388 n1_m1_350400_72000 0 2.116297e-07
I7389 n1_m1_350400_76800 0 1.529303e-07
I7390 n1_m1_350400_81600 0 2.491985e-07
I7391 n1_m1_350400_86400 0 1.563803e-07
I7392 n1_m1_350400_91200 0 1.476948e-07
I7393 n1_m1_350400_96000 0 2.111085e-07
I7394 n1_m1_350400_100800 0 1.411991e-07
I7395 n1_m1_350400_105600 0 2.145528e-07
I7396 n1_m1_350400_110400 0 1.401887e-07
I7397 n1_m1_350400_115200 0 1.413768e-07
I7398 n1_m1_350400_120000 0 2.278945e-07
I7399 n1_m1_350400_124800 0 1.720764e-07
I7400 n1_m1_350400_129600 0 4.128102e-07
I7401 n1_m1_350400_134400 0 2.553594e-07
I7402 n1_m1_350400_139200 0 1.619550e-07
I7403 n1_m1_350400_144000 0 2.342613e-07
I7404 n1_m1_350400_148800 0 1.481252e-07
I7405 n1_m1_350400_153600 0 2.198084e-07
I7406 n1_m1_350400_158400 0 1.430930e-07
I7407 n1_m1_350400_163200 0 1.513987e-07
I7408 n1_m1_350400_168000 0 2.157291e-07
I7409 n1_m1_350400_172800 0 1.542943e-07
I7410 n1_m1_350400_177600 0 4.846642e-07
I7411 n1_m1_350400_182400 0 3.319259e-07
I7412 n1_m1_350400_187200 0 5.804005e-07
I7413 n1_m1_350400_192000 0 4.571662e-07
I7414 n1_m1_350400_196800 0 1.919463e-07
I7415 n1_m1_350400_201600 0 3.808693e-07
I7416 n1_m1_350400_206400 0 1.650820e-07
I7417 n1_m1_350400_211200 0 1.669077e-07
I7418 n1_m1_350400_216000 0 2.622949e-07
I7419 n1_m1_350400_220800 0 2.020533e-07
I7420 n1_m1_350400_225600 0 2.881062e-07
I7421 n1_m1_350400_230400 0 1.588172e-07
I7422 n1_m1_350400_235200 0 2.064292e-07
I7423 n1_m1_350400_240000 0 2.432734e-07
I7424 n1_m1_350400_244800 0 1.667876e-07
I7425 n1_m1_350400_249600 0 2.562910e-07
I7426 n1_m1_350400_254400 0 1.558522e-07
I7427 n1_m1_350400_259200 0 1.546641e-07
I7428 n1_m1_350400_264000 0 2.404679e-07
I7429 n1_m1_350400_268800 0 1.639408e-07
I7430 n1_m1_350400_273600 0 2.410010e-07
I7431 n1_m1_350400_278400 0 1.586840e-07
I7432 n1_m1_350400_283200 0 1.556195e-07
I7433 n1_m1_350400_288000 0 3.904814e-07
I7434 n1_m1_350400_292800 0 6.515419e-07
I7435 n1_m1_350400_297600 0 3.944557e-07
I7436 n1_m1_350400_302400 0 1.917417e-07
I7437 n1_m1_350400_307200 0 1.646722e-07
I7438 n1_m1_350400_312000 0 2.215284e-07
I7439 n1_m1_350400_316800 0 1.465661e-07
I7440 n1_m1_350400_321600 0 2.198491e-07
I7441 n1_m1_350400_326400 0 1.485670e-07
I7442 n1_m1_350400_331200 0 1.532519e-07
I7443 n1_m1_350400_336000 0 2.254532e-07
I7444 n1_m1_350400_340800 0 1.471924e-07
I7445 n1_m1_350400_345600 0 2.198491e-07
I7446 n1_m1_350400_350400 0 1.426294e-07
I7447 n1_m1_350400_355200 0 1.399040e-07
I7448 n1_m1_350400_360000 0 2.098560e-07
I7449 n1_m1_350400_364800 0 1.418586e-07
I7450 n1_m1_350400_369600 0 2.164980e-07
I7451 n1_m1_350400_374400 0 1.430279e-07
I7452 n1_m1_350400_379200 0 1.487966e-07
I7453 n1_m1_350400_384000 0 2.626447e-07
I7454 n1_m1_350400_388800 0 2.343095e-07
I7455 n1_m1_350400_393600 0 3.326730e-07
I7456 n1_m1_350400_398400 0 2.304604e-07
I7457 n1_m1_350400_403200 0 1.990007e-07
I7458 n1_m1_350400_408000 0 2.417155e-07
I7459 n1_m1_350400_412800 0 1.532770e-07
I7460 n1_m1_350400_417600 0 2.205417e-07
I7461 n1_m1_350400_422400 0 1.426294e-07
I7462 n1_m1_350400_427200 0 1.426294e-07
I7463 n1_m1_350400_432000 0 2.105598e-07
I7464 n1_m1_350400_436800 0 1.412216e-07
I7465 n1_m1_350400_441600 0 2.160144e-07
I7466 n1_m1_350400_446400 0 1.461775e-07
I7467 n1_m1_350400_451200 0 1.455612e-07
I7468 n1_m1_350400_456000 0 2.194900e-07
I7469 n1_m1_350400_460800 0 1.624918e-07
I7470 n1_m1_350400_465600 0 2.542464e-07
I7471 n1_m1_350400_470400 0 1.706805e-07
I7472 n1_m1_350400_475200 0 1.671618e-07
I7473 n1_m1_350400_480000 0 2.343433e-07
I7474 n1_m1_355200_0 0 1.480945e-07
I7475 n1_m1_355200_4800 0 1.650239e-07
I7476 n1_m1_355200_9600 0 2.174377e-07
I7477 n1_m1_355200_14400 0 1.332419e-07
I7478 n1_m1_355200_19200 0 1.381421e-07
I7479 n1_m1_355200_24000 0 2.012531e-07
I7480 n1_m1_355200_28800 0 1.332419e-07
I7481 n1_m1_355200_33600 0 2.041492e-07
I7482 n1_m1_355200_38400 0 1.375640e-07
I7483 n1_m1_355200_43200 0 1.375640e-07
I7484 n1_m1_355200_48000 0 2.063460e-07
I7485 n1_m1_355200_52800 0 1.374658e-07
I7486 n1_m1_355200_57600 0 2.007826e-07
I7487 n1_m1_355200_62400 0 1.342378e-07
I7488 n1_m1_355200_67200 0 1.355819e-07
I7489 n1_m1_355200_72000 0 2.093801e-07
I7490 n1_m1_355200_76800 0 1.517559e-07
I7491 n1_m1_355200_81600 0 2.491358e-07
I7492 n1_m1_355200_86400 0 1.531208e-07
I7493 n1_m1_355200_91200 0 1.433727e-07
I7494 n1_m1_355200_96000 0 2.046254e-07
I7495 n1_m1_355200_100800 0 1.376358e-07
I7496 n1_m1_355200_105600 0 2.111859e-07
I7497 n1_m1_355200_110400 0 1.368941e-07
I7498 n1_m1_355200_115200 0 1.402338e-07
I7499 n1_m1_355200_120000 0 2.268220e-07
I7500 n1_m1_355200_124800 0 1.787680e-07
I7501 n1_m1_355200_129600 0 4.115100e-07
I7502 n1_m1_355200_134400 0 2.261902e-07
I7503 n1_m1_355200_139200 0 1.637660e-07
I7504 n1_m1_355200_144000 0 2.255502e-07
I7505 n1_m1_355200_148800 0 1.481226e-07
I7506 n1_m1_355200_153600 0 2.197803e-07
I7507 n1_m1_355200_158400 0 1.408582e-07
I7508 n1_m1_355200_163200 0 1.582379e-07
I7509 n1_m1_355200_168000 0 2.197466e-07
I7510 n1_m1_355200_172800 0 1.571098e-07
I7511 n1_m1_355200_177600 0 4.028780e-07
I7512 n1_m1_355200_182400 0 3.032981e-07
I7513 n1_m1_355200_187200 0 6.277682e-07
I7514 n1_m1_355200_192000 0 4.429898e-07
I7515 n1_m1_355200_196800 0 1.706566e-07
I7516 n1_m1_355200_201600 0 2.560105e-07
I7517 n1_m1_355200_206400 0 1.728510e-07
I7518 n1_m1_355200_211200 0 1.585061e-07
I7519 n1_m1_355200_216000 0 2.692079e-07
I7520 n1_m1_355200_220800 0 1.675372e-07
I7521 n1_m1_355200_225600 0 2.386184e-07
I7522 n1_m1_355200_230400 0 1.612875e-07
I7523 n1_m1_355200_235200 0 1.795412e-07
I7524 n1_m1_355200_240000 0 2.349387e-07
I7525 n1_m1_355200_244800 0 1.595554e-07
I7526 n1_m1_355200_249600 0 2.445354e-07
I7527 n1_m1_355200_254400 0 1.535797e-07
I7528 n1_m1_355200_259200 0 1.532282e-07
I7529 n1_m1_355200_264000 0 2.299728e-07
I7530 n1_m1_355200_268800 0 1.562459e-07
I7531 n1_m1_355200_273600 0 2.444700e-07
I7532 n1_m1_355200_278400 0 1.542821e-07
I7533 n1_m1_355200_283200 0 1.704020e-07
I7534 n1_m1_355200_288000 0 2.916156e-07
I7535 n1_m1_355200_292800 0 2.960868e-07
I7536 n1_m1_355200_297600 0 2.719960e-07
I7537 n1_m1_355200_302400 0 1.755993e-07
I7538 n1_m1_355200_307200 0 1.580420e-07
I7539 n1_m1_355200_312000 0 2.256630e-07
I7540 n1_m1_355200_316800 0 1.526206e-07
I7541 n1_m1_355200_321600 0 2.223048e-07
I7542 n1_m1_355200_326400 0 1.553280e-07
I7543 n1_m1_355200_331200 0 1.678286e-07
I7544 n1_m1_355200_336000 0 2.447371e-07
I7545 n1_m1_355200_340800 0 1.521802e-07
I7546 n1_m1_355200_345600 0 2.181078e-07
I7547 n1_m1_355200_350400 0 1.408612e-07
I7548 n1_m1_355200_355200 0 1.427080e-07
I7549 n1_m1_355200_360000 0 2.152586e-07
I7550 n1_m1_355200_364800 0 1.405905e-07
I7551 n1_m1_355200_369600 0 2.113741e-07
I7552 n1_m1_355200_374400 0 1.410160e-07
I7553 n1_m1_355200_379200 0 1.523191e-07
I7554 n1_m1_355200_384000 0 2.640775e-07
I7555 n1_m1_355200_388800 0 1.922795e-07
I7556 n1_m1_355200_393600 0 3.040832e-07
I7557 n1_m1_355200_398400 0 2.224514e-07
I7558 n1_m1_355200_403200 0 1.971080e-07
I7559 n1_m1_355200_408000 0 2.432785e-07
I7560 n1_m1_355200_412800 0 1.495334e-07
I7561 n1_m1_355200_417600 0 2.162788e-07
I7562 n1_m1_355200_422400 0 1.399040e-07
I7563 n1_m1_355200_427200 0 1.428866e-07
I7564 n1_m1_355200_432000 0 2.163391e-07
I7565 n1_m1_355200_436800 0 1.450093e-07
I7566 n1_m1_355200_441600 0 2.198491e-07
I7567 n1_m1_355200_446400 0 1.465661e-07
I7568 n1_m1_355200_451200 0 1.468650e-07
I7569 n1_m1_355200_456000 0 2.351251e-07
I7570 n1_m1_355200_460800 0 1.939490e-07
I7571 n1_m1_355200_465600 0 3.325505e-07
I7572 n1_m1_355200_470400 0 2.003306e-07
I7573 n1_m1_355200_475200 0 1.765180e-07
I7574 n1_m1_355200_480000 0 2.372634e-07
I7575 n1_m1_360000_0 0 2.382662e-07
I7576 n1_m1_360000_4800 0 2.642788e-07
I7577 n1_m1_360000_9600 0 3.460785e-07
I7578 n1_m1_360000_14400 0 2.086722e-07
I7579 n1_m1_360000_19200 0 2.107439e-07
I7580 n1_m1_360000_24000 0 3.046236e-07
I7581 n1_m1_360000_28800 0 2.069585e-07
I7582 n1_m1_360000_33600 0 3.137905e-07
I7583 n1_m1_360000_38400 0 2.098560e-07
I7584 n1_m1_360000_43200 0 2.098560e-07
I7585 n1_m1_360000_48000 0 3.147839e-07
I7586 n1_m1_360000_52800 0 2.084038e-07
I7587 n1_m1_360000_57600 0 3.015664e-07
I7588 n1_m1_360000_62400 0 2.026983e-07
I7589 n1_m1_360000_67200 0 2.033040e-07
I7590 n1_m1_360000_72000 0 3.133283e-07
I7591 n1_m1_360000_76800 0 2.238581e-07
I7592 n1_m1_360000_81600 0 3.697875e-07
I7593 n1_m1_360000_86400 0 2.309063e-07
I7594 n1_m1_360000_91200 0 2.125703e-07
I7595 n1_m1_360000_96000 0 3.037585e-07
I7596 n1_m1_360000_100800 0 2.064423e-07
I7597 n1_m1_360000_105600 0 3.117420e-07
I7598 n1_m1_360000_110400 0 2.045158e-07
I7599 n1_m1_360000_115200 0 2.037265e-07
I7600 n1_m1_360000_120000 0 3.314847e-07
I7601 n1_m1_360000_124800 0 2.545270e-07
I7602 n1_m1_360000_129600 0 4.661241e-07
I7603 n1_m1_360000_134400 0 2.752786e-07
I7604 n1_m1_360000_139200 0 2.541366e-07
I7605 n1_m1_360000_144000 0 3.429295e-07
I7606 n1_m1_360000_148800 0 2.230130e-07
I7607 n1_m1_360000_153600 0 3.239283e-07
I7608 n1_m1_360000_158400 0 2.176416e-07
I7609 n1_m1_360000_163200 0 2.331537e-07
I7610 n1_m1_360000_168000 0 3.283045e-07
I7611 n1_m1_360000_172800 0 2.322235e-07
I7612 n1_m1_360000_177600 0 4.065033e-07
I7613 n1_m1_360000_182400 0 3.225631e-07
I7614 n1_m1_360000_187200 0 4.614024e-07
I7615 n1_m1_360000_192000 0 6.090129e-07
I7616 n1_m1_360000_196800 0 3.500182e-07
I7617 n1_m1_360000_201600 0 3.855151e-07
I7618 n1_m1_360000_206400 0 2.422532e-07
I7619 n1_m1_360000_211200 0 2.448068e-07
I7620 n1_m1_360000_216000 0 3.829662e-07
I7621 n1_m1_360000_220800 0 2.475005e-07
I7622 n1_m1_360000_225600 0 4.248578e-07
I7623 n1_m1_360000_230400 0 2.473927e-07
I7624 n1_m1_360000_235200 0 2.679404e-07
I7625 n1_m1_360000_240000 0 5.346032e-07
I7626 n1_m1_360000_244800 0 2.797047e-07
I7627 n1_m1_360000_249600 0 3.785959e-07
I7628 n1_m1_360000_254400 0 2.430838e-07
I7629 n1_m1_360000_259200 0 2.457849e-07
I7630 n1_m1_360000_264000 0 3.661576e-07
I7631 n1_m1_360000_268800 0 2.335316e-07
I7632 n1_m1_360000_273600 0 3.614969e-07
I7633 n1_m1_360000_278400 0 2.354588e-07
I7634 n1_m1_360000_283200 0 2.409508e-07
I7635 n1_m1_360000_288000 0 4.063968e-07
I7636 n1_m1_360000_292800 0 3.854850e-07
I7637 n1_m1_360000_297600 0 3.856323e-07
I7638 n1_m1_360000_302400 0 2.645185e-07
I7639 n1_m1_360000_307200 0 2.378319e-07
I7640 n1_m1_360000_312000 0 3.492251e-07
I7641 n1_m1_360000_316800 0 2.398836e-07
I7642 n1_m1_360000_321600 0 3.450499e-07
I7643 n1_m1_360000_326400 0 2.489826e-07
I7644 n1_m1_360000_331200 0 2.743480e-07
I7645 n1_m1_360000_336000 0 3.944848e-07
I7646 n1_m1_360000_340800 0 2.457325e-07
I7647 n1_m1_360000_345600 0 3.335189e-07
I7648 n1_m1_360000_350400 0 2.169104e-07
I7649 n1_m1_360000_355200 0 2.185776e-07
I7650 n1_m1_360000_360000 0 3.349652e-07
I7651 n1_m1_360000_364800 0 2.103446e-07
I7652 n1_m1_360000_369600 0 3.172822e-07
I7653 n1_m1_360000_374400 0 2.133763e-07
I7654 n1_m1_360000_379200 0 2.306337e-07
I7655 n1_m1_360000_384000 0 3.807440e-07
I7656 n1_m1_360000_388800 0 2.473640e-07
I7657 n1_m1_360000_393600 0 3.825438e-07
I7658 n1_m1_360000_398400 0 2.758647e-07
I7659 n1_m1_360000_403200 0 2.532146e-07
I7660 n1_m1_360000_408000 0 3.400650e-07
I7661 n1_m1_360000_412800 0 2.142070e-07
I7662 n1_m1_360000_417600 0 3.277707e-07
I7663 n1_m1_360000_422400 0 2.149183e-07
I7664 n1_m1_360000_427200 0 2.177844e-07
I7665 n1_m1_360000_432000 0 3.319992e-07
I7666 n1_m1_360000_436800 0 2.273302e-07
I7667 n1_m1_360000_441600 0 3.344191e-07
I7668 n1_m1_360000_446400 0 2.259744e-07
I7669 n1_m1_360000_451200 0 2.251863e-07
I7670 n1_m1_360000_456000 0 3.836271e-07
I7671 n1_m1_360000_460800 0 2.927367e-07
I7672 n1_m1_360000_465600 0 4.322115e-07
I7673 n1_m1_360000_470400 0 2.708571e-07
I7674 n1_m1_360000_475200 0 2.625029e-07
I7675 n1_m1_360000_480000 0 3.703243e-07
I7676 n1_m1_364800_0 0 1.546046e-07
I7677 n1_m1_364800_4800 0 1.643629e-07
I7678 n1_m1_364800_9600 0 2.158455e-07
I7679 n1_m1_364800_14400 0 1.415577e-07
I7680 n1_m1_364800_19200 0 1.443061e-07
I7681 n1_m1_364800_24000 0 2.029704e-07
I7682 n1_m1_364800_28800 0 1.372390e-07
I7683 n1_m1_364800_33600 0 2.098560e-07
I7684 n1_m1_364800_38400 0 1.399040e-07
I7685 n1_m1_364800_43200 0 1.399040e-07
I7686 n1_m1_364800_48000 0 2.084425e-07
I7687 n1_m1_364800_52800 0 1.343799e-07
I7688 n1_m1_364800_57600 0 1.998628e-07
I7689 n1_m1_364800_62400 0 1.437521e-07
I7690 n1_m1_364800_67200 0 1.459969e-07
I7691 n1_m1_364800_72000 0 2.103211e-07
I7692 n1_m1_364800_76800 0 1.449919e-07
I7693 n1_m1_364800_81600 0 2.339303e-07
I7694 n1_m1_364800_86400 0 1.495316e-07
I7695 n1_m1_364800_91200 0 1.400114e-07
I7696 n1_m1_364800_96000 0 2.078253e-07
I7697 n1_m1_364800_100800 0 1.416790e-07
I7698 n1_m1_364800_105600 0 2.024870e-07
I7699 n1_m1_364800_110400 0 1.450672e-07
I7700 n1_m1_364800_115200 0 1.354123e-07
I7701 n1_m1_364800_120000 0 2.211622e-07
I7702 n1_m1_364800_124800 0 1.552016e-07
I7703 n1_m1_364800_129600 0 3.000033e-07
I7704 n1_m1_364800_134400 0 1.625350e-07
I7705 n1_m1_364800_139200 0 1.526237e-07
I7706 n1_m1_364800_144000 0 2.300373e-07
I7707 n1_m1_364800_148800 0 1.414325e-07
I7708 n1_m1_364800_153600 0 2.205918e-07
I7709 n1_m1_364800_158400 0 1.474324e-07
I7710 n1_m1_364800_163200 0 1.448780e-07
I7711 n1_m1_364800_168000 0 2.181745e-07
I7712 n1_m1_364800_172800 0 1.433451e-07
I7713 n1_m1_364800_177600 0 2.437814e-07
I7714 n1_m1_364800_182400 0 1.763714e-07
I7715 n1_m1_364800_187200 0 2.097705e-07
I7716 n1_m1_364800_192000 0 7.757295e-07
I7717 n1_m1_364800_196800 0 5.885465e-07
I7718 n1_m1_364800_201600 0 6.336117e-07
I7719 n1_m1_364800_206400 0 2.056178e-07
I7720 n1_m1_364800_211200 0 1.672475e-07
I7721 n1_m1_364800_216000 0 2.651556e-07
I7722 n1_m1_364800_220800 0 1.786112e-07
I7723 n1_m1_364800_225600 0 2.858034e-07
I7724 n1_m1_364800_230400 0 2.553093e-07
I7725 n1_m1_364800_235200 0 4.347492e-07
I7726 n1_m1_364800_240000 0 1.137710e-06
I7727 n1_m1_364800_244800 0 5.720180e-07
I7728 n1_m1_364800_249600 0 7.021236e-07
I7729 n1_m1_364800_254400 0 3.450260e-07
I7730 n1_m1_364800_259200 0 2.342742e-07
I7731 n1_m1_364800_264000 0 3.595650e-07
I7732 n1_m1_364800_268800 0 1.788312e-07
I7733 n1_m1_364800_273600 0 2.536802e-07
I7734 n1_m1_364800_278400 0 2.035867e-07
I7735 n1_m1_364800_283200 0 1.879300e-07
I7736 n1_m1_364800_288000 0 2.685953e-07
I7737 n1_m1_364800_292800 0 2.084327e-07
I7738 n1_m1_364800_297600 0 3.475569e-07
I7739 n1_m1_364800_302400 0 2.067407e-07
I7740 n1_m1_364800_307200 0 1.681227e-07
I7741 n1_m1_364800_312000 0 2.248072e-07
I7742 n1_m1_364800_316800 0 1.553330e-07
I7743 n1_m1_364800_321600 0 2.475436e-07
I7744 n1_m1_364800_326400 0 1.665524e-07
I7745 n1_m1_364800_331200 0 1.643019e-07
I7746 n1_m1_364800_336000 0 2.479344e-07
I7747 n1_m1_364800_340800 0 1.703682e-07
I7748 n1_m1_364800_345600 0 2.320597e-07
I7749 n1_m1_364800_350400 0 1.437844e-07
I7750 n1_m1_364800_355200 0 1.449126e-07
I7751 n1_m1_364800_360000 0 2.231755e-07
I7752 n1_m1_364800_364800 0 1.432397e-07
I7753 n1_m1_364800_369600 0 2.198491e-07
I7754 n1_m1_364800_374400 0 1.470427e-07
I7755 n1_m1_364800_379200 0 1.506414e-07
I7756 n1_m1_364800_384000 0 2.269104e-07
I7757 n1_m1_364800_388800 0 1.525255e-07
I7758 n1_m1_364800_393600 0 2.474822e-07
I7759 n1_m1_364800_398400 0 1.896206e-07
I7760 n1_m1_364800_403200 0 1.576619e-07
I7761 n1_m1_364800_408000 0 2.335807e-07
I7762 n1_m1_364800_412800 0 1.442100e-07
I7763 n1_m1_364800_417600 0 2.222291e-07
I7764 n1_m1_364800_422400 0 1.524176e-07
I7765 n1_m1_364800_427200 0 1.507227e-07
I7766 n1_m1_364800_432000 0 2.337724e-07
I7767 n1_m1_364800_436800 0 1.653103e-07
I7768 n1_m1_364800_441600 0 2.226675e-07
I7769 n1_m1_364800_446400 0 1.619242e-07
I7770 n1_m1_364800_451200 0 1.479962e-07
I7771 n1_m1_364800_456000 0 2.277367e-07
I7772 n1_m1_364800_460800 0 1.591908e-07
I7773 n1_m1_364800_465600 0 2.428223e-07
I7774 n1_m1_364800_470400 0 1.695255e-07
I7775 n1_m1_364800_475200 0 1.714526e-07
I7776 n1_m1_364800_480000 0 2.432645e-07
I7777 n1_m1_369600_0 0 1.386391e-07
I7778 n1_m1_369600_4800 0 1.481725e-07
I7779 n1_m1_369600_9600 0 2.114550e-07
I7780 n1_m1_369600_14400 0 1.341782e-07
I7781 n1_m1_369600_19200 0 1.344876e-07
I7782 n1_m1_369600_24000 0 2.028163e-07
I7783 n1_m1_369600_28800 0 1.401767e-07
I7784 n1_m1_369600_33600 0 2.098560e-07
I7785 n1_m1_369600_38400 0 1.398214e-07
I7786 n1_m1_369600_43200 0 1.384710e-07
I7787 n1_m1_369600_48000 0 2.010294e-07
I7788 n1_m1_369600_52800 0 1.332419e-07
I7789 n1_m1_369600_57600 0 2.016650e-07
I7790 n1_m1_369600_62400 0 1.397766e-07
I7791 n1_m1_369600_67200 0 1.377566e-07
I7792 n1_m1_369600_72000 0 2.077191e-07
I7793 n1_m1_369600_76800 0 1.450424e-07
I7794 n1_m1_369600_81600 0 2.213588e-07
I7795 n1_m1_369600_86400 0 1.448289e-07
I7796 n1_m1_369600_91200 0 1.398651e-07
I7797 n1_m1_369600_96000 0 2.063431e-07
I7798 n1_m1_369600_100800 0 1.402732e-07
I7799 n1_m1_369600_105600 0 2.031953e-07
I7800 n1_m1_369600_110400 0 1.425248e-07
I7801 n1_m1_369600_115200 0 1.363415e-07
I7802 n1_m1_369600_120000 0 2.184459e-07
I7803 n1_m1_369600_124800 0 1.722421e-07
I7804 n1_m1_369600_129600 0 3.712134e-07
I7805 n1_m1_369600_134400 0 1.798234e-07
I7806 n1_m1_369600_139200 0 1.555236e-07
I7807 n1_m1_369600_144000 0 2.366997e-07
I7808 n1_m1_369600_148800 0 1.507650e-07
I7809 n1_m1_369600_153600 0 2.295219e-07
I7810 n1_m1_369600_158400 0 1.432643e-07
I7811 n1_m1_369600_163200 0 1.407796e-07
I7812 n1_m1_369600_168000 0 2.237694e-07
I7813 n1_m1_369600_172800 0 1.461801e-07
I7814 n1_m1_369600_177600 0 2.471355e-07
I7815 n1_m1_369600_182400 0 2.721998e-07
I7816 n1_m1_369600_187200 0 7.039627e-07
I7817 n1_m1_369600_192000 0 1.098476e-06
I7818 n1_m1_369600_196800 0 8.521471e-07
I7819 n1_m1_369600_201600 0 1.273171e-06
I7820 n1_m1_369600_206400 0 2.082450e-07
I7821 n1_m1_369600_211200 0 1.572813e-07
I7822 n1_m1_369600_216000 0 3.765844e-07
I7823 n1_m1_369600_220800 0 1.884770e-07
I7824 n1_m1_369600_225600 0 3.808749e-07
I7825 n1_m1_369600_230400 0 6.963414e-07
I7826 n1_m1_369600_235200 0 8.407490e-07
I7827 n1_m1_369600_240000 0 1.519512e-06
I7828 n1_m1_369600_244800 0 1.204416e-06
I7829 n1_m1_369600_249600 0 1.105734e-06
I7830 n1_m1_369600_254400 0 4.437547e-07
I7831 n1_m1_369600_259200 0 7.069935e-07
I7832 n1_m1_369600_264000 0 7.849103e-07
I7833 n1_m1_369600_268800 0 5.008824e-07
I7834 n1_m1_369600_273600 0 3.693828e-07
I7835 n1_m1_369600_278400 0 3.289261e-07
I7836 n1_m1_369600_283200 0 4.158358e-07
I7837 n1_m1_369600_288000 0 6.102928e-07
I7838 n1_m1_369600_292800 0 7.985213e-07
I7839 n1_m1_369600_297600 0 5.596335e-07
I7840 n1_m1_369600_302400 0 2.399197e-07
I7841 n1_m1_369600_307200 0 1.922024e-07
I7842 n1_m1_369600_312000 0 2.492799e-07
I7843 n1_m1_369600_316800 0 1.641818e-07
I7844 n1_m1_369600_321600 0 2.512512e-07
I7845 n1_m1_369600_326400 0 1.955250e-07
I7846 n1_m1_369600_331200 0 2.351254e-07
I7847 n1_m1_369600_336000 0 3.442833e-07
I7848 n1_m1_369600_340800 0 2.233678e-07
I7849 n1_m1_369600_345600 0 2.531883e-07
I7850 n1_m1_369600_350400 0 1.485707e-07
I7851 n1_m1_369600_355200 0 1.462535e-07
I7852 n1_m1_369600_360000 0 2.204720e-07
I7853 n1_m1_369600_364800 0 1.516076e-07
I7854 n1_m1_369600_369600 0 2.233407e-07
I7855 n1_m1_369600_374400 0 1.465661e-07
I7856 n1_m1_369600_379200 0 1.459282e-07
I7857 n1_m1_369600_384000 0 2.161509e-07
I7858 n1_m1_369600_388800 0 1.481763e-07
I7859 n1_m1_369600_393600 0 2.657734e-07
I7860 n1_m1_369600_398400 0 2.493953e-07
I7861 n1_m1_369600_403200 0 2.420467e-07
I7862 n1_m1_369600_408000 0 2.486406e-07
I7863 n1_m1_369600_412800 0 1.989887e-07
I7864 n1_m1_369600_417600 0 2.942732e-07
I7865 n1_m1_369600_422400 0 1.857881e-07
I7866 n1_m1_369600_427200 0 1.590056e-07
I7867 n1_m1_369600_432000 0 2.368815e-07
I7868 n1_m1_369600_436800 0 2.074337e-07
I7869 n1_m1_369600_441600 0 2.817436e-07
I7870 n1_m1_369600_446400 0 1.680691e-07
I7871 n1_m1_369600_451200 0 1.439818e-07
I7872 n1_m1_369600_456000 0 2.116780e-07
I7873 n1_m1_369600_460800 0 1.454887e-07
I7874 n1_m1_369600_465600 0 2.224906e-07
I7875 n1_m1_369600_470400 0 1.579662e-07
I7876 n1_m1_369600_475200 0 1.633789e-07
I7877 n1_m1_369600_480000 0 2.304869e-07
I7878 n1_m1_374400_0 0 1.405671e-07
I7879 n1_m1_374400_4800 0 1.558511e-07
I7880 n1_m1_374400_9600 0 2.173849e-07
I7881 n1_m1_374400_14400 0 1.339163e-07
I7882 n1_m1_374400_19200 0 1.338982e-07
I7883 n1_m1_374400_24000 0 2.046050e-07
I7884 n1_m1_374400_28800 0 1.430599e-07
I7885 n1_m1_374400_33600 0 2.097598e-07
I7886 n1_m1_374400_38400 0 1.384519e-07
I7887 n1_m1_374400_43200 0 1.344252e-07
I7888 n1_m1_374400_48000 0 1.999010e-07
I7889 n1_m1_374400_52800 0 1.332419e-07
I7890 n1_m1_374400_57600 0 2.002627e-07
I7891 n1_m1_374400_62400 0 1.343293e-07
I7892 n1_m1_374400_67200 0 1.347818e-07
I7893 n1_m1_374400_72000 0 2.187052e-07
I7894 n1_m1_374400_76800 0 1.476648e-07
I7895 n1_m1_374400_81600 0 2.086653e-07
I7896 n1_m1_374400_86400 0 1.436187e-07
I7897 n1_m1_374400_91200 0 1.419857e-07
I7898 n1_m1_374400_96000 0 2.097053e-07
I7899 n1_m1_374400_100800 0 1.477837e-07
I7900 n1_m1_374400_105600 0 2.167300e-07
I7901 n1_m1_374400_110400 0 1.470376e-07
I7902 n1_m1_374400_115200 0 1.366600e-07
I7903 n1_m1_374400_120000 0 2.312605e-07
I7904 n1_m1_374400_124800 0 1.825604e-07
I7905 n1_m1_374400_129600 0 2.831796e-07
I7906 n1_m1_374400_134400 0 1.872022e-07
I7907 n1_m1_374400_139200 0 1.845457e-07
I7908 n1_m1_374400_144000 0 3.212720e-07
I7909 n1_m1_374400_148800 0 1.776366e-07
I7910 n1_m1_374400_153600 0 2.194517e-07
I7911 n1_m1_374400_158400 0 1.420339e-07
I7912 n1_m1_374400_163200 0 1.408295e-07
I7913 n1_m1_374400_168000 0 2.225509e-07
I7914 n1_m1_374400_172800 0 1.506325e-07
I7915 n1_m1_374400_177600 0 2.949149e-07
I7916 n1_m1_374400_182400 0 3.758906e-07
I7917 n1_m1_374400_187200 0 9.545743e-07
I7918 n1_m1_374400_192000 0 1.423217e-06
I7919 n1_m1_374400_196800 0 7.134008e-07
I7920 n1_m1_374400_201600 0 5.269870e-07
I7921 n1_m1_374400_206400 0 1.821122e-07
I7922 n1_m1_374400_211200 0 1.769756e-07
I7923 n1_m1_374400_216000 0 3.644886e-07
I7924 n1_m1_374400_220800 0 1.718888e-07
I7925 n1_m1_374400_225600 0 5.673450e-07
I7926 n1_m1_374400_230400 0 7.692373e-07
I7927 n1_m1_374400_235200 0 7.412883e-07
I7928 n1_m1_374400_240000 0 1.433794e-06
I7929 n1_m1_374400_244800 0 7.137984e-07
I7930 n1_m1_374400_249600 0 7.722198e-07
I7931 n1_m1_374400_254400 0 8.043253e-07
I7932 n1_m1_374400_259200 0 1.050258e-06
I7933 n1_m1_374400_264000 0 1.116633e-06
I7934 n1_m1_374400_268800 0 4.510360e-07
I7935 n1_m1_374400_273600 0 5.098765e-07
I7936 n1_m1_374400_278400 0 6.290265e-07
I7937 n1_m1_374400_283200 0 9.741251e-07
I7938 n1_m1_374400_288000 0 8.448480e-07
I7939 n1_m1_374400_292800 0 4.883727e-07
I7940 n1_m1_374400_297600 0 3.426035e-07
I7941 n1_m1_374400_302400 0 3.437836e-07
I7942 n1_m1_374400_307200 0 2.766009e-07
I7943 n1_m1_374400_312000 0 2.723394e-07
I7944 n1_m1_374400_316800 0 1.598719e-07
I7945 n1_m1_374400_321600 0 2.452374e-07
I7946 n1_m1_374400_326400 0 2.308190e-07
I7947 n1_m1_374400_331200 0 3.050140e-07
I7948 n1_m1_374400_336000 0 2.949239e-07
I7949 n1_m1_374400_340800 0 1.907656e-07
I7950 n1_m1_374400_345600 0 2.382534e-07
I7951 n1_m1_374400_350400 0 1.470109e-07
I7952 n1_m1_374400_355200 0 1.433870e-07
I7953 n1_m1_374400_360000 0 2.138271e-07
I7954 n1_m1_374400_364800 0 1.484167e-07
I7955 n1_m1_374400_369600 0 2.227707e-07
I7956 n1_m1_374400_374400 0 1.465243e-07
I7957 n1_m1_374400_379200 0 1.470962e-07
I7958 n1_m1_374400_384000 0 2.241665e-07
I7959 n1_m1_374400_388800 0 1.570603e-07
I7960 n1_m1_374400_393600 0 4.797579e-07
I7961 n1_m1_374400_398400 0 4.971561e-07
I7962 n1_m1_374400_403200 0 3.937740e-07
I7963 n1_m1_374400_408000 0 3.651144e-07
I7964 n1_m1_374400_412800 0 5.411732e-07
I7965 n1_m1_374400_417600 0 7.753153e-07
I7966 n1_m1_374400_422400 0 3.036415e-07
I7967 n1_m1_374400_427200 0 1.683010e-07
I7968 n1_m1_374400_432000 0 3.734271e-07
I7969 n1_m1_374400_436800 0 6.103168e-07
I7970 n1_m1_374400_441600 0 7.752702e-07
I7971 n1_m1_374400_446400 0 2.798718e-07
I7972 n1_m1_374400_451200 0 1.617655e-07
I7973 n1_m1_374400_456000 0 2.214470e-07
I7974 n1_m1_374400_460800 0 1.511203e-07
I7975 n1_m1_374400_465600 0 2.303050e-07
I7976 n1_m1_374400_470400 0 1.657786e-07
I7977 n1_m1_374400_475200 0 1.710347e-07
I7978 n1_m1_374400_480000 0 2.445635e-07
I7979 n1_m1_379200_0 0 1.484492e-07
I7980 n1_m1_379200_4800 0 1.682423e-07
I7981 n1_m1_379200_9600 0 2.314979e-07
I7982 n1_m1_379200_14400 0 1.398764e-07
I7983 n1_m1_379200_19200 0 1.390604e-07
I7984 n1_m1_379200_24000 0 2.060767e-07
I7985 n1_m1_379200_28800 0 1.432992e-07
I7986 n1_m1_379200_33600 0 2.085930e-07
I7987 n1_m1_379200_38400 0 1.345194e-07
I7988 n1_m1_379200_43200 0 1.332992e-07
I7989 n1_m1_379200_48000 0 1.998628e-07
I7990 n1_m1_379200_52800 0 1.332419e-07
I7991 n1_m1_379200_57600 0 1.998628e-07
I7992 n1_m1_379200_62400 0 1.332419e-07
I7993 n1_m1_379200_67200 0 1.416070e-07
I7994 n1_m1_379200_72000 0 2.201244e-07
I7995 n1_m1_379200_76800 0 1.422926e-07
I7996 n1_m1_379200_81600 0 2.252947e-07
I7997 n1_m1_379200_86400 0 1.985172e-07
I7998 n1_m1_379200_91200 0 1.831665e-07
I7999 n1_m1_379200_96000 0 2.219018e-07
I8000 n1_m1_379200_100800 0 1.447500e-07
I8001 n1_m1_379200_105600 0 2.116271e-07
I8002 n1_m1_379200_110400 0 1.428885e-07
I8003 n1_m1_379200_115200 0 1.495467e-07
I8004 n1_m1_379200_120000 0 2.660212e-07
I8005 n1_m1_379200_124800 0 3.277014e-07
I8006 n1_m1_379200_129600 0 5.627205e-07
I8007 n1_m1_379200_134400 0 3.859494e-07
I8008 n1_m1_379200_139200 0 2.658619e-07
I8009 n1_m1_379200_144000 0 2.696248e-07
I8010 n1_m1_379200_148800 0 1.701055e-07
I8011 n1_m1_379200_153600 0 2.422400e-07
I8012 n1_m1_379200_158400 0 1.564627e-07
I8013 n1_m1_379200_163200 0 1.449028e-07
I8014 n1_m1_379200_168000 0 2.253759e-07
I8015 n1_m1_379200_172800 0 1.636947e-07
I8016 n1_m1_379200_177600 0 5.953375e-07
I8017 n1_m1_379200_182400 0 3.912875e-07
I8018 n1_m1_379200_187200 0 4.459254e-07
I8019 n1_m1_379200_192000 0 9.062630e-07
I8020 n1_m1_379200_196800 0 5.227556e-07
I8021 n1_m1_379200_201600 0 4.285213e-07
I8022 n1_m1_379200_206400 0 2.534090e-07
I8023 n1_m1_379200_211200 0 2.243562e-07
I8024 n1_m1_379200_216000 0 2.655644e-07
I8025 n1_m1_379200_220800 0 2.266419e-07
I8026 n1_m1_379200_225600 0 5.552014e-07
I8027 n1_m1_379200_230400 0 4.904921e-07
I8028 n1_m1_379200_235200 0 7.041271e-07
I8029 n1_m1_379200_240000 0 1.487459e-06
I8030 n1_m1_379200_244800 0 7.514142e-07
I8031 n1_m1_379200_249600 0 1.079181e-06
I8032 n1_m1_379200_254400 0 9.968256e-07
I8033 n1_m1_379200_259200 0 8.147243e-07
I8034 n1_m1_379200_264000 0 9.828387e-07
I8035 n1_m1_379200_268800 0 3.879537e-07
I8036 n1_m1_379200_273600 0 5.686544e-07
I8037 n1_m1_379200_278400 0 4.883559e-07
I8038 n1_m1_379200_283200 0 8.519471e-07
I8039 n1_m1_379200_288000 0 7.251440e-07
I8040 n1_m1_379200_292800 0 3.682086e-07
I8041 n1_m1_379200_297600 0 3.750046e-07
I8042 n1_m1_379200_302400 0 3.280093e-07
I8043 n1_m1_379200_307200 0 2.656230e-07
I8044 n1_m1_379200_312000 0 2.824384e-07
I8045 n1_m1_379200_316800 0 1.622131e-07
I8046 n1_m1_379200_321600 0 2.370912e-07
I8047 n1_m1_379200_326400 0 1.934607e-07
I8048 n1_m1_379200_331200 0 2.257251e-07
I8049 n1_m1_379200_336000 0 2.522582e-07
I8050 n1_m1_379200_340800 0 1.621606e-07
I8051 n1_m1_379200_345600 0 2.234337e-07
I8052 n1_m1_379200_350400 0 1.475909e-07
I8053 n1_m1_379200_355200 0 1.488451e-07
I8054 n1_m1_379200_360000 0 2.207952e-07
I8055 n1_m1_379200_364800 0 1.410612e-07
I8056 n1_m1_379200_369600 0 2.121955e-07
I8057 n1_m1_379200_374400 0 1.462086e-07
I8058 n1_m1_379200_379200 0 1.525354e-07
I8059 n1_m1_379200_384000 0 2.423387e-07
I8060 n1_m1_379200_388800 0 1.704526e-07
I8061 n1_m1_379200_393600 0 4.918832e-07
I8062 n1_m1_379200_398400 0 2.300353e-07
I8063 n1_m1_379200_403200 0 2.309778e-07
I8064 n1_m1_379200_408000 0 6.017043e-07
I8065 n1_m1_379200_412800 0 4.895995e-07
I8066 n1_m1_379200_417600 0 6.265118e-07
I8067 n1_m1_379200_422400 0 2.989027e-07
I8068 n1_m1_379200_427200 0 1.857753e-07
I8069 n1_m1_379200_432000 0 5.701948e-07
I8070 n1_m1_379200_436800 0 6.819048e-07
I8071 n1_m1_379200_441600 0 5.530787e-07
I8072 n1_m1_379200_446400 0 1.956724e-07
I8073 n1_m1_379200_451200 0 1.655519e-07
I8074 n1_m1_379200_456000 0 2.219465e-07
I8075 n1_m1_379200_460800 0 1.474608e-07
I8076 n1_m1_379200_465600 0 2.229880e-07
I8077 n1_m1_379200_470400 0 1.582080e-07
I8078 n1_m1_379200_475200 0 1.665799e-07
I8079 n1_m1_379200_480000 0 2.388856e-07
I8080 n1_m1_384000_0 0 2.313346e-07
I8081 n1_m1_384000_4800 0 2.580186e-07
I8082 n1_m1_384000_9600 0 3.505814e-07
I8083 n1_m1_384000_14400 0 2.181045e-07
I8084 n1_m1_384000_19200 0 2.146502e-07
I8085 n1_m1_384000_24000 0 3.087455e-07
I8086 n1_m1_384000_28800 0 2.109687e-07
I8087 n1_m1_384000_33600 0 3.073137e-07
I8088 n1_m1_384000_38400 0 2.004310e-07
I8089 n1_m1_384000_43200 0 1.998628e-07
I8090 n1_m1_384000_48000 0 2.997942e-07
I8091 n1_m1_384000_52800 0 1.998628e-07
I8092 n1_m1_384000_57600 0 2.997942e-07
I8093 n1_m1_384000_62400 0 1.998628e-07
I8094 n1_m1_384000_67200 0 2.143570e-07
I8095 n1_m1_384000_72000 0 3.164446e-07
I8096 n1_m1_384000_76800 0 2.343884e-07
I8097 n1_m1_384000_81600 0 5.492131e-07
I8098 n1_m1_384000_86400 0 5.787940e-07
I8099 n1_m1_384000_91200 0 4.979634e-07
I8100 n1_m1_384000_96000 0 3.988528e-07
I8101 n1_m1_384000_100800 0 2.238579e-07
I8102 n1_m1_384000_105600 0 3.282830e-07
I8103 n1_m1_384000_110400 0 2.409898e-07
I8104 n1_m1_384000_115200 0 3.235622e-07
I8105 n1_m1_384000_120000 0 9.837319e-07
I8106 n1_m1_384000_124800 0 1.495445e-06
I8107 n1_m1_384000_129600 0 2.140163e-06
I8108 n1_m1_384000_134400 0 1.103385e-06
I8109 n1_m1_384000_139200 0 5.531945e-07
I8110 n1_m1_384000_144000 0 3.928104e-07
I8111 n1_m1_384000_148800 0 3.082143e-07
I8112 n1_m1_384000_153600 0 4.964191e-07
I8113 n1_m1_384000_158400 0 2.624082e-07
I8114 n1_m1_384000_163200 0 2.297533e-07
I8115 n1_m1_384000_168000 0 3.543000e-07
I8116 n1_m1_384000_172800 0 2.721319e-07
I8117 n1_m1_384000_177600 0 1.307996e-06
I8118 n1_m1_384000_182400 0 5.306821e-07
I8119 n1_m1_384000_187200 0 9.962024e-07
I8120 n1_m1_384000_192000 0 1.704106e-06
I8121 n1_m1_384000_196800 0 8.984962e-07
I8122 n1_m1_384000_201600 0 6.319449e-07
I8123 n1_m1_384000_206400 0 3.963165e-07
I8124 n1_m1_384000_211200 0 2.622812e-07
I8125 n1_m1_384000_216000 0 6.026439e-07
I8126 n1_m1_384000_220800 0 3.270605e-07
I8127 n1_m1_384000_225600 0 9.554541e-07
I8128 n1_m1_384000_230400 0 1.098324e-06
I8129 n1_m1_384000_235200 0 1.117529e-06
I8130 n1_m1_384000_240000 0 2.136853e-06
I8131 n1_m1_384000_244800 0 1.152484e-06
I8132 n1_m1_384000_249600 0 1.317007e-06
I8133 n1_m1_384000_254400 0 8.379018e-07
I8134 n1_m1_384000_259200 0 8.333780e-07
I8135 n1_m1_384000_264000 0 2.067426e-06
I8136 n1_m1_384000_268800 0 1.004044e-06
I8137 n1_m1_384000_273600 0 7.812087e-07
I8138 n1_m1_384000_278400 0 4.337073e-07
I8139 n1_m1_384000_283200 0 5.786296e-07
I8140 n1_m1_384000_288000 0 7.830952e-07
I8141 n1_m1_384000_292800 0 7.217244e-07
I8142 n1_m1_384000_297600 0 5.638577e-07
I8143 n1_m1_384000_302400 0 3.104136e-07
I8144 n1_m1_384000_307200 0 2.936466e-07
I8145 n1_m1_384000_312000 0 4.442248e-07
I8146 n1_m1_384000_316800 0 2.761132e-07
I8147 n1_m1_384000_321600 0 3.704959e-07
I8148 n1_m1_384000_326400 0 2.454029e-07
I8149 n1_m1_384000_331200 0 2.507867e-07
I8150 n1_m1_384000_336000 0 3.568741e-07
I8151 n1_m1_384000_340800 0 2.342712e-07
I8152 n1_m1_384000_345600 0 3.369882e-07
I8153 n1_m1_384000_350400 0 2.370049e-07
I8154 n1_m1_384000_355200 0 2.532136e-07
I8155 n1_m1_384000_360000 0 3.695267e-07
I8156 n1_m1_384000_364800 0 2.137376e-07
I8157 n1_m1_384000_369600 0 3.210483e-07
I8158 n1_m1_384000_374400 0 2.198633e-07
I8159 n1_m1_384000_379200 0 2.317145e-07
I8160 n1_m1_384000_384000 0 3.818727e-07
I8161 n1_m1_384000_388800 0 2.689850e-07
I8162 n1_m1_384000_393600 0 5.412176e-07
I8163 n1_m1_384000_398400 0 7.188914e-07
I8164 n1_m1_384000_403200 0 6.810195e-07
I8165 n1_m1_384000_408000 0 9.953822e-07
I8166 n1_m1_384000_412800 0 3.750202e-07
I8167 n1_m1_384000_417600 0 5.567095e-07
I8168 n1_m1_384000_422400 0 3.268805e-07
I8169 n1_m1_384000_427200 0 2.931481e-07
I8170 n1_m1_384000_432000 0 4.682821e-07
I8171 n1_m1_384000_436800 0 4.333190e-07
I8172 n1_m1_384000_441600 0 4.513940e-07
I8173 n1_m1_384000_446400 0 2.618394e-07
I8174 n1_m1_384000_451200 0 2.432299e-07
I8175 n1_m1_384000_456000 0 3.397007e-07
I8176 n1_m1_384000_460800 0 2.249658e-07
I8177 n1_m1_384000_465600 0 3.309807e-07
I8178 n1_m1_384000_470400 0 2.270755e-07
I8179 n1_m1_384000_475200 0 2.405374e-07
I8180 n1_m1_384000_480000 0 3.443298e-07
I8181 n1_m1_388800_0 0 1.470896e-07
I8182 n1_m1_388800_4800 0 1.560434e-07
I8183 n1_m1_388800_9600 0 2.147566e-07
I8184 n1_m1_388800_14400 0 1.447767e-07
I8185 n1_m1_388800_19200 0 1.462082e-07
I8186 n1_m1_388800_24000 0 2.051485e-07
I8187 n1_m1_388800_28800 0 1.380526e-07
I8188 n1_m1_388800_33600 0 2.010801e-07
I8189 n1_m1_388800_38400 0 1.332419e-07
I8190 n1_m1_388800_43200 0 1.332419e-07
I8191 n1_m1_388800_48000 0 1.998628e-07
I8192 n1_m1_388800_52800 0 1.332419e-07
I8193 n1_m1_388800_57600 0 1.998628e-07
I8194 n1_m1_388800_62400 0 1.332419e-07
I8195 n1_m1_388800_67200 0 1.449677e-07
I8196 n1_m1_388800_72000 0 2.165456e-07
I8197 n1_m1_388800_76800 0 1.927912e-07
I8198 n1_m1_388800_81600 0 4.950978e-07
I8199 n1_m1_388800_86400 0 2.606541e-07
I8200 n1_m1_388800_91200 0 2.361641e-07
I8201 n1_m1_388800_96000 0 2.428520e-07
I8202 n1_m1_388800_100800 0 1.511076e-07
I8203 n1_m1_388800_105600 0 2.363942e-07
I8204 n1_m1_388800_110400 0 1.769566e-07
I8205 n1_m1_388800_115200 0 2.434413e-07
I8206 n1_m1_388800_120000 0 7.114126e-07
I8207 n1_m1_388800_124800 0 8.677391e-07
I8208 n1_m1_388800_129600 0 8.734837e-07
I8209 n1_m1_388800_134400 0 5.297061e-07
I8210 n1_m1_388800_139200 0 3.767488e-07
I8211 n1_m1_388800_144000 0 2.835040e-07
I8212 n1_m1_388800_148800 0 1.818916e-07
I8213 n1_m1_388800_153600 0 2.754777e-07
I8214 n1_m1_388800_158400 0 1.725747e-07
I8215 n1_m1_388800_163200 0 1.580400e-07
I8216 n1_m1_388800_168000 0 2.578652e-07
I8217 n1_m1_388800_172800 0 1.797854e-07
I8218 n1_m1_388800_177600 0 7.094274e-07
I8219 n1_m1_388800_182400 0 5.257351e-07
I8220 n1_m1_388800_187200 0 8.923442e-07
I8221 n1_m1_388800_192000 0 8.889514e-07
I8222 n1_m1_388800_196800 0 3.826989e-07
I8223 n1_m1_388800_201600 0 3.681498e-07
I8224 n1_m1_388800_206400 0 1.927506e-07
I8225 n1_m1_388800_211200 0 1.697802e-07
I8226 n1_m1_388800_216000 0 3.685292e-07
I8227 n1_m1_388800_220800 0 2.067749e-07
I8228 n1_m1_388800_225600 0 5.340758e-07
I8229 n1_m1_388800_230400 0 5.094382e-07
I8230 n1_m1_388800_235200 0 4.266783e-07
I8231 n1_m1_388800_240000 0 6.737367e-07
I8232 n1_m1_388800_244800 0 2.967703e-07
I8233 n1_m1_388800_249600 0 3.996565e-07
I8234 n1_m1_388800_254400 0 3.166638e-07
I8235 n1_m1_388800_259200 0 3.544799e-07
I8236 n1_m1_388800_264000 0 9.603770e-07
I8237 n1_m1_388800_268800 0 5.224477e-07
I8238 n1_m1_388800_273600 0 3.763943e-07
I8239 n1_m1_388800_278400 0 2.488074e-07
I8240 n1_m1_388800_283200 0 2.338039e-07
I8241 n1_m1_388800_288000 0 2.772109e-07
I8242 n1_m1_388800_292800 0 1.897994e-07
I8243 n1_m1_388800_297600 0 2.411587e-07
I8244 n1_m1_388800_302400 0 1.759545e-07
I8245 n1_m1_388800_307200 0 1.693213e-07
I8246 n1_m1_388800_312000 0 2.552003e-07
I8247 n1_m1_388800_316800 0 1.689954e-07
I8248 n1_m1_388800_321600 0 2.405554e-07
I8249 n1_m1_388800_326400 0 1.626484e-07
I8250 n1_m1_388800_331200 0 1.688098e-07
I8251 n1_m1_388800_336000 0 2.462360e-07
I8252 n1_m1_388800_340800 0 1.634553e-07
I8253 n1_m1_388800_345600 0 2.371100e-07
I8254 n1_m1_388800_350400 0 1.667838e-07
I8255 n1_m1_388800_355200 0 1.732144e-07
I8256 n1_m1_388800_360000 0 2.501444e-07
I8257 n1_m1_388800_364800 0 1.495812e-07
I8258 n1_m1_388800_369600 0 2.201577e-07
I8259 n1_m1_388800_374400 0 1.503791e-07
I8260 n1_m1_388800_379200 0 1.540854e-07
I8261 n1_m1_388800_384000 0 2.488414e-07
I8262 n1_m1_388800_388800 0 1.774815e-07
I8263 n1_m1_388800_393600 0 4.154234e-07
I8264 n1_m1_388800_398400 0 6.550832e-07
I8265 n1_m1_388800_403200 0 4.411145e-07
I8266 n1_m1_388800_408000 0 7.411718e-07
I8267 n1_m1_388800_412800 0 2.645474e-07
I8268 n1_m1_388800_417600 0 4.660573e-07
I8269 n1_m1_388800_422400 0 1.679562e-07
I8270 n1_m1_388800_427200 0 1.683672e-07
I8271 n1_m1_388800_432000 0 2.620993e-07
I8272 n1_m1_388800_436800 0 2.176225e-07
I8273 n1_m1_388800_441600 0 2.705385e-07
I8274 n1_m1_388800_446400 0 1.740207e-07
I8275 n1_m1_388800_451200 0 1.539106e-07
I8276 n1_m1_388800_456000 0 2.277572e-07
I8277 n1_m1_388800_460800 0 1.510809e-07
I8278 n1_m1_388800_465600 0 2.163428e-07
I8279 n1_m1_388800_470400 0 1.495227e-07
I8280 n1_m1_388800_475200 0 1.556232e-07
I8281 n1_m1_388800_480000 0 2.224506e-07
I8282 n1_m1_393600_0 0 1.586155e-07
I8283 n1_m1_393600_4800 0 1.679009e-07
I8284 n1_m1_393600_9600 0 2.260343e-07
I8285 n1_m1_393600_14400 0 1.447767e-07
I8286 n1_m1_393600_19200 0 1.427861e-07
I8287 n1_m1_393600_24000 0 2.041776e-07
I8288 n1_m1_393600_28800 0 1.370134e-07
I8289 n1_m1_393600_33600 0 2.044768e-07
I8290 n1_m1_393600_38400 0 1.370965e-07
I8291 n1_m1_393600_43200 0 1.335399e-07
I8292 n1_m1_393600_48000 0 1.998628e-07
I8293 n1_m1_393600_52800 0 1.332419e-07
I8294 n1_m1_393600_57600 0 1.998628e-07
I8295 n1_m1_393600_62400 0 1.332419e-07
I8296 n1_m1_393600_67200 0 1.371283e-07
I8297 n1_m1_393600_72000 0 2.116023e-07
I8298 n1_m1_393600_76800 0 1.662074e-07
I8299 n1_m1_393600_81600 0 3.296289e-07
I8300 n1_m1_393600_86400 0 1.745604e-07
I8301 n1_m1_393600_91200 0 1.643158e-07
I8302 n1_m1_393600_96000 0 2.272722e-07
I8303 n1_m1_393600_100800 0 1.475211e-07
I8304 n1_m1_393600_105600 0 2.259237e-07
I8305 n1_m1_393600_110400 0 1.579662e-07
I8306 n1_m1_393600_115200 0 1.840109e-07
I8307 n1_m1_393600_120000 0 4.175883e-07
I8308 n1_m1_393600_124800 0 6.278314e-07
I8309 n1_m1_393600_129600 0 1.003755e-06
I8310 n1_m1_393600_134400 0 8.622144e-07
I8311 n1_m1_393600_139200 0 5.973423e-07
I8312 n1_m1_393600_144000 0 4.761727e-07
I8313 n1_m1_393600_148800 0 1.634835e-07
I8314 n1_m1_393600_153600 0 2.362065e-07
I8315 n1_m1_393600_158400 0 1.537658e-07
I8316 n1_m1_393600_163200 0 1.539866e-07
I8317 n1_m1_393600_168000 0 2.365759e-07
I8318 n1_m1_393600_172800 0 1.793208e-07
I8319 n1_m1_393600_177600 0 6.374185e-07
I8320 n1_m1_393600_182400 0 4.123067e-07
I8321 n1_m1_393600_187200 0 6.177880e-07
I8322 n1_m1_393600_192000 0 6.431874e-07
I8323 n1_m1_393600_196800 0 1.911467e-07
I8324 n1_m1_393600_201600 0 3.879624e-07
I8325 n1_m1_393600_206400 0 1.562924e-07
I8326 n1_m1_393600_211200 0 1.618909e-07
I8327 n1_m1_393600_216000 0 2.520644e-07
I8328 n1_m1_393600_220800 0 1.832935e-07
I8329 n1_m1_393600_225600 0 2.899059e-07
I8330 n1_m1_393600_230400 0 1.880576e-07
I8331 n1_m1_393600_235200 0 1.840783e-07
I8332 n1_m1_393600_240000 0 2.557863e-07
I8333 n1_m1_393600_244800 0 2.385423e-07
I8334 n1_m1_393600_249600 0 3.023442e-07
I8335 n1_m1_393600_254400 0 1.613373e-07
I8336 n1_m1_393600_259200 0 1.874648e-07
I8337 n1_m1_393600_264000 0 3.469236e-07
I8338 n1_m1_393600_268800 0 5.080475e-07
I8339 n1_m1_393600_273600 0 3.232842e-07
I8340 n1_m1_393600_278400 0 1.602481e-07
I8341 n1_m1_393600_283200 0 1.548060e-07
I8342 n1_m1_393600_288000 0 2.349868e-07
I8343 n1_m1_393600_292800 0 1.588891e-07
I8344 n1_m1_393600_297600 0 2.402838e-07
I8345 n1_m1_393600_302400 0 1.639445e-07
I8346 n1_m1_393600_307200 0 1.534709e-07
I8347 n1_m1_393600_312000 0 4.060453e-07
I8348 n1_m1_393600_316800 0 2.839108e-07
I8349 n1_m1_393600_321600 0 2.308399e-07
I8350 n1_m1_393600_326400 0 1.686963e-07
I8351 n1_m1_393600_331200 0 1.554018e-07
I8352 n1_m1_393600_336000 0 7.786991e-07
I8353 n1_m1_393600_340800 0 2.668298e-07
I8354 n1_m1_393600_345600 0 2.391453e-07
I8355 n1_m1_393600_350400 0 1.652259e-07
I8356 n1_m1_393600_355200 0 2.256603e-07
I8357 n1_m1_393600_360000 0 2.654854e-07
I8358 n1_m1_393600_364800 0 1.512736e-07
I8359 n1_m1_393600_369600 0 2.199944e-07
I8360 n1_m1_393600_374400 0 1.506028e-07
I8361 n1_m1_393600_379200 0 1.671587e-07
I8362 n1_m1_393600_384000 0 2.542791e-07
I8363 n1_m1_393600_388800 0 1.778468e-07
I8364 n1_m1_393600_393600 0 2.968556e-07
I8365 n1_m1_393600_398400 0 2.848636e-07
I8366 n1_m1_393600_403200 0 2.037517e-07
I8367 n1_m1_393600_408000 0 3.883039e-07
I8368 n1_m1_393600_412800 0 1.988111e-07
I8369 n1_m1_393600_417600 0 3.097907e-07
I8370 n1_m1_393600_422400 0 1.645427e-07
I8371 n1_m1_393600_427200 0 1.627190e-07
I8372 n1_m1_393600_432000 0 2.356901e-07
I8373 n1_m1_393600_436800 0 1.603536e-07
I8374 n1_m1_393600_441600 0 2.460407e-07
I8375 n1_m1_393600_446400 0 1.622209e-07
I8376 n1_m1_393600_451200 0 1.500151e-07
I8377 n1_m1_393600_456000 0 2.183703e-07
I8378 n1_m1_393600_460800 0 1.425530e-07
I8379 n1_m1_393600_465600 0 2.191802e-07
I8380 n1_m1_393600_470400 0 1.580458e-07
I8381 n1_m1_393600_475200 0 1.607451e-07
I8382 n1_m1_393600_480000 0 2.258367e-07
I8383 n1_m1_398400_0 0 1.512117e-07
I8384 n1_m1_398400_4800 0 1.648766e-07
I8385 n1_m1_398400_9600 0 2.227528e-07
I8386 n1_m1_398400_14400 0 1.393938e-07
I8387 n1_m1_398400_19200 0 1.397250e-07
I8388 n1_m1_398400_24000 0 2.037582e-07
I8389 n1_m1_398400_28800 0 1.378376e-07
I8390 n1_m1_398400_33600 0 2.008283e-07
I8391 n1_m1_398400_38400 0 1.332419e-07
I8392 n1_m1_398400_43200 0 1.332419e-07
I8393 n1_m1_398400_48000 0 1.998628e-07
I8394 n1_m1_398400_52800 0 1.346822e-07
I8395 n1_m1_398400_57600 0 2.020135e-07
I8396 n1_m1_398400_62400 0 1.332419e-07
I8397 n1_m1_398400_67200 0 1.323235e-07
I8398 n1_m1_398400_72000 0 1.997886e-07
I8399 n1_m1_398400_76800 0 1.399222e-07
I8400 n1_m1_398400_81600 0 2.270998e-07
I8401 n1_m1_398400_86400 0 1.490790e-07
I8402 n1_m1_398400_91200 0 1.435739e-07
I8403 n1_m1_398400_96000 0 2.079021e-07
I8404 n1_m1_398400_100800 0 1.380045e-07
I8405 n1_m1_398400_105600 0 2.077840e-07
I8406 n1_m1_398400_110400 0 1.427876e-07
I8407 n1_m1_398400_115200 0 1.466899e-07
I8408 n1_m1_398400_120000 0 2.331055e-07
I8409 n1_m1_398400_124800 0 2.568766e-07
I8410 n1_m1_398400_129600 0 4.521980e-07
I8411 n1_m1_398400_134400 0 4.630551e-07
I8412 n1_m1_398400_139200 0 3.115408e-07
I8413 n1_m1_398400_144000 0 2.866691e-07
I8414 n1_m1_398400_148800 0 1.476074e-07
I8415 n1_m1_398400_153600 0 2.134476e-07
I8416 n1_m1_398400_158400 0 1.399040e-07
I8417 n1_m1_398400_163200 0 1.399040e-07
I8418 n1_m1_398400_168000 0 2.120404e-07
I8419 n1_m1_398400_172800 0 1.554877e-07
I8420 n1_m1_398400_177600 0 3.368784e-07
I8421 n1_m1_398400_182400 0 2.925550e-07
I8422 n1_m1_398400_187200 0 6.227157e-07
I8423 n1_m1_398400_192000 0 5.328077e-07
I8424 n1_m1_398400_196800 0 1.951454e-07
I8425 n1_m1_398400_201600 0 2.633342e-07
I8426 n1_m1_398400_206400 0 1.723968e-07
I8427 n1_m1_398400_211200 0 1.532282e-07
I8428 n1_m1_398400_216000 0 2.308361e-07
I8429 n1_m1_398400_220800 0 1.567312e-07
I8430 n1_m1_398400_225600 0 2.337681e-07
I8431 n1_m1_398400_230400 0 1.648011e-07
I8432 n1_m1_398400_235200 0 1.659605e-07
I8433 n1_m1_398400_240000 0 2.422442e-07
I8434 n1_m1_398400_244800 0 1.537232e-07
I8435 n1_m1_398400_249600 0 2.237458e-07
I8436 n1_m1_398400_254400 0 1.625772e-07
I8437 n1_m1_398400_259200 0 1.606465e-07
I8438 n1_m1_398400_264000 0 2.759173e-07
I8439 n1_m1_398400_268800 0 1.617079e-07
I8440 n1_m1_398400_273600 0 2.471057e-07
I8441 n1_m1_398400_278400 0 1.617898e-07
I8442 n1_m1_398400_283200 0 1.577430e-07
I8443 n1_m1_398400_288000 0 2.360278e-07
I8444 n1_m1_398400_292800 0 1.579907e-07
I8445 n1_m1_398400_297600 0 2.363960e-07
I8446 n1_m1_398400_302400 0 1.500467e-07
I8447 n1_m1_398400_307200 0 1.600984e-07
I8448 n1_m1_398400_312000 0 2.353204e-07
I8449 n1_m1_398400_316800 0 1.591124e-07
I8450 n1_m1_398400_321600 0 4.048453e-07
I8451 n1_m1_398400_326400 0 2.191233e-07
I8452 n1_m1_398400_331200 0 3.478129e-07
I8453 n1_m1_398400_336000 0 4.250266e-07
I8454 n1_m1_398400_340800 0 3.757908e-07
I8455 n1_m1_398400_345600 0 3.065513e-07
I8456 n1_m1_398400_350400 0 1.598415e-07
I8457 n1_m1_398400_355200 0 1.574677e-07
I8458 n1_m1_398400_360000 0 2.854403e-07
I8459 n1_m1_398400_364800 0 1.595941e-07
I8460 n1_m1_398400_369600 0 4.482547e-07
I8461 n1_m1_398400_374400 0 3.114458e-07
I8462 n1_m1_398400_379200 0 2.755840e-07
I8463 n1_m1_398400_384000 0 2.598176e-07
I8464 n1_m1_398400_388800 0 1.612560e-07
I8465 n1_m1_398400_393600 0 2.437333e-07
I8466 n1_m1_398400_398400 0 1.613954e-07
I8467 n1_m1_398400_403200 0 1.532282e-07
I8468 n1_m1_398400_408000 0 2.496937e-07
I8469 n1_m1_398400_412800 0 1.868456e-07
I8470 n1_m1_398400_417600 0 2.579237e-07
I8471 n1_m1_398400_422400 0 1.703514e-07
I8472 n1_m1_398400_427200 0 1.821678e-07
I8473 n1_m1_398400_432000 0 3.016545e-07
I8474 n1_m1_398400_436800 0 1.744506e-07
I8475 n1_m1_398400_441600 0 2.300810e-07
I8476 n1_m1_398400_446400 0 1.541734e-07
I8477 n1_m1_398400_451200 0 1.623103e-07
I8478 n1_m1_398400_456000 0 2.242305e-07
I8479 n1_m1_398400_460800 0 1.484656e-07
I8480 n1_m1_398400_465600 0 2.239776e-07
I8481 n1_m1_398400_470400 0 1.547829e-07
I8482 n1_m1_398400_475200 0 1.561605e-07
I8483 n1_m1_398400_480000 0 2.259161e-07
I8484 n1_m1_403200_0 0 1.457939e-07
I8485 n1_m1_403200_4800 0 1.578566e-07
I8486 n1_m1_403200_9600 0 2.135613e-07
I8487 n1_m1_403200_14400 0 1.381146e-07
I8488 n1_m1_403200_19200 0 1.397250e-07
I8489 n1_m1_403200_24000 0 2.037582e-07
I8490 n1_m1_403200_28800 0 1.389126e-07
I8491 n1_m1_403200_33600 0 2.024133e-07
I8492 n1_m1_403200_38400 0 1.360980e-07
I8493 n1_m1_403200_43200 0 1.398040e-07
I8494 n1_m1_403200_48000 0 2.084927e-07
I8495 n1_m1_403200_52800 0 1.411308e-07
I8496 n1_m1_403200_57600 0 2.099929e-07
I8497 n1_m1_403200_62400 0 1.332419e-07
I8498 n1_m1_403200_67200 0 1.300210e-07
I8499 n1_m1_403200_72000 0 1.944277e-07
I8500 n1_m1_403200_76800 0 1.327131e-07
I8501 n1_m1_403200_81600 0 2.078713e-07
I8502 n1_m1_403200_86400 0 1.343181e-07
I8503 n1_m1_403200_91200 0 1.332419e-07
I8504 n1_m1_403200_96000 0 2.008165e-07
I8505 n1_m1_403200_100800 0 1.355268e-07
I8506 n1_m1_403200_105600 0 2.032902e-07
I8507 n1_m1_403200_110400 0 1.359288e-07
I8508 n1_m1_403200_115200 0 1.380334e-07
I8509 n1_m1_403200_120000 0 2.120486e-07
I8510 n1_m1_403200_124800 0 1.690877e-07
I8511 n1_m1_403200_129600 0 2.631025e-07
I8512 n1_m1_403200_134400 0 2.038546e-07
I8513 n1_m1_403200_139200 0 1.783842e-07
I8514 n1_m1_403200_144000 0 2.440464e-07
I8515 n1_m1_403200_148800 0 1.418740e-07
I8516 n1_m1_403200_153600 0 2.115130e-07
I8517 n1_m1_403200_158400 0 1.382233e-07
I8518 n1_m1_403200_163200 0 1.396113e-07
I8519 n1_m1_403200_168000 0 2.118529e-07
I8520 n1_m1_403200_172800 0 1.433451e-07
I8521 n1_m1_403200_177600 0 2.364122e-07
I8522 n1_m1_403200_182400 0 2.741027e-07
I8523 n1_m1_403200_187200 0 5.664811e-07
I8524 n1_m1_403200_192000 0 4.395893e-07
I8525 n1_m1_403200_196800 0 2.526455e-07
I8526 n1_m1_403200_201600 0 2.716973e-07
I8527 n1_m1_403200_206400 0 1.901981e-07
I8528 n1_m1_403200_211200 0 1.532282e-07
I8529 n1_m1_403200_216000 0 2.324104e-07
I8530 n1_m1_403200_220800 0 1.549702e-07
I8531 n1_m1_403200_225600 0 2.302552e-07
I8532 n1_m1_403200_230400 0 1.639639e-07
I8533 n1_m1_403200_235200 0 1.680471e-07
I8534 n1_m1_403200_240000 0 2.428588e-07
I8535 n1_m1_403200_244800 0 1.556206e-07
I8536 n1_m1_403200_249600 0 2.279927e-07
I8537 n1_m1_403200_254400 0 1.514992e-07
I8538 n1_m1_403200_259200 0 1.610160e-07
I8539 n1_m1_403200_264000 0 2.430855e-07
I8540 n1_m1_403200_268800 0 1.645220e-07
I8541 n1_m1_403200_273600 0 2.563779e-07
I8542 n1_m1_403200_278400 0 1.675815e-07
I8543 n1_m1_403200_283200 0 1.625055e-07
I8544 n1_m1_403200_288000 0 2.320721e-07
I8545 n1_m1_403200_292800 0 1.526380e-07
I8546 n1_m1_403200_297600 0 2.261888e-07
I8547 n1_m1_403200_302400 0 1.493341e-07
I8548 n1_m1_403200_307200 0 1.656951e-07
I8549 n1_m1_403200_312000 0 2.394285e-07
I8550 n1_m1_403200_316800 0 2.141530e-07
I8551 n1_m1_403200_321600 0 6.391291e-07
I8552 n1_m1_403200_326400 0 2.621216e-07
I8553 n1_m1_403200_331200 0 4.400621e-07
I8554 n1_m1_403200_336000 0 3.593176e-07
I8555 n1_m1_403200_340800 0 3.057835e-07
I8556 n1_m1_403200_345600 0 2.756125e-07
I8557 n1_m1_403200_350400 0 1.823392e-07
I8558 n1_m1_403200_355200 0 1.740231e-07
I8559 n1_m1_403200_360000 0 3.339476e-07
I8560 n1_m1_403200_364800 0 1.728826e-07
I8561 n1_m1_403200_369600 0 4.054591e-07
I8562 n1_m1_403200_374400 0 3.440512e-07
I8563 n1_m1_403200_379200 0 3.901040e-07
I8564 n1_m1_403200_384000 0 3.303714e-07
I8565 n1_m1_403200_388800 0 1.655018e-07
I8566 n1_m1_403200_393600 0 2.385460e-07
I8567 n1_m1_403200_398400 0 1.857215e-07
I8568 n1_m1_403200_403200 0 1.871717e-07
I8569 n1_m1_403200_408000 0 2.586535e-07
I8570 n1_m1_403200_412800 0 1.904682e-07
I8571 n1_m1_403200_417600 0 2.859185e-07
I8572 n1_m1_403200_422400 0 1.891201e-07
I8573 n1_m1_403200_427200 0 1.903822e-07
I8574 n1_m1_403200_432000 0 3.157414e-07
I8575 n1_m1_403200_436800 0 1.738235e-07
I8576 n1_m1_403200_441600 0 2.389310e-07
I8577 n1_m1_403200_446400 0 1.546683e-07
I8578 n1_m1_403200_451200 0 1.579866e-07
I8579 n1_m1_403200_456000 0 2.318160e-07
I8580 n1_m1_403200_460800 0 1.570710e-07
I8581 n1_m1_403200_465600 0 2.360833e-07
I8582 n1_m1_403200_470400 0 1.547672e-07
I8583 n1_m1_403200_475200 0 1.532282e-07
I8584 n1_m1_403200_480000 0 2.317259e-07
I8585 n1_m1_408000_0 0 2.264286e-07
I8586 n1_m1_408000_4800 0 2.487686e-07
I8587 n1_m1_408000_9600 0 3.343345e-07
I8588 n1_m1_408000_14400 0 2.086100e-07
I8589 n1_m1_408000_19200 0 2.095876e-07
I8590 n1_m1_408000_24000 0 3.056373e-07
I8591 n1_m1_408000_28800 0 2.055201e-07
I8592 n1_m1_408000_33600 0 3.019822e-07
I8593 n1_m1_408000_38400 0 2.193801e-07
I8594 n1_m1_408000_43200 0 2.457561e-07
I8595 n1_m1_408000_48000 0 3.558635e-07
I8596 n1_m1_408000_52800 0 2.208240e-07
I8597 n1_m1_408000_57600 0 3.203165e-07
I8598 n1_m1_408000_62400 0 1.967873e-07
I8599 n1_m1_408000_67200 0 1.979329e-07
I8600 n1_m1_408000_72000 0 2.891270e-07
I8601 n1_m1_408000_76800 0 1.983779e-07
I8602 n1_m1_408000_81600 0 3.118639e-07
I8603 n1_m1_408000_86400 0 2.013384e-07
I8604 n1_m1_408000_91200 0 1.998628e-07
I8605 n1_m1_408000_96000 0 3.014602e-07
I8606 n1_m1_408000_100800 0 2.063990e-07
I8607 n1_m1_408000_105600 0 3.138135e-07
I8608 n1_m1_408000_110400 0 2.084420e-07
I8609 n1_m1_408000_115200 0 2.052322e-07
I8610 n1_m1_408000_120000 0 3.142449e-07
I8611 n1_m1_408000_124800 0 2.383167e-07
I8612 n1_m1_408000_129600 0 3.496646e-07
I8613 n1_m1_408000_134400 0 2.471719e-07
I8614 n1_m1_408000_139200 0 2.300231e-07
I8615 n1_m1_408000_144000 0 3.356731e-07
I8616 n1_m1_408000_148800 0 2.137229e-07
I8617 n1_m1_408000_153600 0 3.220190e-07
I8618 n1_m1_408000_158400 0 2.012998e-07
I8619 n1_m1_408000_163200 0 2.085317e-07
I8620 n1_m1_408000_168000 0 3.257049e-07
I8621 n1_m1_408000_172800 0 2.182534e-07
I8622 n1_m1_408000_177600 0 3.407854e-07
I8623 n1_m1_408000_182400 0 2.916261e-07
I8624 n1_m1_408000_187200 0 4.453164e-07
I8625 n1_m1_408000_192000 0 4.628759e-07
I8626 n1_m1_408000_196800 0 3.870184e-07
I8627 n1_m1_408000_201600 0 3.929803e-07
I8628 n1_m1_408000_206400 0 2.504932e-07
I8629 n1_m1_408000_211200 0 2.359047e-07
I8630 n1_m1_408000_216000 0 3.667676e-07
I8631 n1_m1_408000_220800 0 2.420364e-07
I8632 n1_m1_408000_225600 0 3.453427e-07
I8633 n1_m1_408000_230400 0 2.449891e-07
I8634 n1_m1_408000_235200 0 2.518255e-07
I8635 n1_m1_408000_240000 0 3.793259e-07
I8636 n1_m1_408000_244800 0 2.450091e-07
I8637 n1_m1_408000_249600 0 3.647010e-07
I8638 n1_m1_408000_254400 0 2.835647e-07
I8639 n1_m1_408000_259200 0 2.399330e-07
I8640 n1_m1_408000_264000 0 4.811382e-07
I8641 n1_m1_408000_268800 0 2.726070e-07
I8642 n1_m1_408000_273600 0 3.869310e-07
I8643 n1_m1_408000_278400 0 2.540382e-07
I8644 n1_m1_408000_283200 0 2.437583e-07
I8645 n1_m1_408000_288000 0 3.488621e-07
I8646 n1_m1_408000_292800 0 2.294583e-07
I8647 n1_m1_408000_297600 0 3.405090e-07
I8648 n1_m1_408000_302400 0 2.402602e-07
I8649 n1_m1_408000_307200 0 2.550313e-07
I8650 n1_m1_408000_312000 0 3.645959e-07
I8651 n1_m1_408000_316800 0 3.257313e-07
I8652 n1_m1_408000_321600 0 6.066751e-07
I8653 n1_m1_408000_326400 0 4.938367e-07
I8654 n1_m1_408000_331200 0 7.270010e-07
I8655 n1_m1_408000_336000 0 7.037054e-07
I8656 n1_m1_408000_340800 0 3.431114e-07
I8657 n1_m1_408000_345600 0 3.903071e-07
I8658 n1_m1_408000_350400 0 2.780611e-07
I8659 n1_m1_408000_355200 0 2.680938e-07
I8660 n1_m1_408000_360000 0 3.965235e-07
I8661 n1_m1_408000_364800 0 2.660594e-07
I8662 n1_m1_408000_369600 0 4.392864e-07
I8663 n1_m1_408000_374400 0 3.016279e-07
I8664 n1_m1_408000_379200 0 3.425775e-07
I8665 n1_m1_408000_384000 0 4.567374e-07
I8666 n1_m1_408000_388800 0 2.486821e-07
I8667 n1_m1_408000_393600 0 6.331795e-07
I8668 n1_m1_408000_398400 0 5.963411e-07
I8669 n1_m1_408000_403200 0 4.732638e-07
I8670 n1_m1_408000_408000 0 4.177840e-07
I8671 n1_m1_408000_412800 0 2.555276e-07
I8672 n1_m1_408000_417600 0 4.364771e-07
I8673 n1_m1_408000_422400 0 2.929282e-07
I8674 n1_m1_408000_427200 0 2.578557e-07
I8675 n1_m1_408000_432000 0 3.889437e-07
I8676 n1_m1_408000_436800 0 2.530552e-07
I8677 n1_m1_408000_441600 0 3.665982e-07
I8678 n1_m1_408000_446400 0 2.301152e-07
I8679 n1_m1_408000_451200 0 2.223674e-07
I8680 n1_m1_408000_456000 0 3.404489e-07
I8681 n1_m1_408000_460800 0 2.389125e-07
I8682 n1_m1_408000_465600 0 3.611198e-07
I8683 n1_m1_408000_470400 0 2.318840e-07
I8684 n1_m1_408000_475200 0 2.291953e-07
I8685 n1_m1_408000_480000 0 3.470837e-07
I8686 n1_m1_412800_0 0 1.527739e-07
I8687 n1_m1_412800_4800 0 1.676673e-07
I8688 n1_m1_412800_9600 0 2.226119e-07
I8689 n1_m1_412800_14400 0 1.383623e-07
I8690 n1_m1_412800_19200 0 1.397250e-07
I8691 n1_m1_412800_24000 0 2.037582e-07
I8692 n1_m1_412800_28800 0 1.370134e-07
I8693 n1_m1_412800_33600 0 2.008244e-07
I8694 n1_m1_412800_38400 0 1.447697e-07
I8695 n1_m1_412800_43200 0 1.695145e-07
I8696 n1_m1_412800_48000 0 2.428498e-07
I8697 n1_m1_412800_52800 0 1.435487e-07
I8698 n1_m1_412800_57600 0 2.133882e-07
I8699 n1_m1_412800_62400 0 1.327122e-07
I8700 n1_m1_412800_67200 0 1.332419e-07
I8701 n1_m1_412800_72000 0 1.991973e-07
I8702 n1_m1_412800_76800 0 1.362309e-07
I8703 n1_m1_412800_81600 0 2.139086e-07
I8704 n1_m1_412800_86400 0 1.348799e-07
I8705 n1_m1_412800_91200 0 1.332419e-07
I8706 n1_m1_412800_96000 0 1.998628e-07
I8707 n1_m1_412800_100800 0 1.336801e-07
I8708 n1_m1_412800_105600 0 2.013832e-07
I8709 n1_m1_412800_110400 0 1.349430e-07
I8710 n1_m1_412800_115200 0 1.360688e-07
I8711 n1_m1_412800_120000 0 2.104650e-07
I8712 n1_m1_412800_124800 0 1.466720e-07
I8713 n1_m1_412800_129600 0 2.240608e-07
I8714 n1_m1_412800_134400 0 1.541504e-07
I8715 n1_m1_412800_139200 0 1.501269e-07
I8716 n1_m1_412800_144000 0 2.134147e-07
I8717 n1_m1_412800_148800 0 1.384642e-07
I8718 n1_m1_412800_153600 0 2.140029e-07
I8719 n1_m1_412800_158400 0 1.354137e-07
I8720 n1_m1_412800_163200 0 1.388240e-07
I8721 n1_m1_412800_168000 0 2.137177e-07
I8722 n1_m1_412800_172800 0 1.490972e-07
I8723 n1_m1_412800_177600 0 2.281903e-07
I8724 n1_m1_412800_182400 0 1.543160e-07
I8725 n1_m1_412800_187200 0 1.592534e-07
I8726 n1_m1_412800_192000 0 2.385985e-07
I8727 n1_m1_412800_196800 0 1.924928e-07
I8728 n1_m1_412800_201600 0 2.604986e-07
I8729 n1_m1_412800_206400 0 1.517255e-07
I8730 n1_m1_412800_211200 0 1.542723e-07
I8731 n1_m1_412800_216000 0 2.447433e-07
I8732 n1_m1_412800_220800 0 1.635634e-07
I8733 n1_m1_412800_225600 0 2.311589e-07
I8734 n1_m1_412800_230400 0 1.558286e-07
I8735 n1_m1_412800_235200 0 1.593600e-07
I8736 n1_m1_412800_240000 0 2.413977e-07
I8737 n1_m1_412800_244800 0 1.785370e-07
I8738 n1_m1_412800_249600 0 2.579074e-07
I8739 n1_m1_412800_254400 0 1.728197e-07
I8740 n1_m1_412800_259200 0 1.574387e-07
I8741 n1_m1_412800_264000 0 2.928248e-07
I8742 n1_m1_412800_268800 0 2.224609e-07
I8743 n1_m1_412800_273600 0 2.606186e-07
I8744 n1_m1_412800_278400 0 1.665063e-07
I8745 n1_m1_412800_283200 0 1.621759e-07
I8746 n1_m1_412800_288000 0 2.387607e-07
I8747 n1_m1_412800_292800 0 1.591849e-07
I8748 n1_m1_412800_297600 0 2.392181e-07
I8749 n1_m1_412800_302400 0 1.546580e-07
I8750 n1_m1_412800_307200 0 1.748203e-07
I8751 n1_m1_412800_312000 0 2.580583e-07
I8752 n1_m1_412800_316800 0 1.759142e-07
I8753 n1_m1_412800_321600 0 3.698756e-07
I8754 n1_m1_412800_326400 0 4.453770e-07
I8755 n1_m1_412800_331200 0 2.795499e-07
I8756 n1_m1_412800_336000 0 7.092425e-07
I8757 n1_m1_412800_340800 0 3.841091e-07
I8758 n1_m1_412800_345600 0 2.820568e-07
I8759 n1_m1_412800_350400 0 1.581559e-07
I8760 n1_m1_412800_355200 0 1.668383e-07
I8761 n1_m1_412800_360000 0 2.397440e-07
I8762 n1_m1_412800_364800 0 1.622222e-07
I8763 n1_m1_412800_369600 0 2.506827e-07
I8764 n1_m1_412800_374400 0 1.788799e-07
I8765 n1_m1_412800_379200 0 2.103171e-07
I8766 n1_m1_412800_384000 0 4.115709e-07
I8767 n1_m1_412800_388800 0 1.790357e-07
I8768 n1_m1_412800_393600 0 8.180738e-07
I8769 n1_m1_412800_398400 0 5.049988e-07
I8770 n1_m1_412800_403200 0 2.428296e-07
I8771 n1_m1_412800_408000 0 2.471912e-07
I8772 n1_m1_412800_412800 0 1.666193e-07
I8773 n1_m1_412800_417600 0 2.574550e-07
I8774 n1_m1_412800_422400 0 1.693925e-07
I8775 n1_m1_412800_427200 0 1.820981e-07
I8776 n1_m1_412800_432000 0 3.853265e-07
I8777 n1_m1_412800_436800 0 2.052389e-07
I8778 n1_m1_412800_441600 0 2.317549e-07
I8779 n1_m1_412800_446400 0 1.490264e-07
I8780 n1_m1_412800_451200 0 1.543756e-07
I8781 n1_m1_412800_456000 0 2.139379e-07
I8782 n1_m1_412800_460800 0 1.423772e-07
I8783 n1_m1_412800_465600 0 2.202739e-07
I8784 n1_m1_412800_470400 0 1.483279e-07
I8785 n1_m1_412800_475200 0 1.480053e-07
I8786 n1_m1_412800_480000 0 2.205403e-07
I8787 n1_m1_417600_0 0 2.163182e-07
I8788 n1_m1_417600_4800 0 2.361836e-07
I8789 n1_m1_417600_9600 0 3.200461e-07
I8790 n1_m1_417600_14400 0 2.043731e-07
I8791 n1_m1_417600_19200 0 2.086783e-07
I8792 n1_m1_417600_24000 0 3.070762e-07
I8793 n1_m1_417600_28800 0 2.093467e-07
I8794 n1_m1_417600_33600 0 3.018431e-07
I8795 n1_m1_417600_38400 0 2.055358e-07
I8796 n1_m1_417600_43200 0 2.279430e-07
I8797 n1_m1_417600_48000 0 3.313442e-07
I8798 n1_m1_417600_52800 0 2.104358e-07
I8799 n1_m1_417600_57600 0 3.202967e-07
I8800 n1_m1_417600_62400 0 2.014915e-07
I8801 n1_m1_417600_67200 0 2.036894e-07
I8802 n1_m1_417600_72000 0 3.030997e-07
I8803 n1_m1_417600_76800 0 2.098484e-07
I8804 n1_m1_417600_81600 0 3.166192e-07
I8805 n1_m1_417600_86400 0 2.013790e-07
I8806 n1_m1_417600_91200 0 1.998628e-07
I8807 n1_m1_417600_96000 0 2.997942e-07
I8808 n1_m1_417600_100800 0 1.998628e-07
I8809 n1_m1_417600_105600 0 3.013063e-07
I8810 n1_m1_417600_110400 0 2.091918e-07
I8811 n1_m1_417600_115200 0 2.141503e-07
I8812 n1_m1_417600_120000 0 3.286007e-07
I8813 n1_m1_417600_124800 0 2.200898e-07
I8814 n1_m1_417600_129600 0 3.390567e-07
I8815 n1_m1_417600_134400 0 2.221891e-07
I8816 n1_m1_417600_139200 0 2.258226e-07
I8817 n1_m1_417600_144000 0 3.285701e-07
I8818 n1_m1_417600_148800 0 2.137352e-07
I8819 n1_m1_417600_153600 0 3.183337e-07
I8820 n1_m1_417600_158400 0 2.189253e-07
I8821 n1_m1_417600_163200 0 2.178561e-07
I8822 n1_m1_417600_168000 0 3.239927e-07
I8823 n1_m1_417600_172800 0 2.202259e-07
I8824 n1_m1_417600_177600 0 3.308679e-07
I8825 n1_m1_417600_182400 0 2.269644e-07
I8826 n1_m1_417600_187200 0 2.448892e-07
I8827 n1_m1_417600_192000 0 3.494636e-07
I8828 n1_m1_417600_196800 0 2.596936e-07
I8829 n1_m1_417600_201600 0 3.701329e-07
I8830 n1_m1_417600_206400 0 2.313652e-07
I8831 n1_m1_417600_211200 0 2.298422e-07
I8832 n1_m1_417600_216000 0 3.587484e-07
I8833 n1_m1_417600_220800 0 2.479412e-07
I8834 n1_m1_417600_225600 0 3.645172e-07
I8835 n1_m1_417600_230400 0 2.460200e-07
I8836 n1_m1_417600_235200 0 2.461326e-07
I8837 n1_m1_417600_240000 0 3.612779e-07
I8838 n1_m1_417600_244800 0 3.587951e-07
I8839 n1_m1_417600_249600 0 4.434129e-07
I8840 n1_m1_417600_254400 0 2.338744e-07
I8841 n1_m1_417600_259200 0 2.438709e-07
I8842 n1_m1_417600_264000 0 3.979763e-07
I8843 n1_m1_417600_268800 0 5.200296e-07
I8844 n1_m1_417600_273600 0 4.299062e-07
I8845 n1_m1_417600_278400 0 2.468404e-07
I8846 n1_m1_417600_283200 0 2.439483e-07
I8847 n1_m1_417600_288000 0 3.654929e-07
I8848 n1_m1_417600_292800 0 2.460544e-07
I8849 n1_m1_417600_297600 0 3.788658e-07
I8850 n1_m1_417600_302400 0 2.447942e-07
I8851 n1_m1_417600_307200 0 2.441425e-07
I8852 n1_m1_417600_312000 0 4.056792e-07
I8853 n1_m1_417600_316800 0 2.806528e-07
I8854 n1_m1_417600_321600 0 7.791070e-07
I8855 n1_m1_417600_326400 0 4.654999e-07
I8856 n1_m1_417600_331200 0 3.780557e-07
I8857 n1_m1_417600_336000 0 1.139797e-06
I8858 n1_m1_417600_340800 0 5.212299e-07
I8859 n1_m1_417600_345600 0 4.183592e-07
I8860 n1_m1_417600_350400 0 2.674648e-07
I8861 n1_m1_417600_355200 0 2.534357e-07
I8862 n1_m1_417600_360000 0 3.583330e-07
I8863 n1_m1_417600_364800 0 2.314499e-07
I8864 n1_m1_417600_369600 0 3.571698e-07
I8865 n1_m1_417600_374400 0 2.835007e-07
I8866 n1_m1_417600_379200 0 4.673755e-07
I8867 n1_m1_417600_384000 0 1.104838e-06
I8868 n1_m1_417600_388800 0 3.336059e-07
I8869 n1_m1_417600_393600 0 9.085798e-07
I8870 n1_m1_417600_398400 0 5.446969e-07
I8871 n1_m1_417600_403200 0 2.738120e-07
I8872 n1_m1_417600_408000 0 3.677319e-07
I8873 n1_m1_417600_412800 0 2.537267e-07
I8874 n1_m1_417600_417600 0 3.832759e-07
I8875 n1_m1_417600_422400 0 2.651451e-07
I8876 n1_m1_417600_427200 0 3.134715e-07
I8877 n1_m1_417600_432000 0 7.014208e-07
I8878 n1_m1_417600_436800 0 4.056298e-07
I8879 n1_m1_417600_441600 0 3.933542e-07
I8880 n1_m1_417600_446400 0 2.271243e-07
I8881 n1_m1_417600_451200 0 2.292454e-07
I8882 n1_m1_417600_456000 0 3.263934e-07
I8883 n1_m1_417600_460800 0 2.136825e-07
I8884 n1_m1_417600_465600 0 3.264030e-07
I8885 n1_m1_417600_470400 0 2.341885e-07
I8886 n1_m1_417600_475200 0 2.332059e-07
I8887 n1_m1_417600_480000 0 3.304621e-07
I8888 n1_m1_422400_0 0 6.829181e-08
I8889 n1_m1_422400_4800 0 7.163790e-08
I8890 n1_m1_422400_9600 0 1.019243e-07
I8891 n1_m1_422400_14400 0 6.662094e-08
I8892 n1_m1_422400_19200 0 6.816998e-08
I8893 n1_m1_422400_24000 0 1.019547e-07
I8894 n1_m1_422400_28800 0 6.991917e-08
I8895 n1_m1_422400_33600 0 1.010018e-07
I8896 n1_m1_422400_38400 0 6.698209e-08
I8897 n1_m1_422400_43200 0 6.859205e-08
I8898 n1_m1_422400_48000 0 1.030904e-07
I8899 n1_m1_422400_52800 0 6.877480e-08
I8900 n1_m1_422400_57600 0 1.042522e-07
I8901 n1_m1_422400_62400 0 6.751729e-08
I8902 n1_m1_422400_67200 0 6.872693e-08
I8903 n1_m1_422400_72000 0 1.012498e-07
I8904 n1_m1_422400_76800 0 6.858334e-08
I8905 n1_m1_422400_81600 0 1.015849e-07
I8906 n1_m1_422400_86400 0 6.662094e-08
I8907 n1_m1_422400_91200 0 6.662094e-08
I8908 n1_m1_422400_96000 0 9.993141e-08
I8909 n1_m1_422400_100800 0 6.662094e-08
I8910 n1_m1_422400_105600 0 1.002752e-07
I8911 n1_m1_422400_110400 0 6.897930e-08
I8912 n1_m1_422400_115200 0 7.074155e-08
I8913 n1_m1_422400_120000 0 1.071505e-07
I8914 n1_m1_422400_124800 0 7.124828e-08
I8915 n1_m1_422400_129600 0 1.088828e-07
I8916 n1_m1_422400_134400 0 6.995199e-08
I8917 n1_m1_422400_139200 0 7.280531e-08
I8918 n1_m1_422400_144000 0 1.085235e-07
I8919 n1_m1_422400_148800 0 7.117704e-08
I8920 n1_m1_422400_153600 0 1.083799e-07
I8921 n1_m1_422400_158400 0 7.641569e-08
I8922 n1_m1_422400_163200 0 7.475773e-08
I8923 n1_m1_422400_168000 0 1.100720e-07
I8924 n1_m1_422400_172800 0 7.328303e-08
I8925 n1_m1_422400_177600 0 1.099246e-07
I8926 n1_m1_422400_182400 0 7.578462e-08
I8927 n1_m1_422400_187200 0 8.303066e-08
I8928 n1_m1_422400_192000 0 1.185427e-07
I8929 n1_m1_422400_196800 0 8.282985e-08
I8930 n1_m1_422400_201600 0 1.177150e-07
I8931 n1_m1_422400_206400 0 7.949738e-08
I8932 n1_m1_422400_211200 0 7.837067e-08
I8933 n1_m1_422400_216000 0 1.198209e-07
I8934 n1_m1_422400_220800 0 8.376886e-08
I8935 n1_m1_422400_225600 0 1.285788e-07
I8936 n1_m1_422400_230400 0 8.537915e-08
I8937 n1_m1_422400_235200 0 8.410689e-08
I8938 n1_m1_422400_240000 0 1.276305e-07
I8939 n1_m1_422400_244800 0 8.578618e-08
I8940 n1_m1_422400_249600 0 1.179729e-07
I8941 n1_m1_422400_254400 0 8.360883e-08
I8942 n1_m1_422400_259200 0 8.560462e-08
I8943 n1_m1_422400_264000 0 1.337005e-07
I8944 n1_m1_422400_268800 0 8.603033e-08
I8945 n1_m1_422400_273600 0 1.400680e-07
I8946 n1_m1_422400_278400 0 8.676404e-08
I8947 n1_m1_422400_283200 0 8.764992e-08
I8948 n1_m1_422400_288000 0 1.248687e-07
I8949 n1_m1_422400_292800 0 8.439717e-08
I8950 n1_m1_422400_297600 0 1.292400e-07
I8951 n1_m1_422400_302400 0 8.791546e-08
I8952 n1_m1_422400_307200 0 8.420683e-08
I8953 n1_m1_422400_312000 0 1.319884e-07
I8954 n1_m1_422400_316800 0 1.165161e-07
I8955 n1_m1_422400_321600 0 2.321647e-07
I8956 n1_m1_422400_326400 0 1.491701e-07
I8957 n1_m1_422400_331200 0 2.655959e-07
I8958 n1_m1_422400_336000 0 1.578574e-07
I8959 n1_m1_422400_340800 0 1.148199e-07
I8960 n1_m1_422400_345600 0 2.351303e-07
I8961 n1_m1_422400_350400 0 1.035083e-07
I8962 n1_m1_422400_355200 0 8.270767e-08
I8963 n1_m1_422400_360000 0 1.237771e-07
I8964 n1_m1_422400_364800 0 7.820464e-08
I8965 n1_m1_422400_369600 0 1.218599e-07
I8966 n1_m1_422400_374400 0 8.968576e-08
I8967 n1_m1_422400_379200 0 1.093318e-07
I8968 n1_m1_422400_384000 0 2.521931e-07
I8969 n1_m1_422400_388800 0 9.965691e-08
I8970 n1_m1_422400_393600 0 1.912485e-07
I8971 n1_m1_422400_398400 0 1.284330e-07
I8972 n1_m1_422400_403200 0 8.797061e-08
I8973 n1_m1_422400_408000 0 1.212391e-07
I8974 n1_m1_422400_412800 0 8.113486e-08
I8975 n1_m1_422400_417600 0 1.277689e-07
I8976 n1_m1_422400_422400 0 9.159373e-08
I8977 n1_m1_422400_427200 0 9.424769e-08
I8978 n1_m1_422400_432000 0 2.045431e-07
I8979 n1_m1_422400_436800 0 1.606757e-07
I8980 n1_m1_422400_441600 0 1.394584e-07
I8981 n1_m1_422400_446400 0 7.813383e-08
I8982 n1_m1_422400_451200 0 7.578769e-08
I8983 n1_m1_422400_456000 0 1.118659e-07
I8984 n1_m1_422400_460800 0 7.367282e-08
I8985 n1_m1_422400_465600 0 1.110559e-07
I8986 n1_m1_422400_470400 0 7.938226e-08
I8987 n1_m1_422400_475200 0 8.199606e-08
I8988 n1_m1_422400_480000 0 1.144256e-07
I8989 n1_m1_427200_0 0 1.332419e-07
I8990 n1_m1_427200_4800 0 1.332419e-07
I8991 n1_m1_427200_9600 0 1.998628e-07
I8992 n1_m1_427200_14400 0 1.332419e-07
I8993 n1_m1_427200_19200 0 1.332419e-07
I8994 n1_m1_427200_24000 0 1.998628e-07
I8995 n1_m1_427200_28800 0 1.332419e-07
I8996 n1_m1_427200_33600 0 1.998628e-07
I8997 n1_m1_427200_38400 0 1.332419e-07
I8998 n1_m1_427200_43200 0 1.332419e-07
I8999 n1_m1_427200_48000 0 1.998628e-07
I9000 n1_m1_427200_52800 0 1.332419e-07
I9001 n1_m1_427200_57600 0 1.998628e-07
I9002 n1_m1_427200_62400 0 1.332419e-07
I9003 n1_m1_427200_67200 0 1.332419e-07
I9004 n1_m1_427200_72000 0 1.998628e-07
I9005 n1_m1_427200_76800 0 1.332419e-07
I9006 n1_m1_427200_81600 0 1.998628e-07
I9007 n1_m1_427200_86400 0 1.332419e-07
I9008 n1_m1_427200_91200 0 1.332419e-07
I9009 n1_m1_427200_96000 0 1.998628e-07
I9010 n1_m1_427200_100800 0 1.332419e-07
I9011 n1_m1_427200_105600 0 1.998628e-07
I9012 n1_m1_427200_110400 0 1.332419e-07
I9013 n1_m1_427200_115200 0 1.332419e-07
I9014 n1_m1_427200_120000 0 2.048295e-07
I9015 n1_m1_427200_124800 0 1.383853e-07
I9016 n1_m1_427200_129600 0 2.094592e-07
I9017 n1_m1_427200_134400 0 1.399040e-07
I9018 n1_m1_427200_139200 0 1.409875e-07
I9019 n1_m1_427200_144000 0 2.129530e-07
I9020 n1_m1_427200_148800 0 1.429660e-07
I9021 n1_m1_427200_153600 0 2.197161e-07
I9022 n1_m1_427200_158400 0 1.431035e-07
I9023 n1_m1_427200_163200 0 1.441450e-07
I9024 n1_m1_427200_168000 0 2.195036e-07
I9025 n1_m1_427200_172800 0 1.465661e-07
I9026 n1_m1_427200_177600 0 2.198491e-07
I9027 n1_m1_427200_182400 0 1.479838e-07
I9028 n1_m1_427200_187200 0 1.546872e-07
I9029 n1_m1_427200_192000 0 2.398354e-07
I9030 n1_m1_427200_196800 0 1.597580e-07
I9031 n1_m1_427200_201600 0 2.380224e-07
I9032 n1_m1_427200_206400 0 1.632764e-07
I9033 n1_m1_427200_211200 0 1.679862e-07
I9034 n1_m1_427200_216000 0 2.733979e-07
I9035 n1_m1_427200_220800 0 1.983015e-07
I9036 n1_m1_427200_225600 0 2.731919e-07
I9037 n1_m1_427200_230400 0 1.798496e-07
I9038 n1_m1_427200_235200 0 1.738105e-07
I9039 n1_m1_427200_240000 0 2.444188e-07
I9040 n1_m1_427200_244800 0 1.645738e-07
I9041 n1_m1_427200_249600 0 2.587170e-07
I9042 n1_m1_427200_254400 0 1.669896e-07
I9043 n1_m1_427200_259200 0 2.434050e-07
I9044 n1_m1_427200_264000 0 9.190881e-07
I9045 n1_m1_427200_268800 0 6.578405e-07
I9046 n1_m1_427200_273600 0 6.190428e-07
I9047 n1_m1_427200_278400 0 3.893632e-07
I9048 n1_m1_427200_283200 0 1.855693e-07
I9049 n1_m1_427200_288000 0 2.643703e-07
I9050 n1_m1_427200_292800 0 1.654448e-07
I9051 n1_m1_427200_297600 0 2.550758e-07
I9052 n1_m1_427200_302400 0 1.787784e-07
I9053 n1_m1_427200_307200 0 2.332909e-07
I9054 n1_m1_427200_312000 0 4.134467e-07
I9055 n1_m1_427200_316800 0 2.758478e-07
I9056 n1_m1_427200_321600 0 4.580998e-07
I9057 n1_m1_427200_326400 0 2.846767e-07
I9058 n1_m1_427200_331200 0 3.656861e-07
I9059 n1_m1_427200_336000 0 3.569908e-07
I9060 n1_m1_427200_340800 0 2.102302e-07
I9061 n1_m1_427200_345600 0 4.511344e-07
I9062 n1_m1_427200_350400 0 2.039860e-07
I9063 n1_m1_427200_355200 0 2.730807e-07
I9064 n1_m1_427200_360000 0 3.040641e-07
I9065 n1_m1_427200_364800 0 1.677362e-07
I9066 n1_m1_427200_369600 0 2.429673e-07
I9067 n1_m1_427200_374400 0 1.625014e-07
I9068 n1_m1_427200_379200 0 1.697785e-07
I9069 n1_m1_427200_384000 0 2.562235e-07
I9070 n1_m1_427200_388800 0 1.681491e-07
I9071 n1_m1_427200_393600 0 3.074159e-07
I9072 n1_m1_427200_398400 0 1.795018e-07
I9073 n1_m1_427200_403200 0 1.651361e-07
I9074 n1_m1_427200_408000 0 2.431880e-07
I9075 n1_m1_427200_412800 0 1.584030e-07
I9076 n1_m1_427200_417600 0 2.372735e-07
I9077 n1_m1_427200_422400 0 1.678462e-07
I9078 n1_m1_427200_427200 0 1.638746e-07
I9079 n1_m1_427200_432000 0 3.063968e-07
I9080 n1_m1_427200_436800 0 2.444671e-07
I9081 n1_m1_427200_441600 0 2.355091e-07
I9082 n1_m1_427200_446400 0 1.609069e-07
I9083 n1_m1_427200_451200 0 1.526448e-07
I9084 n1_m1_427200_456000 0 2.296277e-07
I9085 n1_m1_427200_460800 0 1.518204e-07
I9086 n1_m1_427200_465600 0 2.210554e-07
I9087 n1_m1_427200_470400 0 1.515897e-07
I9088 n1_m1_427200_475200 0 1.611615e-07
I9089 n1_m1_427200_480000 0 2.288512e-07
I9090 n1_m1_432000_0 0 1.998628e-07
I9091 n1_m1_432000_4800 0 1.998628e-07
I9092 n1_m1_432000_9600 0 2.997942e-07
I9093 n1_m1_432000_14400 0 1.998628e-07
I9094 n1_m1_432000_19200 0 1.998628e-07
I9095 n1_m1_432000_24000 0 2.997942e-07
I9096 n1_m1_432000_28800 0 1.998628e-07
I9097 n1_m1_432000_33600 0 2.997942e-07
I9098 n1_m1_432000_38400 0 1.998628e-07
I9099 n1_m1_432000_43200 0 1.998628e-07
I9100 n1_m1_432000_48000 0 2.997942e-07
I9101 n1_m1_432000_52800 0 1.998628e-07
I9102 n1_m1_432000_57600 0 2.997942e-07
I9103 n1_m1_432000_62400 0 1.998628e-07
I9104 n1_m1_432000_67200 0 1.998628e-07
I9105 n1_m1_432000_72000 0 2.997942e-07
I9106 n1_m1_432000_76800 0 1.998628e-07
I9107 n1_m1_432000_81600 0 2.997942e-07
I9108 n1_m1_432000_86400 0 1.998628e-07
I9109 n1_m1_432000_91200 0 1.998628e-07
I9110 n1_m1_432000_96000 0 2.997942e-07
I9111 n1_m1_432000_100800 0 1.998628e-07
I9112 n1_m1_432000_105600 0 2.997942e-07
I9113 n1_m1_432000_110400 0 1.998628e-07
I9114 n1_m1_432000_115200 0 1.998628e-07
I9115 n1_m1_432000_120000 0 3.012043e-07
I9116 n1_m1_432000_124800 0 2.080271e-07
I9117 n1_m1_432000_129600 0 3.147839e-07
I9118 n1_m1_432000_134400 0 2.098560e-07
I9119 n1_m1_432000_139200 0 2.098560e-07
I9120 n1_m1_432000_144000 0 3.147839e-07
I9121 n1_m1_432000_148800 0 2.102292e-07
I9122 n1_m1_432000_153600 0 3.173150e-07
I9123 n1_m1_432000_158400 0 2.105633e-07
I9124 n1_m1_432000_163200 0 2.165310e-07
I9125 n1_m1_432000_168000 0 3.294650e-07
I9126 n1_m1_432000_172800 0 2.241221e-07
I9127 n1_m1_432000_177600 0 3.425217e-07
I9128 n1_m1_432000_182400 0 2.298445e-07
I9129 n1_m1_432000_187200 0 2.302610e-07
I9130 n1_m1_432000_192000 0 3.524675e-07
I9131 n1_m1_432000_196800 0 2.413523e-07
I9132 n1_m1_432000_201600 0 3.673335e-07
I9133 n1_m1_432000_206400 0 2.397724e-07
I9134 n1_m1_432000_211200 0 2.547352e-07
I9135 n1_m1_432000_216000 0 5.899813e-07
I9136 n1_m1_432000_220800 0 4.080820e-07
I9137 n1_m1_432000_225600 0 4.059714e-07
I9138 n1_m1_432000_230400 0 3.350657e-07
I9139 n1_m1_432000_235200 0 3.012017e-07
I9140 n1_m1_432000_240000 0 3.641190e-07
I9141 n1_m1_432000_244800 0 2.562154e-07
I9142 n1_m1_432000_249600 0 3.711173e-07
I9143 n1_m1_432000_254400 0 3.506130e-07
I9144 n1_m1_432000_259200 0 9.123447e-07
I9145 n1_m1_432000_264000 0 1.814057e-06
I9146 n1_m1_432000_268800 0 5.958253e-07
I9147 n1_m1_432000_273600 0 1.084441e-06
I9148 n1_m1_432000_278400 0 7.281109e-07
I9149 n1_m1_432000_283200 0 3.020496e-07
I9150 n1_m1_432000_288000 0 4.142755e-07
I9151 n1_m1_432000_292800 0 2.467865e-07
I9152 n1_m1_432000_297600 0 3.762336e-07
I9153 n1_m1_432000_302400 0 3.240506e-07
I9154 n1_m1_432000_307200 0 9.347410e-07
I9155 n1_m1_432000_312000 0 7.722793e-07
I9156 n1_m1_432000_316800 0 4.353596e-07
I9157 n1_m1_432000_321600 0 1.211166e-06
I9158 n1_m1_432000_326400 0 2.915819e-07
I9159 n1_m1_432000_331200 0 2.727593e-07
I9160 n1_m1_432000_336000 0 4.772514e-07
I9161 n1_m1_432000_340800 0 2.726237e-07
I9162 n1_m1_432000_345600 0 4.482246e-07
I9163 n1_m1_432000_350400 0 9.532807e-07
I9164 n1_m1_432000_355200 0 6.849835e-07
I9165 n1_m1_432000_360000 0 4.158234e-07
I9166 n1_m1_432000_364800 0 2.568898e-07
I9167 n1_m1_432000_369600 0 3.662362e-07
I9168 n1_m1_432000_374400 0 2.401963e-07
I9169 n1_m1_432000_379200 0 2.420849e-07
I9170 n1_m1_432000_384000 0 3.540587e-07
I9171 n1_m1_432000_388800 0 2.292901e-07
I9172 n1_m1_432000_393600 0 3.697555e-07
I9173 n1_m1_432000_398400 0 2.499171e-07
I9174 n1_m1_432000_403200 0 2.491959e-07
I9175 n1_m1_432000_408000 0 3.643569e-07
I9176 n1_m1_432000_412800 0 2.382447e-07
I9177 n1_m1_432000_417600 0 3.582181e-07
I9178 n1_m1_432000_422400 0 2.514291e-07
I9179 n1_m1_432000_427200 0 2.524778e-07
I9180 n1_m1_432000_432000 0 3.553024e-07
I9181 n1_m1_432000_436800 0 2.279929e-07
I9182 n1_m1_432000_441600 0 3.600374e-07
I9183 n1_m1_432000_446400 0 2.486999e-07
I9184 n1_m1_432000_451200 0 2.167037e-07
I9185 n1_m1_432000_456000 0 3.238109e-07
I9186 n1_m1_432000_460800 0 2.166000e-07
I9187 n1_m1_432000_465600 0 3.205222e-07
I9188 n1_m1_432000_470400 0 2.263736e-07
I9189 n1_m1_432000_475200 0 2.398354e-07
I9190 n1_m1_432000_480000 0 3.500965e-07
I9191 n1_m1_436800_0 0 1.332419e-07
I9192 n1_m1_436800_4800 0 1.332419e-07
I9193 n1_m1_436800_9600 0 1.998628e-07
I9194 n1_m1_436800_14400 0 1.332419e-07
I9195 n1_m1_436800_19200 0 1.332419e-07
I9196 n1_m1_436800_24000 0 1.998628e-07
I9197 n1_m1_436800_28800 0 1.332419e-07
I9198 n1_m1_436800_33600 0 1.998628e-07
I9199 n1_m1_436800_38400 0 1.332419e-07
I9200 n1_m1_436800_43200 0 1.332419e-07
I9201 n1_m1_436800_48000 0 1.998628e-07
I9202 n1_m1_436800_52800 0 1.332419e-07
I9203 n1_m1_436800_57600 0 1.998628e-07
I9204 n1_m1_436800_62400 0 1.332419e-07
I9205 n1_m1_436800_67200 0 1.332419e-07
I9206 n1_m1_436800_72000 0 1.998628e-07
I9207 n1_m1_436800_76800 0 1.332419e-07
I9208 n1_m1_436800_81600 0 1.998628e-07
I9209 n1_m1_436800_86400 0 1.332419e-07
I9210 n1_m1_436800_91200 0 1.332419e-07
I9211 n1_m1_436800_96000 0 1.998628e-07
I9212 n1_m1_436800_100800 0 1.332419e-07
I9213 n1_m1_436800_105600 0 1.998628e-07
I9214 n1_m1_436800_110400 0 1.332419e-07
I9215 n1_m1_436800_115200 0 1.332419e-07
I9216 n1_m1_436800_120000 0 1.999269e-07
I9217 n1_m1_436800_124800 0 1.366943e-07
I9218 n1_m1_436800_129600 0 2.074234e-07
I9219 n1_m1_436800_134400 0 1.399040e-07
I9220 n1_m1_436800_139200 0 1.399040e-07
I9221 n1_m1_436800_144000 0 2.098560e-07
I9222 n1_m1_436800_148800 0 1.399040e-07
I9223 n1_m1_436800_153600 0 2.098560e-07
I9224 n1_m1_436800_158400 0 1.399040e-07
I9225 n1_m1_436800_163200 0 1.403582e-07
I9226 n1_m1_436800_168000 0 2.187342e-07
I9227 n1_m1_436800_172800 0 1.500072e-07
I9228 n1_m1_436800_177600 0 2.310673e-07
I9229 n1_m1_436800_182400 0 1.581284e-07
I9230 n1_m1_436800_187200 0 1.528405e-07
I9231 n1_m1_436800_192000 0 2.286977e-07
I9232 n1_m1_436800_196800 0 1.638820e-07
I9233 n1_m1_436800_201600 0 2.468278e-07
I9234 n1_m1_436800_206400 0 1.565042e-07
I9235 n1_m1_436800_211200 0 1.632803e-07
I9236 n1_m1_436800_216000 0 2.893076e-07
I9237 n1_m1_436800_220800 0 1.951083e-07
I9238 n1_m1_436800_225600 0 2.600273e-07
I9239 n1_m1_436800_230400 0 1.780928e-07
I9240 n1_m1_436800_235200 0 1.729799e-07
I9241 n1_m1_436800_240000 0 2.432239e-07
I9242 n1_m1_436800_244800 0 1.912961e-07
I9243 n1_m1_436800_249600 0 2.675824e-07
I9244 n1_m1_436800_254400 0 1.772643e-07
I9245 n1_m1_436800_259200 0 2.485815e-07
I9246 n1_m1_436800_264000 0 4.385947e-07
I9247 n1_m1_436800_268800 0 4.869121e-07
I9248 n1_m1_436800_273600 0 5.052842e-07
I9249 n1_m1_436800_278400 0 2.189343e-07
I9250 n1_m1_436800_283200 0 2.174551e-07
I9251 n1_m1_436800_288000 0 2.550985e-07
I9252 n1_m1_436800_292800 0 1.778712e-07
I9253 n1_m1_436800_297600 0 2.501676e-07
I9254 n1_m1_436800_302400 0 1.731004e-07
I9255 n1_m1_436800_307200 0 2.353509e-07
I9256 n1_m1_436800_312000 0 3.911244e-07
I9257 n1_m1_436800_316800 0 2.343500e-07
I9258 n1_m1_436800_321600 0 3.600955e-07
I9259 n1_m1_436800_326400 0 1.856173e-07
I9260 n1_m1_436800_331200 0 1.672333e-07
I9261 n1_m1_436800_336000 0 4.471142e-07
I9262 n1_m1_436800_340800 0 2.163262e-07
I9263 n1_m1_436800_345600 0 3.024031e-07
I9264 n1_m1_436800_350400 0 2.310298e-07
I9265 n1_m1_436800_355200 0 2.318445e-07
I9266 n1_m1_436800_360000 0 5.024529e-07
I9267 n1_m1_436800_364800 0 1.712599e-07
I9268 n1_m1_436800_369600 0 2.443187e-07
I9269 n1_m1_436800_374400 0 1.622049e-07
I9270 n1_m1_436800_379200 0 1.662474e-07
I9271 n1_m1_436800_384000 0 2.490567e-07
I9272 n1_m1_436800_388800 0 1.621201e-07
I9273 n1_m1_436800_393600 0 2.505562e-07
I9274 n1_m1_436800_398400 0 1.665327e-07
I9275 n1_m1_436800_403200 0 1.650322e-07
I9276 n1_m1_436800_408000 0 2.389710e-07
I9277 n1_m1_436800_412800 0 1.560443e-07
I9278 n1_m1_436800_417600 0 2.387952e-07
I9279 n1_m1_436800_422400 0 1.691242e-07
I9280 n1_m1_436800_427200 0 1.762920e-07
I9281 n1_m1_436800_432000 0 2.723980e-07
I9282 n1_m1_436800_436800 0 1.703024e-07
I9283 n1_m1_436800_441600 0 2.358715e-07
I9284 n1_m1_436800_446400 0 1.546251e-07
I9285 n1_m1_436800_451200 0 1.485653e-07
I9286 n1_m1_436800_456000 0 2.151588e-07
I9287 n1_m1_436800_460800 0 1.473857e-07
I9288 n1_m1_436800_465600 0 2.161394e-07
I9289 n1_m1_436800_470400 0 1.509157e-07
I9290 n1_m1_436800_475200 0 1.590333e-07
I9291 n1_m1_436800_480000 0 2.328367e-07
I9292 n1_m1_441600_0 0 1.998628e-07
I9293 n1_m1_441600_4800 0 1.998628e-07
I9294 n1_m1_441600_9600 0 2.997942e-07
I9295 n1_m1_441600_14400 0 1.998628e-07
I9296 n1_m1_441600_19200 0 1.998628e-07
I9297 n1_m1_441600_24000 0 2.997942e-07
I9298 n1_m1_441600_28800 0 1.998628e-07
I9299 n1_m1_441600_33600 0 2.997942e-07
I9300 n1_m1_441600_38400 0 1.998628e-07
I9301 n1_m1_441600_43200 0 1.998628e-07
I9302 n1_m1_441600_48000 0 2.997942e-07
I9303 n1_m1_441600_52800 0 1.998628e-07
I9304 n1_m1_441600_57600 0 3.019811e-07
I9305 n1_m1_441600_62400 0 2.058092e-07
I9306 n1_m1_441600_67200 0 2.058092e-07
I9307 n1_m1_441600_72000 0 3.087137e-07
I9308 n1_m1_441600_76800 0 2.058092e-07
I9309 n1_m1_441600_81600 0 3.087137e-07
I9310 n1_m1_441600_86400 0 2.058092e-07
I9311 n1_m1_441600_91200 0 2.058092e-07
I9312 n1_m1_441600_96000 0 3.087137e-07
I9313 n1_m1_441600_100800 0 2.058092e-07
I9314 n1_m1_441600_105600 0 3.087137e-07
I9315 n1_m1_441600_110400 0 2.058092e-07
I9316 n1_m1_441600_115200 0 2.058092e-07
I9317 n1_m1_441600_120000 0 3.042540e-07
I9318 n1_m1_441600_124800 0 1.998628e-07
I9319 n1_m1_441600_129600 0 3.038823e-07
I9320 n1_m1_441600_134400 0 2.098560e-07
I9321 n1_m1_441600_139200 0 2.098560e-07
I9322 n1_m1_441600_144000 0 3.147839e-07
I9323 n1_m1_441600_148800 0 2.099903e-07
I9324 n1_m1_441600_153600 0 3.156951e-07
I9325 n1_m1_441600_158400 0 2.099955e-07
I9326 n1_m1_441600_163200 0 2.105373e-07
I9327 n1_m1_441600_168000 0 3.281013e-07
I9328 n1_m1_441600_172800 0 2.246909e-07
I9329 n1_m1_441600_177600 0 3.445784e-07
I9330 n1_m1_441600_182400 0 2.323312e-07
I9331 n1_m1_441600_187200 0 2.290916e-07
I9332 n1_m1_441600_192000 0 3.432375e-07
I9333 n1_m1_441600_196800 0 2.411529e-07
I9334 n1_m1_441600_201600 0 3.631777e-07
I9335 n1_m1_441600_206400 0 2.347665e-07
I9336 n1_m1_441600_211200 0 2.377086e-07
I9337 n1_m1_441600_216000 0 3.510234e-07
I9338 n1_m1_441600_220800 0 2.417964e-07
I9339 n1_m1_441600_225600 0 3.840178e-07
I9340 n1_m1_441600_230400 0 2.477588e-07
I9341 n1_m1_441600_235200 0 2.430910e-07
I9342 n1_m1_441600_240000 0 3.763440e-07
I9343 n1_m1_441600_244800 0 2.619681e-07
I9344 n1_m1_441600_249600 0 3.996756e-07
I9345 n1_m1_441600_254400 0 2.668365e-07
I9346 n1_m1_441600_259200 0 3.003491e-07
I9347 n1_m1_441600_264000 0 5.213629e-07
I9348 n1_m1_441600_268800 0 6.496086e-07
I9349 n1_m1_441600_273600 0 6.384117e-07
I9350 n1_m1_441600_278400 0 3.971844e-07
I9351 n1_m1_441600_283200 0 2.540508e-07
I9352 n1_m1_441600_288000 0 4.437414e-07
I9353 n1_m1_441600_292800 0 2.665631e-07
I9354 n1_m1_441600_297600 0 3.741931e-07
I9355 n1_m1_441600_302400 0 2.538506e-07
I9356 n1_m1_441600_307200 0 3.428815e-07
I9357 n1_m1_441600_312000 0 5.078524e-07
I9358 n1_m1_441600_316800 0 4.441836e-07
I9359 n1_m1_441600_321600 0 5.698206e-07
I9360 n1_m1_441600_326400 0 2.738894e-07
I9361 n1_m1_441600_331200 0 2.862780e-07
I9362 n1_m1_441600_336000 0 7.199876e-07
I9363 n1_m1_441600_340800 0 3.367348e-07
I9364 n1_m1_441600_345600 0 4.672419e-07
I9365 n1_m1_441600_350400 0 2.975813e-07
I9366 n1_m1_441600_355200 0 3.393987e-07
I9367 n1_m1_441600_360000 0 8.047302e-07
I9368 n1_m1_441600_364800 0 2.570715e-07
I9369 n1_m1_441600_369600 0 3.716073e-07
I9370 n1_m1_441600_374400 0 2.452498e-07
I9371 n1_m1_441600_379200 0 2.496399e-07
I9372 n1_m1_441600_384000 0 3.745641e-07
I9373 n1_m1_441600_388800 0 2.434855e-07
I9374 n1_m1_441600_393600 0 3.470317e-07
I9375 n1_m1_441600_398400 0 2.332121e-07
I9376 n1_m1_441600_403200 0 2.403823e-07
I9377 n1_m1_441600_408000 0 3.660679e-07
I9378 n1_m1_441600_412800 0 2.497424e-07
I9379 n1_m1_441600_417600 0 4.580570e-07
I9380 n1_m1_441600_422400 0 4.967284e-07
I9381 n1_m1_441600_427200 0 6.876958e-07
I9382 n1_m1_441600_432000 0 1.116531e-06
I9383 n1_m1_441600_436800 0 5.753573e-07
I9384 n1_m1_441600_441600 0 4.535127e-07
I9385 n1_m1_441600_446400 0 2.256457e-07
I9386 n1_m1_441600_451200 0 2.455264e-07
I9387 n1_m1_441600_456000 0 3.435344e-07
I9388 n1_m1_441600_460800 0 2.368303e-07
I9389 n1_m1_441600_465600 0 3.402096e-07
I9390 n1_m1_441600_470400 0 2.246474e-07
I9391 n1_m1_441600_475200 0 2.319525e-07
I9392 n1_m1_441600_480000 0 3.442527e-07
I9393 n1_m1_446400_0 0 1.332419e-07
I9394 n1_m1_446400_4800 0 1.332419e-07
I9395 n1_m1_446400_9600 0 1.998628e-07
I9396 n1_m1_446400_14400 0 1.332419e-07
I9397 n1_m1_446400_19200 0 1.332419e-07
I9398 n1_m1_446400_24000 0 1.998628e-07
I9399 n1_m1_446400_28800 0 1.332419e-07
I9400 n1_m1_446400_33600 0 1.998628e-07
I9401 n1_m1_446400_38400 0 1.332419e-07
I9402 n1_m1_446400_43200 0 1.332419e-07
I9403 n1_m1_446400_48000 0 1.998628e-07
I9404 n1_m1_446400_52800 0 1.332419e-07
I9405 n1_m1_446400_57600 0 2.023129e-07
I9406 n1_m1_446400_62400 0 1.399040e-07
I9407 n1_m1_446400_67200 0 1.399040e-07
I9408 n1_m1_446400_72000 0 2.098560e-07
I9409 n1_m1_446400_76800 0 1.399040e-07
I9410 n1_m1_446400_81600 0 2.098560e-07
I9411 n1_m1_446400_86400 0 1.399040e-07
I9412 n1_m1_446400_91200 0 1.399040e-07
I9413 n1_m1_446400_96000 0 2.098560e-07
I9414 n1_m1_446400_100800 0 1.399040e-07
I9415 n1_m1_446400_105600 0 2.098560e-07
I9416 n1_m1_446400_110400 0 1.399040e-07
I9417 n1_m1_446400_115200 0 1.399040e-07
I9418 n1_m1_446400_120000 0 2.054685e-07
I9419 n1_m1_446400_124800 0 1.340540e-07
I9420 n1_m1_446400_129600 0 2.034742e-07
I9421 n1_m1_446400_134400 0 1.399040e-07
I9422 n1_m1_446400_139200 0 1.399040e-07
I9423 n1_m1_446400_144000 0 2.100087e-07
I9424 n1_m1_446400_148800 0 1.417406e-07
I9425 n1_m1_446400_153600 0 2.182827e-07
I9426 n1_m1_446400_158400 0 1.418197e-07
I9427 n1_m1_446400_163200 0 1.411150e-07
I9428 n1_m1_446400_168000 0 2.188701e-07
I9429 n1_m1_446400_172800 0 1.470566e-07
I9430 n1_m1_446400_177600 0 2.214231e-07
I9431 n1_m1_446400_182400 0 1.495016e-07
I9432 n1_m1_446400_187200 0 1.552913e-07
I9433 n1_m1_446400_192000 0 2.390029e-07
I9434 n1_m1_446400_196800 0 1.587367e-07
I9435 n1_m1_446400_201600 0 2.321072e-07
I9436 n1_m1_446400_206400 0 1.565986e-07
I9437 n1_m1_446400_211200 0 1.557846e-07
I9438 n1_m1_446400_216000 0 2.372708e-07
I9439 n1_m1_446400_220800 0 1.604117e-07
I9440 n1_m1_446400_225600 0 2.453560e-07
I9441 n1_m1_446400_230400 0 1.716609e-07
I9442 n1_m1_446400_235200 0 1.728915e-07
I9443 n1_m1_446400_240000 0 2.720821e-07
I9444 n1_m1_446400_244800 0 1.983728e-07
I9445 n1_m1_446400_249600 0 2.826670e-07
I9446 n1_m1_446400_254400 0 1.733109e-07
I9447 n1_m1_446400_259200 0 1.837845e-07
I9448 n1_m1_446400_264000 0 3.786883e-07
I9449 n1_m1_446400_268800 0 2.690260e-07
I9450 n1_m1_446400_273600 0 6.295344e-07
I9451 n1_m1_446400_278400 0 4.014123e-07
I9452 n1_m1_446400_283200 0 1.730131e-07
I9453 n1_m1_446400_288000 0 2.776878e-07
I9454 n1_m1_446400_292800 0 1.693424e-07
I9455 n1_m1_446400_297600 0 2.505160e-07
I9456 n1_m1_446400_302400 0 1.734027e-07
I9457 n1_m1_446400_307200 0 1.829876e-07
I9458 n1_m1_446400_312000 0 2.667703e-07
I9459 n1_m1_446400_316800 0 1.964505e-07
I9460 n1_m1_446400_321600 0 3.921096e-07
I9461 n1_m1_446400_326400 0 3.175407e-07
I9462 n1_m1_446400_331200 0 1.782120e-07
I9463 n1_m1_446400_336000 0 4.221223e-07
I9464 n1_m1_446400_340800 0 2.164840e-07
I9465 n1_m1_446400_345600 0 3.864290e-07
I9466 n1_m1_446400_350400 0 1.963309e-07
I9467 n1_m1_446400_355200 0 2.508972e-07
I9468 n1_m1_446400_360000 0 2.950754e-07
I9469 n1_m1_446400_364800 0 1.729358e-07
I9470 n1_m1_446400_369600 0 2.535245e-07
I9471 n1_m1_446400_374400 0 1.665333e-07
I9472 n1_m1_446400_379200 0 1.672369e-07
I9473 n1_m1_446400_384000 0 2.471651e-07
I9474 n1_m1_446400_388800 0 1.575638e-07
I9475 n1_m1_446400_393600 0 2.470304e-07
I9476 n1_m1_446400_398400 0 1.620945e-07
I9477 n1_m1_446400_403200 0 1.600784e-07
I9478 n1_m1_446400_408000 0 2.421763e-07
I9479 n1_m1_446400_412800 0 1.893393e-07
I9480 n1_m1_446400_417600 0 5.656978e-07
I9481 n1_m1_446400_422400 0 5.824233e-07
I9482 n1_m1_446400_427200 0 7.770172e-07
I9483 n1_m1_446400_432000 0 1.029024e-06
I9484 n1_m1_446400_436800 0 4.060930e-07
I9485 n1_m1_446400_441600 0 3.421908e-07
I9486 n1_m1_446400_446400 0 1.560331e-07
I9487 n1_m1_446400_451200 0 1.587995e-07
I9488 n1_m1_446400_456000 0 2.386178e-07
I9489 n1_m1_446400_460800 0 1.697558e-07
I9490 n1_m1_446400_465600 0 2.349019e-07
I9491 n1_m1_446400_470400 0 1.501767e-07
I9492 n1_m1_446400_475200 0 1.493990e-07
I9493 n1_m1_446400_480000 0 2.245844e-07
I9494 n1_m1_451200_0 0 6.662094e-08
I9495 n1_m1_451200_4800 0 6.662094e-08
I9496 n1_m1_451200_9600 0 9.993141e-08
I9497 n1_m1_451200_14400 0 6.662094e-08
I9498 n1_m1_451200_19200 0 6.662094e-08
I9499 n1_m1_451200_24000 0 9.993141e-08
I9500 n1_m1_451200_28800 0 6.662094e-08
I9501 n1_m1_451200_33600 0 9.993141e-08
I9502 n1_m1_451200_38400 0 6.662094e-08
I9503 n1_m1_451200_43200 0 6.662094e-08
I9504 n1_m1_451200_48000 0 9.993141e-08
I9505 n1_m1_451200_52800 0 6.662094e-08
I9506 n1_m1_451200_57600 0 1.011565e-07
I9507 n1_m1_451200_62400 0 6.995199e-08
I9508 n1_m1_451200_67200 0 6.995199e-08
I9509 n1_m1_451200_72000 0 1.049280e-07
I9510 n1_m1_451200_76800 0 6.995199e-08
I9511 n1_m1_451200_81600 0 1.049280e-07
I9512 n1_m1_451200_86400 0 6.995199e-08
I9513 n1_m1_451200_91200 0 6.995199e-08
I9514 n1_m1_451200_96000 0 1.049280e-07
I9515 n1_m1_451200_100800 0 6.995199e-08
I9516 n1_m1_451200_105600 0 1.049280e-07
I9517 n1_m1_451200_110400 0 6.995199e-08
I9518 n1_m1_451200_115200 0 6.995199e-08
I9519 n1_m1_451200_120000 0 1.043602e-07
I9520 n1_m1_451200_124800 0 6.919493e-08
I9521 n1_m1_451200_129600 0 1.041021e-07
I9522 n1_m1_451200_134400 0 6.995199e-08
I9523 n1_m1_451200_139200 0 6.995199e-08
I9524 n1_m1_451200_144000 0 1.054119e-07
I9525 n1_m1_451200_148800 0 7.256790e-08
I9526 n1_m1_451200_153600 0 1.099027e-07
I9527 n1_m1_451200_158400 0 7.269647e-08
I9528 n1_m1_451200_163200 0 7.257760e-08
I9529 n1_m1_451200_168000 0 1.097979e-07
I9530 n1_m1_451200_172800 0 7.328303e-08
I9531 n1_m1_451200_177600 0 1.103979e-07
I9532 n1_m1_451200_182400 0 7.643295e-08
I9533 n1_m1_451200_187200 0 7.991760e-08
I9534 n1_m1_451200_192000 0 1.216886e-07
I9535 n1_m1_451200_196800 0 7.783851e-08
I9536 n1_m1_451200_201600 0 1.150509e-07
I9537 n1_m1_451200_206400 0 7.830713e-08
I9538 n1_m1_451200_211200 0 7.660219e-08
I9539 n1_m1_451200_216000 0 1.234834e-07
I9540 n1_m1_451200_220800 0 8.325834e-08
I9541 n1_m1_451200_225600 0 1.189595e-07
I9542 n1_m1_451200_230400 0 8.949436e-08
I9543 n1_m1_451200_235200 0 9.106916e-08
I9544 n1_m1_451200_240000 0 1.342232e-07
I9545 n1_m1_451200_244800 0 9.380676e-08
I9546 n1_m1_451200_249600 0 1.393108e-07
I9547 n1_m1_451200_254400 0 1.019279e-07
I9548 n1_m1_451200_259200 0 1.261828e-07
I9549 n1_m1_451200_264000 0 4.420050e-07
I9550 n1_m1_451200_268800 0 3.719817e-07
I9551 n1_m1_451200_273600 0 4.745841e-07
I9552 n1_m1_451200_278400 0 1.664554e-07
I9553 n1_m1_451200_283200 0 1.099383e-07
I9554 n1_m1_451200_288000 0 1.265379e-07
I9555 n1_m1_451200_292800 0 8.470301e-08
I9556 n1_m1_451200_297600 0 1.269352e-07
I9557 n1_m1_451200_302400 0 8.386524e-08
I9558 n1_m1_451200_307200 0 8.871572e-08
I9559 n1_m1_451200_312000 0 1.585448e-07
I9560 n1_m1_451200_316800 0 1.089942e-07
I9561 n1_m1_451200_321600 0 1.906026e-07
I9562 n1_m1_451200_326400 0 1.099261e-07
I9563 n1_m1_451200_331200 0 1.060542e-07
I9564 n1_m1_451200_336000 0 1.881319e-07
I9565 n1_m1_451200_340800 0 9.279319e-08
I9566 n1_m1_451200_345600 0 1.506357e-07
I9567 n1_m1_451200_350400 0 1.488510e-07
I9568 n1_m1_451200_355200 0 1.310214e-07
I9569 n1_m1_451200_360000 0 1.379894e-07
I9570 n1_m1_451200_364800 0 8.660722e-08
I9571 n1_m1_451200_369600 0 1.272615e-07
I9572 n1_m1_451200_374400 0 8.543003e-08
I9573 n1_m1_451200_379200 0 8.585017e-08
I9574 n1_m1_451200_384000 0 1.268344e-07
I9575 n1_m1_451200_388800 0 8.203423e-08
I9576 n1_m1_451200_393600 0 1.190095e-07
I9577 n1_m1_451200_398400 0 7.938015e-08
I9578 n1_m1_451200_403200 0 8.251912e-08
I9579 n1_m1_451200_408000 0 1.241757e-07
I9580 n1_m1_451200_412800 0 9.195698e-08
I9581 n1_m1_451200_417600 0 2.323124e-07
I9582 n1_m1_451200_422400 0 1.864229e-07
I9583 n1_m1_451200_427200 0 2.703723e-07
I9584 n1_m1_451200_432000 0 2.971693e-07
I9585 n1_m1_451200_436800 0 1.093546e-07
I9586 n1_m1_451200_441600 0 1.405131e-07
I9587 n1_m1_451200_446400 0 7.849796e-08
I9588 n1_m1_451200_451200 0 7.755915e-08
I9589 n1_m1_451200_456000 0 1.227851e-07
I9590 n1_m1_451200_460800 0 8.636634e-08
I9591 n1_m1_451200_465600 0 1.193461e-07
I9592 n1_m1_451200_470400 0 7.379295e-08
I9593 n1_m1_451200_475200 0 7.357397e-08
I9594 n1_m1_451200_480000 0 1.104360e-07
I9595 n1_m1_456000_0 0 1.332419e-07
I9596 n1_m1_456000_4800 0 1.332419e-07
I9597 n1_m1_456000_9600 0 1.998628e-07
I9598 n1_m1_456000_14400 0 1.332419e-07
I9599 n1_m1_456000_19200 0 1.332419e-07
I9600 n1_m1_456000_24000 0 1.998628e-07
I9601 n1_m1_456000_28800 0 1.332419e-07
I9602 n1_m1_456000_33600 0 1.998628e-07
I9603 n1_m1_456000_38400 0 1.343843e-07
I9604 n1_m1_456000_43200 0 1.386442e-07
I9605 n1_m1_456000_48000 0 2.019550e-07
I9606 n1_m1_456000_52800 0 1.333933e-07
I9607 n1_m1_456000_57600 0 2.075169e-07
I9608 n1_m1_456000_62400 0 1.384651e-07
I9609 n1_m1_456000_67200 0 1.419137e-07
I9610 n1_m1_456000_72000 0 2.149764e-07
I9611 n1_m1_456000_76800 0 1.370371e-07
I9612 n1_m1_456000_81600 0 2.029977e-07
I9613 n1_m1_456000_86400 0 1.422217e-07
I9614 n1_m1_456000_91200 0 1.359056e-07
I9615 n1_m1_456000_96000 0 2.096489e-07
I9616 n1_m1_456000_100800 0 1.380528e-07
I9617 n1_m1_456000_105600 0 2.071541e-07
I9618 n1_m1_456000_110400 0 1.430267e-07
I9619 n1_m1_456000_115200 0 1.449129e-07
I9620 n1_m1_456000_120000 0 2.117950e-07
I9621 n1_m1_456000_124800 0 1.406382e-07
I9622 n1_m1_456000_129600 0 2.169932e-07
I9623 n1_m1_456000_134400 0 1.462768e-07
I9624 n1_m1_456000_139200 0 1.431941e-07
I9625 n1_m1_456000_144000 0 2.139243e-07
I9626 n1_m1_456000_148800 0 1.439824e-07
I9627 n1_m1_456000_153600 0 2.206620e-07
I9628 n1_m1_456000_158400 0 1.641516e-07
I9629 n1_m1_456000_163200 0 1.575975e-07
I9630 n1_m1_456000_168000 0 2.297155e-07
I9631 n1_m1_456000_172800 0 1.550458e-07
I9632 n1_m1_456000_177600 0 3.300537e-07
I9633 n1_m1_456000_182400 0 1.643856e-07
I9634 n1_m1_456000_187200 0 1.780376e-07
I9635 n1_m1_456000_192000 0 2.630165e-07
I9636 n1_m1_456000_196800 0 1.770130e-07
I9637 n1_m1_456000_201600 0 2.673547e-07
I9638 n1_m1_456000_206400 0 1.669449e-07
I9639 n1_m1_456000_211200 0 1.622977e-07
I9640 n1_m1_456000_216000 0 2.694445e-07
I9641 n1_m1_456000_220800 0 1.572893e-07
I9642 n1_m1_456000_225600 0 2.670194e-07
I9643 n1_m1_456000_230400 0 2.261597e-07
I9644 n1_m1_456000_235200 0 3.448224e-07
I9645 n1_m1_456000_240000 0 6.871689e-07
I9646 n1_m1_456000_244800 0 3.142880e-07
I9647 n1_m1_456000_249600 0 4.688069e-07
I9648 n1_m1_456000_254400 0 5.384121e-07
I9649 n1_m1_456000_259200 0 4.581949e-07
I9650 n1_m1_456000_264000 0 9.442974e-07
I9651 n1_m1_456000_268800 0 3.684725e-07
I9652 n1_m1_456000_273600 0 8.393083e-07
I9653 n1_m1_456000_278400 0 4.596456e-07
I9654 n1_m1_456000_283200 0 2.334977e-07
I9655 n1_m1_456000_288000 0 3.504536e-07
I9656 n1_m1_456000_292800 0 2.046621e-07
I9657 n1_m1_456000_297600 0 2.664726e-07
I9658 n1_m1_456000_302400 0 1.829260e-07
I9659 n1_m1_456000_307200 0 3.299478e-07
I9660 n1_m1_456000_312000 0 2.821817e-07
I9661 n1_m1_456000_316800 0 2.624866e-07
I9662 n1_m1_456000_321600 0 6.677510e-07
I9663 n1_m1_456000_326400 0 2.443474e-07
I9664 n1_m1_456000_331200 0 2.171185e-07
I9665 n1_m1_456000_336000 0 2.824129e-07
I9666 n1_m1_456000_340800 0 2.143419e-07
I9667 n1_m1_456000_345600 0 2.918689e-07
I9668 n1_m1_456000_350400 0 3.850075e-07
I9669 n1_m1_456000_355200 0 7.412332e-07
I9670 n1_m1_456000_360000 0 1.088571e-06
I9671 n1_m1_456000_364800 0 1.952012e-07
I9672 n1_m1_456000_369600 0 2.810703e-07
I9673 n1_m1_456000_374400 0 1.981546e-07
I9674 n1_m1_456000_379200 0 1.779213e-07
I9675 n1_m1_456000_384000 0 2.604699e-07
I9676 n1_m1_456000_388800 0 1.716099e-07
I9677 n1_m1_456000_393600 0 2.383915e-07
I9678 n1_m1_456000_398400 0 1.665524e-07
I9679 n1_m1_456000_403200 0 1.634082e-07
I9680 n1_m1_456000_408000 0 2.334664e-07
I9681 n1_m1_456000_412800 0 1.639162e-07
I9682 n1_m1_456000_417600 0 2.514399e-07
I9683 n1_m1_456000_422400 0 1.733246e-07
I9684 n1_m1_456000_427200 0 1.736274e-07
I9685 n1_m1_456000_432000 0 2.452671e-07
I9686 n1_m1_456000_436800 0 1.598903e-07
I9687 n1_m1_456000_441600 0 2.332696e-07
I9688 n1_m1_456000_446400 0 1.475158e-07
I9689 n1_m1_456000_451200 0 1.483266e-07
I9690 n1_m1_456000_456000 0 2.322120e-07
I9691 n1_m1_456000_460800 0 1.481603e-07
I9692 n1_m1_456000_465600 0 2.205220e-07
I9693 n1_m1_456000_470400 0 1.490712e-07
I9694 n1_m1_456000_475200 0 1.465110e-07
I9695 n1_m1_456000_480000 0 2.115485e-07
I9696 n1_m1_460800_0 0 1.332419e-07
I9697 n1_m1_460800_4800 0 1.332419e-07
I9698 n1_m1_460800_9600 0 1.998628e-07
I9699 n1_m1_460800_14400 0 1.332419e-07
I9700 n1_m1_460800_19200 0 1.332419e-07
I9701 n1_m1_460800_24000 0 1.998628e-07
I9702 n1_m1_460800_28800 0 1.352127e-07
I9703 n1_m1_460800_33600 0 2.021715e-07
I9704 n1_m1_460800_38400 0 1.343843e-07
I9705 n1_m1_460800_43200 0 1.390524e-07
I9706 n1_m1_460800_48000 0 2.034660e-07
I9707 n1_m1_460800_52800 0 1.334965e-07
I9708 n1_m1_460800_57600 0 2.126145e-07
I9709 n1_m1_460800_62400 0 1.399040e-07
I9710 n1_m1_460800_67200 0 1.409288e-07
I9711 n1_m1_460800_72000 0 2.126808e-07
I9712 n1_m1_460800_76800 0 1.396324e-07
I9713 n1_m1_460800_81600 0 2.082749e-07
I9714 n1_m1_460800_86400 0 1.414237e-07
I9715 n1_m1_460800_91200 0 1.390205e-07
I9716 n1_m1_460800_96000 0 2.154169e-07
I9717 n1_m1_460800_100800 0 1.412804e-07
I9718 n1_m1_460800_105600 0 2.096076e-07
I9719 n1_m1_460800_110400 0 1.445251e-07
I9720 n1_m1_460800_115200 0 1.450013e-07
I9721 n1_m1_460800_120000 0 2.133591e-07
I9722 n1_m1_460800_124800 0 1.445383e-07
I9723 n1_m1_460800_129600 0 2.184507e-07
I9724 n1_m1_460800_134400 0 1.431537e-07
I9725 n1_m1_460800_139200 0 1.409113e-07
I9726 n1_m1_460800_144000 0 2.209440e-07
I9727 n1_m1_460800_148800 0 1.543487e-07
I9728 n1_m1_460800_153600 0 2.221659e-07
I9729 n1_m1_460800_158400 0 1.723154e-07
I9730 n1_m1_460800_163200 0 1.566387e-07
I9731 n1_m1_460800_168000 0 2.402821e-07
I9732 n1_m1_460800_172800 0 1.720482e-07
I9733 n1_m1_460800_177600 0 3.028994e-07
I9734 n1_m1_460800_182400 0 1.687541e-07
I9735 n1_m1_460800_187200 0 1.854193e-07
I9736 n1_m1_460800_192000 0 2.450109e-07
I9737 n1_m1_460800_196800 0 2.219908e-07
I9738 n1_m1_460800_201600 0 5.065713e-07
I9739 n1_m1_460800_206400 0 1.885896e-07
I9740 n1_m1_460800_211200 0 1.677536e-07
I9741 n1_m1_460800_216000 0 2.582631e-07
I9742 n1_m1_460800_220800 0 2.882795e-07
I9743 n1_m1_460800_225600 0 4.876030e-07
I9744 n1_m1_460800_230400 0 3.012808e-07
I9745 n1_m1_460800_235200 0 6.480595e-07
I9746 n1_m1_460800_240000 0 4.817499e-07
I9747 n1_m1_460800_244800 0 7.214970e-07
I9748 n1_m1_460800_249600 0 8.032053e-07
I9749 n1_m1_460800_254400 0 5.539048e-07
I9750 n1_m1_460800_259200 0 5.083544e-07
I9751 n1_m1_460800_264000 0 6.243874e-07
I9752 n1_m1_460800_268800 0 5.931960e-07
I9753 n1_m1_460800_273600 0 4.856252e-07
I9754 n1_m1_460800_278400 0 2.734562e-07
I9755 n1_m1_460800_283200 0 2.313238e-07
I9756 n1_m1_460800_288000 0 4.258516e-07
I9757 n1_m1_460800_292800 0 5.017530e-07
I9758 n1_m1_460800_297600 0 2.989953e-07
I9759 n1_m1_460800_302400 0 2.554164e-07
I9760 n1_m1_460800_307200 0 2.399224e-07
I9761 n1_m1_460800_312000 0 4.646704e-07
I9762 n1_m1_460800_316800 0 3.337041e-07
I9763 n1_m1_460800_321600 0 3.718303e-07
I9764 n1_m1_460800_326400 0 2.808591e-07
I9765 n1_m1_460800_331200 0 1.923486e-07
I9766 n1_m1_460800_336000 0 7.044457e-07
I9767 n1_m1_460800_340800 0 3.193363e-07
I9768 n1_m1_460800_345600 0 5.186429e-07
I9769 n1_m1_460800_350400 0 4.154311e-07
I9770 n1_m1_460800_355200 0 5.137308e-07
I9771 n1_m1_460800_360000 0 1.470824e-06
I9772 n1_m1_460800_364800 0 2.236844e-07
I9773 n1_m1_460800_369600 0 2.567515e-07
I9774 n1_m1_460800_374400 0 1.680702e-07
I9775 n1_m1_460800_379200 0 1.934591e-07
I9776 n1_m1_460800_384000 0 3.474475e-07
I9777 n1_m1_460800_388800 0 1.641298e-07
I9778 n1_m1_460800_393600 0 2.396164e-07
I9779 n1_m1_460800_398400 0 1.633051e-07
I9780 n1_m1_460800_403200 0 1.673832e-07
I9781 n1_m1_460800_408000 0 2.472258e-07
I9782 n1_m1_460800_412800 0 1.596531e-07
I9783 n1_m1_460800_417600 0 2.335193e-07
I9784 n1_m1_460800_422400 0 1.580283e-07
I9785 n1_m1_460800_427200 0 1.581246e-07
I9786 n1_m1_460800_432000 0 2.335693e-07
I9787 n1_m1_460800_436800 0 1.553479e-07
I9788 n1_m1_460800_441600 0 2.273008e-07
I9789 n1_m1_460800_446400 0 1.507630e-07
I9790 n1_m1_460800_451200 0 1.507430e-07
I9791 n1_m1_460800_456000 0 2.219113e-07
I9792 n1_m1_460800_460800 0 1.465661e-07
I9793 n1_m1_460800_465600 0 2.198491e-07
I9794 n1_m1_460800_470400 0 1.465661e-07
I9795 n1_m1_460800_475200 0 1.457515e-07
I9796 n1_m1_460800_480000 0 2.166695e-07
I9797 n1_m1_465600_0 0 2.145635e-07
I9798 n1_m1_465600_4800 0 2.134297e-07
I9799 n1_m1_465600_9600 0 3.082004e-07
I9800 n1_m1_465600_14400 0 2.003434e-07
I9801 n1_m1_465600_19200 0 1.998628e-07
I9802 n1_m1_465600_24000 0 2.997942e-07
I9803 n1_m1_465600_28800 0 2.013977e-07
I9804 n1_m1_465600_33600 0 3.015922e-07
I9805 n1_m1_465600_38400 0 2.001626e-07
I9806 n1_m1_465600_43200 0 2.014990e-07
I9807 n1_m1_465600_48000 0 3.011523e-07
I9808 n1_m1_465600_52800 0 2.003171e-07
I9809 n1_m1_465600_57600 0 3.268517e-07
I9810 n1_m1_465600_62400 0 2.234692e-07
I9811 n1_m1_465600_67200 0 2.226041e-07
I9812 n1_m1_465600_72000 0 3.311399e-07
I9813 n1_m1_465600_76800 0 2.139969e-07
I9814 n1_m1_465600_81600 0 3.188730e-07
I9815 n1_m1_465600_86400 0 2.102959e-07
I9816 n1_m1_465600_91200 0 2.099390e-07
I9817 n1_m1_465600_96000 0 3.170774e-07
I9818 n1_m1_465600_100800 0 2.107734e-07
I9819 n1_m1_465600_105600 0 3.182636e-07
I9820 n1_m1_465600_110400 0 2.209159e-07
I9821 n1_m1_465600_115200 0 2.216476e-07
I9822 n1_m1_465600_120000 0 3.406687e-07
I9823 n1_m1_465600_124800 0 2.240501e-07
I9824 n1_m1_465600_129600 0 3.351575e-07
I9825 n1_m1_465600_134400 0 2.328057e-07
I9826 n1_m1_465600_139200 0 2.368028e-07
I9827 n1_m1_465600_144000 0 3.486183e-07
I9828 n1_m1_465600_148800 0 2.267013e-07
I9829 n1_m1_465600_153600 0 3.682107e-07
I9830 n1_m1_465600_158400 0 2.479975e-07
I9831 n1_m1_465600_163200 0 3.727816e-07
I9832 n1_m1_465600_168000 0 5.354755e-07
I9833 n1_m1_465600_172800 0 2.634075e-07
I9834 n1_m1_465600_177600 0 4.300774e-07
I9835 n1_m1_465600_182400 0 2.632767e-07
I9836 n1_m1_465600_187200 0 2.521450e-07
I9837 n1_m1_465600_192000 0 3.755889e-07
I9838 n1_m1_465600_196800 0 3.701802e-07
I9839 n1_m1_465600_201600 0 5.255011e-07
I9840 n1_m1_465600_206400 0 5.129583e-07
I9841 n1_m1_465600_211200 0 5.133719e-07
I9842 n1_m1_465600_216000 0 4.925451e-07
I9843 n1_m1_465600_220800 0 3.309566e-07
I9844 n1_m1_465600_225600 0 5.718759e-07
I9845 n1_m1_465600_230400 0 3.860719e-07
I9846 n1_m1_465600_235200 0 5.773485e-07
I9847 n1_m1_465600_240000 0 6.774942e-07
I9848 n1_m1_465600_244800 0 7.422318e-07
I9849 n1_m1_465600_249600 0 1.039013e-06
I9850 n1_m1_465600_254400 0 1.300359e-06
I9851 n1_m1_465600_259200 0 6.774228e-07
I9852 n1_m1_465600_264000 0 1.014955e-06
I9853 n1_m1_465600_268800 0 5.593493e-07
I9854 n1_m1_465600_273600 0 7.731368e-07
I9855 n1_m1_465600_278400 0 3.744384e-07
I9856 n1_m1_465600_283200 0 4.766193e-07
I9857 n1_m1_465600_288000 0 5.908200e-07
I9858 n1_m1_465600_292800 0 5.363099e-07
I9859 n1_m1_465600_297600 0 8.356500e-07
I9860 n1_m1_465600_302400 0 4.012932e-07
I9861 n1_m1_465600_307200 0 3.889054e-07
I9862 n1_m1_465600_312000 0 5.030057e-07
I9863 n1_m1_465600_316800 0 3.212178e-07
I9864 n1_m1_465600_321600 0 5.557653e-07
I9865 n1_m1_465600_326400 0 3.099353e-07
I9866 n1_m1_465600_331200 0 3.190074e-07
I9867 n1_m1_465600_336000 0 6.718549e-07
I9868 n1_m1_465600_340800 0 4.075390e-07
I9869 n1_m1_465600_345600 0 1.027214e-06
I9870 n1_m1_465600_350400 0 3.926256e-07
I9871 n1_m1_465600_355200 0 4.011293e-07
I9872 n1_m1_465600_360000 0 7.409538e-07
I9873 n1_m1_465600_364800 0 3.303031e-07
I9874 n1_m1_465600_369600 0 4.929084e-07
I9875 n1_m1_465600_374400 0 2.879564e-07
I9876 n1_m1_465600_379200 0 2.698415e-07
I9877 n1_m1_465600_384000 0 4.475601e-07
I9878 n1_m1_465600_388800 0 3.430720e-07
I9879 n1_m1_465600_393600 0 4.011789e-07
I9880 n1_m1_465600_398400 0 2.403338e-07
I9881 n1_m1_465600_403200 0 2.478387e-07
I9882 n1_m1_465600_408000 0 3.841479e-07
I9883 n1_m1_465600_412800 0 2.347884e-07
I9884 n1_m1_465600_417600 0 3.517462e-07
I9885 n1_m1_465600_422400 0 2.353220e-07
I9886 n1_m1_465600_427200 0 2.328665e-07
I9887 n1_m1_465600_432000 0 3.518581e-07
I9888 n1_m1_465600_436800 0 2.300624e-07
I9889 n1_m1_465600_441600 0 3.320850e-07
I9890 n1_m1_465600_446400 0 2.213480e-07
I9891 n1_m1_465600_451200 0 2.225771e-07
I9892 n1_m1_465600_456000 0 3.415908e-07
I9893 n1_m1_465600_460800 0 2.280941e-07
I9894 n1_m1_465600_465600 0 3.319371e-07
I9895 n1_m1_465600_470400 0 2.198491e-07
I9896 n1_m1_465600_475200 0 2.198491e-07
I9897 n1_m1_465600_480000 0 3.350955e-07
I9898 n1_m1_470400_0 0 1.377292e-07
I9899 n1_m1_470400_4800 0 1.381111e-07
I9900 n1_m1_470400_9600 0 2.097257e-07
I9901 n1_m1_470400_14400 0 1.382126e-07
I9902 n1_m1_470400_19200 0 1.376499e-07
I9903 n1_m1_470400_24000 0 2.091957e-07
I9904 n1_m1_470400_28800 0 1.436005e-07
I9905 n1_m1_470400_33600 0 2.159878e-07
I9906 n1_m1_470400_38400 0 1.403415e-07
I9907 n1_m1_470400_43200 0 1.413660e-07
I9908 n1_m1_470400_48000 0 2.081532e-07
I9909 n1_m1_470400_52800 0 1.395928e-07
I9910 n1_m1_470400_57600 0 2.385496e-07
I9911 n1_m1_470400_62400 0 1.777500e-07
I9912 n1_m1_470400_67200 0 1.720307e-07
I9913 n1_m1_470400_72000 0 2.498686e-07
I9914 n1_m1_470400_76800 0 1.618065e-07
I9915 n1_m1_470400_81600 0 2.349517e-07
I9916 n1_m1_470400_86400 0 1.480260e-07
I9917 n1_m1_470400_91200 0 1.447254e-07
I9918 n1_m1_470400_96000 0 2.172881e-07
I9919 n1_m1_470400_100800 0 1.484954e-07
I9920 n1_m1_470400_105600 0 2.334269e-07
I9921 n1_m1_470400_110400 0 1.600033e-07
I9922 n1_m1_470400_115200 0 1.633059e-07
I9923 n1_m1_470400_120000 0 2.433944e-07
I9924 n1_m1_470400_124800 0 1.901246e-07
I9925 n1_m1_470400_129600 0 3.628061e-07
I9926 n1_m1_470400_134400 0 2.079108e-07
I9927 n1_m1_470400_139200 0 1.741631e-07
I9928 n1_m1_470400_144000 0 2.794406e-07
I9929 n1_m1_470400_148800 0 2.444873e-07
I9930 n1_m1_470400_153600 0 3.241769e-07
I9931 n1_m1_470400_158400 0 3.293385e-07
I9932 n1_m1_470400_163200 0 5.822993e-07
I9933 n1_m1_470400_168000 0 7.104749e-07
I9934 n1_m1_470400_172800 0 2.417192e-07
I9935 n1_m1_470400_177600 0 3.826998e-07
I9936 n1_m1_470400_182400 0 1.868997e-07
I9937 n1_m1_470400_187200 0 1.901819e-07
I9938 n1_m1_470400_192000 0 2.926753e-07
I9939 n1_m1_470400_196800 0 1.976799e-07
I9940 n1_m1_470400_201600 0 2.966211e-07
I9941 n1_m1_470400_206400 0 5.835520e-07
I9942 n1_m1_470400_211200 0 7.864196e-07
I9943 n1_m1_470400_216000 0 5.409568e-07
I9944 n1_m1_470400_220800 0 2.064215e-07
I9945 n1_m1_470400_225600 0 3.209560e-07
I9946 n1_m1_470400_230400 0 1.924472e-07
I9947 n1_m1_470400_235200 0 2.926752e-07
I9948 n1_m1_470400_240000 0 2.798260e-07
I9949 n1_m1_470400_244800 0 2.527680e-07
I9950 n1_m1_470400_249600 0 7.997258e-07
I9951 n1_m1_470400_254400 0 5.816283e-07
I9952 n1_m1_470400_259200 0 2.260716e-07
I9953 n1_m1_470400_264000 0 4.990661e-07
I9954 n1_m1_470400_268800 0 2.726492e-07
I9955 n1_m1_470400_273600 0 4.672178e-07
I9956 n1_m1_470400_278400 0 2.667612e-07
I9957 n1_m1_470400_283200 0 6.100269e-07
I9958 n1_m1_470400_288000 0 6.829782e-07
I9959 n1_m1_470400_292800 0 1.986730e-07
I9960 n1_m1_470400_297600 0 9.118056e-07
I9961 n1_m1_470400_302400 0 5.352598e-07
I9962 n1_m1_470400_307200 0 4.585629e-07
I9963 n1_m1_470400_312000 0 2.900168e-07
I9964 n1_m1_470400_316800 0 1.767380e-07
I9965 n1_m1_470400_321600 0 3.633620e-07
I9966 n1_m1_470400_326400 0 1.944597e-07
I9967 n1_m1_470400_331200 0 2.415762e-07
I9968 n1_m1_470400_336000 0 2.924013e-07
I9969 n1_m1_470400_340800 0 3.748321e-07
I9970 n1_m1_470400_345600 0 6.074913e-07
I9971 n1_m1_470400_350400 0 3.027236e-07
I9972 n1_m1_470400_355200 0 2.670453e-07
I9973 n1_m1_470400_360000 0 3.484446e-07
I9974 n1_m1_470400_364800 0 2.442566e-07
I9975 n1_m1_470400_369600 0 3.728029e-07
I9976 n1_m1_470400_374400 0 2.497311e-07
I9977 n1_m1_470400_379200 0 2.494964e-07
I9978 n1_m1_470400_384000 0 4.050720e-07
I9979 n1_m1_470400_388800 0 4.211116e-07
I9980 n1_m1_470400_393600 0 3.852192e-07
I9981 n1_m1_470400_398400 0 1.847569e-07
I9982 n1_m1_470400_403200 0 1.730965e-07
I9983 n1_m1_470400_408000 0 2.573029e-07
I9984 n1_m1_470400_412800 0 1.593953e-07
I9985 n1_m1_470400_417600 0 2.496213e-07
I9986 n1_m1_470400_422400 0 1.718901e-07
I9987 n1_m1_470400_427200 0 1.716861e-07
I9988 n1_m1_470400_432000 0 2.627406e-07
I9989 n1_m1_470400_436800 0 1.649954e-07
I9990 n1_m1_470400_441600 0 2.282770e-07
I9991 n1_m1_470400_446400 0 1.468761e-07
I9992 n1_m1_470400_451200 0 1.482269e-07
I9993 n1_m1_470400_456000 0 2.367909e-07
I9994 n1_m1_470400_460800 0 1.597526e-07
I9995 n1_m1_470400_465600 0 2.307997e-07
I9996 n1_m1_470400_470400 0 1.502057e-07
I9997 n1_m1_470400_475200 0 1.487409e-07
I9998 n1_m1_470400_480000 0 2.231113e-07
I9999 n1_m1_475200_0 0 1.383623e-07
I10000 n1_m1_475200_4800 0 1.390827e-07
I10001 n1_m1_475200_9600 0 2.134505e-07
I10002 n1_m1_475200_14400 0 1.454643e-07
I10003 n1_m1_475200_19200 0 1.486282e-07
I10004 n1_m1_475200_24000 0 2.289863e-07
I10005 n1_m1_475200_28800 0 1.612310e-07
I10006 n1_m1_475200_33600 0 2.499524e-07
I10007 n1_m1_475200_38400 0 1.596714e-07
I10008 n1_m1_475200_43200 0 1.608526e-07
I10009 n1_m1_475200_48000 0 2.290990e-07
I10010 n1_m1_475200_52800 0 1.565735e-07
I10011 n1_m1_475200_57600 0 2.707918e-07
I10012 n1_m1_475200_62400 0 1.942629e-07
I10013 n1_m1_475200_67200 0 1.848593e-07
I10014 n1_m1_475200_72000 0 2.682844e-07
I10015 n1_m1_475200_76800 0 1.788969e-07
I10016 n1_m1_475200_81600 0 2.590605e-07
I10017 n1_m1_475200_86400 0 1.639646e-07
I10018 n1_m1_475200_91200 0 1.572337e-07
I10019 n1_m1_475200_96000 0 2.364630e-07
I10020 n1_m1_475200_100800 0 1.699989e-07
I10021 n1_m1_475200_105600 0 2.724615e-07
I10022 n1_m1_475200_110400 0 1.748547e-07
I10023 n1_m1_475200_115200 0 1.786112e-07
I10024 n1_m1_475200_120000 0 2.923672e-07
I10025 n1_m1_475200_124800 0 2.899096e-07
I10026 n1_m1_475200_129600 0 5.232620e-07
I10027 n1_m1_475200_134400 0 2.163594e-07
I10028 n1_m1_475200_139200 0 1.592793e-07
I10029 n1_m1_475200_144000 0 3.904157e-07
I10030 n1_m1_475200_148800 0 4.619962e-07
I10031 n1_m1_475200_153600 0 4.360064e-07
I10032 n1_m1_475200_158400 0 5.488819e-07
I10033 n1_m1_475200_163200 0 4.243906e-07
I10034 n1_m1_475200_168000 0 6.937759e-07
I10035 n1_m1_475200_172800 0 4.807077e-07
I10036 n1_m1_475200_177600 0 3.235104e-07
I10037 n1_m1_475200_182400 0 2.031824e-07
I10038 n1_m1_475200_187200 0 2.555724e-07
I10039 n1_m1_475200_192000 0 3.641062e-07
I10040 n1_m1_475200_196800 0 3.385705e-07
I10041 n1_m1_475200_201600 0 4.885634e-07
I10042 n1_m1_475200_206400 0 3.186991e-07
I10043 n1_m1_475200_211200 0 5.280924e-07
I10044 n1_m1_475200_216000 0 9.174298e-07
I10045 n1_m1_475200_220800 0 3.101946e-07
I10046 n1_m1_475200_225600 0 4.411481e-07
I10047 n1_m1_475200_230400 0 2.135918e-07
I10048 n1_m1_475200_235200 0 2.866101e-07
I10049 n1_m1_475200_240000 0 4.402122e-07
I10050 n1_m1_475200_244800 0 3.596667e-07
I10051 n1_m1_475200_249600 0 8.203931e-07
I10052 n1_m1_475200_254400 0 3.008021e-07
I10053 n1_m1_475200_259200 0 2.968077e-07
I10054 n1_m1_475200_264000 0 4.680614e-07
I10055 n1_m1_475200_268800 0 2.954604e-07
I10056 n1_m1_475200_273600 0 4.337949e-07
I10057 n1_m1_475200_278400 0 3.625942e-07
I10058 n1_m1_475200_283200 0 4.951031e-07
I10059 n1_m1_475200_288000 0 8.235414e-07
I10060 n1_m1_475200_292800 0 3.946518e-07
I10061 n1_m1_475200_297600 0 6.411273e-07
I10062 n1_m1_475200_302400 0 7.008984e-07
I10063 n1_m1_475200_307200 0 5.999131e-07
I10064 n1_m1_475200_312000 0 3.184182e-07
I10065 n1_m1_475200_316800 0 2.122930e-07
I10066 n1_m1_475200_321600 0 3.408212e-07
I10067 n1_m1_475200_326400 0 2.483890e-07
I10068 n1_m1_475200_331200 0 3.865036e-07
I10069 n1_m1_475200_336000 0 3.413217e-07
I10070 n1_m1_475200_340800 0 4.193670e-07
I10071 n1_m1_475200_345600 0 4.129199e-07
I10072 n1_m1_475200_350400 0 3.820731e-07
I10073 n1_m1_475200_355200 0 2.662197e-07
I10074 n1_m1_475200_360000 0 3.952563e-07
I10075 n1_m1_475200_364800 0 2.139503e-07
I10076 n1_m1_475200_369600 0 3.576371e-07
I10077 n1_m1_475200_374400 0 3.856317e-07
I10078 n1_m1_475200_379200 0 4.283554e-07
I10079 n1_m1_475200_384000 0 4.267493e-07
I10080 n1_m1_475200_388800 0 2.443617e-07
I10081 n1_m1_475200_393600 0 4.071864e-07
I10082 n1_m1_475200_398400 0 2.539855e-07
I10083 n1_m1_475200_403200 0 2.018126e-07
I10084 n1_m1_475200_408000 0 2.638151e-07
I10085 n1_m1_475200_412800 0 1.701656e-07
I10086 n1_m1_475200_417600 0 2.676445e-07
I10087 n1_m1_475200_422400 0 1.855971e-07
I10088 n1_m1_475200_427200 0 1.847719e-07
I10089 n1_m1_475200_432000 0 2.698084e-07
I10090 n1_m1_475200_436800 0 1.692813e-07
I10091 n1_m1_475200_441600 0 2.396016e-07
I10092 n1_m1_475200_446400 0 1.500761e-07
I10093 n1_m1_475200_451200 0 1.509823e-07
I10094 n1_m1_475200_456000 0 2.468599e-07
I10095 n1_m1_475200_460800 0 1.723998e-07
I10096 n1_m1_475200_465600 0 2.529558e-07
I10097 n1_m1_475200_470400 0 1.602757e-07
I10098 n1_m1_475200_475200 0 1.548045e-07
I10099 n1_m1_475200_480000 0 2.319528e-07
I10100 n1_m1_480000_0 0 2.363254e-07
I10101 n1_m1_480000_4800 0 2.353609e-07
I10102 n1_m1_480000_9600 0 3.428798e-07
I10103 n1_m1_480000_14400 0 2.213243e-07
I10104 n1_m1_480000_19200 0 2.231332e-07
I10105 n1_m1_480000_24000 0 3.273679e-07
I10106 n1_m1_480000_28800 0 2.283265e-07
I10107 n1_m1_480000_33600 0 3.604344e-07
I10108 n1_m1_480000_38400 0 2.287892e-07
I10109 n1_m1_480000_43200 0 2.269581e-07
I10110 n1_m1_480000_48000 0 3.319418e-07
I10111 n1_m1_480000_52800 0 2.305298e-07
I10112 n1_m1_480000_57600 0 3.865977e-07
I10113 n1_m1_480000_62400 0 2.535863e-07
I10114 n1_m1_480000_67200 0 2.456703e-07
I10115 n1_m1_480000_72000 0 3.676096e-07
I10116 n1_m1_480000_76800 0 2.577748e-07
I10117 n1_m1_480000_81600 0 3.850282e-07
I10118 n1_m1_480000_86400 0 2.466076e-07
I10119 n1_m1_480000_91200 0 2.362502e-07
I10120 n1_m1_480000_96000 0 3.484801e-07
I10121 n1_m1_480000_100800 0 2.504809e-07
I10122 n1_m1_480000_105600 0 4.004276e-07
I10123 n1_m1_480000_110400 0 2.444580e-07
I10124 n1_m1_480000_115200 0 2.403008e-07
I10125 n1_m1_480000_120000 0 4.137891e-07
I10126 n1_m1_480000_124800 0 3.521720e-07
I10127 n1_m1_480000_129600 0 5.140344e-07
I10128 n1_m1_480000_134400 0 2.583151e-07
I10129 n1_m1_480000_139200 0 2.463185e-07
I10130 n1_m1_480000_144000 0 5.105132e-07
I10131 n1_m1_480000_148800 0 4.861169e-07
I10132 n1_m1_480000_153600 0 5.188666e-07
I10133 n1_m1_480000_158400 0 4.553476e-07
I10134 n1_m1_480000_163200 0 3.066936e-07
I10135 n1_m1_480000_168000 0 6.122595e-07
I10136 n1_m1_480000_172800 0 5.493905e-07
I10137 n1_m1_480000_177600 0 4.393865e-07
I10138 n1_m1_480000_182400 0 2.689552e-07
I10139 n1_m1_480000_187200 0 3.386779e-07
I10140 n1_m1_480000_192000 0 4.682455e-07
I10141 n1_m1_480000_196800 0 4.677182e-07
I10142 n1_m1_480000_201600 0 6.938438e-07
I10143 n1_m1_480000_206400 0 2.600858e-07
I10144 n1_m1_480000_211200 0 2.647164e-07
I10145 n1_m1_480000_216000 0 9.641055e-07
I10146 n1_m1_480000_220800 0 3.827210e-07
I10147 n1_m1_480000_225600 0 5.312965e-07
I10148 n1_m1_480000_230400 0 3.208654e-07
I10149 n1_m1_480000_235200 0 4.722950e-07
I10150 n1_m1_480000_240000 0 6.877769e-07
I10151 n1_m1_480000_244800 0 4.004959e-07
I10152 n1_m1_480000_249600 0 5.983996e-07
I10153 n1_m1_480000_254400 0 4.599006e-07
I10154 n1_m1_480000_259200 0 3.704489e-07
I10155 n1_m1_480000_264000 0 4.845042e-07
I10156 n1_m1_480000_268800 0 2.733687e-07
I10157 n1_m1_480000_273600 0 4.859227e-07
I10158 n1_m1_480000_278400 0 3.996782e-07
I10159 n1_m1_480000_283200 0 3.185547e-07
I10160 n1_m1_480000_288000 0 7.137477e-07
I10161 n1_m1_480000_292800 0 5.424196e-07
I10162 n1_m1_480000_297600 0 5.238480e-07
I10163 n1_m1_480000_302400 0 4.809850e-07
I10164 n1_m1_480000_307200 0 6.147524e-07
I10165 n1_m1_480000_312000 0 4.599024e-07
I10166 n1_m1_480000_316800 0 3.172739e-07
I10167 n1_m1_480000_321600 0 5.013226e-07
I10168 n1_m1_480000_326400 0 4.033078e-07
I10169 n1_m1_480000_331200 0 4.698722e-07
I10170 n1_m1_480000_336000 0 5.487395e-07
I10171 n1_m1_480000_340800 0 3.575688e-07
I10172 n1_m1_480000_345600 0 4.037066e-07
I10173 n1_m1_480000_350400 0 2.655859e-07
I10174 n1_m1_480000_355200 0 2.976766e-07
I10175 n1_m1_480000_360000 0 4.017965e-07
I10176 n1_m1_480000_364800 0 2.524275e-07
I10177 n1_m1_480000_369600 0 4.140568e-07
I10178 n1_m1_480000_374400 0 4.190301e-07
I10179 n1_m1_480000_379200 0 4.609248e-07
I10180 n1_m1_480000_384000 0 4.780969e-07
I10181 n1_m1_480000_388800 0 2.676953e-07
I10182 n1_m1_480000_393600 0 4.658850e-07
I10183 n1_m1_480000_398400 0 3.322254e-07
I10184 n1_m1_480000_403200 0 2.797953e-07
I10185 n1_m1_480000_408000 0 3.519785e-07
I10186 n1_m1_480000_412800 0 2.424612e-07
I10187 n1_m1_480000_417600 0 3.726044e-07
I10188 n1_m1_480000_422400 0 2.590891e-07
I10189 n1_m1_480000_427200 0 2.581377e-07
I10190 n1_m1_480000_432000 0 3.648322e-07
I10191 n1_m1_480000_436800 0 2.351905e-07
I10192 n1_m1_480000_441600 0 3.582220e-07
I10193 n1_m1_480000_446400 0 2.305974e-07
I10194 n1_m1_480000_451200 0 2.241459e-07
I10195 n1_m1_480000_456000 0 3.343693e-07
I10196 n1_m1_480000_460800 0 2.346736e-07
I10197 n1_m1_480000_465600 0 3.608928e-07
I10198 n1_m1_480000_470400 0 2.300900e-07
I10199 n1_m1_480000_475200 0 2.216294e-07
I10200 n1_m1_480000_480000 0 3.319976e-07
I10201 n1_m1_4000_0 0 8.587258e-08
I10202 n1_m1_4000_4800 0 7.932253e-08
I10203 n1_m1_4000_9600 0 1.055622e-07
I10204 n1_m1_4000_14400 0 7.238833e-08
I10205 n1_m1_4000_19200 0 7.573314e-08
I10206 n1_m1_4000_24000 0 1.083371e-07
I10207 n1_m1_4000_28800 0 6.695601e-08
I10208 n1_m1_4000_33600 0 1.031228e-07
I10209 n1_m1_4000_38400 0 7.295268e-08
I10210 n1_m1_4000_43200 0 7.635781e-08
I10211 n1_m1_4000_48000 0 1.200266e-07
I10212 n1_m1_4000_52800 0 8.408860e-08
I10213 n1_m1_4000_57600 0 1.287584e-07
I10214 n1_m1_4000_62400 0 8.725962e-08
I10215 n1_m1_4000_67200 0 9.129807e-08
I10216 n1_m1_4000_72000 0 1.224542e-07
I10217 n1_m1_4000_76800 0 7.745373e-08
I10218 n1_m1_4000_81600 0 1.064523e-07
I10219 n1_m1_4000_86400 0 7.667565e-08
I10220 n1_m1_4000_91200 0 8.894699e-08
I10221 n1_m1_4000_96000 0 1.525645e-07
I10222 n1_m1_4000_100800 0 9.391262e-08
I10223 n1_m1_4000_105600 0 1.331381e-07
I10224 n1_m1_4000_110400 0 9.429746e-08
I10225 n1_m1_4000_115200 0 9.706492e-08
I10226 n1_m1_4000_120000 0 1.388906e-07
I10227 n1_m1_4000_124800 0 8.993995e-08
I10228 n1_m1_4000_129600 0 1.323577e-07
I10229 n1_m1_4000_134400 0 8.816263e-08
I10230 n1_m1_4000_139200 0 8.785201e-08
I10231 n1_m1_4000_144000 0 1.272493e-07
I10232 n1_m1_4000_148800 0 7.904983e-08
I10233 n1_m1_4000_153600 0 1.206610e-07
I10234 n1_m1_4000_158400 0 8.467329e-08
I10235 n1_m1_4000_163200 0 8.538311e-08
I10236 n1_m1_4000_168000 0 1.258186e-07
I10237 n1_m1_4000_172800 0 8.039140e-08
I10238 n1_m1_4000_177600 0 1.206732e-07
I10239 n1_m1_4000_182400 0 8.501453e-08
I10240 n1_m1_4000_187200 0 8.484503e-08
I10241 n1_m1_4000_192000 0 1.272682e-07
I10242 n1_m1_4000_196800 0 8.548028e-08
I10243 n1_m1_4000_201600 0 1.345083e-07
I10244 n1_m1_4000_206400 0 1.001026e-07
I10245 n1_m1_4000_211200 0 9.890850e-08
I10246 n1_m1_4000_216000 0 1.399835e-07
I10247 n1_m1_4000_220800 0 8.876102e-08
I10248 n1_m1_4000_225600 0 1.468106e-07
I10249 n1_m1_4000_230400 0 1.423515e-07
I10250 n1_m1_4000_235200 0 1.374589e-07
I10251 n1_m1_4000_240000 0 1.518940e-07
I10252 n1_m1_4000_244800 0 1.103655e-07
I10253 n1_m1_4000_249600 0 1.566641e-07
I10254 n1_m1_4000_254400 0 1.409125e-07
I10255 n1_m1_4000_259200 0 9.494687e-08
I10256 n1_m1_4000_264000 0 1.442711e-07
I10257 n1_m1_4000_268800 0 1.005025e-07
I10258 n1_m1_4000_273600 0 1.798285e-07
I10259 n1_m1_4000_278400 0 1.228151e-07
I10260 n1_m1_4000_283200 0 8.885968e-08
I10261 n1_m1_4000_288000 0 1.284678e-07
I10262 n1_m1_4000_292800 0 9.049551e-08
I10263 n1_m1_4000_297600 0 1.706479e-07
I10264 n1_m1_4000_302400 0 8.692910e-08
I10265 n1_m1_4000_307200 0 9.944029e-08
I10266 n1_m1_4000_312000 0 1.670436e-07
I10267 n1_m1_4000_316800 0 1.156118e-07
I10268 n1_m1_4000_321600 0 1.923215e-07
I10269 n1_m1_4000_326400 0 8.523394e-08
I10270 n1_m1_4000_331200 0 7.325750e-08
I10271 n1_m1_4000_336000 0 1.148999e-07
I10272 n1_m1_4000_340800 0 7.613232e-08
I10273 n1_m1_4000_345600 0 1.269674e-07
I10274 n1_m1_4000_350400 0 9.540784e-08
I10275 n1_m1_4000_355200 0 9.141917e-08
I10276 n1_m1_4000_360000 0 1.232283e-07
I10277 n1_m1_4000_364800 0 7.504491e-08
I10278 n1_m1_4000_369600 0 1.069031e-07
I10279 n1_m1_4000_374400 0 7.258129e-08
I10280 n1_m1_4000_379200 0 7.593139e-08
I10281 n1_m1_4000_384000 0 1.178534e-07
I10282 n1_m1_4000_388800 0 8.089489e-08
I10283 n1_m1_4000_393600 0 1.190372e-07
I10284 n1_m1_4000_398400 0 7.507244e-08
I10285 n1_m1_4000_403200 0 7.175169e-08
I10286 n1_m1_4000_408000 0 1.079287e-07
I10287 n1_m1_4000_412800 0 7.286321e-08
I10288 n1_m1_4000_417600 0 1.052927e-07
I10289 n1_m1_4000_422400 0 6.995199e-08
I10290 n1_m1_4000_427200 0 6.995199e-08
I10291 n1_m1_4000_432000 0 1.090877e-07
I10292 n1_m1_4000_436800 0 7.562843e-08
I10293 n1_m1_4000_441600 0 1.110601e-07
I10294 n1_m1_4000_446400 0 7.269115e-08
I10295 n1_m1_4000_451200 0 7.310429e-08
I10296 n1_m1_4000_456000 0 1.170704e-07
I10297 n1_m1_4000_460800 0 8.436358e-08
I10298 n1_m1_4000_465600 0 1.134015e-07
I10299 n1_m1_4000_470400 0 6.662094e-08
I10300 n1_m1_4000_475200 0 6.662094e-08
I10301 n1_m1_4000_480000 0 9.993141e-08
I10302 n1_m1_32000_0 0 6.662094e-08
I10303 n1_m1_32000_4800 0 6.662094e-08
I10304 n1_m1_32000_9600 0 9.993141e-08
I10305 n1_m1_32000_14400 0 6.662094e-08
I10306 n1_m1_32000_19200 0 6.860368e-08
I10307 n1_m1_32000_24000 0 1.044853e-07
I10308 n1_m1_32000_28800 0 6.807812e-08
I10309 n1_m1_32000_33600 0 9.993141e-08
I10310 n1_m1_32000_38400 0 6.662094e-08
I10311 n1_m1_32000_43200 0 6.662094e-08
I10312 n1_m1_32000_48000 0 9.993141e-08
I10313 n1_m1_32000_52800 0 6.662094e-08
I10314 n1_m1_32000_57600 0 1.008780e-07
I10315 n1_m1_32000_62400 0 6.919493e-08
I10316 n1_m1_32000_67200 0 6.795048e-08
I10317 n1_m1_32000_72000 0 9.993141e-08
I10318 n1_m1_32000_76800 0 6.662094e-08
I10319 n1_m1_32000_81600 0 9.993141e-08
I10320 n1_m1_32000_86400 0 6.662094e-08
I10321 n1_m1_32000_91200 0 6.662094e-08
I10322 n1_m1_32000_96000 0 9.993141e-08
I10323 n1_m1_32000_100800 0 6.662094e-08
I10324 n1_m1_32000_105600 0 9.993141e-08
I10325 n1_m1_32000_110400 0 6.662094e-08
I10326 n1_m1_32000_115200 0 6.662094e-08
I10327 n1_m1_32000_120000 0 9.993141e-08
I10328 n1_m1_32000_124800 0 6.662094e-08
I10329 n1_m1_32000_129600 0 9.993141e-08
I10330 n1_m1_32000_134400 0 6.662094e-08
I10331 n1_m1_32000_139200 0 6.662094e-08
I10332 n1_m1_32000_144000 0 1.035378e-07
I10333 n1_m1_32000_148800 0 6.922934e-08
I10334 n1_m1_32000_153600 0 9.999335e-08
I10335 n1_m1_32000_158400 0 6.662094e-08
I10336 n1_m1_32000_163200 0 6.662094e-08
I10337 n1_m1_32000_168000 0 9.993141e-08
I10338 n1_m1_32000_172800 0 6.662094e-08
I10339 n1_m1_32000_177600 0 9.993141e-08
I10340 n1_m1_32000_182400 0 6.662094e-08
I10341 n1_m1_32000_187200 0 6.662094e-08
I10342 n1_m1_32000_192000 0 1.025192e-07
I10343 n1_m1_32000_196800 0 6.973864e-08
I10344 n1_m1_32000_201600 0 1.005026e-07
I10345 n1_m1_32000_206400 0 6.662094e-08
I10346 n1_m1_32000_211200 0 6.662094e-08
I10347 n1_m1_32000_216000 0 9.993141e-08
I10348 n1_m1_32000_220800 0 6.723253e-08
I10349 n1_m1_32000_225600 0 1.043743e-07
I10350 n1_m1_32000_230400 0 6.995199e-08
I10351 n1_m1_32000_235200 0 7.011341e-08
I10352 n1_m1_32000_240000 0 1.048129e-07
I10353 n1_m1_32000_244800 0 6.662094e-08
I10354 n1_m1_32000_249600 0 1.006128e-07
I10355 n1_m1_32000_254400 0 7.044971e-08
I10356 n1_m1_32000_259200 0 7.271931e-08
I10357 n1_m1_32000_264000 0 1.070133e-07
I10358 n1_m1_32000_268800 0 6.743775e-08
I10359 n1_m1_32000_273600 0 1.034042e-07
I10360 n1_m1_32000_278400 0 6.778030e-08
I10361 n1_m1_32000_283200 0 6.662094e-08
I10362 n1_m1_32000_288000 0 9.993141e-08
I10363 n1_m1_32000_292800 0 6.662094e-08
I10364 n1_m1_32000_297600 0 9.993141e-08
I10365 n1_m1_32000_302400 0 6.662094e-08
I10366 n1_m1_32000_307200 0 6.662094e-08
I10367 n1_m1_32000_312000 0 9.993141e-08
I10368 n1_m1_32000_316800 0 6.662094e-08
I10369 n1_m1_32000_321600 0 9.993141e-08
I10370 n1_m1_32000_326400 0 6.681333e-08
I10371 n1_m1_32000_331200 0 6.815445e-08
I10372 n1_m1_32000_336000 0 1.026578e-07
I10373 n1_m1_32000_340800 0 6.674138e-08
I10374 n1_m1_32000_345600 0 1.003350e-07
I10375 n1_m1_32000_350400 0 7.131469e-08
I10376 n1_m1_32000_355200 0 7.138789e-08
I10377 n1_m1_32000_360000 0 1.009087e-07
I10378 n1_m1_32000_364800 0 6.662094e-08
I10379 n1_m1_32000_369600 0 1.001723e-07
I10380 n1_m1_32000_374400 0 6.940828e-08
I10381 n1_m1_32000_379200 0 6.995199e-08
I10382 n1_m1_32000_384000 0 1.049280e-07
I10383 n1_m1_32000_388800 0 6.781847e-08
I10384 n1_m1_32000_393600 0 1.074726e-07
I10385 n1_m1_32000_398400 0 6.927752e-08
I10386 n1_m1_32000_403200 0 7.237832e-08
I10387 n1_m1_32000_408000 0 1.064402e-07
I10388 n1_m1_32000_412800 0 6.929973e-08
I10389 n1_m1_32000_417600 0 1.067208e-07
I10390 n1_m1_32000_422400 0 7.212368e-08
I10391 n1_m1_32000_427200 0 6.995199e-08
I10392 n1_m1_32000_432000 0 1.049280e-07
I10393 n1_m1_32000_436800 0 7.081353e-08
I10394 n1_m1_32000_441600 0 1.061818e-07
I10395 n1_m1_32000_446400 0 6.709582e-08
I10396 n1_m1_32000_451200 0 6.712335e-08
I10397 n1_m1_32000_456000 0 1.046458e-07
I10398 n1_m1_32000_460800 0 6.995199e-08
I10399 n1_m1_32000_465600 0 1.040333e-07
I10400 n1_m1_32000_470400 0 6.686808e-08
I10401 n1_m1_32000_475200 0 6.836718e-08
I10402 n1_m1_32000_480000 0 1.076740e-07
I10403 n1_m1_60000_0 0 6.662094e-08
I10404 n1_m1_60000_4800 0 6.662094e-08
I10405 n1_m1_60000_9600 0 1.013499e-07
I10406 n1_m1_60000_14400 0 6.872693e-08
I10407 n1_m1_60000_19200 0 6.712133e-08
I10408 n1_m1_60000_24000 0 9.993141e-08
I10409 n1_m1_60000_28800 0 6.662094e-08
I10410 n1_m1_60000_33600 0 9.993141e-08
I10411 n1_m1_60000_38400 0 6.662094e-08
I10412 n1_m1_60000_43200 0 6.662094e-08
I10413 n1_m1_60000_48000 0 9.993141e-08
I10414 n1_m1_60000_52800 0 6.821784e-08
I10415 n1_m1_60000_57600 0 1.030904e-07
I10416 n1_m1_60000_62400 0 6.924834e-08
I10417 n1_m1_60000_67200 0 6.935971e-08
I10418 n1_m1_60000_72000 0 1.008974e-07
I10419 n1_m1_60000_76800 0 6.662094e-08
I10420 n1_m1_60000_81600 0 9.993141e-08
I10421 n1_m1_60000_86400 0 6.662094e-08
I10422 n1_m1_60000_91200 0 6.662094e-08
I10423 n1_m1_60000_96000 0 9.993141e-08
I10424 n1_m1_60000_100800 0 6.662094e-08
I10425 n1_m1_60000_105600 0 9.993141e-08
I10426 n1_m1_60000_110400 0 6.662094e-08
I10427 n1_m1_60000_115200 0 6.662094e-08
I10428 n1_m1_60000_120000 0 1.008325e-07
I10429 n1_m1_60000_124800 0 6.698314e-08
I10430 n1_m1_60000_129600 0 1.044088e-07
I10431 n1_m1_60000_134400 0 7.449432e-08
I10432 n1_m1_60000_139200 0 7.516475e-08
I10433 n1_m1_60000_144000 0 1.089659e-07
I10434 n1_m1_60000_148800 0 7.160110e-08
I10435 n1_m1_60000_153600 0 1.065253e-07
I10436 n1_m1_60000_158400 0 7.115691e-08
I10437 n1_m1_60000_163200 0 7.181753e-08
I10438 n1_m1_60000_168000 0 1.086489e-07
I10439 n1_m1_60000_172800 0 7.373806e-08
I10440 n1_m1_60000_177600 0 1.129593e-07
I10441 n1_m1_60000_182400 0 7.272844e-08
I10442 n1_m1_60000_187200 0 7.002769e-08
I10443 n1_m1_60000_192000 0 1.023402e-07
I10444 n1_m1_60000_196800 0 6.662094e-08
I10445 n1_m1_60000_201600 0 1.014318e-07
I10446 n1_m1_60000_206400 0 7.057464e-08
I10447 n1_m1_60000_211200 0 7.872007e-08
I10448 n1_m1_60000_216000 0 1.314466e-07
I10449 n1_m1_60000_220800 0 9.176561e-08
I10450 n1_m1_60000_225600 0 1.334645e-07
I10451 n1_m1_60000_230400 0 8.580993e-08
I10452 n1_m1_60000_235200 0 8.370211e-08
I10453 n1_m1_60000_240000 0 1.116436e-07
I10454 n1_m1_60000_244800 0 6.716260e-08
I10455 n1_m1_60000_249600 0 9.993141e-08
I10456 n1_m1_60000_254400 0 6.711263e-08
I10457 n1_m1_60000_259200 0 6.904403e-08
I10458 n1_m1_60000_264000 0 1.076534e-07
I10459 n1_m1_60000_268800 0 7.300086e-08
I10460 n1_m1_60000_273600 0 1.054304e-07
I10461 n1_m1_60000_278400 0 6.927871e-08
I10462 n1_m1_60000_283200 0 6.744767e-08
I10463 n1_m1_60000_288000 0 1.004144e-07
I10464 n1_m1_60000_292800 0 6.871388e-08
I10465 n1_m1_60000_297600 0 1.030449e-07
I10466 n1_m1_60000_302400 0 6.790927e-08
I10467 n1_m1_60000_307200 0 6.681077e-08
I10468 n1_m1_60000_312000 0 1.010714e-07
I10469 n1_m1_60000_316800 0 6.872693e-08
I10470 n1_m1_60000_321600 0 1.050528e-07
I10471 n1_m1_60000_326400 0 6.821349e-08
I10472 n1_m1_60000_331200 0 6.762576e-08
I10473 n1_m1_60000_336000 0 1.049280e-07
I10474 n1_m1_60000_340800 0 7.008107e-08
I10475 n1_m1_60000_345600 0 1.083817e-07
I10476 n1_m1_60000_350400 0 7.989257e-08
I10477 n1_m1_60000_355200 0 8.441506e-08
I10478 n1_m1_60000_360000 0 1.206316e-07
I10479 n1_m1_60000_364800 0 7.475585e-08
I10480 n1_m1_60000_369600 0 1.063652e-07
I10481 n1_m1_60000_374400 0 6.840295e-08
I10482 n1_m1_60000_379200 0 6.966916e-08
I10483 n1_m1_60000_384000 0 1.049280e-07
I10484 n1_m1_60000_388800 0 7.073663e-08
I10485 n1_m1_60000_393600 0 1.401534e-07
I10486 n1_m1_60000_398400 0 1.540669e-07
I10487 n1_m1_60000_403200 0 1.407664e-07
I10488 n1_m1_60000_408000 0 2.343348e-07
I10489 n1_m1_60000_412800 0 1.240595e-07
I10490 n1_m1_60000_417600 0 1.440701e-07
I10491 n1_m1_60000_422400 0 7.672522e-08
I10492 n1_m1_60000_427200 0 7.400682e-08
I10493 n1_m1_60000_432000 0 1.064761e-07
I10494 n1_m1_60000_436800 0 6.784600e-08
I10495 n1_m1_60000_441600 0 1.016551e-07
I10496 n1_m1_60000_446400 0 6.679559e-08
I10497 n1_m1_60000_451200 0 6.730812e-08
I10498 n1_m1_60000_456000 0 1.056152e-07
I10499 n1_m1_60000_460800 0 6.851608e-08
I10500 n1_m1_60000_465600 0 1.091002e-07
I10501 n1_m1_60000_470400 0 7.994513e-08
I10502 n1_m1_60000_475200 0 7.738490e-08
I10503 n1_m1_60000_480000 0 1.071785e-07
I10504 n1_m1_88000_0 0 6.662094e-08
I10505 n1_m1_88000_4800 0 6.662094e-08
I10506 n1_m1_88000_9600 0 1.000149e-07
I10507 n1_m1_88000_14400 0 6.674482e-08
I10508 n1_m1_88000_19200 0 6.665038e-08
I10509 n1_m1_88000_24000 0 9.997799e-08
I10510 n1_m1_88000_28800 0 6.669107e-08
I10511 n1_m1_88000_33600 0 9.993141e-08
I10512 n1_m1_88000_38400 0 6.662094e-08
I10513 n1_m1_88000_43200 0 6.662094e-08
I10514 n1_m1_88000_48000 0 9.993141e-08
I10515 n1_m1_88000_52800 0 6.662376e-08
I10516 n1_m1_88000_57600 0 1.012704e-07
I10517 n1_m1_88000_62400 0 7.268205e-08
I10518 n1_m1_88000_67200 0 7.630642e-08
I10519 n1_m1_88000_72000 0 1.071475e-07
I10520 n1_m1_88000_76800 0 6.683961e-08
I10521 n1_m1_88000_81600 0 9.993141e-08
I10522 n1_m1_88000_86400 0 6.662094e-08
I10523 n1_m1_88000_91200 0 6.662094e-08
I10524 n1_m1_88000_96000 0 9.993141e-08
I10525 n1_m1_88000_100800 0 6.662094e-08
I10526 n1_m1_88000_105600 0 9.993141e-08
I10527 n1_m1_88000_110400 0 6.662094e-08
I10528 n1_m1_88000_115200 0 6.662094e-08
I10529 n1_m1_88000_120000 0 1.026224e-07
I10530 n1_m1_88000_124800 0 8.030904e-08
I10531 n1_m1_88000_129600 0 1.206342e-07
I10532 n1_m1_88000_134400 0 7.378675e-08
I10533 n1_m1_88000_139200 0 7.345964e-08
I10534 n1_m1_88000_144000 0 1.197848e-07
I10535 n1_m1_88000_148800 0 8.142355e-08
I10536 n1_m1_88000_153600 0 1.218090e-07
I10537 n1_m1_88000_158400 0 7.142444e-08
I10538 n1_m1_88000_163200 0 6.994354e-08
I10539 n1_m1_88000_168000 0 1.077618e-07
I10540 n1_m1_88000_172800 0 7.649430e-08
I10541 n1_m1_88000_177600 0 1.134373e-07
I10542 n1_m1_88000_182400 0 6.727380e-08
I10543 n1_m1_88000_187200 0 6.671488e-08
I10544 n1_m1_88000_192000 0 9.993141e-08
I10545 n1_m1_88000_196800 0 6.662094e-08
I10546 n1_m1_88000_201600 0 9.993141e-08
I10547 n1_m1_88000_206400 0 6.662094e-08
I10548 n1_m1_88000_211200 0 6.843657e-08
I10549 n1_m1_88000_216000 0 1.084861e-07
I10550 n1_m1_88000_220800 0 7.163509e-08
I10551 n1_m1_88000_225600 0 1.002128e-07
I10552 n1_m1_88000_230400 0 6.919743e-08
I10553 n1_m1_88000_235200 0 6.954317e-08
I10554 n1_m1_88000_240000 0 1.004019e-07
I10555 n1_m1_88000_244800 0 6.669005e-08
I10556 n1_m1_88000_249600 0 9.997902e-08
I10557 n1_m1_88000_254400 0 6.662094e-08
I10558 n1_m1_88000_259200 0 6.746249e-08
I10559 n1_m1_88000_264000 0 1.047422e-07
I10560 n1_m1_88000_268800 0 6.955642e-08
I10561 n1_m1_88000_273600 0 1.035693e-07
I10562 n1_m1_88000_278400 0 7.127266e-08
I10563 n1_m1_88000_283200 0 6.795520e-08
I10564 n1_m1_88000_288000 0 1.209477e-07
I10565 n1_m1_88000_292800 0 1.156904e-07
I10566 n1_m1_88000_297600 0 1.425849e-07
I10567 n1_m1_88000_302400 0 8.517706e-08
I10568 n1_m1_88000_307200 0 8.010487e-08
I10569 n1_m1_88000_312000 0 1.088423e-07
I10570 n1_m1_88000_316800 0 7.002621e-08
I10571 n1_m1_88000_321600 0 1.053447e-07
I10572 n1_m1_88000_326400 0 7.001546e-08
I10573 n1_m1_88000_331200 0 6.889802e-08
I10574 n1_m1_88000_336000 0 1.028738e-07
I10575 n1_m1_88000_340800 0 6.996504e-08
I10576 n1_m1_88000_345600 0 1.085169e-07
I10577 n1_m1_88000_350400 0 8.217563e-08
I10578 n1_m1_88000_355200 0 8.627243e-08
I10579 n1_m1_88000_360000 0 1.235320e-07
I10580 n1_m1_88000_364800 0 7.264104e-08
I10581 n1_m1_88000_369600 0 1.050798e-07
I10582 n1_m1_88000_374400 0 6.986087e-08
I10583 n1_m1_88000_379200 0 6.993535e-08
I10584 n1_m1_88000_384000 0 1.049280e-07
I10585 n1_m1_88000_388800 0 6.995199e-08
I10586 n1_m1_88000_393600 0 1.089621e-07
I10587 n1_m1_88000_398400 0 8.551566e-08
I10588 n1_m1_88000_403200 0 8.001515e-08
I10589 n1_m1_88000_408000 0 1.066493e-07
I10590 n1_m1_88000_412800 0 6.706491e-08
I10591 n1_m1_88000_417600 0 9.993141e-08
I10592 n1_m1_88000_422400 0 6.662094e-08
I10593 n1_m1_88000_427200 0 6.662094e-08
I10594 n1_m1_88000_432000 0 9.993141e-08
I10595 n1_m1_88000_436800 0 6.662094e-08
I10596 n1_m1_88000_441600 0 1.002411e-07
I10597 n1_m1_88000_446400 0 6.908615e-08
I10598 n1_m1_88000_451200 0 6.759300e-08
I10599 n1_m1_88000_456000 0 1.046563e-07
I10600 n1_m1_88000_460800 0 6.995199e-08
I10601 n1_m1_88000_465600 0 1.106533e-07
I10602 n1_m1_88000_470400 0 7.981869e-08
I10603 n1_m1_88000_475200 0 7.755639e-08
I10604 n1_m1_88000_480000 0 1.074480e-07
I10605 n1_m1_116000_0 0 1.337588e-07
I10606 n1_m1_116000_4800 0 1.358495e-07
I10607 n1_m1_116000_9600 0 2.190862e-07
I10608 n1_m1_116000_14400 0 2.360770e-07
I10609 n1_m1_116000_19200 0 4.047537e-07
I10610 n1_m1_116000_24000 0 4.950160e-07
I10611 n1_m1_116000_28800 0 1.681996e-07
I10612 n1_m1_116000_33600 0 2.260224e-07
I10613 n1_m1_116000_38400 0 1.396369e-07
I10614 n1_m1_116000_43200 0 1.346120e-07
I10615 n1_m1_116000_48000 0 2.115764e-07
I10616 n1_m1_116000_52800 0 1.519020e-07
I10617 n1_m1_116000_57600 0 2.420653e-07
I10618 n1_m1_116000_62400 0 1.645152e-07
I10619 n1_m1_116000_67200 0 1.597436e-07
I10620 n1_m1_116000_72000 0 2.328719e-07
I10621 n1_m1_116000_76800 0 1.512812e-07
I10622 n1_m1_116000_81600 0 2.178661e-07
I10623 n1_m1_116000_86400 0 1.426933e-07
I10624 n1_m1_116000_91200 0 1.441875e-07
I10625 n1_m1_116000_96000 0 2.149525e-07
I10626 n1_m1_116000_100800 0 1.399040e-07
I10627 n1_m1_116000_105600 0 2.087686e-07
I10628 n1_m1_116000_110400 0 1.337236e-07
I10629 n1_m1_116000_115200 0 1.332419e-07
I10630 n1_m1_116000_120000 0 2.053129e-07
I10631 n1_m1_116000_124800 0 1.631716e-07
I10632 n1_m1_116000_129600 0 2.391897e-07
I10633 n1_m1_116000_134400 0 1.790315e-07
I10634 n1_m1_116000_139200 0 1.649138e-07
I10635 n1_m1_116000_144000 0 2.194499e-07
I10636 n1_m1_116000_148800 0 1.478680e-07
I10637 n1_m1_116000_153600 0 2.223722e-07
I10638 n1_m1_116000_158400 0 1.390096e-07
I10639 n1_m1_116000_163200 0 1.379494e-07
I10640 n1_m1_116000_168000 0 2.099798e-07
I10641 n1_m1_116000_172800 0 1.421799e-07
I10642 n1_m1_116000_177600 0 2.110810e-07
I10643 n1_m1_116000_182400 0 1.462220e-07
I10644 n1_m1_116000_187200 0 1.481765e-07
I10645 n1_m1_116000_192000 0 2.334307e-07
I10646 n1_m1_116000_196800 0 1.560713e-07
I10647 n1_m1_116000_201600 0 2.255973e-07
I10648 n1_m1_116000_206400 0 1.431800e-07
I10649 n1_m1_116000_211200 0 1.399040e-07
I10650 n1_m1_116000_216000 0 2.098560e-07
I10651 n1_m1_116000_220800 0 1.410225e-07
I10652 n1_m1_116000_225600 0 2.132991e-07
I10653 n1_m1_116000_230400 0 1.399040e-07
I10654 n1_m1_116000_235200 0 1.397303e-07
I10655 n1_m1_116000_240000 0 2.081881e-07
I10656 n1_m1_116000_244800 0 1.399040e-07
I10657 n1_m1_116000_249600 0 2.084933e-07
I10658 n1_m1_116000_254400 0 1.345474e-07
I10659 n1_m1_116000_259200 0 1.367044e-07
I10660 n1_m1_116000_264000 0 2.049420e-07
I10661 n1_m1_116000_268800 0 1.354025e-07
I10662 n1_m1_116000_273600 0 2.096116e-07
I10663 n1_m1_116000_278400 0 1.332419e-07
I10664 n1_m1_116000_283200 0 1.372887e-07
I10665 n1_m1_116000_288000 0 2.165396e-07
I10666 n1_m1_116000_292800 0 1.436083e-07
I10667 n1_m1_116000_297600 0 2.312784e-07
I10668 n1_m1_116000_302400 0 1.861566e-07
I10669 n1_m1_116000_307200 0 2.403487e-07
I10670 n1_m1_116000_312000 0 3.434250e-07
I10671 n1_m1_116000_316800 0 1.619550e-07
I10672 n1_m1_116000_321600 0 2.133153e-07
I10673 n1_m1_116000_326400 0 1.391659e-07
I10674 n1_m1_116000_331200 0 1.412369e-07
I10675 n1_m1_116000_336000 0 2.050062e-07
I10676 n1_m1_116000_340800 0 1.406234e-07
I10677 n1_m1_116000_345600 0 2.159550e-07
I10678 n1_m1_116000_350400 0 1.407036e-07
I10679 n1_m1_116000_355200 0 1.399040e-07
I10680 n1_m1_116000_360000 0 2.233657e-07
I10681 n1_m1_116000_364800 0 1.385228e-07
I10682 n1_m1_116000_369600 0 2.011309e-07
I10683 n1_m1_116000_374400 0 1.337185e-07
I10684 n1_m1_116000_379200 0 1.375716e-07
I10685 n1_m1_116000_384000 0 2.057684e-07
I10686 n1_m1_116000_388800 0 1.332419e-07
I10687 n1_m1_116000_393600 0 2.015008e-07
I10688 n1_m1_116000_398400 0 1.418035e-07
I10689 n1_m1_116000_403200 0 1.442811e-07
I10690 n1_m1_116000_408000 0 2.043117e-07
I10691 n1_m1_116000_412800 0 1.375441e-07
I10692 n1_m1_116000_417600 0 2.085193e-07
I10693 n1_m1_116000_422400 0 1.349732e-07
I10694 n1_m1_116000_427200 0 1.332419e-07
I10695 n1_m1_116000_432000 0 1.998628e-07
I10696 n1_m1_116000_436800 0 1.332419e-07
I10697 n1_m1_116000_441600 0 2.004822e-07
I10698 n1_m1_116000_446400 0 1.389542e-07
I10699 n1_m1_116000_451200 0 1.399040e-07
I10700 n1_m1_116000_456000 0 2.098560e-07
I10701 n1_m1_116000_460800 0 1.399040e-07
I10702 n1_m1_116000_465600 0 2.116454e-07
I10703 n1_m1_116000_470400 0 1.530905e-07
I10704 n1_m1_116000_475200 0 1.639921e-07
I10705 n1_m1_116000_480000 0 2.288512e-07
I10706 n1_m1_172000_0 0 6.785612e-08
I10707 n1_m1_172000_4800 0 6.677013e-08
I10708 n1_m1_172000_9600 0 9.993141e-08
I10709 n1_m1_172000_14400 0 6.662094e-08
I10710 n1_m1_172000_19200 0 6.726108e-08
I10711 n1_m1_172000_24000 0 1.015066e-07
I10712 n1_m1_172000_28800 0 6.901690e-08
I10713 n1_m1_172000_33600 0 1.050477e-07
I10714 n1_m1_172000_38400 0 7.056958e-08
I10715 n1_m1_172000_43200 0 6.950646e-08
I10716 n1_m1_172000_48000 0 1.024728e-07
I10717 n1_m1_172000_52800 0 6.911234e-08
I10718 n1_m1_172000_57600 0 1.033698e-07
I10719 n1_m1_172000_62400 0 6.971799e-08
I10720 n1_m1_172000_67200 0 7.122533e-08
I10721 n1_m1_172000_72000 0 1.034167e-07
I10722 n1_m1_172000_76800 0 7.298417e-08
I10723 n1_m1_172000_81600 0 1.214126e-07
I10724 n1_m1_172000_86400 0 7.656184e-08
I10725 n1_m1_172000_91200 0 8.987781e-08
I10726 n1_m1_172000_96000 0 1.264042e-07
I10727 n1_m1_172000_100800 0 8.966161e-08
I10728 n1_m1_172000_105600 0 1.369104e-07
I10729 n1_m1_172000_110400 0 7.839678e-08
I10730 n1_m1_172000_115200 0 7.522567e-08
I10731 n1_m1_172000_120000 0 1.127455e-07
I10732 n1_m1_172000_124800 0 9.103657e-08
I10733 n1_m1_172000_129600 0 1.444914e-07
I10734 n1_m1_172000_134400 0 9.343011e-08
I10735 n1_m1_172000_139200 0 7.927049e-08
I10736 n1_m1_172000_144000 0 1.106826e-07
I10737 n1_m1_172000_148800 0 6.835756e-08
I10738 n1_m1_172000_153600 0 1.024315e-07
I10739 n1_m1_172000_158400 0 7.021497e-08
I10740 n1_m1_172000_163200 0 9.046784e-08
I10741 n1_m1_172000_168000 0 2.745264e-07
I10742 n1_m1_172000_172800 0 2.739598e-07
I10743 n1_m1_172000_177600 0 3.548068e-07
I10744 n1_m1_172000_182400 0 2.108678e-07
I10745 n1_m1_172000_187200 0 1.199971e-07
I10746 n1_m1_172000_192000 0 2.085788e-07
I10747 n1_m1_172000_196800 0 1.007952e-07
I10748 n1_m1_172000_201600 0 2.163793e-07
I10749 n1_m1_172000_206400 0 7.949072e-08
I10750 n1_m1_172000_211200 0 7.849984e-08
I10751 n1_m1_172000_216000 0 1.665013e-07
I10752 n1_m1_172000_220800 0 1.520052e-07
I10753 n1_m1_172000_225600 0 1.536823e-07
I10754 n1_m1_172000_230400 0 8.868734e-08
I10755 n1_m1_172000_235200 0 9.395294e-08
I10756 n1_m1_172000_240000 0 2.052628e-07
I10757 n1_m1_172000_244800 0 1.665208e-07
I10758 n1_m1_172000_249600 0 1.470020e-07
I10759 n1_m1_172000_254400 0 8.547036e-08
I10760 n1_m1_172000_259200 0 8.572975e-08
I10761 n1_m1_172000_264000 0 1.220499e-07
I10762 n1_m1_172000_268800 0 7.790156e-08
I10763 n1_m1_172000_273600 0 1.145426e-07
I10764 n1_m1_172000_278400 0 7.275344e-08
I10765 n1_m1_172000_283200 0 7.365468e-08
I10766 n1_m1_172000_288000 0 1.174961e-07
I10767 n1_m1_172000_292800 0 7.889031e-08
I10768 n1_m1_172000_297600 0 1.123429e-07
I10769 n1_m1_172000_302400 0 7.412268e-08
I10770 n1_m1_172000_307200 0 7.403073e-08
I10771 n1_m1_172000_312000 0 1.086817e-07
I10772 n1_m1_172000_316800 0 7.028854e-08
I10773 n1_m1_172000_321600 0 1.056782e-07
I10774 n1_m1_172000_326400 0 7.324862e-08
I10775 n1_m1_172000_331200 0 7.428785e-08
I10776 n1_m1_172000_336000 0 1.127578e-07
I10777 n1_m1_172000_340800 0 8.036677e-08
I10778 n1_m1_172000_345600 0 1.179022e-07
I10779 n1_m1_172000_350400 0 9.112266e-08
I10780 n1_m1_172000_355200 0 1.026018e-07
I10781 n1_m1_172000_360000 0 2.381176e-07
I10782 n1_m1_172000_364800 0 8.676006e-08
I10783 n1_m1_172000_369600 0 1.217267e-07
I10784 n1_m1_172000_374400 0 7.795372e-08
I10785 n1_m1_172000_379200 0 7.974736e-08
I10786 n1_m1_172000_384000 0 1.232979e-07
I10787 n1_m1_172000_388800 0 8.088113e-08
I10788 n1_m1_172000_393600 0 1.606259e-07
I10789 n1_m1_172000_398400 0 1.986874e-07
I10790 n1_m1_172000_403200 0 1.278510e-07
I10791 n1_m1_172000_408000 0 1.247832e-07
I10792 n1_m1_172000_412800 0 6.931546e-08
I10793 n1_m1_172000_417600 0 1.065965e-07
I10794 n1_m1_172000_422400 0 6.995199e-08
I10795 n1_m1_172000_427200 0 6.995199e-08
I10796 n1_m1_172000_432000 0 1.049280e-07
I10797 n1_m1_172000_436800 0 6.995199e-08
I10798 n1_m1_172000_441600 0 1.049280e-07
I10799 n1_m1_172000_446400 0 6.995199e-08
I10800 n1_m1_172000_451200 0 6.995199e-08
I10801 n1_m1_172000_456000 0 1.049280e-07
I10802 n1_m1_172000_460800 0 6.995199e-08
I10803 n1_m1_172000_465600 0 1.069429e-07
I10804 n1_m1_172000_470400 0 7.962854e-08
I10805 n1_m1_172000_475200 0 8.379315e-08
I10806 n1_m1_172000_480000 0 1.187300e-07
I10807 n1_m1_200000_0 0 8.748816e-08
I10808 n1_m1_200000_4800 0 8.944169e-08
I10809 n1_m1_200000_9600 0 1.273008e-07
I10810 n1_m1_200000_14400 0 7.507244e-08
I10811 n1_m1_200000_19200 0 7.582261e-08
I10812 n1_m1_200000_24000 0 1.124160e-07
I10813 n1_m1_200000_28800 0 6.995199e-08
I10814 n1_m1_200000_33600 0 1.025946e-07
I10815 n1_m1_200000_38400 0 6.672716e-08
I10816 n1_m1_200000_43200 0 6.684991e-08
I10817 n1_m1_200000_48000 0 1.016050e-07
I10818 n1_m1_200000_52800 0 6.937319e-08
I10819 n1_m1_200000_57600 0 1.029158e-07
I10820 n1_m1_200000_62400 0 7.043824e-08
I10821 n1_m1_200000_67200 0 7.054210e-08
I10822 n1_m1_200000_72000 0 1.049280e-07
I10823 n1_m1_200000_76800 0 7.148387e-08
I10824 n1_m1_200000_81600 0 1.163284e-07
I10825 n1_m1_200000_86400 0 7.277315e-08
I10826 n1_m1_200000_91200 0 7.264995e-08
I10827 n1_m1_200000_96000 0 1.050775e-07
I10828 n1_m1_200000_100800 0 6.935243e-08
I10829 n1_m1_200000_105600 0 1.049280e-07
I10830 n1_m1_200000_110400 0 7.017151e-08
I10831 n1_m1_200000_115200 0 7.203386e-08
I10832 n1_m1_200000_120000 0 1.169290e-07
I10833 n1_m1_200000_124800 0 1.410249e-07
I10834 n1_m1_200000_129600 0 1.653008e-07
I10835 n1_m1_200000_134400 0 1.373344e-07
I10836 n1_m1_200000_139200 0 1.052165e-07
I10837 n1_m1_200000_144000 0 1.178402e-07
I10838 n1_m1_200000_148800 0 7.691571e-08
I10839 n1_m1_200000_153600 0 1.116244e-07
I10840 n1_m1_200000_158400 0 7.362587e-08
I10841 n1_m1_200000_163200 0 7.100393e-08
I10842 n1_m1_200000_168000 0 2.898211e-07
I10843 n1_m1_200000_172800 0 3.494553e-07
I10844 n1_m1_200000_177600 0 8.337839e-07
I10845 n1_m1_200000_182400 0 5.951483e-07
I10846 n1_m1_200000_187200 0 4.828068e-07
I10847 n1_m1_200000_192000 0 4.555616e-07
I10848 n1_m1_200000_196800 0 2.242357e-07
I10849 n1_m1_200000_201600 0 4.920801e-07
I10850 n1_m1_200000_206400 0 2.233604e-07
I10851 n1_m1_200000_211200 0 1.243379e-07
I10852 n1_m1_200000_216000 0 1.552996e-07
I10853 n1_m1_200000_220800 0 1.856480e-07
I10854 n1_m1_200000_225600 0 3.609046e-07
I10855 n1_m1_200000_230400 0 2.015020e-07
I10856 n1_m1_200000_235200 0 2.802848e-07
I10857 n1_m1_200000_240000 0 4.596531e-07
I10858 n1_m1_200000_244800 0 3.935954e-07
I10859 n1_m1_200000_249600 0 3.416214e-07
I10860 n1_m1_200000_254400 0 2.028927e-07
I10861 n1_m1_200000_259200 0 2.785877e-07
I10862 n1_m1_200000_264000 0 5.377831e-07
I10863 n1_m1_200000_268800 0 3.884398e-07
I10864 n1_m1_200000_273600 0 4.726046e-07
I10865 n1_m1_200000_278400 0 2.948102e-07
I10866 n1_m1_200000_283200 0 2.208927e-07
I10867 n1_m1_200000_288000 0 2.238093e-07
I10868 n1_m1_200000_292800 0 1.664500e-07
I10869 n1_m1_200000_297600 0 1.879338e-07
I10870 n1_m1_200000_302400 0 9.058276e-08
I10871 n1_m1_200000_307200 0 9.009372e-08
I10872 n1_m1_200000_312000 0 1.655980e-07
I10873 n1_m1_200000_316800 0 1.159545e-07
I10874 n1_m1_200000_321600 0 1.488743e-07
I10875 n1_m1_200000_326400 0 8.914427e-08
I10876 n1_m1_200000_331200 0 1.022485e-07
I10877 n1_m1_200000_336000 0 3.130735e-07
I10878 n1_m1_200000_340800 0 1.752164e-07
I10879 n1_m1_200000_345600 0 2.096587e-07
I10880 n1_m1_200000_350400 0 1.907913e-07
I10881 n1_m1_200000_355200 0 1.659678e-07
I10882 n1_m1_200000_360000 0 1.792576e-07
I10883 n1_m1_200000_364800 0 8.684122e-08
I10884 n1_m1_200000_369600 0 1.272591e-07
I10885 n1_m1_200000_374400 0 7.991006e-08
I10886 n1_m1_200000_379200 0 7.708356e-08
I10887 n1_m1_200000_384000 0 1.191971e-07
I10888 n1_m1_200000_388800 0 7.614830e-08
I10889 n1_m1_200000_393600 0 1.115549e-07
I10890 n1_m1_200000_398400 0 7.537526e-08
I10891 n1_m1_200000_403200 0 7.775655e-08
I10892 n1_m1_200000_408000 0 1.135232e-07
I10893 n1_m1_200000_412800 0 7.344119e-08
I10894 n1_m1_200000_417600 0 1.111816e-07
I10895 n1_m1_200000_422400 0 7.198193e-08
I10896 n1_m1_200000_427200 0 7.225069e-08
I10897 n1_m1_200000_432000 0 1.057883e-07
I10898 n1_m1_200000_436800 0 6.995199e-08
I10899 n1_m1_200000_441600 0 1.079011e-07
I10900 n1_m1_200000_446400 0 7.328303e-08
I10901 n1_m1_200000_451200 0 7.361313e-08
I10902 n1_m1_200000_456000 0 1.130220e-07
I10903 n1_m1_200000_460800 0 7.547162e-08
I10904 n1_m1_200000_465600 0 1.169986e-07
I10905 n1_m1_200000_470400 0 8.763957e-08
I10906 n1_m1_200000_475200 0 9.000567e-08
I10907 n1_m1_200000_480000 0 1.216727e-07
I10908 n1_m1_228000_0 0 1.056819e-07
I10909 n1_m1_228000_4800 0 1.617133e-07
I10910 n1_m1_228000_9600 0 2.049816e-07
I10911 n1_m1_228000_14400 0 8.984271e-08
I10912 n1_m1_228000_19200 0 8.922205e-08
I10913 n1_m1_228000_24000 0 1.160962e-07
I10914 n1_m1_228000_28800 0 7.207920e-08
I10915 n1_m1_228000_33600 0 1.065239e-07
I10916 n1_m1_228000_38400 0 7.358594e-08
I10917 n1_m1_228000_43200 0 7.620748e-08
I10918 n1_m1_228000_48000 0 4.318882e-07
I10919 n1_m1_228000_52800 0 2.281192e-07
I10920 n1_m1_228000_57600 0 4.122748e-07
I10921 n1_m1_228000_62400 0 2.050160e-07
I10922 n1_m1_228000_67200 0 1.682010e-07
I10923 n1_m1_228000_72000 0 2.332353e-07
I10924 n1_m1_228000_76800 0 3.389097e-07
I10925 n1_m1_228000_81600 0 3.340741e-07
I10926 n1_m1_228000_86400 0 1.258096e-07
I10927 n1_m1_228000_91200 0 1.500990e-07
I10928 n1_m1_228000_96000 0 2.800755e-07
I10929 n1_m1_228000_100800 0 2.905963e-07
I10930 n1_m1_228000_105600 0 4.392926e-07
I10931 n1_m1_228000_110400 0 2.070931e-07
I10932 n1_m1_228000_115200 0 2.741771e-07
I10933 n1_m1_228000_120000 0 5.650877e-07
I10934 n1_m1_228000_124800 0 6.156876e-07
I10935 n1_m1_228000_129600 0 9.374546e-07
I10936 n1_m1_228000_134400 0 6.327873e-07
I10937 n1_m1_228000_139200 0 4.752120e-07
I10938 n1_m1_228000_144000 0 6.402382e-07
I10939 n1_m1_228000_148800 0 3.122725e-07
I10940 n1_m1_228000_153600 0 3.517586e-07
I10941 n1_m1_228000_158400 0 1.940927e-07
I10942 n1_m1_228000_163200 0 2.629652e-07
I10943 n1_m1_228000_168000 0 8.001196e-07
I10944 n1_m1_228000_172800 0 6.458652e-07
I10945 n1_m1_228000_177600 0 9.898611e-07
I10946 n1_m1_228000_182400 0 6.162402e-07
I10947 n1_m1_228000_187200 0 5.094443e-07
I10948 n1_m1_228000_192000 0 5.701080e-07
I10949 n1_m1_228000_196800 0 1.277068e-07
I10950 n1_m1_228000_201600 0 1.370455e-07
I10951 n1_m1_228000_206400 0 2.720491e-07
I10952 n1_m1_228000_211200 0 2.859636e-07
I10953 n1_m1_228000_216000 0 2.190143e-07
I10954 n1_m1_228000_220800 0 1.000028e-07
I10955 n1_m1_228000_225600 0 1.857150e-07
I10956 n1_m1_228000_230400 0 1.958564e-07
I10957 n1_m1_228000_235200 0 2.366973e-07
I10958 n1_m1_228000_240000 0 2.468220e-07
I10959 n1_m1_228000_244800 0 1.452014e-07
I10960 n1_m1_228000_249600 0 3.942584e-07
I10961 n1_m1_228000_254400 0 5.643001e-07
I10962 n1_m1_228000_259200 0 4.839668e-07
I10963 n1_m1_228000_264000 0 5.039308e-07
I10964 n1_m1_228000_268800 0 1.373996e-07
I10965 n1_m1_228000_273600 0 2.715509e-07
I10966 n1_m1_228000_278400 0 1.737654e-07
I10967 n1_m1_228000_283200 0 3.147087e-07
I10968 n1_m1_228000_288000 0 3.006114e-07
I10969 n1_m1_228000_292800 0 2.088954e-07
I10970 n1_m1_228000_297600 0 3.784462e-07
I10971 n1_m1_228000_302400 0 3.330927e-07
I10972 n1_m1_228000_307200 0 2.190765e-07
I10973 n1_m1_228000_312000 0 2.576462e-07
I10974 n1_m1_228000_316800 0 9.193449e-08
I10975 n1_m1_228000_321600 0 1.360000e-07
I10976 n1_m1_228000_326400 0 9.021572e-08
I10977 n1_m1_228000_331200 0 9.078446e-08
I10978 n1_m1_228000_336000 0 1.294296e-07
I10979 n1_m1_228000_340800 0 8.881801e-08
I10980 n1_m1_228000_345600 0 1.281490e-07
I10981 n1_m1_228000_350400 0 8.101690e-08
I10982 n1_m1_228000_355200 0 8.189971e-08
I10983 n1_m1_228000_360000 0 1.263231e-07
I10984 n1_m1_228000_364800 0 7.543032e-08
I10985 n1_m1_228000_369600 0 1.098408e-07
I10986 n1_m1_228000_374400 0 7.571204e-08
I10987 n1_m1_228000_379200 0 7.594630e-08
I10988 n1_m1_228000_384000 0 1.119067e-07
I10989 n1_m1_228000_388800 0 8.067466e-08
I10990 n1_m1_228000_393600 0 1.172567e-07
I10991 n1_m1_228000_398400 0 8.689184e-08
I10992 n1_m1_228000_403200 0 8.150054e-08
I10993 n1_m1_228000_408000 0 1.191487e-07
I10994 n1_m1_228000_412800 0 7.530271e-08
I10995 n1_m1_228000_417600 0 1.204889e-07
I10996 n1_m1_228000_422400 0 7.123165e-08
I10997 n1_m1_228000_427200 0 7.461337e-08
I10998 n1_m1_228000_432000 0 1.355702e-07
I10999 n1_m1_228000_436800 0 1.730599e-07
I11000 n1_m1_228000_441600 0 2.244080e-07
I11001 n1_m1_228000_446400 0 8.807168e-08
I11002 n1_m1_228000_451200 0 7.429474e-08
I11003 n1_m1_228000_456000 0 1.072886e-07
I11004 n1_m1_228000_460800 0 7.541343e-08
I11005 n1_m1_228000_465600 0 1.240793e-07
I11006 n1_m1_228000_470400 0 9.332722e-08
I11007 n1_m1_228000_475200 0 9.729992e-08
I11008 n1_m1_228000_480000 0 1.267000e-07
I11009 n1_m1_256000_0 0 8.484694e-08
I11010 n1_m1_256000_4800 0 8.670625e-08
I11011 n1_m1_256000_9600 0 1.164351e-07
I11012 n1_m1_256000_14400 0 7.334219e-08
I11013 n1_m1_256000_19200 0 6.934794e-08
I11014 n1_m1_256000_24000 0 1.015086e-07
I11015 n1_m1_256000_28800 0 6.995199e-08
I11016 n1_m1_256000_33600 0 1.049280e-07
I11017 n1_m1_256000_38400 0 7.021872e-08
I11018 n1_m1_256000_43200 0 7.140777e-08
I11019 n1_m1_256000_48000 0 1.072611e-07
I11020 n1_m1_256000_52800 0 7.150739e-08
I11021 n1_m1_256000_57600 0 1.072611e-07
I11022 n1_m1_256000_62400 0 7.084538e-08
I11023 n1_m1_256000_67200 0 6.909352e-08
I11024 n1_m1_256000_72000 0 1.041135e-07
I11025 n1_m1_256000_76800 0 7.025728e-08
I11026 n1_m1_256000_81600 0 1.060881e-07
I11027 n1_m1_256000_86400 0 6.750188e-08
I11028 n1_m1_256000_91200 0 6.922934e-08
I11029 n1_m1_256000_96000 0 1.041869e-07
I11030 n1_m1_256000_100800 0 6.743721e-08
I11031 n1_m1_256000_105600 0 9.993141e-08
I11032 n1_m1_256000_110400 0 6.691981e-08
I11033 n1_m1_256000_115200 0 6.850141e-08
I11034 n1_m1_256000_120000 0 1.074006e-07
I11035 n1_m1_256000_124800 0 7.328303e-08
I11036 n1_m1_256000_129600 0 1.099246e-07
I11037 n1_m1_256000_134400 0 7.328303e-08
I11038 n1_m1_256000_139200 0 7.328303e-08
I11039 n1_m1_256000_144000 0 1.135309e-07
I11040 n1_m1_256000_148800 0 7.656630e-08
I11041 n1_m1_256000_153600 0 1.109846e-07
I11042 n1_m1_256000_158400 0 7.428874e-08
I11043 n1_m1_256000_163200 0 7.848855e-08
I11044 n1_m1_256000_168000 0 1.126684e-07
I11045 n1_m1_256000_172800 0 1.145591e-07
I11046 n1_m1_256000_177600 0 7.752757e-07
I11047 n1_m1_256000_182400 0 5.982826e-07
I11048 n1_m1_256000_187200 0 5.609657e-07
I11049 n1_m1_256000_192000 0 6.360220e-07
I11050 n1_m1_256000_196800 0 4.058317e-07
I11051 n1_m1_256000_201600 0 1.974519e-07
I11052 n1_m1_256000_206400 0 1.266691e-07
I11053 n1_m1_256000_211200 0 1.179228e-07
I11054 n1_m1_256000_216000 0 6.218479e-07
I11055 n1_m1_256000_220800 0 2.501814e-07
I11056 n1_m1_256000_225600 0 4.546226e-07
I11057 n1_m1_256000_230400 0 2.033917e-07
I11058 n1_m1_256000_235200 0 2.932723e-07
I11059 n1_m1_256000_240000 0 5.179557e-07
I11060 n1_m1_256000_244800 0 1.971155e-07
I11061 n1_m1_256000_249600 0 1.714565e-07
I11062 n1_m1_256000_254400 0 1.503850e-07
I11063 n1_m1_256000_259200 0 3.145087e-07
I11064 n1_m1_256000_264000 0 6.190787e-07
I11065 n1_m1_256000_268800 0 2.513134e-07
I11066 n1_m1_256000_273600 0 3.485909e-07
I11067 n1_m1_256000_278400 0 2.222025e-07
I11068 n1_m1_256000_283200 0 2.461614e-07
I11069 n1_m1_256000_288000 0 3.229548e-07
I11070 n1_m1_256000_292800 0 1.455521e-07
I11071 n1_m1_256000_297600 0 1.197048e-07
I11072 n1_m1_256000_302400 0 8.019065e-08
I11073 n1_m1_256000_307200 0 7.958037e-08
I11074 n1_m1_256000_312000 0 1.153409e-07
I11075 n1_m1_256000_316800 0 7.461821e-08
I11076 n1_m1_256000_321600 0 1.095743e-07
I11077 n1_m1_256000_326400 0 7.174370e-08
I11078 n1_m1_256000_331200 0 7.119200e-08
I11079 n1_m1_256000_336000 0 1.049280e-07
I11080 n1_m1_256000_340800 0 6.995199e-08
I11081 n1_m1_256000_345600 0 1.049280e-07
I11082 n1_m1_256000_350400 0 6.995199e-08
I11083 n1_m1_256000_355200 0 6.995199e-08
I11084 n1_m1_256000_360000 0 1.049280e-07
I11085 n1_m1_256000_364800 0 6.995199e-08
I11086 n1_m1_256000_369600 0 1.077635e-07
I11087 n1_m1_256000_374400 0 7.328303e-08
I11088 n1_m1_256000_379200 0 7.305191e-08
I11089 n1_m1_256000_384000 0 1.065419e-07
I11090 n1_m1_256000_388800 0 6.995199e-08
I11091 n1_m1_256000_393600 0 1.086558e-07
I11092 n1_m1_256000_398400 0 7.306280e-08
I11093 n1_m1_256000_403200 0 7.306280e-08
I11094 n1_m1_256000_408000 0 1.097666e-07
I11095 n1_m1_256000_412800 0 7.439661e-08
I11096 n1_m1_256000_417600 0 1.092015e-07
I11097 n1_m1_256000_422400 0 7.481700e-08
I11098 n1_m1_256000_427200 0 7.768744e-08
I11099 n1_m1_256000_432000 0 1.180453e-07
I11100 n1_m1_256000_436800 0 7.640027e-08
I11101 n1_m1_256000_441600 0 1.196235e-07
I11102 n1_m1_256000_446400 0 7.104619e-08
I11103 n1_m1_256000_451200 0 7.576107e-08
I11104 n1_m1_256000_456000 0 1.174155e-07
I11105 n1_m1_256000_460800 0 7.611855e-08
I11106 n1_m1_256000_465600 0 1.186451e-07
I11107 n1_m1_256000_470400 0 8.856180e-08
I11108 n1_m1_256000_475200 0 9.185361e-08
I11109 n1_m1_256000_480000 0 1.281331e-07
I11110 n1_m1_284000_0 0 1.796593e-07
I11111 n1_m1_284000_4800 0 1.976700e-07
I11112 n1_m1_284000_9600 0 2.521361e-07
I11113 n1_m1_284000_14400 0 1.453317e-07
I11114 n1_m1_284000_19200 0 1.415444e-07
I11115 n1_m1_284000_24000 0 2.026756e-07
I11116 n1_m1_284000_28800 0 1.454095e-07
I11117 n1_m1_284000_33600 0 2.209782e-07
I11118 n1_m1_284000_38400 0 1.628488e-07
I11119 n1_m1_284000_43200 0 1.496366e-07
I11120 n1_m1_284000_48000 0 2.175979e-07
I11121 n1_m1_284000_52800 0 1.466083e-07
I11122 n1_m1_284000_57600 0 2.276092e-07
I11123 n1_m1_284000_62400 0 1.460312e-07
I11124 n1_m1_284000_67200 0 1.411950e-07
I11125 n1_m1_284000_72000 0 2.127660e-07
I11126 n1_m1_284000_76800 0 1.434888e-07
I11127 n1_m1_284000_81600 0 2.168115e-07
I11128 n1_m1_284000_86400 0 1.495763e-07
I11129 n1_m1_284000_91200 0 1.459583e-07
I11130 n1_m1_284000_96000 0 2.133421e-07
I11131 n1_m1_284000_100800 0 1.421089e-07
I11132 n1_m1_284000_105600 0 2.162279e-07
I11133 n1_m1_284000_110400 0 1.400294e-07
I11134 n1_m1_284000_115200 0 1.601058e-07
I11135 n1_m1_284000_120000 0 2.655399e-07
I11136 n1_m1_284000_124800 0 2.617061e-07
I11137 n1_m1_284000_129600 0 3.121640e-07
I11138 n1_m1_284000_134400 0 1.696453e-07
I11139 n1_m1_284000_139200 0 1.604779e-07
I11140 n1_m1_284000_144000 0 2.231462e-07
I11141 n1_m1_284000_148800 0 1.485846e-07
I11142 n1_m1_284000_153600 0 2.263703e-07
I11143 n1_m1_284000_158400 0 1.715946e-07
I11144 n1_m1_284000_163200 0 1.737469e-07
I11145 n1_m1_284000_168000 0 2.440085e-07
I11146 n1_m1_284000_172800 0 1.838491e-07
I11147 n1_m1_284000_177600 0 6.848734e-07
I11148 n1_m1_284000_182400 0 7.062418e-07
I11149 n1_m1_284000_187200 0 1.107346e-06
I11150 n1_m1_284000_192000 0 1.567762e-06
I11151 n1_m1_284000_196800 0 8.368918e-07
I11152 n1_m1_284000_201600 0 4.585556e-07
I11153 n1_m1_284000_206400 0 4.660443e-07
I11154 n1_m1_284000_211200 0 6.780391e-07
I11155 n1_m1_284000_216000 0 1.030910e-06
I11156 n1_m1_284000_220800 0 6.546243e-07
I11157 n1_m1_284000_225600 0 1.278149e-06
I11158 n1_m1_284000_230400 0 1.145478e-06
I11159 n1_m1_284000_235200 0 1.249037e-06
I11160 n1_m1_284000_240000 0 1.226341e-06
I11161 n1_m1_284000_244800 0 5.166321e-07
I11162 n1_m1_284000_249600 0 9.930333e-07
I11163 n1_m1_284000_254400 0 1.229714e-06
I11164 n1_m1_284000_259200 0 1.005970e-06
I11165 n1_m1_284000_264000 0 1.265634e-06
I11166 n1_m1_284000_268800 0 4.816238e-07
I11167 n1_m1_284000_273600 0 8.648307e-07
I11168 n1_m1_284000_278400 0 5.316198e-07
I11169 n1_m1_284000_283200 0 8.144684e-07
I11170 n1_m1_284000_288000 0 8.437396e-07
I11171 n1_m1_284000_292800 0 5.070641e-07
I11172 n1_m1_284000_297600 0 6.145235e-07
I11173 n1_m1_284000_302400 0 8.375370e-07
I11174 n1_m1_284000_307200 0 6.561129e-07
I11175 n1_m1_284000_312000 0 6.919658e-07
I11176 n1_m1_284000_316800 0 3.238485e-07
I11177 n1_m1_284000_321600 0 4.719345e-07
I11178 n1_m1_284000_326400 0 3.544085e-07
I11179 n1_m1_284000_331200 0 4.477641e-07
I11180 n1_m1_284000_336000 0 3.101315e-07
I11181 n1_m1_284000_340800 0 1.755994e-07
I11182 n1_m1_284000_345600 0 3.477928e-07
I11183 n1_m1_284000_350400 0 2.276230e-07
I11184 n1_m1_284000_355200 0 1.556106e-07
I11185 n1_m1_284000_360000 0 2.369391e-07
I11186 n1_m1_284000_364800 0 1.477725e-07
I11187 n1_m1_284000_369600 0 2.061008e-07
I11188 n1_m1_284000_374400 0 1.399966e-07
I11189 n1_m1_284000_379200 0 1.431498e-07
I11190 n1_m1_284000_384000 0 2.272324e-07
I11191 n1_m1_284000_388800 0 1.569071e-07
I11192 n1_m1_284000_393600 0 2.402768e-07
I11193 n1_m1_284000_398400 0 1.702391e-07
I11194 n1_m1_284000_403200 0 1.662669e-07
I11195 n1_m1_284000_408000 0 2.326207e-07
I11196 n1_m1_284000_412800 0 1.577963e-07
I11197 n1_m1_284000_417600 0 2.328739e-07
I11198 n1_m1_284000_422400 0 1.605606e-07
I11199 n1_m1_284000_427200 0 2.454212e-07
I11200 n1_m1_284000_432000 0 3.852162e-07
I11201 n1_m1_284000_436800 0 3.951910e-07
I11202 n1_m1_284000_441600 0 4.520963e-07
I11203 n1_m1_284000_446400 0 2.578070e-07
I11204 n1_m1_284000_451200 0 1.668888e-07
I11205 n1_m1_284000_456000 0 2.440804e-07
I11206 n1_m1_284000_460800 0 1.521426e-07
I11207 n1_m1_284000_465600 0 2.335112e-07
I11208 n1_m1_284000_470400 0 1.797389e-07
I11209 n1_m1_284000_475200 0 1.855200e-07
I11210 n1_m1_284000_480000 0 2.440943e-07
I11211 n1_m1_340000_0 0 8.527080e-08
I11212 n1_m1_340000_4800 0 9.574101e-08
I11213 n1_m1_340000_9600 0 1.186876e-07
I11214 n1_m1_340000_14400 0 6.829084e-08
I11215 n1_m1_340000_19200 0 6.687277e-08
I11216 n1_m1_340000_24000 0 9.993141e-08
I11217 n1_m1_340000_28800 0 6.806623e-08
I11218 n1_m1_340000_33600 0 1.049280e-07
I11219 n1_m1_340000_38400 0 6.995199e-08
I11220 n1_m1_340000_43200 0 6.949682e-08
I11221 n1_m1_340000_48000 0 1.008346e-07
I11222 n1_m1_340000_52800 0 6.742461e-08
I11223 n1_m1_340000_57600 0 1.011314e-07
I11224 n1_m1_340000_62400 0 6.803870e-08
I11225 n1_m1_340000_67200 0 6.885394e-08
I11226 n1_m1_340000_72000 0 1.050012e-07
I11227 n1_m1_340000_76800 0 7.767552e-08
I11228 n1_m1_340000_81600 0 1.262009e-07
I11229 n1_m1_340000_86400 0 7.840849e-08
I11230 n1_m1_340000_91200 0 7.206893e-08
I11231 n1_m1_340000_96000 0 1.035378e-07
I11232 n1_m1_340000_100800 0 7.209114e-08
I11233 n1_m1_340000_105600 0 1.061127e-07
I11234 n1_m1_340000_110400 0 6.912517e-08
I11235 n1_m1_340000_115200 0 7.626308e-08
I11236 n1_m1_340000_120000 0 1.292436e-07
I11237 n1_m1_340000_124800 0 2.333144e-07
I11238 n1_m1_340000_129600 0 2.446086e-07
I11239 n1_m1_340000_134400 0 1.607775e-07
I11240 n1_m1_340000_139200 0 1.161681e-07
I11241 n1_m1_340000_144000 0 1.274814e-07
I11242 n1_m1_340000_148800 0 1.001864e-07
I11243 n1_m1_340000_153600 0 1.300285e-07
I11244 n1_m1_340000_158400 0 8.602441e-08
I11245 n1_m1_340000_163200 0 7.435324e-08
I11246 n1_m1_340000_168000 0 1.095276e-07
I11247 n1_m1_340000_172800 0 7.547600e-08
I11248 n1_m1_340000_177600 0 3.802612e-07
I11249 n1_m1_340000_182400 0 2.649240e-07
I11250 n1_m1_340000_187200 0 4.971797e-07
I11251 n1_m1_340000_192000 0 5.974981e-07
I11252 n1_m1_340000_196800 0 5.505985e-07
I11253 n1_m1_340000_201600 0 2.522639e-07
I11254 n1_m1_340000_206400 0 1.299158e-07
I11255 n1_m1_340000_211200 0 1.077210e-07
I11256 n1_m1_340000_216000 0 6.014871e-07
I11257 n1_m1_340000_220800 0 1.637678e-07
I11258 n1_m1_340000_225600 0 1.551734e-07
I11259 n1_m1_340000_230400 0 1.545668e-07
I11260 n1_m1_340000_235200 0 9.975216e-08
I11261 n1_m1_340000_240000 0 1.645928e-07
I11262 n1_m1_340000_244800 0 8.474899e-08
I11263 n1_m1_340000_249600 0 1.186639e-07
I11264 n1_m1_340000_254400 0 7.975962e-08
I11265 n1_m1_340000_259200 0 9.310445e-08
I11266 n1_m1_340000_264000 0 1.525991e-07
I11267 n1_m1_340000_268800 0 8.413866e-08
I11268 n1_m1_340000_273600 0 1.193515e-07
I11269 n1_m1_340000_278400 0 7.936263e-08
I11270 n1_m1_340000_283200 0 7.888525e-08
I11271 n1_m1_340000_288000 0 1.228148e-07
I11272 n1_m1_340000_292800 0 1.032152e-07
I11273 n1_m1_340000_297600 0 1.280445e-07
I11274 n1_m1_340000_302400 0 8.722788e-08
I11275 n1_m1_340000_307200 0 8.205800e-08
I11276 n1_m1_340000_312000 0 1.119329e-07
I11277 n1_m1_340000_316800 0 7.264798e-08
I11278 n1_m1_340000_321600 0 1.095610e-07
I11279 n1_m1_340000_326400 0 7.328303e-08
I11280 n1_m1_340000_331200 0 7.227821e-08
I11281 n1_m1_340000_336000 0 1.068801e-07
I11282 n1_m1_340000_340800 0 7.222316e-08
I11283 n1_m1_340000_345600 0 1.083347e-07
I11284 n1_m1_340000_350400 0 7.222316e-08
I11285 n1_m1_340000_355200 0 7.291076e-08
I11286 n1_m1_340000_360000 0 1.090918e-07
I11287 n1_m1_340000_364800 0 6.995199e-08
I11288 n1_m1_340000_369600 0 1.051689e-07
I11289 n1_m1_340000_374400 0 7.273933e-08
I11290 n1_m1_340000_379200 0 7.328303e-08
I11291 n1_m1_340000_384000 0 1.131887e-07
I11292 n1_m1_340000_388800 0 8.741934e-08
I11293 n1_m1_340000_393600 0 1.435338e-07
I11294 n1_m1_340000_398400 0 8.860247e-08
I11295 n1_m1_340000_403200 0 7.915241e-08
I11296 n1_m1_340000_408000 0 1.100275e-07
I11297 n1_m1_340000_412800 0 7.419619e-08
I11298 n1_m1_340000_417600 0 1.089923e-07
I11299 n1_m1_340000_422400 0 7.205798e-08
I11300 n1_m1_340000_427200 0 7.255163e-08
I11301 n1_m1_340000_432000 0 1.055145e-07
I11302 n1_m1_340000_436800 0 6.995199e-08
I11303 n1_m1_340000_441600 0 1.051391e-07
I11304 n1_m1_340000_446400 0 7.202857e-08
I11305 n1_m1_340000_451200 0 7.282004e-08
I11306 n1_m1_340000_456000 0 1.081273e-07
I11307 n1_m1_340000_460800 0 7.245716e-08
I11308 n1_m1_340000_465600 0 1.105070e-07
I11309 n1_m1_340000_470400 0 8.317982e-08
I11310 n1_m1_340000_475200 0 8.597968e-08
I11311 n1_m1_340000_480000 0 1.166761e-07
I11312 n1_m1_368000_0 0 7.222930e-08
I11313 n1_m1_368000_4800 0 7.743641e-08
I11314 n1_m1_368000_9600 0 1.058018e-07
I11315 n1_m1_368000_14400 0 6.884587e-08
I11316 n1_m1_368000_19200 0 6.958122e-08
I11317 n1_m1_368000_24000 0 1.018188e-07
I11318 n1_m1_368000_28800 0 6.995199e-08
I11319 n1_m1_368000_33600 0 1.049280e-07
I11320 n1_m1_368000_38400 0 6.995199e-08
I11321 n1_m1_368000_43200 0 6.989406e-08
I11322 n1_m1_368000_48000 0 1.023048e-07
I11323 n1_m1_368000_52800 0 6.662094e-08
I11324 n1_m1_368000_57600 0 1.000377e-07
I11325 n1_m1_368000_62400 0 7.079419e-08
I11326 n1_m1_368000_67200 0 7.148407e-08
I11327 n1_m1_368000_72000 0 1.012990e-07
I11328 n1_m1_368000_76800 0 7.219469e-08
I11329 n1_m1_368000_81600 0 1.163453e-07
I11330 n1_m1_368000_86400 0 7.607126e-08
I11331 n1_m1_368000_91200 0 7.045363e-08
I11332 n1_m1_368000_96000 0 1.020686e-07
I11333 n1_m1_368000_100800 0 6.852075e-08
I11334 n1_m1_368000_105600 0 1.005223e-07
I11335 n1_m1_368000_110400 0 6.928366e-08
I11336 n1_m1_368000_115200 0 6.757832e-08
I11337 n1_m1_368000_120000 0 1.118740e-07
I11338 n1_m1_368000_124800 0 7.597838e-08
I11339 n1_m1_368000_129600 0 1.187772e-07
I11340 n1_m1_368000_134400 0 7.653337e-08
I11341 n1_m1_368000_139200 0 8.284805e-08
I11342 n1_m1_368000_144000 0 1.271583e-07
I11343 n1_m1_368000_148800 0 7.392397e-08
I11344 n1_m1_368000_153600 0 1.170279e-07
I11345 n1_m1_368000_158400 0 7.282249e-08
I11346 n1_m1_368000_163200 0 7.040622e-08
I11347 n1_m1_368000_168000 0 1.108830e-07
I11348 n1_m1_368000_172800 0 7.181232e-08
I11349 n1_m1_368000_177600 0 1.246397e-07
I11350 n1_m1_368000_182400 0 9.432903e-08
I11351 n1_m1_368000_187200 0 1.399794e-07
I11352 n1_m1_368000_192000 0 3.282591e-07
I11353 n1_m1_368000_196800 0 4.079584e-07
I11354 n1_m1_368000_201600 0 7.419622e-07
I11355 n1_m1_368000_206400 0 1.486423e-07
I11356 n1_m1_368000_211200 0 8.281119e-08
I11357 n1_m1_368000_216000 0 1.307630e-07
I11358 n1_m1_368000_220800 0 1.195863e-07
I11359 n1_m1_368000_225600 0 1.856364e-07
I11360 n1_m1_368000_230400 0 2.445429e-07
I11361 n1_m1_368000_235200 0 4.634081e-07
I11362 n1_m1_368000_240000 0 8.600409e-07
I11363 n1_m1_368000_244800 0 6.330623e-07
I11364 n1_m1_368000_249600 0 8.341516e-07
I11365 n1_m1_368000_254400 0 3.534366e-07
I11366 n1_m1_368000_259200 0 2.013294e-07
I11367 n1_m1_368000_264000 0 3.253110e-07
I11368 n1_m1_368000_268800 0 1.282935e-07
I11369 n1_m1_368000_273600 0 1.447226e-07
I11370 n1_m1_368000_278400 0 1.492089e-07
I11371 n1_m1_368000_283200 0 1.235825e-07
I11372 n1_m1_368000_288000 0 1.518162e-07
I11373 n1_m1_368000_292800 0 1.866431e-07
I11374 n1_m1_368000_297600 0 2.665159e-07
I11375 n1_m1_368000_302400 0 1.083229e-07
I11376 n1_m1_368000_307200 0 8.232275e-08
I11377 n1_m1_368000_312000 0 1.162445e-07
I11378 n1_m1_368000_316800 0 7.901488e-08
I11379 n1_m1_368000_321600 0 1.240011e-07
I11380 n1_m1_368000_326400 0 8.465637e-08
I11381 n1_m1_368000_331200 0 8.751558e-08
I11382 n1_m1_368000_336000 0 1.422079e-07
I11383 n1_m1_368000_340800 0 9.498347e-08
I11384 n1_m1_368000_345600 0 1.215851e-07
I11385 n1_m1_368000_350400 0 7.340129e-08
I11386 n1_m1_368000_355200 0 7.328303e-08
I11387 n1_m1_368000_360000 0 1.099968e-07
I11388 n1_m1_368000_364800 0 7.357209e-08
I11389 n1_m1_368000_369600 0 1.101121e-07
I11390 n1_m1_368000_374400 0 7.328303e-08
I11391 n1_m1_368000_379200 0 7.324541e-08
I11392 n1_m1_368000_384000 0 1.096898e-07
I11393 n1_m1_368000_388800 0 7.523142e-08
I11394 n1_m1_368000_393600 0 1.249849e-07
I11395 n1_m1_368000_398400 0 8.250348e-08
I11396 n1_m1_368000_403200 0 8.259824e-08
I11397 n1_m1_368000_408000 0 1.283081e-07
I11398 n1_m1_368000_412800 0 7.600491e-08
I11399 n1_m1_368000_417600 0 1.157634e-07
I11400 n1_m1_368000_422400 0 7.917345e-08
I11401 n1_m1_368000_427200 0 7.801899e-08
I11402 n1_m1_368000_432000 0 1.294466e-07
I11403 n1_m1_368000_436800 0 9.825610e-08
I11404 n1_m1_368000_441600 0 1.115124e-07
I11405 n1_m1_368000_446400 0 7.084365e-08
I11406 n1_m1_368000_451200 0 7.008338e-08
I11407 n1_m1_368000_456000 0 1.068261e-07
I11408 n1_m1_368000_460800 0 7.319106e-08
I11409 n1_m1_368000_465600 0 1.108193e-07
I11410 n1_m1_368000_470400 0 7.779585e-08
I11411 n1_m1_368000_475200 0 7.895407e-08
I11412 n1_m1_368000_480000 0 1.148781e-07
I11413 n1_m1_396000_0 0 7.974514e-08
I11414 n1_m1_396000_4800 0 8.609694e-08
I11415 n1_m1_396000_9600 0 1.149852e-07
I11416 n1_m1_396000_14400 0 7.119030e-08
I11417 n1_m1_396000_19200 0 7.026479e-08
I11418 n1_m1_396000_24000 0 1.018791e-07
I11419 n1_m1_396000_28800 0 6.850670e-08
I11420 n1_m1_396000_33600 0 1.016105e-07
I11421 n1_m1_396000_38400 0 6.802366e-08
I11422 n1_m1_396000_43200 0 6.672938e-08
I11423 n1_m1_396000_48000 0 9.993141e-08
I11424 n1_m1_396000_52800 0 6.662094e-08
I11425 n1_m1_396000_57600 0 9.993141e-08
I11426 n1_m1_396000_62400 0 6.662094e-08
I11427 n1_m1_396000_67200 0 6.662094e-08
I11428 n1_m1_396000_72000 0 1.022519e-07
I11429 n1_m1_396000_76800 0 7.305788e-08
I11430 n1_m1_396000_81600 0 1.220536e-07
I11431 n1_m1_396000_86400 0 8.075724e-08
I11432 n1_m1_396000_91200 0 7.723349e-08
I11433 n1_m1_396000_96000 0 1.099268e-07
I11434 n1_m1_396000_100800 0 7.164504e-08
I11435 n1_m1_396000_105600 0 1.077349e-07
I11436 n1_m1_396000_110400 0 7.381522e-08
I11437 n1_m1_396000_115200 0 7.799504e-08
I11438 n1_m1_396000_120000 0 1.484741e-07
I11439 n1_m1_396000_124800 0 2.176226e-07
I11440 n1_m1_396000_129600 0 4.037613e-07
I11441 n1_m1_396000_134400 0 3.872502e-07
I11442 n1_m1_396000_139200 0 2.589808e-07
I11443 n1_m1_396000_144000 0 2.158652e-07
I11444 n1_m1_396000_148800 0 7.821798e-08
I11445 n1_m1_396000_153600 0 1.124387e-07
I11446 n1_m1_396000_158400 0 7.171150e-08
I11447 n1_m1_396000_163200 0 7.289034e-08
I11448 n1_m1_396000_168000 0 1.092788e-07
I11449 n1_m1_396000_172800 0 8.535646e-08
I11450 n1_m1_396000_177600 0 2.560744e-07
I11451 n1_m1_396000_182400 0 1.593346e-07
I11452 n1_m1_396000_187200 0 2.919923e-07
I11453 n1_m1_396000_192000 0 3.099581e-07
I11454 n1_m1_396000_196800 0 8.982272e-08
I11455 n1_m1_396000_201600 0 1.659862e-07
I11456 n1_m1_396000_206400 0 7.903046e-08
I11457 n1_m1_396000_211200 0 7.757255e-08
I11458 n1_m1_396000_216000 0 1.200588e-07
I11459 n1_m1_396000_220800 0 8.204802e-08
I11460 n1_m1_396000_225600 0 1.201242e-07
I11461 n1_m1_396000_230400 0 8.428788e-08
I11462 n1_m1_396000_235200 0 8.467329e-08
I11463 n1_m1_396000_240000 0 1.220719e-07
I11464 n1_m1_396000_244800 0 1.045385e-07
I11465 n1_m1_396000_249600 0 1.373007e-07
I11466 n1_m1_396000_254400 0 8.152098e-08
I11467 n1_m1_396000_259200 0 8.296786e-08
I11468 n1_m1_396000_264000 0 1.432101e-07
I11469 n1_m1_396000_268800 0 1.813165e-07
I11470 n1_m1_396000_273600 0 1.429554e-07
I11471 n1_m1_396000_278400 0 7.901465e-08
I11472 n1_m1_396000_283200 0 7.725710e-08
I11473 n1_m1_396000_288000 0 1.168299e-07
I11474 n1_m1_396000_292800 0 7.868933e-08
I11475 n1_m1_396000_297600 0 1.197485e-07
I11476 n1_m1_396000_302400 0 7.726267e-08
I11477 n1_m1_396000_307200 0 7.658212e-08
I11478 n1_m1_396000_312000 0 1.790385e-07
I11479 n1_m1_396000_316800 0 1.231140e-07
I11480 n1_m1_396000_321600 0 1.314144e-07
I11481 n1_m1_396000_326400 0 9.358480e-08
I11482 n1_m1_396000_331200 0 1.148248e-07
I11483 n1_m1_396000_336000 0 3.678700e-07
I11484 n1_m1_396000_340800 0 1.726870e-07
I11485 n1_m1_396000_345600 0 1.376739e-07
I11486 n1_m1_396000_350400 0 8.035244e-08
I11487 n1_m1_396000_355200 0 1.013539e-07
I11488 n1_m1_396000_360000 0 1.321167e-07
I11489 n1_m1_396000_364800 0 7.707850e-08
I11490 n1_m1_396000_369600 0 1.647669e-07
I11491 n1_m1_396000_374400 0 1.056681e-07
I11492 n1_m1_396000_379200 0 9.693603e-08
I11493 n1_m1_396000_384000 0 1.246220e-07
I11494 n1_m1_396000_388800 0 8.454855e-08
I11495 n1_m1_396000_393600 0 1.265959e-07
I11496 n1_m1_396000_398400 0 8.911432e-08
I11497 n1_m1_396000_403200 0 8.503037e-08
I11498 n1_m1_396000_408000 0 1.286454e-07
I11499 n1_m1_396000_412800 0 8.861800e-08
I11500 n1_m1_396000_417600 0 1.242560e-07
I11501 n1_m1_396000_422400 0 8.327618e-08
I11502 n1_m1_396000_427200 0 8.436853e-08
I11503 n1_m1_396000_432000 0 1.283473e-07
I11504 n1_m1_396000_436800 0 8.265466e-08
I11505 n1_m1_396000_441600 0 1.208819e-07
I11506 n1_m1_396000_446400 0 7.854293e-08
I11507 n1_m1_396000_451200 0 7.746837e-08
I11508 n1_m1_396000_456000 0 1.092844e-07
I11509 n1_m1_396000_460800 0 7.158998e-08
I11510 n1_m1_396000_465600 0 1.108297e-07
I11511 n1_m1_396000_470400 0 7.939454e-08
I11512 n1_m1_396000_475200 0 8.035807e-08
I11513 n1_m1_396000_480000 0 1.133189e-07
I11514 n1_m1_424000_0 0 6.689396e-08
I11515 n1_m1_424000_4800 0 6.744071e-08
I11516 n1_m1_424000_9600 0 1.002570e-07
I11517 n1_m1_424000_14400 0 6.662094e-08
I11518 n1_m1_424000_19200 0 6.687405e-08
I11519 n1_m1_424000_24000 0 1.002620e-07
I11520 n1_m1_424000_28800 0 6.715987e-08
I11521 n1_m1_424000_33600 0 1.001063e-07
I11522 n1_m1_424000_38400 0 6.667995e-08
I11523 n1_m1_424000_43200 0 6.694302e-08
I11524 n1_m1_424000_48000 0 1.004476e-07
I11525 n1_m1_424000_52800 0 6.697288e-08
I11526 n1_m1_424000_57600 0 1.006374e-07
I11527 n1_m1_424000_62400 0 6.676740e-08
I11528 n1_m1_424000_67200 0 6.696506e-08
I11529 n1_m1_424000_72000 0 1.001468e-07
I11530 n1_m1_424000_76800 0 6.694159e-08
I11531 n1_m1_424000_81600 0 1.002016e-07
I11532 n1_m1_424000_86400 0 6.662094e-08
I11533 n1_m1_424000_91200 0 6.662094e-08
I11534 n1_m1_424000_96000 0 9.993141e-08
I11535 n1_m1_424000_100800 0 6.662094e-08
I11536 n1_m1_424000_105600 0 9.998758e-08
I11537 n1_m1_424000_110400 0 6.700629e-08
I11538 n1_m1_424000_115200 0 6.729424e-08
I11539 n1_m1_424000_120000 0 1.031608e-07
I11540 n1_m1_424000_124800 0 6.811404e-08
I11541 n1_m1_424000_129600 0 1.050387e-07
I11542 n1_m1_424000_134400 0 6.995199e-08
I11543 n1_m1_424000_139200 0 7.188069e-08
I11544 n1_m1_424000_144000 0 1.096956e-07
I11545 n1_m1_424000_148800 0 7.293892e-08
I11546 n1_m1_424000_153600 0 1.096722e-07
I11547 n1_m1_424000_158400 0 7.368551e-08
I11548 n1_m1_424000_163200 0 7.147423e-08
I11549 n1_m1_424000_168000 0 1.094823e-07
I11550 n1_m1_424000_172800 0 7.328303e-08
I11551 n1_m1_424000_177600 0 1.099246e-07
I11552 n1_m1_424000_182400 0 7.428484e-08
I11553 n1_m1_424000_187200 0 7.827287e-08
I11554 n1_m1_424000_192000 0 1.196930e-07
I11555 n1_m1_424000_196800 0 8.023800e-08
I11556 n1_m1_424000_201600 0 1.171107e-07
I11557 n1_m1_424000_206400 0 8.128838e-08
I11558 n1_m1_424000_211200 0 8.089699e-08
I11559 n1_m1_424000_216000 0 1.204834e-07
I11560 n1_m1_424000_220800 0 8.460611e-08
I11561 n1_m1_424000_225600 0 1.337006e-07
I11562 n1_m1_424000_230400 0 8.459286e-08
I11563 n1_m1_424000_235200 0 8.136215e-08
I11564 n1_m1_424000_240000 0 1.277360e-07
I11565 n1_m1_424000_244800 0 8.304144e-08
I11566 n1_m1_424000_249600 0 1.176998e-07
I11567 n1_m1_424000_254400 0 8.790795e-08
I11568 n1_m1_424000_259200 0 8.644916e-08
I11569 n1_m1_424000_264000 0 1.324992e-07
I11570 n1_m1_424000_268800 0 8.826908e-08
I11571 n1_m1_424000_273600 0 1.618621e-07
I11572 n1_m1_424000_278400 0 9.178029e-08
I11573 n1_m1_424000_283200 0 9.394026e-08
I11574 n1_m1_424000_288000 0 1.248032e-07
I11575 n1_m1_424000_292800 0 8.477212e-08
I11576 n1_m1_424000_297600 0 1.277802e-07
I11577 n1_m1_424000_302400 0 8.390756e-08
I11578 n1_m1_424000_307200 0 9.089031e-08
I11579 n1_m1_424000_312000 0 1.447656e-07
I11580 n1_m1_424000_316800 0 1.566607e-07
I11581 n1_m1_424000_321600 0 1.756208e-07
I11582 n1_m1_424000_326400 0 1.932207e-07
I11583 n1_m1_424000_331200 0 3.880463e-07
I11584 n1_m1_424000_336000 0 1.384732e-07
I11585 n1_m1_424000_340800 0 1.193956e-07
I11586 n1_m1_424000_345600 0 3.776675e-07
I11587 n1_m1_424000_350400 0 1.173631e-07
I11588 n1_m1_424000_355200 0 8.137535e-08
I11589 n1_m1_424000_360000 0 1.285459e-07
I11590 n1_m1_424000_364800 0 7.966074e-08
I11591 n1_m1_424000_369600 0 1.204366e-07
I11592 n1_m1_424000_374400 0 8.443289e-08
I11593 n1_m1_424000_379200 0 9.272138e-08
I11594 n1_m1_424000_384000 0 1.579582e-07
I11595 n1_m1_424000_388800 0 9.431304e-08
I11596 n1_m1_424000_393600 0 2.227876e-07
I11597 n1_m1_424000_398400 0 1.125688e-07
I11598 n1_m1_424000_403200 0 8.213166e-08
I11599 n1_m1_424000_408000 0 1.159535e-07
I11600 n1_m1_424000_412800 0 7.805522e-08
I11601 n1_m1_424000_417600 0 1.263710e-07
I11602 n1_m1_424000_422400 0 9.094576e-08
I11603 n1_m1_424000_427200 0 8.573681e-08
I11604 n1_m1_424000_432000 0 2.184306e-07
I11605 n1_m1_424000_436800 0 1.969834e-07
I11606 n1_m1_424000_441600 0 1.254252e-07
I11607 n1_m1_424000_446400 0 7.885459e-08
I11608 n1_m1_424000_451200 0 7.884549e-08
I11609 n1_m1_424000_456000 0 1.146580e-07
I11610 n1_m1_424000_460800 0 7.423342e-08
I11611 n1_m1_424000_465600 0 1.101094e-07
I11612 n1_m1_424000_470400 0 7.700882e-08
I11613 n1_m1_424000_475200 0 8.199606e-08
I11614 n1_m1_424000_480000 0 1.144256e-07
I11615 n1_m1_452000_0 0 1.332419e-07
I11616 n1_m1_452000_4800 0 1.332419e-07
I11617 n1_m1_452000_9600 0 1.998628e-07
I11618 n1_m1_452000_14400 0 1.332419e-07
I11619 n1_m1_452000_19200 0 1.332419e-07
I11620 n1_m1_452000_24000 0 1.998628e-07
I11621 n1_m1_452000_28800 0 1.332419e-07
I11622 n1_m1_452000_33600 0 1.998628e-07
I11623 n1_m1_452000_38400 0 1.338886e-07
I11624 n1_m1_452000_43200 0 1.367718e-07
I11625 n1_m1_452000_48000 0 2.027928e-07
I11626 n1_m1_452000_52800 0 1.333276e-07
I11627 n1_m1_452000_57600 0 2.043935e-07
I11628 n1_m1_452000_62400 0 1.377377e-07
I11629 n1_m1_452000_67200 0 1.399040e-07
I11630 n1_m1_452000_72000 0 2.092248e-07
I11631 n1_m1_452000_76800 0 1.363896e-07
I11632 n1_m1_452000_81600 0 2.041987e-07
I11633 n1_m1_452000_86400 0 1.389065e-07
I11634 n1_m1_452000_91200 0 1.371299e-07
I11635 n1_m1_452000_96000 0 2.107209e-07
I11636 n1_m1_452000_100800 0 1.400910e-07
I11637 n1_m1_452000_105600 0 2.087105e-07
I11638 n1_m1_452000_110400 0 1.434028e-07
I11639 n1_m1_452000_115200 0 1.428417e-07
I11640 n1_m1_452000_120000 0 2.126846e-07
I11641 n1_m1_452000_124800 0 1.407378e-07
I11642 n1_m1_452000_129600 0 2.098560e-07
I11643 n1_m1_452000_134400 0 1.399040e-07
I11644 n1_m1_452000_139200 0 1.418832e-07
I11645 n1_m1_452000_144000 0 2.153476e-07
I11646 n1_m1_452000_148800 0 1.428364e-07
I11647 n1_m1_452000_153600 0 2.252882e-07
I11648 n1_m1_452000_158400 0 1.463401e-07
I11649 n1_m1_452000_163200 0 1.465972e-07
I11650 n1_m1_452000_168000 0 2.297376e-07
I11651 n1_m1_452000_172800 0 1.563066e-07
I11652 n1_m1_452000_177600 0 2.291003e-07
I11653 n1_m1_452000_182400 0 1.551044e-07
I11654 n1_m1_452000_187200 0 1.650351e-07
I11655 n1_m1_452000_192000 0 2.677884e-07
I11656 n1_m1_452000_196800 0 1.818055e-07
I11657 n1_m1_452000_201600 0 2.300059e-07
I11658 n1_m1_452000_206400 0 1.566766e-07
I11659 n1_m1_452000_211200 0 1.539836e-07
I11660 n1_m1_452000_216000 0 2.819602e-07
I11661 n1_m1_452000_220800 0 1.611564e-07
I11662 n1_m1_452000_225600 0 2.436667e-07
I11663 n1_m1_452000_230400 0 1.723058e-07
I11664 n1_m1_452000_235200 0 2.172962e-07
I11665 n1_m1_452000_240000 0 7.001752e-07
I11666 n1_m1_452000_244800 0 2.649935e-07
I11667 n1_m1_452000_249600 0 3.289645e-07
I11668 n1_m1_452000_254400 0 2.420248e-07
I11669 n1_m1_452000_259200 0 4.674970e-07
I11670 n1_m1_452000_264000 0 1.406126e-06
I11671 n1_m1_452000_268800 0 6.234843e-07
I11672 n1_m1_452000_273600 0 1.218873e-06
I11673 n1_m1_452000_278400 0 5.196171e-07
I11674 n1_m1_452000_283200 0 2.301993e-07
I11675 n1_m1_452000_288000 0 2.622655e-07
I11676 n1_m1_452000_292800 0 1.691063e-07
I11677 n1_m1_452000_297600 0 2.594241e-07
I11678 n1_m1_452000_302400 0 1.715336e-07
I11679 n1_m1_452000_307200 0 2.533931e-07
I11680 n1_m1_452000_312000 0 3.039549e-07
I11681 n1_m1_452000_316800 0 2.355969e-07
I11682 n1_m1_452000_321600 0 6.933507e-07
I11683 n1_m1_452000_326400 0 2.697238e-07
I11684 n1_m1_452000_331200 0 2.098122e-07
I11685 n1_m1_452000_336000 0 3.230977e-07
I11686 n1_m1_452000_340800 0 1.789423e-07
I11687 n1_m1_452000_345600 0 3.010720e-07
I11688 n1_m1_452000_350400 0 5.082913e-07
I11689 n1_m1_452000_355200 0 5.005489e-07
I11690 n1_m1_452000_360000 0 3.152493e-07
I11691 n1_m1_452000_364800 0 1.860407e-07
I11692 n1_m1_452000_369600 0 2.993997e-07
I11693 n1_m1_452000_374400 0 2.205178e-07
I11694 n1_m1_452000_379200 0 1.803523e-07
I11695 n1_m1_452000_384000 0 2.489503e-07
I11696 n1_m1_452000_388800 0 1.679082e-07
I11697 n1_m1_452000_393600 0 2.357161e-07
I11698 n1_m1_452000_398400 0 1.624195e-07
I11699 n1_m1_452000_403200 0 1.639653e-07
I11700 n1_m1_452000_408000 0 2.398934e-07
I11701 n1_m1_452000_412800 0 1.758418e-07
I11702 n1_m1_452000_417600 0 3.327357e-07
I11703 n1_m1_452000_422400 0 2.275532e-07
I11704 n1_m1_452000_427200 0 2.966207e-07
I11705 n1_m1_452000_432000 0 3.320270e-07
I11706 n1_m1_452000_436800 0 1.589347e-07
I11707 n1_m1_452000_441600 0 2.445393e-07
I11708 n1_m1_452000_446400 0 1.516427e-07
I11709 n1_m1_452000_451200 0 1.515992e-07
I11710 n1_m1_452000_456000 0 2.455433e-07
I11711 n1_m1_452000_460800 0 1.605284e-07
I11712 n1_m1_452000_465600 0 2.294980e-07
I11713 n1_m1_452000_470400 0 1.503376e-07
I11714 n1_m1_452000_475200 0 1.488882e-07
I11715 n1_m1_452000_480000 0 2.167399e-07
.op
.end
