R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_470400_0 n1_m1_475200_0 5.356235
R114 n1_m1_475200_0 n1_m1_480000_0 5.356235
R115 n1_m1_480000_0 n1_m1_484800_0 5.356235
R116 n1_m1_484800_0 n1_m1_489600_0 5.356235
R117 n1_m1_489600_0 n1_m1_494400_0 5.356235
R118 n1_m1_494400_0 n1_m1_499200_0 5.356235
R119 n1_m1_499200_0 n1_m1_504000_0 5.356235
R120 n1_m1_504000_0 n1_m1_508000_0 4.463529
R121 n1_m1_508800_0 n1_m1_508000_0 0.892706
R122 n1_m1_508800_0 n1_m1_513600_0 5.356235
R123 n1_m1_513600_0 n1_m1_518400_0 5.356235
R124 n1_m1_518400_0 n1_m1_523200_0 5.356235
R125 n1_m1_523200_0 n1_m1_528000_0 5.356235
R126 n1_m1_528000_0 n1_m1_532800_0 5.356235
R127 n1_m1_532800_0 n1_m1_536000_0 3.570824
R128 n1_m1_537600_0 n1_m1_536000_0 1.785412
R129 n1_m1_537600_0 n1_m1_542400_0 5.356235
R130 n1_m1_542400_0 n1_m1_547200_0 5.356235
R131 n1_m1_547200_0 n1_m1_552000_0 5.356235
R132 n1_m1_552000_0 n1_m1_556800_0 5.356235
R133 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R134 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R135 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R136 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R137 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R138 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R139 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R140 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R141 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R142 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R143 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R144 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R145 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R146 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R147 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R148 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R149 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R150 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R151 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R152 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R153 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R154 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R155 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R156 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R157 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R158 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R159 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R160 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R161 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R162 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R163 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R164 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R165 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R166 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R167 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R168 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R169 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R170 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R171 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R172 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R173 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R174 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R175 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R176 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R177 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R178 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R179 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R180 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R181 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R182 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R183 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R184 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R185 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R186 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R187 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R188 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R189 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R190 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R191 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R192 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R193 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R194 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R195 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R196 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R197 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R198 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R199 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R200 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R201 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R202 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R203 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R204 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R205 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R206 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R207 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R208 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R209 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R210 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R211 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R212 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R213 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R214 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R215 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R216 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R217 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R218 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R219 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R220 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R221 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R222 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R223 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R224 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R225 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R226 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R227 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R228 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R229 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R230 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R231 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R232 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R233 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R234 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R235 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R236 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R237 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R238 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R239 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R240 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R241 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R242 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R243 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R244 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R245 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R246 n1_m1_470400_4800 n1_m1_475200_4800 5.356235
R247 n1_m1_475200_4800 n1_m1_480000_4800 5.356235
R248 n1_m1_480000_4800 n1_m1_484800_4800 5.356235
R249 n1_m1_484800_4800 n1_m1_489600_4800 5.356235
R250 n1_m1_489600_4800 n1_m1_494400_4800 5.356235
R251 n1_m1_494400_4800 n1_m1_499200_4800 5.356235
R252 n1_m1_499200_4800 n1_m1_504000_4800 5.356235
R253 n1_m1_504000_4800 n1_m1_508000_4800 4.463529
R254 n1_m1_508800_4800 n1_m1_508000_4800 0.892706
R255 n1_m1_508800_4800 n1_m1_513600_4800 5.356235
R256 n1_m1_513600_4800 n1_m1_518400_4800 5.356235
R257 n1_m1_518400_4800 n1_m1_523200_4800 5.356235
R258 n1_m1_523200_4800 n1_m1_528000_4800 5.356235
R259 n1_m1_528000_4800 n1_m1_532800_4800 5.356235
R260 n1_m1_532800_4800 n1_m1_536000_4800 3.570824
R261 n1_m1_537600_4800 n1_m1_536000_4800 1.785412
R262 n1_m1_537600_4800 n1_m1_542400_4800 5.356235
R263 n1_m1_542400_4800 n1_m1_547200_4800 5.356235
R264 n1_m1_547200_4800 n1_m1_552000_4800 5.356235
R265 n1_m1_552000_4800 n1_m1_556800_4800 5.356235
R266 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R267 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R268 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R269 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R270 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R271 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R272 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R273 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R274 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R275 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R276 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R277 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R278 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R279 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R280 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R281 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R282 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R283 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R284 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R285 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R286 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R287 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R288 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R289 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R290 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R291 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R292 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R293 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R294 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R295 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R296 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R297 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R298 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R299 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R300 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R301 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R302 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R303 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R304 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R305 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R306 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R307 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R308 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R309 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R310 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R311 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R312 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R313 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R314 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R315 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R316 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R317 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R318 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R319 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R320 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R321 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R322 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R323 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R324 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R325 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R326 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R327 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R328 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R329 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R330 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R331 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R332 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R333 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R334 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R335 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R336 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R337 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R338 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R339 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R340 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R341 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R342 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R343 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R344 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R345 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R346 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R347 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R348 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R349 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R350 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R351 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R352 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R353 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R354 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R355 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R356 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R357 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R358 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R359 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R360 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R361 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R362 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R363 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R364 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R365 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R366 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R367 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R368 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R369 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R370 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R371 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R372 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R373 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R374 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R375 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R376 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R377 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R378 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R379 n1_m1_470400_9600 n1_m1_475200_9600 5.356235
R380 n1_m1_475200_9600 n1_m1_480000_9600 5.356235
R381 n1_m1_480000_9600 n1_m1_484800_9600 5.356235
R382 n1_m1_484800_9600 n1_m1_489600_9600 5.356235
R383 n1_m1_489600_9600 n1_m1_494400_9600 5.356235
R384 n1_m1_494400_9600 n1_m1_499200_9600 5.356235
R385 n1_m1_499200_9600 n1_m1_504000_9600 5.356235
R386 n1_m1_504000_9600 n1_m1_508000_9600 4.463529
R387 n1_m1_508800_9600 n1_m1_508000_9600 0.892706
R388 n1_m1_508800_9600 n1_m1_513600_9600 5.356235
R389 n1_m1_513600_9600 n1_m1_518400_9600 5.356235
R390 n1_m1_518400_9600 n1_m1_523200_9600 5.356235
R391 n1_m1_523200_9600 n1_m1_528000_9600 5.356235
R392 n1_m1_528000_9600 n1_m1_532800_9600 5.356235
R393 n1_m1_532800_9600 n1_m1_536000_9600 3.570824
R394 n1_m1_537600_9600 n1_m1_536000_9600 1.785412
R395 n1_m1_537600_9600 n1_m1_542400_9600 5.356235
R396 n1_m1_542400_9600 n1_m1_547200_9600 5.356235
R397 n1_m1_547200_9600 n1_m1_552000_9600 5.356235
R398 n1_m1_552000_9600 n1_m1_556800_9600 5.356235
R399 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R400 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R401 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R402 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R403 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R404 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R405 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R406 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R407 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R408 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R409 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R410 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R411 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R412 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R413 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R414 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R415 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R416 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R417 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R418 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R419 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R420 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R421 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R422 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R423 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R424 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R425 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R426 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R427 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R428 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R429 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R430 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R431 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R432 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R433 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R434 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R435 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R436 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R437 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R438 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R439 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R440 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R441 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R442 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R443 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R444 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R445 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R446 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R447 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R448 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R449 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R450 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R451 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R452 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R453 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R454 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R455 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R456 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R457 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R458 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R459 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R460 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R461 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R462 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R463 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R464 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R465 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R466 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R467 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R468 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R469 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R470 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R471 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R472 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R473 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R474 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R475 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R476 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R477 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R478 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R479 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R480 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R481 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R482 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R483 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R484 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R485 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R486 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R487 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R488 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R489 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R490 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R491 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R492 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R493 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R494 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R495 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R496 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R497 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R498 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R499 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R500 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R501 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R502 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R503 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R504 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R505 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R506 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R507 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R508 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R509 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R510 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R511 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R512 n1_m1_470400_14400 n1_m1_475200_14400 5.356235
R513 n1_m1_475200_14400 n1_m1_480000_14400 5.356235
R514 n1_m1_480000_14400 n1_m1_484800_14400 5.356235
R515 n1_m1_484800_14400 n1_m1_489600_14400 5.356235
R516 n1_m1_489600_14400 n1_m1_494400_14400 5.356235
R517 n1_m1_494400_14400 n1_m1_499200_14400 5.356235
R518 n1_m1_499200_14400 n1_m1_504000_14400 5.356235
R519 n1_m1_504000_14400 n1_m1_508000_14400 4.463529
R520 n1_m1_508800_14400 n1_m1_508000_14400 0.892706
R521 n1_m1_508800_14400 n1_m1_513600_14400 5.356235
R522 n1_m1_513600_14400 n1_m1_518400_14400 5.356235
R523 n1_m1_518400_14400 n1_m1_523200_14400 5.356235
R524 n1_m1_523200_14400 n1_m1_528000_14400 5.356235
R525 n1_m1_528000_14400 n1_m1_532800_14400 5.356235
R526 n1_m1_532800_14400 n1_m1_536000_14400 3.570824
R527 n1_m1_537600_14400 n1_m1_536000_14400 1.785412
R528 n1_m1_537600_14400 n1_m1_542400_14400 5.356235
R529 n1_m1_542400_14400 n1_m1_547200_14400 5.356235
R530 n1_m1_547200_14400 n1_m1_552000_14400 5.356235
R531 n1_m1_552000_14400 n1_m1_556800_14400 5.356235
R532 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R533 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R534 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R535 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R536 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R537 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R538 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R539 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R540 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R541 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R542 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R543 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R544 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R545 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R546 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R547 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R548 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R549 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R550 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R551 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R552 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R553 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R554 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R555 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R556 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R557 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R558 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R559 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R560 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R561 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R562 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R563 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R564 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R565 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R566 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R567 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R568 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R569 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R570 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R571 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R572 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R573 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R574 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R575 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R576 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R577 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R578 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R579 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R580 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R581 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R582 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R583 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R584 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R585 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R586 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R587 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R588 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R589 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R590 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R591 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R592 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R593 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R594 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R595 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R596 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R597 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R598 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R599 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R600 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R601 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R602 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R603 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R604 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R605 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R606 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R607 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R608 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R609 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R610 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R611 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R612 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R613 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R614 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R615 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R616 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R617 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R618 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R619 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R620 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R621 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R622 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R623 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R624 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R625 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R626 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R627 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R628 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R629 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R630 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R631 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R632 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R633 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R634 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R635 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R636 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R637 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R638 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R639 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R640 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R641 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R642 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R643 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R644 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R645 n1_m1_470400_19200 n1_m1_475200_19200 5.356235
R646 n1_m1_475200_19200 n1_m1_480000_19200 5.356235
R647 n1_m1_480000_19200 n1_m1_484800_19200 5.356235
R648 n1_m1_484800_19200 n1_m1_489600_19200 5.356235
R649 n1_m1_489600_19200 n1_m1_494400_19200 5.356235
R650 n1_m1_494400_19200 n1_m1_499200_19200 5.356235
R651 n1_m1_499200_19200 n1_m1_504000_19200 5.356235
R652 n1_m1_504000_19200 n1_m1_508000_19200 4.463529
R653 n1_m1_508800_19200 n1_m1_508000_19200 0.892706
R654 n1_m1_508800_19200 n1_m1_513600_19200 5.356235
R655 n1_m1_513600_19200 n1_m1_518400_19200 5.356235
R656 n1_m1_518400_19200 n1_m1_523200_19200 5.356235
R657 n1_m1_523200_19200 n1_m1_528000_19200 5.356235
R658 n1_m1_528000_19200 n1_m1_532800_19200 5.356235
R659 n1_m1_532800_19200 n1_m1_536000_19200 3.570824
R660 n1_m1_537600_19200 n1_m1_536000_19200 1.785412
R661 n1_m1_537600_19200 n1_m1_542400_19200 5.356235
R662 n1_m1_542400_19200 n1_m1_547200_19200 5.356235
R663 n1_m1_547200_19200 n1_m1_552000_19200 5.356235
R664 n1_m1_552000_19200 n1_m1_556800_19200 5.356235
R665 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R666 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R667 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R668 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R669 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R670 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R671 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R672 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R673 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R674 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R675 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R676 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R677 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R678 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R679 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R680 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R681 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R682 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R683 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R684 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R685 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R686 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R687 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R688 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R689 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R690 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R691 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R692 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R693 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R694 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R695 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R696 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R697 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R698 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R699 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R700 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R701 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R702 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R703 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R704 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R705 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R706 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R707 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R708 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R709 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R710 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R711 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R712 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R713 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R714 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R715 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R716 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R717 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R718 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R719 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R720 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R721 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R722 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R723 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R724 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R725 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R726 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R727 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R728 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R729 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R730 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R731 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R732 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R733 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R734 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R735 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R736 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R737 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R738 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R739 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R740 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R741 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R742 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R743 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R744 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R745 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R746 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R747 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R748 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R749 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R750 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R751 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R752 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R753 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R754 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R755 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R756 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R757 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R758 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R759 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R760 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R761 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R762 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R763 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R764 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R765 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R766 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R767 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R768 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R769 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R770 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R771 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R772 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R773 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R774 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R775 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R776 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R777 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R778 n1_m1_470400_24000 n1_m1_475200_24000 5.356235
R779 n1_m1_475200_24000 n1_m1_480000_24000 5.356235
R780 n1_m1_480000_24000 n1_m1_484800_24000 5.356235
R781 n1_m1_484800_24000 n1_m1_489600_24000 5.356235
R782 n1_m1_489600_24000 n1_m1_494400_24000 5.356235
R783 n1_m1_494400_24000 n1_m1_499200_24000 5.356235
R784 n1_m1_499200_24000 n1_m1_504000_24000 5.356235
R785 n1_m1_504000_24000 n1_m1_508000_24000 4.463529
R786 n1_m1_508800_24000 n1_m1_508000_24000 0.892706
R787 n1_m1_508800_24000 n1_m1_513600_24000 5.356235
R788 n1_m1_513600_24000 n1_m1_518400_24000 5.356235
R789 n1_m1_518400_24000 n1_m1_523200_24000 5.356235
R790 n1_m1_523200_24000 n1_m1_528000_24000 5.356235
R791 n1_m1_528000_24000 n1_m1_532800_24000 5.356235
R792 n1_m1_532800_24000 n1_m1_536000_24000 3.570824
R793 n1_m1_537600_24000 n1_m1_536000_24000 1.785412
R794 n1_m1_537600_24000 n1_m1_542400_24000 5.356235
R795 n1_m1_542400_24000 n1_m1_547200_24000 5.356235
R796 n1_m1_547200_24000 n1_m1_552000_24000 5.356235
R797 n1_m1_552000_24000 n1_m1_556800_24000 5.356235
R798 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R799 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R800 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R801 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R802 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R803 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R804 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R805 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R806 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R807 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R808 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R809 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R810 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R811 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R812 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R813 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R814 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R815 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R816 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R817 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R818 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R819 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R820 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R821 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R822 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R823 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R824 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R825 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R826 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R827 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R828 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R829 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R830 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R831 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R832 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R833 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R834 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R835 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R836 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R837 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R838 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R839 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R840 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R841 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R842 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R843 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R844 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R845 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R846 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R847 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R848 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R849 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R850 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R851 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R852 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R853 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R854 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R855 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R856 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R857 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R858 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R859 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R860 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R861 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R862 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R863 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R864 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R865 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R866 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R867 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R868 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R869 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R870 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R871 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R872 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R873 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R874 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R875 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R876 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R877 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R878 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R879 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R880 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R881 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R882 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R883 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R884 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R885 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R886 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R887 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R888 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R889 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R890 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R891 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R892 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R893 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R894 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R895 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R896 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R897 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R898 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R899 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R900 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R901 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R902 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R903 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R904 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R905 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R906 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R907 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R908 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R909 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R910 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R911 n1_m1_470400_28800 n1_m1_475200_28800 5.356235
R912 n1_m1_475200_28800 n1_m1_480000_28800 5.356235
R913 n1_m1_480000_28800 n1_m1_484800_28800 5.356235
R914 n1_m1_484800_28800 n1_m1_489600_28800 5.356235
R915 n1_m1_489600_28800 n1_m1_494400_28800 5.356235
R916 n1_m1_494400_28800 n1_m1_499200_28800 5.356235
R917 n1_m1_499200_28800 n1_m1_504000_28800 5.356235
R918 n1_m1_504000_28800 n1_m1_508000_28800 4.463529
R919 n1_m1_508800_28800 n1_m1_508000_28800 0.892706
R920 n1_m1_508800_28800 n1_m1_513600_28800 5.356235
R921 n1_m1_513600_28800 n1_m1_518400_28800 5.356235
R922 n1_m1_518400_28800 n1_m1_523200_28800 5.356235
R923 n1_m1_523200_28800 n1_m1_528000_28800 5.356235
R924 n1_m1_528000_28800 n1_m1_532800_28800 5.356235
R925 n1_m1_532800_28800 n1_m1_536000_28800 3.570824
R926 n1_m1_537600_28800 n1_m1_536000_28800 1.785412
R927 n1_m1_537600_28800 n1_m1_542400_28800 5.356235
R928 n1_m1_542400_28800 n1_m1_547200_28800 5.356235
R929 n1_m1_547200_28800 n1_m1_552000_28800 5.356235
R930 n1_m1_552000_28800 n1_m1_556800_28800 5.356235
R931 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R932 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R933 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R934 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R935 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R936 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R937 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R938 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R939 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R940 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R941 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R942 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R943 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R944 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R945 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R946 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R947 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R948 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R949 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R950 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R951 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R952 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R953 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R954 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R955 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R956 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R957 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R958 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R959 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R960 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R961 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R962 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R963 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R964 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R965 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R966 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R967 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R968 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R969 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R970 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R971 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R972 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R973 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R974 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R975 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R976 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R977 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R978 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R979 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R980 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R981 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R982 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R983 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R984 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R985 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R986 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R987 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R988 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R989 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R990 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R991 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R992 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R993 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R994 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R995 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R996 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R997 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R998 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R999 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R1000 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R1001 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R1002 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R1003 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R1004 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R1005 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R1006 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R1007 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R1008 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R1009 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R1010 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R1011 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R1012 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R1013 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R1014 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R1015 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R1016 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R1017 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R1018 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R1019 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R1020 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R1021 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R1022 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R1023 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R1024 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R1025 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R1026 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R1027 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R1028 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R1029 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R1030 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R1031 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R1032 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R1033 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R1034 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R1035 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R1036 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R1037 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R1038 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R1039 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R1040 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R1041 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R1042 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R1043 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R1044 n1_m1_470400_33600 n1_m1_475200_33600 5.356235
R1045 n1_m1_475200_33600 n1_m1_480000_33600 5.356235
R1046 n1_m1_480000_33600 n1_m1_484800_33600 5.356235
R1047 n1_m1_484800_33600 n1_m1_489600_33600 5.356235
R1048 n1_m1_489600_33600 n1_m1_494400_33600 5.356235
R1049 n1_m1_494400_33600 n1_m1_499200_33600 5.356235
R1050 n1_m1_499200_33600 n1_m1_504000_33600 5.356235
R1051 n1_m1_504000_33600 n1_m1_508000_33600 4.463529
R1052 n1_m1_508800_33600 n1_m1_508000_33600 0.892706
R1053 n1_m1_508800_33600 n1_m1_513600_33600 5.356235
R1054 n1_m1_513600_33600 n1_m1_518400_33600 5.356235
R1055 n1_m1_518400_33600 n1_m1_523200_33600 5.356235
R1056 n1_m1_523200_33600 n1_m1_528000_33600 5.356235
R1057 n1_m1_528000_33600 n1_m1_532800_33600 5.356235
R1058 n1_m1_532800_33600 n1_m1_536000_33600 3.570824
R1059 n1_m1_537600_33600 n1_m1_536000_33600 1.785412
R1060 n1_m1_537600_33600 n1_m1_542400_33600 5.356235
R1061 n1_m1_542400_33600 n1_m1_547200_33600 5.356235
R1062 n1_m1_547200_33600 n1_m1_552000_33600 5.356235
R1063 n1_m1_552000_33600 n1_m1_556800_33600 5.356235
R1064 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R1065 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R1066 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R1067 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R1068 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R1069 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R1070 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R1071 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R1072 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R1073 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R1074 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R1075 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R1076 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R1077 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R1078 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R1079 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R1080 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R1081 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R1082 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R1083 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R1084 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R1085 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R1086 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R1087 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R1088 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R1089 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R1090 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R1091 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R1092 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R1093 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R1094 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R1095 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R1096 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R1097 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R1098 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R1099 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R1100 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R1101 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R1102 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R1103 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R1104 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R1105 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R1106 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R1107 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R1108 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R1109 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R1110 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R1111 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R1112 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R1113 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R1114 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R1115 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R1116 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R1117 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R1118 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R1119 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R1120 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R1121 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R1122 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R1123 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R1124 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R1125 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R1126 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R1127 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R1128 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R1129 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R1130 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R1131 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R1132 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R1133 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R1134 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R1135 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R1136 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R1137 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R1138 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R1139 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R1140 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R1141 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R1142 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R1143 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R1144 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R1145 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R1146 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R1147 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R1148 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R1149 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R1150 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R1151 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R1152 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R1153 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R1154 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R1155 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R1156 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R1157 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R1158 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R1159 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1160 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1161 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1162 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1163 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1164 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1165 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1166 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1167 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1168 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1169 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1170 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1171 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1172 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1173 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1174 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1175 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1176 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1177 n1_m1_470400_38400 n1_m1_475200_38400 5.356235
R1178 n1_m1_475200_38400 n1_m1_480000_38400 5.356235
R1179 n1_m1_480000_38400 n1_m1_484800_38400 5.356235
R1180 n1_m1_484800_38400 n1_m1_489600_38400 5.356235
R1181 n1_m1_489600_38400 n1_m1_494400_38400 5.356235
R1182 n1_m1_494400_38400 n1_m1_499200_38400 5.356235
R1183 n1_m1_499200_38400 n1_m1_504000_38400 5.356235
R1184 n1_m1_504000_38400 n1_m1_508000_38400 4.463529
R1185 n1_m1_508800_38400 n1_m1_508000_38400 0.892706
R1186 n1_m1_508800_38400 n1_m1_513600_38400 5.356235
R1187 n1_m1_513600_38400 n1_m1_518400_38400 5.356235
R1188 n1_m1_518400_38400 n1_m1_523200_38400 5.356235
R1189 n1_m1_523200_38400 n1_m1_528000_38400 5.356235
R1190 n1_m1_528000_38400 n1_m1_532800_38400 5.356235
R1191 n1_m1_532800_38400 n1_m1_536000_38400 3.570824
R1192 n1_m1_537600_38400 n1_m1_536000_38400 1.785412
R1193 n1_m1_537600_38400 n1_m1_542400_38400 5.356235
R1194 n1_m1_542400_38400 n1_m1_547200_38400 5.356235
R1195 n1_m1_547200_38400 n1_m1_552000_38400 5.356235
R1196 n1_m1_552000_38400 n1_m1_556800_38400 5.356235
R1197 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1198 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1199 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1200 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1201 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1202 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1203 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1204 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1205 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1206 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1207 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1208 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1209 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1210 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1211 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1212 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1213 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1214 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1215 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1216 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1217 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1218 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1219 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1220 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1221 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1222 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1223 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1224 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1225 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1226 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1227 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1228 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1229 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1230 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1231 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1232 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1233 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1234 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1235 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1236 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1237 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1238 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1239 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1240 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1241 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1242 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1243 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1244 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1245 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1246 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1247 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1248 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1249 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1250 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1251 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1252 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1253 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1254 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1255 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1256 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1257 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1258 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1259 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1260 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1261 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1262 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1263 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1264 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1265 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1266 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1267 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1268 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1269 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1270 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1271 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1272 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1273 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1274 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1275 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1276 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1277 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1278 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1279 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1280 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1281 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1282 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1283 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1284 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1285 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1286 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1287 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1288 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1289 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1290 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1291 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1292 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1293 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1294 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1295 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1296 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1297 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1298 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1299 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1300 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1301 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1302 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1303 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1304 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1305 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1306 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1307 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1308 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1309 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1310 n1_m1_470400_43200 n1_m1_475200_43200 5.356235
R1311 n1_m1_475200_43200 n1_m1_480000_43200 5.356235
R1312 n1_m1_480000_43200 n1_m1_484800_43200 5.356235
R1313 n1_m1_484800_43200 n1_m1_489600_43200 5.356235
R1314 n1_m1_489600_43200 n1_m1_494400_43200 5.356235
R1315 n1_m1_494400_43200 n1_m1_499200_43200 5.356235
R1316 n1_m1_499200_43200 n1_m1_504000_43200 5.356235
R1317 n1_m1_504000_43200 n1_m1_508000_43200 4.463529
R1318 n1_m1_508800_43200 n1_m1_508000_43200 0.892706
R1319 n1_m1_508800_43200 n1_m1_513600_43200 5.356235
R1320 n1_m1_513600_43200 n1_m1_518400_43200 5.356235
R1321 n1_m1_518400_43200 n1_m1_523200_43200 5.356235
R1322 n1_m1_523200_43200 n1_m1_528000_43200 5.356235
R1323 n1_m1_528000_43200 n1_m1_532800_43200 5.356235
R1324 n1_m1_532800_43200 n1_m1_536000_43200 3.570824
R1325 n1_m1_537600_43200 n1_m1_536000_43200 1.785412
R1326 n1_m1_537600_43200 n1_m1_542400_43200 5.356235
R1327 n1_m1_542400_43200 n1_m1_547200_43200 5.356235
R1328 n1_m1_547200_43200 n1_m1_552000_43200 5.356235
R1329 n1_m1_552000_43200 n1_m1_556800_43200 5.356235
R1330 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1331 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1332 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1333 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1334 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1335 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1336 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1337 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1338 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1339 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1340 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1341 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1342 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1343 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1344 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1345 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1346 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1347 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1348 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1349 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1350 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1351 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1352 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1353 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1354 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1355 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1356 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1357 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1358 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1359 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1360 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1361 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1362 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1363 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1364 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1365 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1366 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1367 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1368 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1369 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1370 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1371 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1372 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1373 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1374 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1375 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1376 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1377 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1378 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1379 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1380 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1381 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1382 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1383 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1384 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1385 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1386 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1387 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1388 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1389 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1390 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1391 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1392 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1393 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1394 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1395 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1396 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1397 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1398 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1399 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1400 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1401 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1402 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1403 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1404 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1405 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1406 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1407 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1408 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1409 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1410 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1411 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1412 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1413 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1414 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1415 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1416 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1417 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1418 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1419 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1420 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1421 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1422 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1423 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1424 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1425 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1426 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1427 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1428 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1429 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1430 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1431 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1432 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1433 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1434 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1435 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1436 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1437 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1438 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1439 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1440 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1441 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1442 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1443 n1_m1_470400_48000 n1_m1_475200_48000 5.356235
R1444 n1_m1_475200_48000 n1_m1_480000_48000 5.356235
R1445 n1_m1_480000_48000 n1_m1_484800_48000 5.356235
R1446 n1_m1_484800_48000 n1_m1_489600_48000 5.356235
R1447 n1_m1_489600_48000 n1_m1_494400_48000 5.356235
R1448 n1_m1_494400_48000 n1_m1_499200_48000 5.356235
R1449 n1_m1_499200_48000 n1_m1_504000_48000 5.356235
R1450 n1_m1_504000_48000 n1_m1_508000_48000 4.463529
R1451 n1_m1_508800_48000 n1_m1_508000_48000 0.892706
R1452 n1_m1_508800_48000 n1_m1_513600_48000 5.356235
R1453 n1_m1_513600_48000 n1_m1_518400_48000 5.356235
R1454 n1_m1_518400_48000 n1_m1_523200_48000 5.356235
R1455 n1_m1_523200_48000 n1_m1_528000_48000 5.356235
R1456 n1_m1_528000_48000 n1_m1_532800_48000 5.356235
R1457 n1_m1_532800_48000 n1_m1_536000_48000 3.570824
R1458 n1_m1_537600_48000 n1_m1_536000_48000 1.785412
R1459 n1_m1_537600_48000 n1_m1_542400_48000 5.356235
R1460 n1_m1_542400_48000 n1_m1_547200_48000 5.356235
R1461 n1_m1_547200_48000 n1_m1_552000_48000 5.356235
R1462 n1_m1_552000_48000 n1_m1_556800_48000 5.356235
R1463 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1464 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1465 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1466 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1467 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1468 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1469 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1470 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1471 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1472 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1473 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1474 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1475 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1476 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1477 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1478 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1479 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1480 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1481 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1482 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1483 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1484 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1485 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1486 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1487 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1488 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1489 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1490 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1491 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1492 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1493 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1494 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1495 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1496 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1497 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1498 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1499 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1500 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1501 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1502 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1503 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1504 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1505 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1506 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1507 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1508 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1509 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1510 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1511 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1512 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1513 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1514 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1515 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1516 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1517 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1518 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1519 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1520 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1521 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1522 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1523 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1524 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1525 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1526 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1527 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1528 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1529 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1530 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1531 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1532 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1533 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1534 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1535 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1536 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1537 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1538 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1539 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1540 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1541 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1542 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1543 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1544 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1545 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1546 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1547 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1548 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1549 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1550 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1551 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1552 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1553 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1554 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1555 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1556 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1557 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1558 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1559 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1560 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1561 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1562 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1563 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1564 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1565 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1566 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1567 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1568 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1569 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1570 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1571 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1572 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1573 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1574 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1575 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1576 n1_m1_470400_52800 n1_m1_475200_52800 5.356235
R1577 n1_m1_475200_52800 n1_m1_480000_52800 5.356235
R1578 n1_m1_480000_52800 n1_m1_484800_52800 5.356235
R1579 n1_m1_484800_52800 n1_m1_489600_52800 5.356235
R1580 n1_m1_489600_52800 n1_m1_494400_52800 5.356235
R1581 n1_m1_494400_52800 n1_m1_499200_52800 5.356235
R1582 n1_m1_499200_52800 n1_m1_504000_52800 5.356235
R1583 n1_m1_504000_52800 n1_m1_508000_52800 4.463529
R1584 n1_m1_508800_52800 n1_m1_508000_52800 0.892706
R1585 n1_m1_508800_52800 n1_m1_513600_52800 5.356235
R1586 n1_m1_513600_52800 n1_m1_518400_52800 5.356235
R1587 n1_m1_518400_52800 n1_m1_523200_52800 5.356235
R1588 n1_m1_523200_52800 n1_m1_528000_52800 5.356235
R1589 n1_m1_528000_52800 n1_m1_532800_52800 5.356235
R1590 n1_m1_532800_52800 n1_m1_536000_52800 3.570824
R1591 n1_m1_537600_52800 n1_m1_536000_52800 1.785412
R1592 n1_m1_537600_52800 n1_m1_542400_52800 5.356235
R1593 n1_m1_542400_52800 n1_m1_547200_52800 5.356235
R1594 n1_m1_547200_52800 n1_m1_552000_52800 5.356235
R1595 n1_m1_552000_52800 n1_m1_556800_52800 5.356235
R1596 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1597 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1598 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1599 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1600 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1601 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1602 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1603 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1604 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1605 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1606 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1607 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1608 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1609 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1610 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1611 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1612 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1613 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1614 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1615 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1616 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1617 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1618 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1619 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1620 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1621 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1622 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1623 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1624 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1625 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1626 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1627 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1628 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1629 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1630 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1631 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1632 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1633 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1634 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1635 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1636 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1637 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1638 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1639 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1640 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1641 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1642 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1643 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1644 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1645 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1646 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1647 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1648 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1649 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1650 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1651 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1652 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1653 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1654 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1655 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1656 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1657 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1658 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1659 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1660 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1661 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1662 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1663 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1664 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1665 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1666 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1667 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1668 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1669 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1670 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1671 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1672 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1673 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1674 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1675 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1676 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1677 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1678 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1679 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1680 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1681 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1682 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1683 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1684 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1685 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1686 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1687 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1688 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1689 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1690 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1691 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1692 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1693 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1694 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1695 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1696 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1697 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1698 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1699 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1700 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1701 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1702 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1703 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1704 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1705 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1706 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1707 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1708 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1709 n1_m1_470400_57600 n1_m1_475200_57600 5.356235
R1710 n1_m1_475200_57600 n1_m1_480000_57600 5.356235
R1711 n1_m1_480000_57600 n1_m1_484800_57600 5.356235
R1712 n1_m1_484800_57600 n1_m1_489600_57600 5.356235
R1713 n1_m1_489600_57600 n1_m1_494400_57600 5.356235
R1714 n1_m1_494400_57600 n1_m1_499200_57600 5.356235
R1715 n1_m1_499200_57600 n1_m1_504000_57600 5.356235
R1716 n1_m1_504000_57600 n1_m1_508000_57600 4.463529
R1717 n1_m1_508800_57600 n1_m1_508000_57600 0.892706
R1718 n1_m1_508800_57600 n1_m1_513600_57600 5.356235
R1719 n1_m1_513600_57600 n1_m1_518400_57600 5.356235
R1720 n1_m1_518400_57600 n1_m1_523200_57600 5.356235
R1721 n1_m1_523200_57600 n1_m1_528000_57600 5.356235
R1722 n1_m1_528000_57600 n1_m1_532800_57600 5.356235
R1723 n1_m1_532800_57600 n1_m1_536000_57600 3.570824
R1724 n1_m1_537600_57600 n1_m1_536000_57600 1.785412
R1725 n1_m1_537600_57600 n1_m1_542400_57600 5.356235
R1726 n1_m1_542400_57600 n1_m1_547200_57600 5.356235
R1727 n1_m1_547200_57600 n1_m1_552000_57600 5.356235
R1728 n1_m1_552000_57600 n1_m1_556800_57600 5.356235
R1729 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1730 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1731 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1732 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1733 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1734 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1735 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1736 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1737 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1738 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1739 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1740 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1741 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1742 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1743 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1744 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1745 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1746 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1747 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1748 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1749 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1750 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1751 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1752 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1753 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1754 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1755 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1756 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1757 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1758 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1759 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1760 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1761 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1762 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1763 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1764 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1765 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1766 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1767 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1768 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1769 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1770 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1771 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1772 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1773 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1774 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1775 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1776 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1777 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1778 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1779 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1780 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1781 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1782 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1783 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1784 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1785 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1786 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1787 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1788 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1789 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1790 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1791 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1792 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1793 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1794 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1795 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1796 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1797 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1798 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1799 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1800 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1801 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1802 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1803 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1804 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1805 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1806 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1807 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1808 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1809 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1810 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1811 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1812 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1813 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1814 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1815 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1816 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1817 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1818 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1819 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1820 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1821 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1822 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1823 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1824 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1825 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1826 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1827 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1828 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1829 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1830 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1831 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1832 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1833 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1834 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1835 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1836 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1837 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1838 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1839 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1840 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1841 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1842 n1_m1_470400_62400 n1_m1_475200_62400 5.356235
R1843 n1_m1_475200_62400 n1_m1_480000_62400 5.356235
R1844 n1_m1_480000_62400 n1_m1_484800_62400 5.356235
R1845 n1_m1_484800_62400 n1_m1_489600_62400 5.356235
R1846 n1_m1_489600_62400 n1_m1_494400_62400 5.356235
R1847 n1_m1_494400_62400 n1_m1_499200_62400 5.356235
R1848 n1_m1_499200_62400 n1_m1_504000_62400 5.356235
R1849 n1_m1_504000_62400 n1_m1_508000_62400 4.463529
R1850 n1_m1_508800_62400 n1_m1_508000_62400 0.892706
R1851 n1_m1_508800_62400 n1_m1_513600_62400 5.356235
R1852 n1_m1_513600_62400 n1_m1_518400_62400 5.356235
R1853 n1_m1_518400_62400 n1_m1_523200_62400 5.356235
R1854 n1_m1_523200_62400 n1_m1_528000_62400 5.356235
R1855 n1_m1_528000_62400 n1_m1_532800_62400 5.356235
R1856 n1_m1_532800_62400 n1_m1_536000_62400 3.570824
R1857 n1_m1_537600_62400 n1_m1_536000_62400 1.785412
R1858 n1_m1_537600_62400 n1_m1_542400_62400 5.356235
R1859 n1_m1_542400_62400 n1_m1_547200_62400 5.356235
R1860 n1_m1_547200_62400 n1_m1_552000_62400 5.356235
R1861 n1_m1_552000_62400 n1_m1_556800_62400 5.356235
R1862 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1863 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1864 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1865 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1866 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1867 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1868 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1869 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1870 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1871 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1872 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1873 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1874 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1875 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1876 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1877 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1878 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1879 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1880 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1881 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1882 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1883 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1884 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1885 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1886 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1887 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1888 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1889 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1890 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1891 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1892 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1893 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1894 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1895 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1896 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1897 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1898 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1899 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1900 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1901 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1902 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1903 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1904 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1905 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1906 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1907 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1908 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1909 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1910 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1911 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1912 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1913 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1914 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1915 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1916 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1917 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1918 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1919 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1920 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1921 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1922 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1923 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1924 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1925 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1926 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1927 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1928 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1929 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1930 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1931 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1932 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1933 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1934 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1935 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1936 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1937 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1938 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1939 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1940 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1941 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1942 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1943 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1944 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1945 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1946 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1947 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1948 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1949 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1950 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1951 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1952 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1953 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1954 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1955 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1956 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1957 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1958 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1959 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1960 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R1961 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R1962 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R1963 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R1964 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R1965 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R1966 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R1967 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R1968 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R1969 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R1970 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R1971 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R1972 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R1973 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R1974 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R1975 n1_m1_470400_67200 n1_m1_475200_67200 5.356235
R1976 n1_m1_475200_67200 n1_m1_480000_67200 5.356235
R1977 n1_m1_480000_67200 n1_m1_484800_67200 5.356235
R1978 n1_m1_484800_67200 n1_m1_489600_67200 5.356235
R1979 n1_m1_489600_67200 n1_m1_494400_67200 5.356235
R1980 n1_m1_494400_67200 n1_m1_499200_67200 5.356235
R1981 n1_m1_499200_67200 n1_m1_504000_67200 5.356235
R1982 n1_m1_504000_67200 n1_m1_508000_67200 4.463529
R1983 n1_m1_508800_67200 n1_m1_508000_67200 0.892706
R1984 n1_m1_508800_67200 n1_m1_513600_67200 5.356235
R1985 n1_m1_513600_67200 n1_m1_518400_67200 5.356235
R1986 n1_m1_518400_67200 n1_m1_523200_67200 5.356235
R1987 n1_m1_523200_67200 n1_m1_528000_67200 5.356235
R1988 n1_m1_528000_67200 n1_m1_532800_67200 5.356235
R1989 n1_m1_532800_67200 n1_m1_536000_67200 3.570824
R1990 n1_m1_537600_67200 n1_m1_536000_67200 1.785412
R1991 n1_m1_537600_67200 n1_m1_542400_67200 5.356235
R1992 n1_m1_542400_67200 n1_m1_547200_67200 5.356235
R1993 n1_m1_547200_67200 n1_m1_552000_67200 5.356235
R1994 n1_m1_552000_67200 n1_m1_556800_67200 5.356235
R1995 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1996 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1997 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1998 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1999 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R2000 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R2001 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R2002 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R2003 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R2004 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R2005 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R2006 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R2007 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R2008 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R2009 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R2010 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R2011 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R2012 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R2013 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R2014 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R2015 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R2016 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R2017 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R2018 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R2019 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R2020 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R2021 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R2022 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R2023 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R2024 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R2025 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R2026 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R2027 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R2028 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R2029 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R2030 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R2031 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R2032 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R2033 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R2034 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R2035 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R2036 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R2037 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R2038 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R2039 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R2040 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R2041 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R2042 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R2043 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R2044 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R2045 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R2046 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R2047 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R2048 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R2049 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R2050 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R2051 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R2052 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R2053 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R2054 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R2055 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R2056 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R2057 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R2058 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R2059 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R2060 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R2061 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R2062 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R2063 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R2064 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R2065 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R2066 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R2067 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R2068 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R2069 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R2070 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R2071 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R2072 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R2073 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R2074 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R2075 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R2076 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R2077 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R2078 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R2079 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R2080 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R2081 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R2082 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R2083 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R2084 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R2085 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R2086 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R2087 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R2088 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R2089 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R2090 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R2091 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R2092 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R2093 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R2094 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R2095 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R2096 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R2097 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R2098 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R2099 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R2100 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R2101 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R2102 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R2103 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R2104 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R2105 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R2106 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R2107 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R2108 n1_m1_470400_72000 n1_m1_475200_72000 5.356235
R2109 n1_m1_475200_72000 n1_m1_480000_72000 5.356235
R2110 n1_m1_480000_72000 n1_m1_484800_72000 5.356235
R2111 n1_m1_484800_72000 n1_m1_489600_72000 5.356235
R2112 n1_m1_489600_72000 n1_m1_494400_72000 5.356235
R2113 n1_m1_494400_72000 n1_m1_499200_72000 5.356235
R2114 n1_m1_499200_72000 n1_m1_504000_72000 5.356235
R2115 n1_m1_504000_72000 n1_m1_508000_72000 4.463529
R2116 n1_m1_508800_72000 n1_m1_508000_72000 0.892706
R2117 n1_m1_508800_72000 n1_m1_513600_72000 5.356235
R2118 n1_m1_513600_72000 n1_m1_518400_72000 5.356235
R2119 n1_m1_518400_72000 n1_m1_523200_72000 5.356235
R2120 n1_m1_523200_72000 n1_m1_528000_72000 5.356235
R2121 n1_m1_528000_72000 n1_m1_532800_72000 5.356235
R2122 n1_m1_532800_72000 n1_m1_536000_72000 3.570824
R2123 n1_m1_537600_72000 n1_m1_536000_72000 1.785412
R2124 n1_m1_537600_72000 n1_m1_542400_72000 5.356235
R2125 n1_m1_542400_72000 n1_m1_547200_72000 5.356235
R2126 n1_m1_547200_72000 n1_m1_552000_72000 5.356235
R2127 n1_m1_552000_72000 n1_m1_556800_72000 5.356235
R2128 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R2129 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R2130 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R2131 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R2132 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R2133 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R2134 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R2135 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R2136 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R2137 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R2138 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R2139 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R2140 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R2141 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R2142 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R2143 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R2144 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R2145 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R2146 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R2147 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R2148 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R2149 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R2150 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R2151 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R2152 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R2153 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R2154 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R2155 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R2156 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R2157 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R2158 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R2159 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R2160 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R2161 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R2162 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R2163 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R2164 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R2165 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R2166 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R2167 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R2168 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R2169 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R2170 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R2171 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R2172 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R2173 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R2174 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R2175 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R2176 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R2177 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R2178 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R2179 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R2180 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R2181 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R2182 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R2183 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R2184 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R2185 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R2186 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R2187 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R2188 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R2189 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R2190 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R2191 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R2192 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R2193 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R2194 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R2195 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R2196 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R2197 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R2198 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R2199 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R2200 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R2201 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R2202 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R2203 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R2204 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R2205 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R2206 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R2207 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R2208 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R2209 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R2210 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R2211 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R2212 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R2213 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R2214 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R2215 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R2216 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R2217 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R2218 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R2219 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R2220 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R2221 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R2222 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R2223 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R2224 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R2225 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R2226 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R2227 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R2228 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R2229 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R2230 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R2231 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R2232 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R2233 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R2234 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R2235 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R2236 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R2237 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R2238 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R2239 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R2240 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R2241 n1_m1_470400_76800 n1_m1_475200_76800 5.356235
R2242 n1_m1_475200_76800 n1_m1_480000_76800 5.356235
R2243 n1_m1_480000_76800 n1_m1_484800_76800 5.356235
R2244 n1_m1_484800_76800 n1_m1_489600_76800 5.356235
R2245 n1_m1_489600_76800 n1_m1_494400_76800 5.356235
R2246 n1_m1_494400_76800 n1_m1_499200_76800 5.356235
R2247 n1_m1_499200_76800 n1_m1_504000_76800 5.356235
R2248 n1_m1_504000_76800 n1_m1_508000_76800 4.463529
R2249 n1_m1_508800_76800 n1_m1_508000_76800 0.892706
R2250 n1_m1_508800_76800 n1_m1_513600_76800 5.356235
R2251 n1_m1_513600_76800 n1_m1_518400_76800 5.356235
R2252 n1_m1_518400_76800 n1_m1_523200_76800 5.356235
R2253 n1_m1_523200_76800 n1_m1_528000_76800 5.356235
R2254 n1_m1_528000_76800 n1_m1_532800_76800 5.356235
R2255 n1_m1_532800_76800 n1_m1_536000_76800 3.570824
R2256 n1_m1_537600_76800 n1_m1_536000_76800 1.785412
R2257 n1_m1_537600_76800 n1_m1_542400_76800 5.356235
R2258 n1_m1_542400_76800 n1_m1_547200_76800 5.356235
R2259 n1_m1_547200_76800 n1_m1_552000_76800 5.356235
R2260 n1_m1_552000_76800 n1_m1_556800_76800 5.356235
R2261 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R2262 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R2263 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R2264 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R2265 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R2266 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R2267 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R2268 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R2269 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R2270 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R2271 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R2272 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R2273 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R2274 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R2275 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R2276 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R2277 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R2278 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R2279 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R2280 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R2281 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R2282 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R2283 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R2284 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R2285 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R2286 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R2287 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R2288 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R2289 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R2290 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R2291 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R2292 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R2293 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R2294 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R2295 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R2296 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R2297 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R2298 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R2299 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R2300 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R2301 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R2302 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R2303 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R2304 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R2305 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R2306 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R2307 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R2308 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R2309 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R2310 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R2311 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R2312 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R2313 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R2314 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R2315 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R2316 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R2317 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R2318 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R2319 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R2320 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R2321 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R2322 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R2323 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R2324 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R2325 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R2326 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R2327 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R2328 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R2329 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R2330 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R2331 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R2332 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R2333 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R2334 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R2335 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R2336 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R2337 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R2338 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R2339 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2340 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2341 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2342 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2343 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2344 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2345 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2346 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2347 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2348 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2349 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2350 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2351 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2352 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2353 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2354 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2355 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2356 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2357 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2358 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2359 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2360 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2361 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2362 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2363 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2364 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2365 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2366 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2367 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2368 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2369 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2370 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2371 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2372 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2373 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2374 n1_m1_470400_81600 n1_m1_475200_81600 5.356235
R2375 n1_m1_475200_81600 n1_m1_480000_81600 5.356235
R2376 n1_m1_480000_81600 n1_m1_484800_81600 5.356235
R2377 n1_m1_484800_81600 n1_m1_489600_81600 5.356235
R2378 n1_m1_489600_81600 n1_m1_494400_81600 5.356235
R2379 n1_m1_494400_81600 n1_m1_499200_81600 5.356235
R2380 n1_m1_499200_81600 n1_m1_504000_81600 5.356235
R2381 n1_m1_504000_81600 n1_m1_508000_81600 4.463529
R2382 n1_m1_508800_81600 n1_m1_508000_81600 0.892706
R2383 n1_m1_508800_81600 n1_m1_513600_81600 5.356235
R2384 n1_m1_513600_81600 n1_m1_518400_81600 5.356235
R2385 n1_m1_518400_81600 n1_m1_523200_81600 5.356235
R2386 n1_m1_523200_81600 n1_m1_528000_81600 5.356235
R2387 n1_m1_528000_81600 n1_m1_532800_81600 5.356235
R2388 n1_m1_532800_81600 n1_m1_536000_81600 3.570824
R2389 n1_m1_537600_81600 n1_m1_536000_81600 1.785412
R2390 n1_m1_537600_81600 n1_m1_542400_81600 5.356235
R2391 n1_m1_542400_81600 n1_m1_547200_81600 5.356235
R2392 n1_m1_547200_81600 n1_m1_552000_81600 5.356235
R2393 n1_m1_552000_81600 n1_m1_556800_81600 5.356235
R2394 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2395 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2396 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2397 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2398 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2399 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2400 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2401 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2402 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2403 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2404 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2405 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2406 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2407 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2408 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2409 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2410 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2411 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2412 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2413 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2414 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2415 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2416 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2417 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2418 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2419 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2420 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2421 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2422 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2423 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2424 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2425 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2426 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2427 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2428 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2429 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2430 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2431 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2432 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2433 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2434 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2435 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2436 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2437 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2438 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2439 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2440 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2441 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2442 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2443 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2444 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2445 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2446 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2447 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2448 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2449 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2450 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2451 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2452 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2453 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2454 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2455 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2456 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2457 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2458 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2459 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2460 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2461 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2462 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2463 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2464 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2465 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2466 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2467 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2468 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2469 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2470 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2471 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2472 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2473 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2474 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2475 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2476 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2477 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2478 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2479 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2480 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2481 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2482 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2483 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2484 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2485 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2486 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2487 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2488 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2489 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2490 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2491 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2492 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2493 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2494 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2495 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2496 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2497 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2498 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2499 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2500 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2501 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2502 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2503 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2504 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2505 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2506 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2507 n1_m1_470400_86400 n1_m1_475200_86400 5.356235
R2508 n1_m1_475200_86400 n1_m1_480000_86400 5.356235
R2509 n1_m1_480000_86400 n1_m1_484800_86400 5.356235
R2510 n1_m1_484800_86400 n1_m1_489600_86400 5.356235
R2511 n1_m1_489600_86400 n1_m1_494400_86400 5.356235
R2512 n1_m1_494400_86400 n1_m1_499200_86400 5.356235
R2513 n1_m1_499200_86400 n1_m1_504000_86400 5.356235
R2514 n1_m1_504000_86400 n1_m1_508000_86400 4.463529
R2515 n1_m1_508800_86400 n1_m1_508000_86400 0.892706
R2516 n1_m1_508800_86400 n1_m1_513600_86400 5.356235
R2517 n1_m1_513600_86400 n1_m1_518400_86400 5.356235
R2518 n1_m1_518400_86400 n1_m1_523200_86400 5.356235
R2519 n1_m1_523200_86400 n1_m1_528000_86400 5.356235
R2520 n1_m1_528000_86400 n1_m1_532800_86400 5.356235
R2521 n1_m1_532800_86400 n1_m1_536000_86400 3.570824
R2522 n1_m1_537600_86400 n1_m1_536000_86400 1.785412
R2523 n1_m1_537600_86400 n1_m1_542400_86400 5.356235
R2524 n1_m1_542400_86400 n1_m1_547200_86400 5.356235
R2525 n1_m1_547200_86400 n1_m1_552000_86400 5.356235
R2526 n1_m1_552000_86400 n1_m1_556800_86400 5.356235
R2527 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2528 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2529 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2530 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2531 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2532 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2533 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2534 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2535 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2536 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2537 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2538 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2539 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2540 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2541 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2542 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2543 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2544 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2545 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2546 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2547 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2548 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2549 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2550 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2551 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2552 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2553 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2554 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2555 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2556 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2557 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2558 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2559 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2560 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2561 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2562 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2563 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2564 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2565 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2566 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2567 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2568 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2569 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2570 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2571 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2572 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2573 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2574 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2575 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2576 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2577 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2578 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2579 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2580 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2581 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2582 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2583 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2584 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2585 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2586 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2587 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2588 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2589 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2590 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2591 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2592 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2593 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2594 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2595 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2596 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2597 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2598 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2599 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2600 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2601 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2602 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2603 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2604 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2605 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2606 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2607 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2608 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2609 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2610 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2611 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2612 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2613 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2614 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2615 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2616 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2617 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2618 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2619 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2620 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2621 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2622 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2623 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2624 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2625 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2626 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2627 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2628 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2629 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2630 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2631 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2632 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2633 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2634 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2635 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2636 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2637 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2638 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2639 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2640 n1_m1_470400_91200 n1_m1_475200_91200 5.356235
R2641 n1_m1_475200_91200 n1_m1_480000_91200 5.356235
R2642 n1_m1_480000_91200 n1_m1_484800_91200 5.356235
R2643 n1_m1_484800_91200 n1_m1_489600_91200 5.356235
R2644 n1_m1_489600_91200 n1_m1_494400_91200 5.356235
R2645 n1_m1_494400_91200 n1_m1_499200_91200 5.356235
R2646 n1_m1_499200_91200 n1_m1_504000_91200 5.356235
R2647 n1_m1_504000_91200 n1_m1_508000_91200 4.463529
R2648 n1_m1_508800_91200 n1_m1_508000_91200 0.892706
R2649 n1_m1_508800_91200 n1_m1_513600_91200 5.356235
R2650 n1_m1_513600_91200 n1_m1_518400_91200 5.356235
R2651 n1_m1_518400_91200 n1_m1_523200_91200 5.356235
R2652 n1_m1_523200_91200 n1_m1_528000_91200 5.356235
R2653 n1_m1_528000_91200 n1_m1_532800_91200 5.356235
R2654 n1_m1_532800_91200 n1_m1_536000_91200 3.570824
R2655 n1_m1_537600_91200 n1_m1_536000_91200 1.785412
R2656 n1_m1_537600_91200 n1_m1_542400_91200 5.356235
R2657 n1_m1_542400_91200 n1_m1_547200_91200 5.356235
R2658 n1_m1_547200_91200 n1_m1_552000_91200 5.356235
R2659 n1_m1_552000_91200 n1_m1_556800_91200 5.356235
R2660 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2661 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2662 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2663 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2664 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2665 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2666 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2667 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2668 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2669 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2670 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2671 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2672 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2673 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2674 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2675 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2676 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2677 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2678 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2679 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2680 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2681 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2682 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2683 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2684 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2685 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2686 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2687 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2688 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2689 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2690 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2691 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2692 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2693 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2694 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2695 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2696 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2697 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2698 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2699 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2700 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2701 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2702 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2703 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2704 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2705 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2706 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2707 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2708 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2709 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2710 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2711 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2712 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2713 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2714 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2715 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2716 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2717 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2718 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2719 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2720 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2721 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2722 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2723 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2724 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2725 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2726 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2727 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2728 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2729 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2730 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2731 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2732 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2733 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2734 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2735 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2736 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2737 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2738 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2739 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2740 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2741 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2742 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2743 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2744 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2745 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2746 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2747 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2748 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2749 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2750 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2751 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2752 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2753 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2754 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2755 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2756 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2757 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2758 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2759 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2760 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2761 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2762 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2763 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2764 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2765 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2766 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2767 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2768 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2769 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2770 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2771 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2772 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2773 n1_m1_470400_96000 n1_m1_475200_96000 5.356235
R2774 n1_m1_475200_96000 n1_m1_480000_96000 5.356235
R2775 n1_m1_480000_96000 n1_m1_484800_96000 5.356235
R2776 n1_m1_484800_96000 n1_m1_489600_96000 5.356235
R2777 n1_m1_489600_96000 n1_m1_494400_96000 5.356235
R2778 n1_m1_494400_96000 n1_m1_499200_96000 5.356235
R2779 n1_m1_499200_96000 n1_m1_504000_96000 5.356235
R2780 n1_m1_504000_96000 n1_m1_508000_96000 4.463529
R2781 n1_m1_508800_96000 n1_m1_508000_96000 0.892706
R2782 n1_m1_508800_96000 n1_m1_513600_96000 5.356235
R2783 n1_m1_513600_96000 n1_m1_518400_96000 5.356235
R2784 n1_m1_518400_96000 n1_m1_523200_96000 5.356235
R2785 n1_m1_523200_96000 n1_m1_528000_96000 5.356235
R2786 n1_m1_528000_96000 n1_m1_532800_96000 5.356235
R2787 n1_m1_532800_96000 n1_m1_536000_96000 3.570824
R2788 n1_m1_537600_96000 n1_m1_536000_96000 1.785412
R2789 n1_m1_537600_96000 n1_m1_542400_96000 5.356235
R2790 n1_m1_542400_96000 n1_m1_547200_96000 5.356235
R2791 n1_m1_547200_96000 n1_m1_552000_96000 5.356235
R2792 n1_m1_552000_96000 n1_m1_556800_96000 5.356235
R2793 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2794 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2795 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2796 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2797 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2798 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2799 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2800 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2801 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2802 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2803 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2804 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2805 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2806 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2807 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2808 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2809 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2810 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2811 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2812 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2813 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2814 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2815 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2816 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2817 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2818 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2819 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2820 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2821 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2822 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2823 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2824 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2825 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2826 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2827 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2828 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2829 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2830 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2831 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2832 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2833 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2834 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2835 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2836 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2837 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2838 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2839 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2840 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2841 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2842 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2843 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2844 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2845 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2846 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2847 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2848 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2849 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2850 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2851 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2852 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2853 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2854 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2855 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2856 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2857 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2858 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2859 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2860 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2861 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2862 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2863 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2864 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2865 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2866 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2867 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2868 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2869 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2870 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2871 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2872 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2873 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2874 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2875 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2876 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2877 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2878 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2879 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2880 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2881 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2882 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2883 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2884 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2885 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2886 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2887 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2888 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2889 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2890 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2891 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R2892 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R2893 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R2894 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R2895 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R2896 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R2897 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R2898 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R2899 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R2900 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R2901 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R2902 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R2903 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R2904 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R2905 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R2906 n1_m1_470400_100800 n1_m1_475200_100800 5.356235
R2907 n1_m1_475200_100800 n1_m1_480000_100800 5.356235
R2908 n1_m1_480000_100800 n1_m1_484800_100800 5.356235
R2909 n1_m1_484800_100800 n1_m1_489600_100800 5.356235
R2910 n1_m1_489600_100800 n1_m1_494400_100800 5.356235
R2911 n1_m1_494400_100800 n1_m1_499200_100800 5.356235
R2912 n1_m1_499200_100800 n1_m1_504000_100800 5.356235
R2913 n1_m1_504000_100800 n1_m1_508000_100800 4.463529
R2914 n1_m1_508800_100800 n1_m1_508000_100800 0.892706
R2915 n1_m1_508800_100800 n1_m1_513600_100800 5.356235
R2916 n1_m1_513600_100800 n1_m1_518400_100800 5.356235
R2917 n1_m1_518400_100800 n1_m1_523200_100800 5.356235
R2918 n1_m1_523200_100800 n1_m1_528000_100800 5.356235
R2919 n1_m1_528000_100800 n1_m1_532800_100800 5.356235
R2920 n1_m1_532800_100800 n1_m1_536000_100800 3.570824
R2921 n1_m1_537600_100800 n1_m1_536000_100800 1.785412
R2922 n1_m1_537600_100800 n1_m1_542400_100800 5.356235
R2923 n1_m1_542400_100800 n1_m1_547200_100800 5.356235
R2924 n1_m1_547200_100800 n1_m1_552000_100800 5.356235
R2925 n1_m1_552000_100800 n1_m1_556800_100800 5.356235
R2926 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2927 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2928 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2929 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2930 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2931 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2932 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2933 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2934 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2935 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2936 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2937 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2938 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2939 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2940 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2941 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2942 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2943 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2944 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2945 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2946 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2947 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2948 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2949 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2950 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2951 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2952 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2953 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2954 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2955 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2956 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2957 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2958 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2959 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2960 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2961 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2962 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2963 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2964 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2965 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2966 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2967 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2968 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2969 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2970 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2971 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2972 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2973 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2974 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2975 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2976 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2977 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2978 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2979 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2980 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2981 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2982 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2983 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2984 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2985 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2986 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2987 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2988 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2989 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2990 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2991 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2992 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2993 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2994 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2995 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2996 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2997 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2998 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2999 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R3000 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R3001 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R3002 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R3003 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R3004 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R3005 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R3006 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R3007 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R3008 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R3009 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R3010 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R3011 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R3012 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R3013 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R3014 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R3015 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R3016 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R3017 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R3018 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R3019 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R3020 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R3021 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R3022 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R3023 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R3024 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R3025 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R3026 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R3027 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R3028 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R3029 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R3030 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R3031 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R3032 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R3033 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R3034 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R3035 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R3036 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R3037 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R3038 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R3039 n1_m1_470400_105600 n1_m1_475200_105600 5.356235
R3040 n1_m1_475200_105600 n1_m1_480000_105600 5.356235
R3041 n1_m1_480000_105600 n1_m1_484800_105600 5.356235
R3042 n1_m1_484800_105600 n1_m1_489600_105600 5.356235
R3043 n1_m1_489600_105600 n1_m1_494400_105600 5.356235
R3044 n1_m1_494400_105600 n1_m1_499200_105600 5.356235
R3045 n1_m1_499200_105600 n1_m1_504000_105600 5.356235
R3046 n1_m1_504000_105600 n1_m1_508000_105600 4.463529
R3047 n1_m1_508800_105600 n1_m1_508000_105600 0.892706
R3048 n1_m1_508800_105600 n1_m1_513600_105600 5.356235
R3049 n1_m1_513600_105600 n1_m1_518400_105600 5.356235
R3050 n1_m1_518400_105600 n1_m1_523200_105600 5.356235
R3051 n1_m1_523200_105600 n1_m1_528000_105600 5.356235
R3052 n1_m1_528000_105600 n1_m1_532800_105600 5.356235
R3053 n1_m1_532800_105600 n1_m1_536000_105600 3.570824
R3054 n1_m1_537600_105600 n1_m1_536000_105600 1.785412
R3055 n1_m1_537600_105600 n1_m1_542400_105600 5.356235
R3056 n1_m1_542400_105600 n1_m1_547200_105600 5.356235
R3057 n1_m1_547200_105600 n1_m1_552000_105600 5.356235
R3058 n1_m1_552000_105600 n1_m1_556800_105600 5.356235
R3059 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R3060 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R3061 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R3062 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R3063 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R3064 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R3065 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R3066 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R3067 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R3068 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R3069 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R3070 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R3071 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R3072 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R3073 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R3074 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R3075 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R3076 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R3077 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R3078 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R3079 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R3080 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R3081 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R3082 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R3083 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R3084 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R3085 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R3086 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R3087 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R3088 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R3089 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R3090 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R3091 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R3092 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R3093 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R3094 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R3095 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R3096 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R3097 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R3098 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R3099 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R3100 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R3101 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R3102 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R3103 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R3104 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R3105 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R3106 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R3107 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R3108 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R3109 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R3110 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R3111 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R3112 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R3113 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R3114 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R3115 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R3116 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R3117 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R3118 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R3119 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R3120 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R3121 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R3122 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R3123 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R3124 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R3125 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R3126 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R3127 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R3128 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R3129 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R3130 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R3131 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R3132 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R3133 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R3134 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R3135 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R3136 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R3137 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R3138 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R3139 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R3140 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R3141 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R3142 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R3143 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R3144 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R3145 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R3146 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R3147 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R3148 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R3149 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R3150 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R3151 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R3152 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R3153 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R3154 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R3155 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R3156 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R3157 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R3158 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R3159 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R3160 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R3161 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R3162 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R3163 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R3164 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R3165 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R3166 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R3167 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R3168 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R3169 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R3170 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R3171 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R3172 n1_m1_470400_110400 n1_m1_475200_110400 5.356235
R3173 n1_m1_475200_110400 n1_m1_480000_110400 5.356235
R3174 n1_m1_480000_110400 n1_m1_484800_110400 5.356235
R3175 n1_m1_484800_110400 n1_m1_489600_110400 5.356235
R3176 n1_m1_489600_110400 n1_m1_494400_110400 5.356235
R3177 n1_m1_494400_110400 n1_m1_499200_110400 5.356235
R3178 n1_m1_499200_110400 n1_m1_504000_110400 5.356235
R3179 n1_m1_504000_110400 n1_m1_508000_110400 4.463529
R3180 n1_m1_508800_110400 n1_m1_508000_110400 0.892706
R3181 n1_m1_508800_110400 n1_m1_513600_110400 5.356235
R3182 n1_m1_513600_110400 n1_m1_518400_110400 5.356235
R3183 n1_m1_518400_110400 n1_m1_523200_110400 5.356235
R3184 n1_m1_523200_110400 n1_m1_528000_110400 5.356235
R3185 n1_m1_528000_110400 n1_m1_532800_110400 5.356235
R3186 n1_m1_532800_110400 n1_m1_536000_110400 3.570824
R3187 n1_m1_537600_110400 n1_m1_536000_110400 1.785412
R3188 n1_m1_537600_110400 n1_m1_542400_110400 5.356235
R3189 n1_m1_542400_110400 n1_m1_547200_110400 5.356235
R3190 n1_m1_547200_110400 n1_m1_552000_110400 5.356235
R3191 n1_m1_552000_110400 n1_m1_556800_110400 5.356235
R3192 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R3193 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R3194 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R3195 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R3196 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R3197 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R3198 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R3199 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R3200 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R3201 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R3202 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R3203 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R3204 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R3205 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R3206 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R3207 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R3208 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R3209 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R3210 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R3211 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R3212 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R3213 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R3214 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R3215 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R3216 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R3217 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R3218 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R3219 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R3220 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R3221 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R3222 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R3223 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R3224 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R3225 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R3226 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R3227 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R3228 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R3229 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R3230 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R3231 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R3232 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R3233 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R3234 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R3235 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R3236 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R3237 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R3238 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R3239 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R3240 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R3241 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R3242 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R3243 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R3244 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R3245 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R3246 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R3247 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R3248 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R3249 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R3250 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R3251 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R3252 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R3253 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R3254 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R3255 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R3256 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R3257 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R3258 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R3259 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R3260 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R3261 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R3262 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R3263 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R3264 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R3265 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R3266 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R3267 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R3268 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R3269 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R3270 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R3271 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R3272 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R3273 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R3274 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R3275 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R3276 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R3277 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R3278 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R3279 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R3280 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R3281 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R3282 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R3283 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R3284 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R3285 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R3286 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R3287 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R3288 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R3289 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R3290 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R3291 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R3292 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R3293 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R3294 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R3295 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R3296 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R3297 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R3298 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R3299 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R3300 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R3301 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R3302 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R3303 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R3304 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R3305 n1_m1_470400_115200 n1_m1_475200_115200 5.356235
R3306 n1_m1_475200_115200 n1_m1_480000_115200 5.356235
R3307 n1_m1_480000_115200 n1_m1_484800_115200 5.356235
R3308 n1_m1_484800_115200 n1_m1_489600_115200 5.356235
R3309 n1_m1_489600_115200 n1_m1_494400_115200 5.356235
R3310 n1_m1_494400_115200 n1_m1_499200_115200 5.356235
R3311 n1_m1_499200_115200 n1_m1_504000_115200 5.356235
R3312 n1_m1_504000_115200 n1_m1_508000_115200 4.463529
R3313 n1_m1_508800_115200 n1_m1_508000_115200 0.892706
R3314 n1_m1_508800_115200 n1_m1_513600_115200 5.356235
R3315 n1_m1_513600_115200 n1_m1_518400_115200 5.356235
R3316 n1_m1_518400_115200 n1_m1_523200_115200 5.356235
R3317 n1_m1_523200_115200 n1_m1_528000_115200 5.356235
R3318 n1_m1_528000_115200 n1_m1_532800_115200 5.356235
R3319 n1_m1_532800_115200 n1_m1_536000_115200 3.570824
R3320 n1_m1_537600_115200 n1_m1_536000_115200 1.785412
R3321 n1_m1_537600_115200 n1_m1_542400_115200 5.356235
R3322 n1_m1_542400_115200 n1_m1_547200_115200 5.356235
R3323 n1_m1_547200_115200 n1_m1_552000_115200 5.356235
R3324 n1_m1_552000_115200 n1_m1_556800_115200 5.356235
R3325 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R3326 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R3327 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R3328 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R3329 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R3330 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R3331 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R3332 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R3333 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R3334 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R3335 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R3336 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R3337 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R3338 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R3339 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R3340 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R3341 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R3342 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R3343 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R3344 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R3345 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R3346 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R3347 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R3348 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R3349 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R3350 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R3351 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R3352 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R3353 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R3354 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R3355 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R3356 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R3357 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R3358 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R3359 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R3360 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R3361 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R3362 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R3363 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R3364 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R3365 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R3366 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R3367 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R3368 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R3369 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R3370 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R3371 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R3372 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R3373 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R3374 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R3375 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R3376 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R3377 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R3378 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R3379 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R3380 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R3381 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R3382 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R3383 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R3384 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R3385 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R3386 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R3387 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R3388 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R3389 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R3390 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R3391 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R3392 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R3393 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R3394 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R3395 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R3396 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R3397 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R3398 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R3399 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R3400 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R3401 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R3402 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R3403 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R3404 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R3405 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R3406 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R3407 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R3408 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R3409 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R3410 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R3411 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R3412 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R3413 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R3414 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R3415 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R3416 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R3417 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R3418 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R3419 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R3420 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R3421 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R3422 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R3423 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R3424 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R3425 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R3426 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R3427 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R3428 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R3429 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R3430 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R3431 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R3432 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R3433 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R3434 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R3435 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R3436 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R3437 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R3438 n1_m1_470400_120000 n1_m1_475200_120000 5.356235
R3439 n1_m1_475200_120000 n1_m1_480000_120000 5.356235
R3440 n1_m1_480000_120000 n1_m1_484800_120000 5.356235
R3441 n1_m1_484800_120000 n1_m1_489600_120000 5.356235
R3442 n1_m1_489600_120000 n1_m1_494400_120000 5.356235
R3443 n1_m1_494400_120000 n1_m1_499200_120000 5.356235
R3444 n1_m1_499200_120000 n1_m1_504000_120000 5.356235
R3445 n1_m1_504000_120000 n1_m1_508000_120000 4.463529
R3446 n1_m1_508800_120000 n1_m1_508000_120000 0.892706
R3447 n1_m1_508800_120000 n1_m1_513600_120000 5.356235
R3448 n1_m1_513600_120000 n1_m1_518400_120000 5.356235
R3449 n1_m1_518400_120000 n1_m1_523200_120000 5.356235
R3450 n1_m1_523200_120000 n1_m1_528000_120000 5.356235
R3451 n1_m1_528000_120000 n1_m1_532800_120000 5.356235
R3452 n1_m1_532800_120000 n1_m1_536000_120000 3.570824
R3453 n1_m1_537600_120000 n1_m1_536000_120000 1.785412
R3454 n1_m1_537600_120000 n1_m1_542400_120000 5.356235
R3455 n1_m1_542400_120000 n1_m1_547200_120000 5.356235
R3456 n1_m1_547200_120000 n1_m1_552000_120000 5.356235
R3457 n1_m1_552000_120000 n1_m1_556800_120000 5.356235
R3458 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R3459 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R3460 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R3461 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R3462 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R3463 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R3464 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R3465 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R3466 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R3467 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R3468 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R3469 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R3470 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R3471 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R3472 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R3473 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R3474 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R3475 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R3476 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R3477 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R3478 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R3479 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R3480 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R3481 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R3482 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R3483 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R3484 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R3485 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R3486 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R3487 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R3488 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R3489 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R3490 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R3491 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R3492 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R3493 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R3494 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R3495 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R3496 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R3497 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R3498 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R3499 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R3500 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R3501 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R3502 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R3503 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R3504 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R3505 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R3506 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R3507 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R3508 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R3509 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R3510 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R3511 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R3512 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R3513 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R3514 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R3515 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R3516 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R3517 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R3518 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R3519 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3520 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3521 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3522 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3523 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3524 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3525 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3526 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3527 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3528 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3529 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3530 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3531 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3532 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3533 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3534 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3535 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3536 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3537 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3538 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3539 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3540 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3541 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3542 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3543 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3544 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3545 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3546 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3547 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3548 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3549 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3550 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3551 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3552 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3553 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3554 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3555 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3556 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3557 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3558 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3559 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3560 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3561 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3562 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3563 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3564 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3565 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3566 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3567 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3568 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3569 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3570 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3571 n1_m1_470400_124800 n1_m1_475200_124800 5.356235
R3572 n1_m1_475200_124800 n1_m1_480000_124800 5.356235
R3573 n1_m1_480000_124800 n1_m1_484800_124800 5.356235
R3574 n1_m1_484800_124800 n1_m1_489600_124800 5.356235
R3575 n1_m1_489600_124800 n1_m1_494400_124800 5.356235
R3576 n1_m1_494400_124800 n1_m1_499200_124800 5.356235
R3577 n1_m1_499200_124800 n1_m1_504000_124800 5.356235
R3578 n1_m1_504000_124800 n1_m1_508000_124800 4.463529
R3579 n1_m1_508800_124800 n1_m1_508000_124800 0.892706
R3580 n1_m1_508800_124800 n1_m1_513600_124800 5.356235
R3581 n1_m1_513600_124800 n1_m1_518400_124800 5.356235
R3582 n1_m1_518400_124800 n1_m1_523200_124800 5.356235
R3583 n1_m1_523200_124800 n1_m1_528000_124800 5.356235
R3584 n1_m1_528000_124800 n1_m1_532800_124800 5.356235
R3585 n1_m1_532800_124800 n1_m1_536000_124800 3.570824
R3586 n1_m1_537600_124800 n1_m1_536000_124800 1.785412
R3587 n1_m1_537600_124800 n1_m1_542400_124800 5.356235
R3588 n1_m1_542400_124800 n1_m1_547200_124800 5.356235
R3589 n1_m1_547200_124800 n1_m1_552000_124800 5.356235
R3590 n1_m1_552000_124800 n1_m1_556800_124800 5.356235
R3591 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3592 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3593 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3594 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3595 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3596 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3597 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3598 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3599 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3600 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3601 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3602 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3603 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3604 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3605 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3606 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3607 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3608 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3609 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3610 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3611 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3612 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3613 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3614 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3615 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3616 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3617 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3618 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3619 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3620 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3621 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3622 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3623 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3624 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3625 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3626 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3627 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3628 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3629 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3630 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3631 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3632 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3633 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3634 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3635 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3636 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3637 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3638 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3639 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3640 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3641 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3642 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3643 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3644 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3645 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3646 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3647 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3648 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3649 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3650 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3651 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3652 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3653 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3654 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3655 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3656 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3657 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3658 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3659 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3660 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3661 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3662 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3663 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3664 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3665 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3666 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3667 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3668 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3669 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3670 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3671 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3672 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3673 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3674 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3675 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3676 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3677 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3678 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3679 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3680 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3681 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3682 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3683 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3684 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3685 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3686 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3687 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3688 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3689 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3690 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3691 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3692 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3693 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3694 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3695 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3696 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3697 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3698 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3699 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3700 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3701 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3702 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3703 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3704 n1_m1_470400_129600 n1_m1_475200_129600 5.356235
R3705 n1_m1_475200_129600 n1_m1_480000_129600 5.356235
R3706 n1_m1_480000_129600 n1_m1_484800_129600 5.356235
R3707 n1_m1_484800_129600 n1_m1_489600_129600 5.356235
R3708 n1_m1_489600_129600 n1_m1_494400_129600 5.356235
R3709 n1_m1_494400_129600 n1_m1_499200_129600 5.356235
R3710 n1_m1_499200_129600 n1_m1_504000_129600 5.356235
R3711 n1_m1_504000_129600 n1_m1_508000_129600 4.463529
R3712 n1_m1_508800_129600 n1_m1_508000_129600 0.892706
R3713 n1_m1_508800_129600 n1_m1_513600_129600 5.356235
R3714 n1_m1_513600_129600 n1_m1_518400_129600 5.356235
R3715 n1_m1_518400_129600 n1_m1_523200_129600 5.356235
R3716 n1_m1_523200_129600 n1_m1_528000_129600 5.356235
R3717 n1_m1_528000_129600 n1_m1_532800_129600 5.356235
R3718 n1_m1_532800_129600 n1_m1_536000_129600 3.570824
R3719 n1_m1_537600_129600 n1_m1_536000_129600 1.785412
R3720 n1_m1_537600_129600 n1_m1_542400_129600 5.356235
R3721 n1_m1_542400_129600 n1_m1_547200_129600 5.356235
R3722 n1_m1_547200_129600 n1_m1_552000_129600 5.356235
R3723 n1_m1_552000_129600 n1_m1_556800_129600 5.356235
R3724 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R3725 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R3726 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R3727 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R3728 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R3729 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R3730 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R3731 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R3732 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R3733 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R3734 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R3735 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R3736 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R3737 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R3738 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R3739 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R3740 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R3741 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R3742 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R3743 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R3744 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R3745 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R3746 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R3747 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R3748 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R3749 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R3750 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R3751 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R3752 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R3753 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R3754 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R3755 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R3756 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R3757 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R3758 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R3759 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R3760 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R3761 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R3762 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R3763 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R3764 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R3765 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R3766 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R3767 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R3768 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R3769 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R3770 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R3771 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R3772 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R3773 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R3774 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R3775 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R3776 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R3777 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R3778 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R3779 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R3780 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R3781 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R3782 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R3783 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R3784 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R3785 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R3786 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R3787 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R3788 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R3789 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R3790 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R3791 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R3792 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R3793 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R3794 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R3795 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R3796 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R3797 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R3798 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R3799 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R3800 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R3801 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R3802 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R3803 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R3804 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R3805 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R3806 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R3807 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R3808 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R3809 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R3810 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R3811 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R3812 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R3813 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R3814 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R3815 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R3816 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R3817 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R3818 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R3819 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R3820 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R3821 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R3822 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R3823 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R3824 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R3825 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R3826 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R3827 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R3828 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R3829 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R3830 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R3831 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R3832 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R3833 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R3834 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R3835 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R3836 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R3837 n1_m1_470400_134400 n1_m1_475200_134400 5.356235
R3838 n1_m1_475200_134400 n1_m1_480000_134400 5.356235
R3839 n1_m1_480000_134400 n1_m1_484800_134400 5.356235
R3840 n1_m1_484800_134400 n1_m1_489600_134400 5.356235
R3841 n1_m1_489600_134400 n1_m1_494400_134400 5.356235
R3842 n1_m1_494400_134400 n1_m1_499200_134400 5.356235
R3843 n1_m1_499200_134400 n1_m1_504000_134400 5.356235
R3844 n1_m1_504000_134400 n1_m1_508000_134400 4.463529
R3845 n1_m1_508800_134400 n1_m1_508000_134400 0.892706
R3846 n1_m1_508800_134400 n1_m1_513600_134400 5.356235
R3847 n1_m1_513600_134400 n1_m1_518400_134400 5.356235
R3848 n1_m1_518400_134400 n1_m1_523200_134400 5.356235
R3849 n1_m1_523200_134400 n1_m1_528000_134400 5.356235
R3850 n1_m1_528000_134400 n1_m1_532800_134400 5.356235
R3851 n1_m1_532800_134400 n1_m1_536000_134400 3.570824
R3852 n1_m1_537600_134400 n1_m1_536000_134400 1.785412
R3853 n1_m1_537600_134400 n1_m1_542400_134400 5.356235
R3854 n1_m1_542400_134400 n1_m1_547200_134400 5.356235
R3855 n1_m1_547200_134400 n1_m1_552000_134400 5.356235
R3856 n1_m1_552000_134400 n1_m1_556800_134400 5.356235
R3857 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R3858 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R3859 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R3860 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R3861 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R3862 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R3863 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R3864 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R3865 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R3866 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R3867 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R3868 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R3869 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R3870 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R3871 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R3872 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R3873 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R3874 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R3875 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R3876 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R3877 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R3878 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R3879 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R3880 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R3881 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R3882 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R3883 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R3884 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R3885 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R3886 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R3887 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R3888 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R3889 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R3890 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R3891 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R3892 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R3893 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R3894 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R3895 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R3896 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R3897 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R3898 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R3899 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R3900 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R3901 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R3902 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R3903 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R3904 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R3905 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R3906 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R3907 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R3908 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R3909 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R3910 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R3911 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R3912 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R3913 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R3914 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R3915 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R3916 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R3917 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R3918 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R3919 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R3920 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R3921 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R3922 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R3923 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R3924 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R3925 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R3926 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R3927 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R3928 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R3929 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R3930 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R3931 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R3932 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R3933 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R3934 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R3935 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R3936 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R3937 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R3938 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R3939 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R3940 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R3941 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R3942 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R3943 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R3944 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R3945 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R3946 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R3947 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R3948 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R3949 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R3950 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R3951 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R3952 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R3953 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R3954 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R3955 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R3956 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R3957 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R3958 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R3959 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R3960 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R3961 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R3962 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R3963 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R3964 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R3965 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R3966 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R3967 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R3968 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R3969 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R3970 n1_m1_470400_139200 n1_m1_475200_139200 5.356235
R3971 n1_m1_475200_139200 n1_m1_480000_139200 5.356235
R3972 n1_m1_480000_139200 n1_m1_484800_139200 5.356235
R3973 n1_m1_484800_139200 n1_m1_489600_139200 5.356235
R3974 n1_m1_489600_139200 n1_m1_494400_139200 5.356235
R3975 n1_m1_494400_139200 n1_m1_499200_139200 5.356235
R3976 n1_m1_499200_139200 n1_m1_504000_139200 5.356235
R3977 n1_m1_504000_139200 n1_m1_508000_139200 4.463529
R3978 n1_m1_508800_139200 n1_m1_508000_139200 0.892706
R3979 n1_m1_508800_139200 n1_m1_513600_139200 5.356235
R3980 n1_m1_513600_139200 n1_m1_518400_139200 5.356235
R3981 n1_m1_518400_139200 n1_m1_523200_139200 5.356235
R3982 n1_m1_523200_139200 n1_m1_528000_139200 5.356235
R3983 n1_m1_528000_139200 n1_m1_532800_139200 5.356235
R3984 n1_m1_532800_139200 n1_m1_536000_139200 3.570824
R3985 n1_m1_537600_139200 n1_m1_536000_139200 1.785412
R3986 n1_m1_537600_139200 n1_m1_542400_139200 5.356235
R3987 n1_m1_542400_139200 n1_m1_547200_139200 5.356235
R3988 n1_m1_547200_139200 n1_m1_552000_139200 5.356235
R3989 n1_m1_552000_139200 n1_m1_556800_139200 5.356235
R3990 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R3991 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R3992 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R3993 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R3994 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R3995 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R3996 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R3997 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R3998 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R3999 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R4000 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R4001 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R4002 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R4003 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R4004 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R4005 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R4006 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R4007 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R4008 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R4009 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R4010 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R4011 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R4012 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R4013 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R4014 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R4015 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R4016 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R4017 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R4018 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R4019 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R4020 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R4021 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R4022 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R4023 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R4024 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R4025 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R4026 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R4027 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R4028 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R4029 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R4030 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R4031 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R4032 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R4033 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R4034 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R4035 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R4036 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R4037 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R4038 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R4039 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R4040 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R4041 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R4042 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R4043 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R4044 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R4045 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R4046 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R4047 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R4048 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R4049 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R4050 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R4051 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R4052 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R4053 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R4054 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R4055 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R4056 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R4057 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R4058 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R4059 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R4060 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R4061 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R4062 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R4063 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R4064 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R4065 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R4066 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R4067 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R4068 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R4069 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R4070 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R4071 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R4072 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R4073 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R4074 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R4075 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R4076 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R4077 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R4078 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R4079 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R4080 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R4081 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R4082 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R4083 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R4084 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R4085 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R4086 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R4087 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R4088 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R4089 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R4090 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R4091 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R4092 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R4093 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R4094 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R4095 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R4096 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R4097 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R4098 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R4099 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R4100 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R4101 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R4102 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R4103 n1_m1_470400_144000 n1_m1_475200_144000 5.356235
R4104 n1_m1_475200_144000 n1_m1_480000_144000 5.356235
R4105 n1_m1_480000_144000 n1_m1_484800_144000 5.356235
R4106 n1_m1_484800_144000 n1_m1_489600_144000 5.356235
R4107 n1_m1_489600_144000 n1_m1_494400_144000 5.356235
R4108 n1_m1_494400_144000 n1_m1_499200_144000 5.356235
R4109 n1_m1_499200_144000 n1_m1_504000_144000 5.356235
R4110 n1_m1_504000_144000 n1_m1_508000_144000 4.463529
R4111 n1_m1_508800_144000 n1_m1_508000_144000 0.892706
R4112 n1_m1_508800_144000 n1_m1_513600_144000 5.356235
R4113 n1_m1_513600_144000 n1_m1_518400_144000 5.356235
R4114 n1_m1_518400_144000 n1_m1_523200_144000 5.356235
R4115 n1_m1_523200_144000 n1_m1_528000_144000 5.356235
R4116 n1_m1_528000_144000 n1_m1_532800_144000 5.356235
R4117 n1_m1_532800_144000 n1_m1_536000_144000 3.570824
R4118 n1_m1_537600_144000 n1_m1_536000_144000 1.785412
R4119 n1_m1_537600_144000 n1_m1_542400_144000 5.356235
R4120 n1_m1_542400_144000 n1_m1_547200_144000 5.356235
R4121 n1_m1_547200_144000 n1_m1_552000_144000 5.356235
R4122 n1_m1_552000_144000 n1_m1_556800_144000 5.356235
R4123 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R4124 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R4125 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R4126 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R4127 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R4128 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R4129 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R4130 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R4131 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R4132 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R4133 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R4134 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R4135 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R4136 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R4137 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R4138 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R4139 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R4140 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R4141 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R4142 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R4143 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R4144 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R4145 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R4146 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R4147 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R4148 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R4149 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R4150 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R4151 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R4152 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R4153 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R4154 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R4155 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R4156 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R4157 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R4158 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R4159 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R4160 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R4161 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R4162 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R4163 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R4164 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R4165 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R4166 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R4167 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R4168 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R4169 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R4170 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R4171 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R4172 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R4173 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R4174 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R4175 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R4176 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R4177 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R4178 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R4179 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R4180 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R4181 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R4182 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R4183 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R4184 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R4185 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R4186 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R4187 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R4188 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R4189 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R4190 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R4191 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R4192 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R4193 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R4194 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R4195 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R4196 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R4197 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R4198 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R4199 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R4200 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R4201 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R4202 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R4203 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R4204 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R4205 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R4206 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R4207 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R4208 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R4209 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R4210 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R4211 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R4212 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R4213 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R4214 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R4215 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R4216 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R4217 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R4218 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R4219 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R4220 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R4221 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R4222 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R4223 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R4224 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R4225 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R4226 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R4227 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R4228 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R4229 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R4230 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R4231 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R4232 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R4233 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R4234 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R4235 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R4236 n1_m1_470400_148800 n1_m1_475200_148800 5.356235
R4237 n1_m1_475200_148800 n1_m1_480000_148800 5.356235
R4238 n1_m1_480000_148800 n1_m1_484800_148800 5.356235
R4239 n1_m1_484800_148800 n1_m1_489600_148800 5.356235
R4240 n1_m1_489600_148800 n1_m1_494400_148800 5.356235
R4241 n1_m1_494400_148800 n1_m1_499200_148800 5.356235
R4242 n1_m1_499200_148800 n1_m1_504000_148800 5.356235
R4243 n1_m1_504000_148800 n1_m1_508000_148800 4.463529
R4244 n1_m1_508800_148800 n1_m1_508000_148800 0.892706
R4245 n1_m1_508800_148800 n1_m1_513600_148800 5.356235
R4246 n1_m1_513600_148800 n1_m1_518400_148800 5.356235
R4247 n1_m1_518400_148800 n1_m1_523200_148800 5.356235
R4248 n1_m1_523200_148800 n1_m1_528000_148800 5.356235
R4249 n1_m1_528000_148800 n1_m1_532800_148800 5.356235
R4250 n1_m1_532800_148800 n1_m1_536000_148800 3.570824
R4251 n1_m1_537600_148800 n1_m1_536000_148800 1.785412
R4252 n1_m1_537600_148800 n1_m1_542400_148800 5.356235
R4253 n1_m1_542400_148800 n1_m1_547200_148800 5.356235
R4254 n1_m1_547200_148800 n1_m1_552000_148800 5.356235
R4255 n1_m1_552000_148800 n1_m1_556800_148800 5.356235
R4256 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R4257 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R4258 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R4259 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R4260 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R4261 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R4262 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R4263 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R4264 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R4265 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R4266 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R4267 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R4268 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R4269 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R4270 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R4271 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R4272 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R4273 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R4274 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R4275 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R4276 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R4277 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R4278 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R4279 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R4280 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R4281 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R4282 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R4283 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R4284 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R4285 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R4286 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R4287 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R4288 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R4289 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R4290 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R4291 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R4292 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R4293 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R4294 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R4295 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R4296 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R4297 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R4298 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R4299 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R4300 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R4301 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R4302 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R4303 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R4304 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R4305 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R4306 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R4307 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R4308 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R4309 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R4310 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R4311 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R4312 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R4313 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R4314 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R4315 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R4316 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R4317 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R4318 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R4319 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R4320 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R4321 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R4322 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R4323 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R4324 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R4325 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R4326 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R4327 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R4328 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R4329 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R4330 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R4331 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R4332 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R4333 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R4334 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R4335 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R4336 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R4337 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R4338 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R4339 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R4340 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R4341 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R4342 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R4343 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R4344 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R4345 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R4346 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R4347 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R4348 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R4349 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R4350 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R4351 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R4352 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R4353 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R4354 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R4355 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R4356 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R4357 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R4358 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R4359 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R4360 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R4361 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R4362 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R4363 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R4364 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R4365 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R4366 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R4367 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R4368 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R4369 n1_m1_470400_153600 n1_m1_475200_153600 5.356235
R4370 n1_m1_475200_153600 n1_m1_480000_153600 5.356235
R4371 n1_m1_480000_153600 n1_m1_484800_153600 5.356235
R4372 n1_m1_484800_153600 n1_m1_489600_153600 5.356235
R4373 n1_m1_489600_153600 n1_m1_494400_153600 5.356235
R4374 n1_m1_494400_153600 n1_m1_499200_153600 5.356235
R4375 n1_m1_499200_153600 n1_m1_504000_153600 5.356235
R4376 n1_m1_504000_153600 n1_m1_508000_153600 4.463529
R4377 n1_m1_508800_153600 n1_m1_508000_153600 0.892706
R4378 n1_m1_508800_153600 n1_m1_513600_153600 5.356235
R4379 n1_m1_513600_153600 n1_m1_518400_153600 5.356235
R4380 n1_m1_518400_153600 n1_m1_523200_153600 5.356235
R4381 n1_m1_523200_153600 n1_m1_528000_153600 5.356235
R4382 n1_m1_528000_153600 n1_m1_532800_153600 5.356235
R4383 n1_m1_532800_153600 n1_m1_536000_153600 3.570824
R4384 n1_m1_537600_153600 n1_m1_536000_153600 1.785412
R4385 n1_m1_537600_153600 n1_m1_542400_153600 5.356235
R4386 n1_m1_542400_153600 n1_m1_547200_153600 5.356235
R4387 n1_m1_547200_153600 n1_m1_552000_153600 5.356235
R4388 n1_m1_552000_153600 n1_m1_556800_153600 5.356235
R4389 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R4390 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R4391 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R4392 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R4393 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R4394 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R4395 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R4396 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R4397 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R4398 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R4399 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R4400 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R4401 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R4402 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R4403 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R4404 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R4405 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R4406 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R4407 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R4408 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R4409 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R4410 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R4411 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R4412 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R4413 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R4414 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R4415 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R4416 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R4417 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R4418 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R4419 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R4420 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R4421 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R4422 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R4423 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R4424 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R4425 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R4426 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R4427 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R4428 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R4429 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R4430 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R4431 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R4432 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R4433 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R4434 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R4435 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R4436 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R4437 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R4438 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R4439 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R4440 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R4441 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R4442 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R4443 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R4444 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R4445 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R4446 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R4447 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R4448 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R4449 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R4450 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R4451 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R4452 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R4453 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R4454 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R4455 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R4456 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R4457 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R4458 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R4459 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R4460 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R4461 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R4462 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R4463 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R4464 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R4465 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R4466 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R4467 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R4468 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R4469 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R4470 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R4471 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R4472 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R4473 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R4474 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R4475 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R4476 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R4477 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R4478 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R4479 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R4480 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R4481 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R4482 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R4483 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R4484 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R4485 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R4486 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R4487 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R4488 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R4489 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R4490 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R4491 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R4492 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R4493 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R4494 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R4495 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R4496 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R4497 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R4498 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R4499 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R4500 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R4501 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R4502 n1_m1_470400_158400 n1_m1_475200_158400 5.356235
R4503 n1_m1_475200_158400 n1_m1_480000_158400 5.356235
R4504 n1_m1_480000_158400 n1_m1_484800_158400 5.356235
R4505 n1_m1_484800_158400 n1_m1_489600_158400 5.356235
R4506 n1_m1_489600_158400 n1_m1_494400_158400 5.356235
R4507 n1_m1_494400_158400 n1_m1_499200_158400 5.356235
R4508 n1_m1_499200_158400 n1_m1_504000_158400 5.356235
R4509 n1_m1_504000_158400 n1_m1_508000_158400 4.463529
R4510 n1_m1_508800_158400 n1_m1_508000_158400 0.892706
R4511 n1_m1_508800_158400 n1_m1_513600_158400 5.356235
R4512 n1_m1_513600_158400 n1_m1_518400_158400 5.356235
R4513 n1_m1_518400_158400 n1_m1_523200_158400 5.356235
R4514 n1_m1_523200_158400 n1_m1_528000_158400 5.356235
R4515 n1_m1_528000_158400 n1_m1_532800_158400 5.356235
R4516 n1_m1_532800_158400 n1_m1_536000_158400 3.570824
R4517 n1_m1_537600_158400 n1_m1_536000_158400 1.785412
R4518 n1_m1_537600_158400 n1_m1_542400_158400 5.356235
R4519 n1_m1_542400_158400 n1_m1_547200_158400 5.356235
R4520 n1_m1_547200_158400 n1_m1_552000_158400 5.356235
R4521 n1_m1_552000_158400 n1_m1_556800_158400 5.356235
R4522 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R4523 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R4524 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R4525 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R4526 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R4527 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R4528 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R4529 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R4530 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R4531 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R4532 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R4533 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R4534 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R4535 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R4536 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R4537 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R4538 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R4539 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R4540 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R4541 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R4542 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R4543 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R4544 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R4545 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R4546 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R4547 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R4548 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R4549 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R4550 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R4551 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R4552 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R4553 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R4554 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R4555 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R4556 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R4557 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R4558 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R4559 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R4560 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R4561 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R4562 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R4563 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R4564 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R4565 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R4566 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R4567 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R4568 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R4569 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R4570 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R4571 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R4572 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R4573 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R4574 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R4575 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R4576 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R4577 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R4578 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R4579 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R4580 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R4581 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R4582 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R4583 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R4584 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R4585 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R4586 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R4587 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R4588 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R4589 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R4590 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R4591 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R4592 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R4593 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R4594 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R4595 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R4596 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R4597 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R4598 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R4599 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R4600 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R4601 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R4602 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R4603 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R4604 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R4605 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R4606 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R4607 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R4608 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R4609 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R4610 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R4611 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R4612 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R4613 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R4614 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R4615 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R4616 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R4617 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R4618 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R4619 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R4620 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R4621 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R4622 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R4623 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R4624 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R4625 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R4626 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R4627 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R4628 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R4629 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R4630 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R4631 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R4632 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R4633 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R4634 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R4635 n1_m1_470400_163200 n1_m1_475200_163200 5.356235
R4636 n1_m1_475200_163200 n1_m1_480000_163200 5.356235
R4637 n1_m1_480000_163200 n1_m1_484800_163200 5.356235
R4638 n1_m1_484800_163200 n1_m1_489600_163200 5.356235
R4639 n1_m1_489600_163200 n1_m1_494400_163200 5.356235
R4640 n1_m1_494400_163200 n1_m1_499200_163200 5.356235
R4641 n1_m1_499200_163200 n1_m1_504000_163200 5.356235
R4642 n1_m1_504000_163200 n1_m1_508000_163200 4.463529
R4643 n1_m1_508800_163200 n1_m1_508000_163200 0.892706
R4644 n1_m1_508800_163200 n1_m1_513600_163200 5.356235
R4645 n1_m1_513600_163200 n1_m1_518400_163200 5.356235
R4646 n1_m1_518400_163200 n1_m1_523200_163200 5.356235
R4647 n1_m1_523200_163200 n1_m1_528000_163200 5.356235
R4648 n1_m1_528000_163200 n1_m1_532800_163200 5.356235
R4649 n1_m1_532800_163200 n1_m1_536000_163200 3.570824
R4650 n1_m1_537600_163200 n1_m1_536000_163200 1.785412
R4651 n1_m1_537600_163200 n1_m1_542400_163200 5.356235
R4652 n1_m1_542400_163200 n1_m1_547200_163200 5.356235
R4653 n1_m1_547200_163200 n1_m1_552000_163200 5.356235
R4654 n1_m1_552000_163200 n1_m1_556800_163200 5.356235
R4655 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R4656 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R4657 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R4658 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R4659 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R4660 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R4661 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R4662 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R4663 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R4664 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R4665 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R4666 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R4667 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R4668 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R4669 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R4670 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R4671 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R4672 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R4673 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R4674 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R4675 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R4676 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R4677 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R4678 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R4679 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R4680 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R4681 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R4682 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R4683 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R4684 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R4685 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R4686 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R4687 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R4688 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R4689 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R4690 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R4691 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R4692 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R4693 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R4694 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R4695 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R4696 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R4697 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R4698 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R4699 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R4700 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R4701 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R4702 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R4703 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R4704 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R4705 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R4706 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R4707 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R4708 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R4709 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R4710 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R4711 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R4712 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R4713 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R4714 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R4715 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R4716 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R4717 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R4718 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R4719 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R4720 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R4721 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R4722 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R4723 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R4724 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R4725 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R4726 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R4727 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R4728 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R4729 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R4730 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R4731 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R4732 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R4733 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R4734 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R4735 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R4736 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R4737 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R4738 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R4739 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R4740 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R4741 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R4742 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R4743 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R4744 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R4745 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R4746 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R4747 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R4748 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R4749 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R4750 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R4751 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R4752 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R4753 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R4754 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R4755 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R4756 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R4757 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R4758 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R4759 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R4760 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R4761 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R4762 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R4763 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R4764 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R4765 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R4766 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R4767 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R4768 n1_m1_470400_168000 n1_m1_475200_168000 5.356235
R4769 n1_m1_475200_168000 n1_m1_480000_168000 5.356235
R4770 n1_m1_480000_168000 n1_m1_484800_168000 5.356235
R4771 n1_m1_484800_168000 n1_m1_489600_168000 5.356235
R4772 n1_m1_489600_168000 n1_m1_494400_168000 5.356235
R4773 n1_m1_494400_168000 n1_m1_499200_168000 5.356235
R4774 n1_m1_499200_168000 n1_m1_504000_168000 5.356235
R4775 n1_m1_504000_168000 n1_m1_508000_168000 4.463529
R4776 n1_m1_508800_168000 n1_m1_508000_168000 0.892706
R4777 n1_m1_508800_168000 n1_m1_513600_168000 5.356235
R4778 n1_m1_513600_168000 n1_m1_518400_168000 5.356235
R4779 n1_m1_518400_168000 n1_m1_523200_168000 5.356235
R4780 n1_m1_523200_168000 n1_m1_528000_168000 5.356235
R4781 n1_m1_528000_168000 n1_m1_532800_168000 5.356235
R4782 n1_m1_532800_168000 n1_m1_536000_168000 3.570824
R4783 n1_m1_537600_168000 n1_m1_536000_168000 1.785412
R4784 n1_m1_537600_168000 n1_m1_542400_168000 5.356235
R4785 n1_m1_542400_168000 n1_m1_547200_168000 5.356235
R4786 n1_m1_547200_168000 n1_m1_552000_168000 5.356235
R4787 n1_m1_552000_168000 n1_m1_556800_168000 5.356235
R4788 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R4789 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R4790 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R4791 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R4792 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R4793 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R4794 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R4795 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R4796 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R4797 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R4798 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R4799 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R4800 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R4801 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R4802 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R4803 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R4804 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R4805 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R4806 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R4807 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R4808 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R4809 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R4810 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R4811 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R4812 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R4813 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R4814 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R4815 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R4816 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R4817 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R4818 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R4819 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R4820 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R4821 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R4822 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R4823 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R4824 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R4825 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R4826 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R4827 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R4828 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R4829 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R4830 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R4831 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R4832 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R4833 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R4834 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R4835 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R4836 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R4837 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R4838 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R4839 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R4840 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R4841 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R4842 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R4843 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R4844 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R4845 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R4846 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R4847 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R4848 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R4849 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R4850 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R4851 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R4852 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R4853 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R4854 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R4855 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R4856 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R4857 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R4858 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R4859 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R4860 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R4861 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R4862 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R4863 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R4864 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R4865 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R4866 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R4867 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R4868 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R4869 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R4870 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R4871 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R4872 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R4873 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R4874 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R4875 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R4876 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R4877 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R4878 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R4879 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R4880 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R4881 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R4882 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R4883 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R4884 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R4885 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R4886 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R4887 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R4888 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R4889 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R4890 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R4891 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R4892 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R4893 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R4894 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R4895 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R4896 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R4897 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R4898 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R4899 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R4900 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R4901 n1_m1_470400_172800 n1_m1_475200_172800 5.356235
R4902 n1_m1_475200_172800 n1_m1_480000_172800 5.356235
R4903 n1_m1_480000_172800 n1_m1_484800_172800 5.356235
R4904 n1_m1_484800_172800 n1_m1_489600_172800 5.356235
R4905 n1_m1_489600_172800 n1_m1_494400_172800 5.356235
R4906 n1_m1_494400_172800 n1_m1_499200_172800 5.356235
R4907 n1_m1_499200_172800 n1_m1_504000_172800 5.356235
R4908 n1_m1_504000_172800 n1_m1_508000_172800 4.463529
R4909 n1_m1_508800_172800 n1_m1_508000_172800 0.892706
R4910 n1_m1_508800_172800 n1_m1_513600_172800 5.356235
R4911 n1_m1_513600_172800 n1_m1_518400_172800 5.356235
R4912 n1_m1_518400_172800 n1_m1_523200_172800 5.356235
R4913 n1_m1_523200_172800 n1_m1_528000_172800 5.356235
R4914 n1_m1_528000_172800 n1_m1_532800_172800 5.356235
R4915 n1_m1_532800_172800 n1_m1_536000_172800 3.570824
R4916 n1_m1_537600_172800 n1_m1_536000_172800 1.785412
R4917 n1_m1_537600_172800 n1_m1_542400_172800 5.356235
R4918 n1_m1_542400_172800 n1_m1_547200_172800 5.356235
R4919 n1_m1_547200_172800 n1_m1_552000_172800 5.356235
R4920 n1_m1_552000_172800 n1_m1_556800_172800 5.356235
R4921 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R4922 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R4923 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R4924 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R4925 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R4926 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R4927 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R4928 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R4929 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R4930 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R4931 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R4932 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R4933 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R4934 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R4935 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R4936 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R4937 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R4938 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R4939 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R4940 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R4941 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R4942 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R4943 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R4944 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R4945 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R4946 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R4947 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R4948 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R4949 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R4950 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R4951 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R4952 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R4953 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R4954 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R4955 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R4956 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R4957 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R4958 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R4959 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R4960 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R4961 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R4962 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R4963 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R4964 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R4965 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R4966 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R4967 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R4968 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R4969 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R4970 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R4971 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R4972 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R4973 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R4974 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R4975 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R4976 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R4977 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R4978 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R4979 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R4980 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R4981 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R4982 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R4983 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R4984 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R4985 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R4986 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R4987 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R4988 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R4989 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R4990 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R4991 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R4992 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R4993 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R4994 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R4995 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R4996 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R4997 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R4998 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R4999 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R5000 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R5001 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R5002 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R5003 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R5004 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R5005 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R5006 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R5007 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R5008 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R5009 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R5010 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R5011 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R5012 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R5013 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R5014 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R5015 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R5016 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R5017 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R5018 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R5019 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R5020 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R5021 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R5022 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R5023 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R5024 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R5025 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R5026 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R5027 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R5028 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R5029 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R5030 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R5031 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R5032 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R5033 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R5034 n1_m1_470400_177600 n1_m1_475200_177600 5.356235
R5035 n1_m1_475200_177600 n1_m1_480000_177600 5.356235
R5036 n1_m1_480000_177600 n1_m1_484800_177600 5.356235
R5037 n1_m1_484800_177600 n1_m1_489600_177600 5.356235
R5038 n1_m1_489600_177600 n1_m1_494400_177600 5.356235
R5039 n1_m1_494400_177600 n1_m1_499200_177600 5.356235
R5040 n1_m1_499200_177600 n1_m1_504000_177600 5.356235
R5041 n1_m1_504000_177600 n1_m1_508000_177600 4.463529
R5042 n1_m1_508800_177600 n1_m1_508000_177600 0.892706
R5043 n1_m1_508800_177600 n1_m1_513600_177600 5.356235
R5044 n1_m1_513600_177600 n1_m1_518400_177600 5.356235
R5045 n1_m1_518400_177600 n1_m1_523200_177600 5.356235
R5046 n1_m1_523200_177600 n1_m1_528000_177600 5.356235
R5047 n1_m1_528000_177600 n1_m1_532800_177600 5.356235
R5048 n1_m1_532800_177600 n1_m1_536000_177600 3.570824
R5049 n1_m1_537600_177600 n1_m1_536000_177600 1.785412
R5050 n1_m1_537600_177600 n1_m1_542400_177600 5.356235
R5051 n1_m1_542400_177600 n1_m1_547200_177600 5.356235
R5052 n1_m1_547200_177600 n1_m1_552000_177600 5.356235
R5053 n1_m1_552000_177600 n1_m1_556800_177600 5.356235
R5054 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R5055 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R5056 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R5057 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R5058 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R5059 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R5060 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R5061 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R5062 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R5063 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R5064 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R5065 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R5066 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R5067 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R5068 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R5069 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R5070 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R5071 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R5072 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R5073 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R5074 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R5075 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R5076 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R5077 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R5078 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R5079 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R5080 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R5081 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R5082 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R5083 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R5084 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R5085 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R5086 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R5087 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R5088 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R5089 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R5090 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R5091 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R5092 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R5093 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R5094 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R5095 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R5096 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R5097 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R5098 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R5099 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R5100 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R5101 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R5102 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R5103 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R5104 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R5105 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R5106 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R5107 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R5108 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R5109 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R5110 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R5111 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R5112 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R5113 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R5114 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R5115 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R5116 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R5117 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R5118 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R5119 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R5120 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R5121 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R5122 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R5123 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R5124 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R5125 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R5126 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R5127 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R5128 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R5129 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R5130 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R5131 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R5132 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R5133 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R5134 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R5135 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R5136 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R5137 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R5138 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R5139 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R5140 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R5141 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R5142 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R5143 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R5144 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R5145 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R5146 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R5147 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R5148 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R5149 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R5150 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R5151 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R5152 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R5153 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R5154 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R5155 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R5156 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R5157 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R5158 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R5159 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R5160 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R5161 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R5162 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R5163 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R5164 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R5165 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R5166 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R5167 n1_m1_470400_182400 n1_m1_475200_182400 5.356235
R5168 n1_m1_475200_182400 n1_m1_480000_182400 5.356235
R5169 n1_m1_480000_182400 n1_m1_484800_182400 5.356235
R5170 n1_m1_484800_182400 n1_m1_489600_182400 5.356235
R5171 n1_m1_489600_182400 n1_m1_494400_182400 5.356235
R5172 n1_m1_494400_182400 n1_m1_499200_182400 5.356235
R5173 n1_m1_499200_182400 n1_m1_504000_182400 5.356235
R5174 n1_m1_504000_182400 n1_m1_508000_182400 4.463529
R5175 n1_m1_508800_182400 n1_m1_508000_182400 0.892706
R5176 n1_m1_508800_182400 n1_m1_513600_182400 5.356235
R5177 n1_m1_513600_182400 n1_m1_518400_182400 5.356235
R5178 n1_m1_518400_182400 n1_m1_523200_182400 5.356235
R5179 n1_m1_523200_182400 n1_m1_528000_182400 5.356235
R5180 n1_m1_528000_182400 n1_m1_532800_182400 5.356235
R5181 n1_m1_532800_182400 n1_m1_536000_182400 3.570824
R5182 n1_m1_537600_182400 n1_m1_536000_182400 1.785412
R5183 n1_m1_537600_182400 n1_m1_542400_182400 5.356235
R5184 n1_m1_542400_182400 n1_m1_547200_182400 5.356235
R5185 n1_m1_547200_182400 n1_m1_552000_182400 5.356235
R5186 n1_m1_552000_182400 n1_m1_556800_182400 5.356235
R5187 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R5188 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R5189 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R5190 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R5191 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R5192 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R5193 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R5194 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R5195 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R5196 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R5197 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R5198 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R5199 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R5200 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R5201 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R5202 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R5203 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R5204 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R5205 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R5206 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R5207 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R5208 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R5209 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R5210 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R5211 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R5212 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R5213 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R5214 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R5215 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R5216 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R5217 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R5218 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R5219 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R5220 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R5221 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R5222 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R5223 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R5224 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R5225 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R5226 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R5227 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R5228 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R5229 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R5230 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R5231 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R5232 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R5233 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R5234 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R5235 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R5236 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R5237 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R5238 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R5239 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R5240 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R5241 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R5242 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R5243 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R5244 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R5245 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R5246 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R5247 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R5248 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R5249 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R5250 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R5251 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R5252 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R5253 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R5254 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R5255 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R5256 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R5257 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R5258 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R5259 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R5260 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R5261 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R5262 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R5263 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R5264 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R5265 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R5266 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R5267 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R5268 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R5269 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R5270 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R5271 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R5272 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R5273 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R5274 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R5275 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R5276 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R5277 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R5278 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R5279 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R5280 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R5281 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R5282 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R5283 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R5284 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R5285 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R5286 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R5287 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R5288 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R5289 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R5290 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R5291 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R5292 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R5293 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R5294 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R5295 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R5296 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R5297 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R5298 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R5299 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R5300 n1_m1_470400_187200 n1_m1_475200_187200 5.356235
R5301 n1_m1_475200_187200 n1_m1_480000_187200 5.356235
R5302 n1_m1_480000_187200 n1_m1_484800_187200 5.356235
R5303 n1_m1_484800_187200 n1_m1_489600_187200 5.356235
R5304 n1_m1_489600_187200 n1_m1_494400_187200 5.356235
R5305 n1_m1_494400_187200 n1_m1_499200_187200 5.356235
R5306 n1_m1_499200_187200 n1_m1_504000_187200 5.356235
R5307 n1_m1_504000_187200 n1_m1_508000_187200 4.463529
R5308 n1_m1_508800_187200 n1_m1_508000_187200 0.892706
R5309 n1_m1_508800_187200 n1_m1_513600_187200 5.356235
R5310 n1_m1_513600_187200 n1_m1_518400_187200 5.356235
R5311 n1_m1_518400_187200 n1_m1_523200_187200 5.356235
R5312 n1_m1_523200_187200 n1_m1_528000_187200 5.356235
R5313 n1_m1_528000_187200 n1_m1_532800_187200 5.356235
R5314 n1_m1_532800_187200 n1_m1_536000_187200 3.570824
R5315 n1_m1_537600_187200 n1_m1_536000_187200 1.785412
R5316 n1_m1_537600_187200 n1_m1_542400_187200 5.356235
R5317 n1_m1_542400_187200 n1_m1_547200_187200 5.356235
R5318 n1_m1_547200_187200 n1_m1_552000_187200 5.356235
R5319 n1_m1_552000_187200 n1_m1_556800_187200 5.356235
R5320 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R5321 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R5322 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R5323 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R5324 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R5325 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R5326 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R5327 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R5328 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R5329 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R5330 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R5331 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R5332 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R5333 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R5334 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R5335 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R5336 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R5337 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R5338 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R5339 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R5340 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R5341 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R5342 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R5343 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R5344 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R5345 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R5346 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R5347 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R5348 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R5349 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R5350 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R5351 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R5352 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R5353 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R5354 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R5355 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R5356 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R5357 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R5358 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R5359 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R5360 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R5361 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R5362 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R5363 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R5364 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R5365 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R5366 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R5367 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R5368 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R5369 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R5370 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R5371 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R5372 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R5373 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R5374 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R5375 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R5376 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R5377 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R5378 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R5379 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R5380 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R5381 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R5382 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R5383 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R5384 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R5385 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R5386 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R5387 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R5388 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R5389 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R5390 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R5391 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R5392 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R5393 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R5394 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R5395 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R5396 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R5397 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R5398 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R5399 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R5400 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R5401 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R5402 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R5403 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R5404 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R5405 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R5406 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R5407 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R5408 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R5409 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R5410 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R5411 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R5412 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R5413 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R5414 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R5415 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R5416 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R5417 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R5418 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R5419 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R5420 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R5421 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R5422 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R5423 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R5424 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R5425 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R5426 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R5427 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R5428 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R5429 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R5430 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R5431 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R5432 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R5433 n1_m1_470400_192000 n1_m1_475200_192000 5.356235
R5434 n1_m1_475200_192000 n1_m1_480000_192000 5.356235
R5435 n1_m1_480000_192000 n1_m1_484800_192000 5.356235
R5436 n1_m1_484800_192000 n1_m1_489600_192000 5.356235
R5437 n1_m1_489600_192000 n1_m1_494400_192000 5.356235
R5438 n1_m1_494400_192000 n1_m1_499200_192000 5.356235
R5439 n1_m1_499200_192000 n1_m1_504000_192000 5.356235
R5440 n1_m1_504000_192000 n1_m1_508000_192000 4.463529
R5441 n1_m1_508800_192000 n1_m1_508000_192000 0.892706
R5442 n1_m1_508800_192000 n1_m1_513600_192000 5.356235
R5443 n1_m1_513600_192000 n1_m1_518400_192000 5.356235
R5444 n1_m1_518400_192000 n1_m1_523200_192000 5.356235
R5445 n1_m1_523200_192000 n1_m1_528000_192000 5.356235
R5446 n1_m1_528000_192000 n1_m1_532800_192000 5.356235
R5447 n1_m1_532800_192000 n1_m1_536000_192000 3.570824
R5448 n1_m1_537600_192000 n1_m1_536000_192000 1.785412
R5449 n1_m1_537600_192000 n1_m1_542400_192000 5.356235
R5450 n1_m1_542400_192000 n1_m1_547200_192000 5.356235
R5451 n1_m1_547200_192000 n1_m1_552000_192000 5.356235
R5452 n1_m1_552000_192000 n1_m1_556800_192000 5.356235
R5453 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R5454 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R5455 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R5456 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R5457 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R5458 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R5459 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R5460 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R5461 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R5462 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R5463 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R5464 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R5465 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R5466 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R5467 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R5468 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R5469 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R5470 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R5471 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R5472 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R5473 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R5474 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R5475 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R5476 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R5477 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R5478 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R5479 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R5480 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R5481 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R5482 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R5483 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R5484 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R5485 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R5486 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R5487 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R5488 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R5489 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R5490 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R5491 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R5492 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R5493 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R5494 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R5495 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R5496 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R5497 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R5498 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R5499 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R5500 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R5501 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R5502 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R5503 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R5504 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R5505 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R5506 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R5507 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R5508 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R5509 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R5510 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R5511 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R5512 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R5513 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R5514 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R5515 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R5516 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R5517 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R5518 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R5519 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R5520 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R5521 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R5522 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R5523 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R5524 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R5525 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R5526 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R5527 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R5528 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R5529 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R5530 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R5531 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R5532 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R5533 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R5534 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R5535 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R5536 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R5537 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R5538 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R5539 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R5540 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R5541 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R5542 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R5543 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R5544 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R5545 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R5546 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R5547 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R5548 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R5549 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R5550 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R5551 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R5552 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R5553 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R5554 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R5555 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R5556 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R5557 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R5558 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R5559 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R5560 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R5561 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R5562 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R5563 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R5564 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R5565 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R5566 n1_m1_470400_196800 n1_m1_475200_196800 5.356235
R5567 n1_m1_475200_196800 n1_m1_480000_196800 5.356235
R5568 n1_m1_480000_196800 n1_m1_484800_196800 5.356235
R5569 n1_m1_484800_196800 n1_m1_489600_196800 5.356235
R5570 n1_m1_489600_196800 n1_m1_494400_196800 5.356235
R5571 n1_m1_494400_196800 n1_m1_499200_196800 5.356235
R5572 n1_m1_499200_196800 n1_m1_504000_196800 5.356235
R5573 n1_m1_504000_196800 n1_m1_508000_196800 4.463529
R5574 n1_m1_508800_196800 n1_m1_508000_196800 0.892706
R5575 n1_m1_508800_196800 n1_m1_513600_196800 5.356235
R5576 n1_m1_513600_196800 n1_m1_518400_196800 5.356235
R5577 n1_m1_518400_196800 n1_m1_523200_196800 5.356235
R5578 n1_m1_523200_196800 n1_m1_528000_196800 5.356235
R5579 n1_m1_528000_196800 n1_m1_532800_196800 5.356235
R5580 n1_m1_532800_196800 n1_m1_536000_196800 3.570824
R5581 n1_m1_537600_196800 n1_m1_536000_196800 1.785412
R5582 n1_m1_537600_196800 n1_m1_542400_196800 5.356235
R5583 n1_m1_542400_196800 n1_m1_547200_196800 5.356235
R5584 n1_m1_547200_196800 n1_m1_552000_196800 5.356235
R5585 n1_m1_552000_196800 n1_m1_556800_196800 5.356235
R5586 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R5587 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R5588 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R5589 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R5590 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R5591 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R5592 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R5593 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R5594 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R5595 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R5596 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R5597 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R5598 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R5599 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R5600 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R5601 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R5602 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R5603 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R5604 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R5605 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R5606 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R5607 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R5608 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R5609 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R5610 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R5611 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R5612 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R5613 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R5614 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R5615 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R5616 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R5617 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R5618 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R5619 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R5620 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R5621 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R5622 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R5623 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R5624 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R5625 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R5626 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R5627 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R5628 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R5629 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R5630 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R5631 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R5632 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R5633 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R5634 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R5635 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R5636 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R5637 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R5638 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R5639 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R5640 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R5641 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R5642 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R5643 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R5644 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R5645 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R5646 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R5647 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R5648 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R5649 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R5650 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R5651 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R5652 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R5653 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R5654 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R5655 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R5656 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R5657 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R5658 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R5659 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R5660 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R5661 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R5662 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R5663 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R5664 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R5665 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R5666 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R5667 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R5668 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R5669 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R5670 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R5671 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R5672 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R5673 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R5674 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R5675 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R5676 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R5677 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R5678 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R5679 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R5680 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R5681 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R5682 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R5683 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R5684 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R5685 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R5686 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R5687 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R5688 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R5689 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R5690 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R5691 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R5692 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R5693 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R5694 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R5695 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R5696 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R5697 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R5698 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R5699 n1_m1_470400_201600 n1_m1_475200_201600 5.356235
R5700 n1_m1_475200_201600 n1_m1_480000_201600 5.356235
R5701 n1_m1_480000_201600 n1_m1_484800_201600 5.356235
R5702 n1_m1_484800_201600 n1_m1_489600_201600 5.356235
R5703 n1_m1_489600_201600 n1_m1_494400_201600 5.356235
R5704 n1_m1_494400_201600 n1_m1_499200_201600 5.356235
R5705 n1_m1_499200_201600 n1_m1_504000_201600 5.356235
R5706 n1_m1_504000_201600 n1_m1_508000_201600 4.463529
R5707 n1_m1_508800_201600 n1_m1_508000_201600 0.892706
R5708 n1_m1_508800_201600 n1_m1_513600_201600 5.356235
R5709 n1_m1_513600_201600 n1_m1_518400_201600 5.356235
R5710 n1_m1_518400_201600 n1_m1_523200_201600 5.356235
R5711 n1_m1_523200_201600 n1_m1_528000_201600 5.356235
R5712 n1_m1_528000_201600 n1_m1_532800_201600 5.356235
R5713 n1_m1_532800_201600 n1_m1_536000_201600 3.570824
R5714 n1_m1_537600_201600 n1_m1_536000_201600 1.785412
R5715 n1_m1_537600_201600 n1_m1_542400_201600 5.356235
R5716 n1_m1_542400_201600 n1_m1_547200_201600 5.356235
R5717 n1_m1_547200_201600 n1_m1_552000_201600 5.356235
R5718 n1_m1_552000_201600 n1_m1_556800_201600 5.356235
R5719 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R5720 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R5721 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R5722 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R5723 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R5724 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R5725 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R5726 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R5727 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R5728 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R5729 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R5730 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R5731 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R5732 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R5733 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R5734 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R5735 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R5736 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R5737 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R5738 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R5739 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R5740 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R5741 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R5742 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R5743 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R5744 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R5745 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R5746 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R5747 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R5748 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R5749 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R5750 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R5751 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R5752 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R5753 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R5754 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R5755 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R5756 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R5757 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R5758 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R5759 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R5760 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R5761 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R5762 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R5763 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R5764 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R5765 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R5766 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R5767 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R5768 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R5769 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R5770 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R5771 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R5772 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R5773 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R5774 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R5775 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R5776 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R5777 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R5778 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R5779 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R5780 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R5781 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R5782 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R5783 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R5784 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R5785 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R5786 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R5787 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R5788 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R5789 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R5790 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R5791 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R5792 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R5793 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R5794 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R5795 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R5796 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R5797 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R5798 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R5799 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R5800 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R5801 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R5802 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R5803 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R5804 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R5805 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R5806 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R5807 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R5808 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R5809 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R5810 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R5811 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R5812 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R5813 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R5814 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R5815 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R5816 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R5817 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R5818 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R5819 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R5820 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R5821 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R5822 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R5823 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R5824 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R5825 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R5826 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R5827 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R5828 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R5829 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R5830 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R5831 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R5832 n1_m1_470400_206400 n1_m1_475200_206400 5.356235
R5833 n1_m1_475200_206400 n1_m1_480000_206400 5.356235
R5834 n1_m1_480000_206400 n1_m1_484800_206400 5.356235
R5835 n1_m1_484800_206400 n1_m1_489600_206400 5.356235
R5836 n1_m1_489600_206400 n1_m1_494400_206400 5.356235
R5837 n1_m1_494400_206400 n1_m1_499200_206400 5.356235
R5838 n1_m1_499200_206400 n1_m1_504000_206400 5.356235
R5839 n1_m1_504000_206400 n1_m1_508000_206400 4.463529
R5840 n1_m1_508800_206400 n1_m1_508000_206400 0.892706
R5841 n1_m1_508800_206400 n1_m1_513600_206400 5.356235
R5842 n1_m1_513600_206400 n1_m1_518400_206400 5.356235
R5843 n1_m1_518400_206400 n1_m1_523200_206400 5.356235
R5844 n1_m1_523200_206400 n1_m1_528000_206400 5.356235
R5845 n1_m1_528000_206400 n1_m1_532800_206400 5.356235
R5846 n1_m1_532800_206400 n1_m1_536000_206400 3.570824
R5847 n1_m1_537600_206400 n1_m1_536000_206400 1.785412
R5848 n1_m1_537600_206400 n1_m1_542400_206400 5.356235
R5849 n1_m1_542400_206400 n1_m1_547200_206400 5.356235
R5850 n1_m1_547200_206400 n1_m1_552000_206400 5.356235
R5851 n1_m1_552000_206400 n1_m1_556800_206400 5.356235
R5852 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R5853 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R5854 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R5855 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R5856 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R5857 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R5858 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R5859 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R5860 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R5861 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R5862 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R5863 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R5864 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R5865 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R5866 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R5867 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R5868 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R5869 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R5870 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R5871 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R5872 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R5873 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R5874 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R5875 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R5876 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R5877 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R5878 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R5879 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R5880 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R5881 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R5882 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R5883 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R5884 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R5885 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R5886 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R5887 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R5888 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R5889 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R5890 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R5891 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R5892 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R5893 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R5894 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R5895 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R5896 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R5897 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R5898 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R5899 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R5900 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R5901 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R5902 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R5903 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R5904 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R5905 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R5906 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R5907 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R5908 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R5909 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R5910 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R5911 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R5912 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R5913 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R5914 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R5915 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R5916 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R5917 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R5918 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R5919 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R5920 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R5921 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R5922 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R5923 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R5924 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R5925 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R5926 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R5927 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R5928 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R5929 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R5930 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R5931 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R5932 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R5933 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R5934 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R5935 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R5936 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R5937 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R5938 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R5939 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R5940 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R5941 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R5942 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R5943 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R5944 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R5945 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R5946 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R5947 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R5948 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R5949 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R5950 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R5951 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R5952 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R5953 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R5954 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R5955 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R5956 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R5957 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R5958 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R5959 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R5960 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R5961 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R5962 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R5963 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R5964 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R5965 n1_m1_470400_211200 n1_m1_475200_211200 5.356235
R5966 n1_m1_475200_211200 n1_m1_480000_211200 5.356235
R5967 n1_m1_480000_211200 n1_m1_484800_211200 5.356235
R5968 n1_m1_484800_211200 n1_m1_489600_211200 5.356235
R5969 n1_m1_489600_211200 n1_m1_494400_211200 5.356235
R5970 n1_m1_494400_211200 n1_m1_499200_211200 5.356235
R5971 n1_m1_499200_211200 n1_m1_504000_211200 5.356235
R5972 n1_m1_504000_211200 n1_m1_508000_211200 4.463529
R5973 n1_m1_508800_211200 n1_m1_508000_211200 0.892706
R5974 n1_m1_508800_211200 n1_m1_513600_211200 5.356235
R5975 n1_m1_513600_211200 n1_m1_518400_211200 5.356235
R5976 n1_m1_518400_211200 n1_m1_523200_211200 5.356235
R5977 n1_m1_523200_211200 n1_m1_528000_211200 5.356235
R5978 n1_m1_528000_211200 n1_m1_532800_211200 5.356235
R5979 n1_m1_532800_211200 n1_m1_536000_211200 3.570824
R5980 n1_m1_537600_211200 n1_m1_536000_211200 1.785412
R5981 n1_m1_537600_211200 n1_m1_542400_211200 5.356235
R5982 n1_m1_542400_211200 n1_m1_547200_211200 5.356235
R5983 n1_m1_547200_211200 n1_m1_552000_211200 5.356235
R5984 n1_m1_552000_211200 n1_m1_556800_211200 5.356235
R5985 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R5986 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R5987 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R5988 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R5989 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R5990 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R5991 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R5992 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R5993 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R5994 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R5995 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R5996 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R5997 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R5998 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R5999 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R6000 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R6001 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R6002 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R6003 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R6004 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R6005 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R6006 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R6007 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R6008 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R6009 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R6010 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R6011 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R6012 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R6013 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R6014 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R6015 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R6016 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R6017 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R6018 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R6019 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R6020 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R6021 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R6022 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R6023 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R6024 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R6025 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R6026 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R6027 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R6028 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R6029 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R6030 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R6031 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R6032 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R6033 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R6034 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R6035 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R6036 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R6037 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R6038 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R6039 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R6040 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R6041 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R6042 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R6043 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R6044 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R6045 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R6046 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R6047 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R6048 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R6049 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R6050 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R6051 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R6052 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R6053 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R6054 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R6055 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R6056 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R6057 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R6058 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R6059 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R6060 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R6061 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R6062 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R6063 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R6064 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R6065 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R6066 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R6067 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R6068 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R6069 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R6070 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R6071 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R6072 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R6073 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R6074 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R6075 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R6076 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R6077 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R6078 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R6079 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R6080 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R6081 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R6082 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R6083 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R6084 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R6085 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R6086 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R6087 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R6088 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R6089 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R6090 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R6091 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R6092 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R6093 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R6094 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R6095 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R6096 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R6097 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R6098 n1_m1_470400_216000 n1_m1_475200_216000 5.356235
R6099 n1_m1_475200_216000 n1_m1_480000_216000 5.356235
R6100 n1_m1_480000_216000 n1_m1_484800_216000 5.356235
R6101 n1_m1_484800_216000 n1_m1_489600_216000 5.356235
R6102 n1_m1_489600_216000 n1_m1_494400_216000 5.356235
R6103 n1_m1_494400_216000 n1_m1_499200_216000 5.356235
R6104 n1_m1_499200_216000 n1_m1_504000_216000 5.356235
R6105 n1_m1_504000_216000 n1_m1_508000_216000 4.463529
R6106 n1_m1_508800_216000 n1_m1_508000_216000 0.892706
R6107 n1_m1_508800_216000 n1_m1_513600_216000 5.356235
R6108 n1_m1_513600_216000 n1_m1_518400_216000 5.356235
R6109 n1_m1_518400_216000 n1_m1_523200_216000 5.356235
R6110 n1_m1_523200_216000 n1_m1_528000_216000 5.356235
R6111 n1_m1_528000_216000 n1_m1_532800_216000 5.356235
R6112 n1_m1_532800_216000 n1_m1_536000_216000 3.570824
R6113 n1_m1_537600_216000 n1_m1_536000_216000 1.785412
R6114 n1_m1_537600_216000 n1_m1_542400_216000 5.356235
R6115 n1_m1_542400_216000 n1_m1_547200_216000 5.356235
R6116 n1_m1_547200_216000 n1_m1_552000_216000 5.356235
R6117 n1_m1_552000_216000 n1_m1_556800_216000 5.356235
R6118 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R6119 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R6120 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R6121 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R6122 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R6123 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R6124 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R6125 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R6126 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R6127 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R6128 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R6129 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R6130 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R6131 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R6132 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R6133 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R6134 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R6135 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R6136 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R6137 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R6138 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R6139 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R6140 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R6141 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R6142 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R6143 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R6144 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R6145 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R6146 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R6147 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R6148 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R6149 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R6150 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R6151 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R6152 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R6153 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R6154 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R6155 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R6156 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R6157 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R6158 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R6159 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R6160 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R6161 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R6162 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R6163 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R6164 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R6165 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R6166 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R6167 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R6168 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R6169 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R6170 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R6171 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R6172 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R6173 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R6174 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R6175 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R6176 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R6177 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R6178 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R6179 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R6180 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R6181 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R6182 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R6183 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R6184 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R6185 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R6186 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R6187 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R6188 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R6189 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R6190 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R6191 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R6192 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R6193 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R6194 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R6195 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R6196 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R6197 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R6198 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R6199 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R6200 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R6201 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R6202 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R6203 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R6204 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R6205 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R6206 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R6207 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R6208 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R6209 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R6210 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R6211 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R6212 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R6213 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R6214 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R6215 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R6216 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R6217 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R6218 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R6219 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R6220 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R6221 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R6222 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R6223 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R6224 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R6225 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R6226 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R6227 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R6228 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R6229 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R6230 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R6231 n1_m1_470400_220800 n1_m1_475200_220800 5.356235
R6232 n1_m1_475200_220800 n1_m1_480000_220800 5.356235
R6233 n1_m1_480000_220800 n1_m1_484800_220800 5.356235
R6234 n1_m1_484800_220800 n1_m1_489600_220800 5.356235
R6235 n1_m1_489600_220800 n1_m1_494400_220800 5.356235
R6236 n1_m1_494400_220800 n1_m1_499200_220800 5.356235
R6237 n1_m1_499200_220800 n1_m1_504000_220800 5.356235
R6238 n1_m1_504000_220800 n1_m1_508000_220800 4.463529
R6239 n1_m1_508800_220800 n1_m1_508000_220800 0.892706
R6240 n1_m1_508800_220800 n1_m1_513600_220800 5.356235
R6241 n1_m1_513600_220800 n1_m1_518400_220800 5.356235
R6242 n1_m1_518400_220800 n1_m1_523200_220800 5.356235
R6243 n1_m1_523200_220800 n1_m1_528000_220800 5.356235
R6244 n1_m1_528000_220800 n1_m1_532800_220800 5.356235
R6245 n1_m1_532800_220800 n1_m1_536000_220800 3.570824
R6246 n1_m1_537600_220800 n1_m1_536000_220800 1.785412
R6247 n1_m1_537600_220800 n1_m1_542400_220800 5.356235
R6248 n1_m1_542400_220800 n1_m1_547200_220800 5.356235
R6249 n1_m1_547200_220800 n1_m1_552000_220800 5.356235
R6250 n1_m1_552000_220800 n1_m1_556800_220800 5.356235
R6251 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R6252 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R6253 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R6254 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R6255 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R6256 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R6257 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R6258 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R6259 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R6260 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R6261 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R6262 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R6263 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R6264 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R6265 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R6266 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R6267 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R6268 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R6269 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R6270 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R6271 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R6272 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R6273 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R6274 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R6275 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R6276 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R6277 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R6278 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R6279 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R6280 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R6281 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R6282 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R6283 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R6284 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R6285 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R6286 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R6287 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R6288 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R6289 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R6290 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R6291 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R6292 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R6293 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R6294 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R6295 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R6296 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R6297 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R6298 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R6299 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R6300 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R6301 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R6302 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R6303 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R6304 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R6305 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R6306 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R6307 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R6308 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R6309 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R6310 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R6311 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R6312 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R6313 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R6314 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R6315 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R6316 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R6317 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R6318 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R6319 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R6320 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R6321 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R6322 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R6323 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R6324 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R6325 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R6326 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R6327 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R6328 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R6329 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R6330 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R6331 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R6332 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R6333 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R6334 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R6335 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R6336 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R6337 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R6338 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R6339 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R6340 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R6341 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R6342 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R6343 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R6344 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R6345 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R6346 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R6347 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R6348 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R6349 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R6350 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R6351 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R6352 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R6353 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R6354 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R6355 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R6356 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R6357 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R6358 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R6359 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R6360 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R6361 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R6362 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R6363 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R6364 n1_m1_470400_225600 n1_m1_475200_225600 5.356235
R6365 n1_m1_475200_225600 n1_m1_480000_225600 5.356235
R6366 n1_m1_480000_225600 n1_m1_484800_225600 5.356235
R6367 n1_m1_484800_225600 n1_m1_489600_225600 5.356235
R6368 n1_m1_489600_225600 n1_m1_494400_225600 5.356235
R6369 n1_m1_494400_225600 n1_m1_499200_225600 5.356235
R6370 n1_m1_499200_225600 n1_m1_504000_225600 5.356235
R6371 n1_m1_504000_225600 n1_m1_508000_225600 4.463529
R6372 n1_m1_508800_225600 n1_m1_508000_225600 0.892706
R6373 n1_m1_508800_225600 n1_m1_513600_225600 5.356235
R6374 n1_m1_513600_225600 n1_m1_518400_225600 5.356235
R6375 n1_m1_518400_225600 n1_m1_523200_225600 5.356235
R6376 n1_m1_523200_225600 n1_m1_528000_225600 5.356235
R6377 n1_m1_528000_225600 n1_m1_532800_225600 5.356235
R6378 n1_m1_532800_225600 n1_m1_536000_225600 3.570824
R6379 n1_m1_537600_225600 n1_m1_536000_225600 1.785412
R6380 n1_m1_537600_225600 n1_m1_542400_225600 5.356235
R6381 n1_m1_542400_225600 n1_m1_547200_225600 5.356235
R6382 n1_m1_547200_225600 n1_m1_552000_225600 5.356235
R6383 n1_m1_552000_225600 n1_m1_556800_225600 5.356235
R6384 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R6385 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R6386 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R6387 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R6388 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R6389 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R6390 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R6391 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R6392 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R6393 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R6394 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R6395 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R6396 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R6397 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R6398 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R6399 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R6400 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R6401 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R6402 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R6403 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R6404 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R6405 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R6406 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R6407 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R6408 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R6409 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R6410 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R6411 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R6412 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R6413 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R6414 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R6415 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R6416 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R6417 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R6418 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R6419 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R6420 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R6421 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R6422 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R6423 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R6424 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R6425 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R6426 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R6427 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R6428 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R6429 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R6430 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R6431 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R6432 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R6433 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R6434 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R6435 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R6436 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R6437 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R6438 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R6439 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R6440 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R6441 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R6442 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R6443 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R6444 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R6445 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R6446 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R6447 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R6448 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R6449 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R6450 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R6451 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R6452 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R6453 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R6454 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R6455 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R6456 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R6457 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R6458 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R6459 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R6460 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R6461 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R6462 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R6463 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R6464 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R6465 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R6466 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R6467 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R6468 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R6469 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R6470 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R6471 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R6472 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R6473 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R6474 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R6475 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R6476 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R6477 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R6478 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R6479 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R6480 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R6481 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R6482 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R6483 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R6484 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R6485 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R6486 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R6487 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R6488 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R6489 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R6490 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R6491 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R6492 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R6493 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R6494 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R6495 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R6496 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R6497 n1_m1_470400_230400 n1_m1_475200_230400 5.356235
R6498 n1_m1_475200_230400 n1_m1_480000_230400 5.356235
R6499 n1_m1_480000_230400 n1_m1_484800_230400 5.356235
R6500 n1_m1_484800_230400 n1_m1_489600_230400 5.356235
R6501 n1_m1_489600_230400 n1_m1_494400_230400 5.356235
R6502 n1_m1_494400_230400 n1_m1_499200_230400 5.356235
R6503 n1_m1_499200_230400 n1_m1_504000_230400 5.356235
R6504 n1_m1_504000_230400 n1_m1_508000_230400 4.463529
R6505 n1_m1_508800_230400 n1_m1_508000_230400 0.892706
R6506 n1_m1_508800_230400 n1_m1_513600_230400 5.356235
R6507 n1_m1_513600_230400 n1_m1_518400_230400 5.356235
R6508 n1_m1_518400_230400 n1_m1_523200_230400 5.356235
R6509 n1_m1_523200_230400 n1_m1_528000_230400 5.356235
R6510 n1_m1_528000_230400 n1_m1_532800_230400 5.356235
R6511 n1_m1_532800_230400 n1_m1_536000_230400 3.570824
R6512 n1_m1_537600_230400 n1_m1_536000_230400 1.785412
R6513 n1_m1_537600_230400 n1_m1_542400_230400 5.356235
R6514 n1_m1_542400_230400 n1_m1_547200_230400 5.356235
R6515 n1_m1_547200_230400 n1_m1_552000_230400 5.356235
R6516 n1_m1_552000_230400 n1_m1_556800_230400 5.356235
R6517 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R6518 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R6519 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R6520 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R6521 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R6522 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R6523 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R6524 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R6525 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R6526 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R6527 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R6528 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R6529 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R6530 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R6531 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R6532 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R6533 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R6534 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R6535 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R6536 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R6537 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R6538 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R6539 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R6540 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R6541 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R6542 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R6543 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R6544 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R6545 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R6546 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R6547 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R6548 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R6549 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R6550 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R6551 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R6552 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R6553 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R6554 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R6555 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R6556 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R6557 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R6558 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R6559 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R6560 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R6561 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R6562 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R6563 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R6564 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R6565 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R6566 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R6567 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R6568 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R6569 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R6570 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R6571 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R6572 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R6573 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R6574 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R6575 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R6576 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R6577 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R6578 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R6579 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R6580 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R6581 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R6582 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R6583 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R6584 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R6585 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R6586 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R6587 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R6588 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R6589 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R6590 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R6591 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R6592 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R6593 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R6594 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R6595 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R6596 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R6597 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R6598 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R6599 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R6600 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R6601 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R6602 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R6603 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R6604 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R6605 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R6606 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R6607 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R6608 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R6609 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R6610 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R6611 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R6612 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R6613 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R6614 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R6615 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R6616 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R6617 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R6618 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R6619 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R6620 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R6621 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R6622 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R6623 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R6624 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R6625 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R6626 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R6627 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R6628 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R6629 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R6630 n1_m1_470400_235200 n1_m1_475200_235200 5.356235
R6631 n1_m1_475200_235200 n1_m1_480000_235200 5.356235
R6632 n1_m1_480000_235200 n1_m1_484800_235200 5.356235
R6633 n1_m1_484800_235200 n1_m1_489600_235200 5.356235
R6634 n1_m1_489600_235200 n1_m1_494400_235200 5.356235
R6635 n1_m1_494400_235200 n1_m1_499200_235200 5.356235
R6636 n1_m1_499200_235200 n1_m1_504000_235200 5.356235
R6637 n1_m1_504000_235200 n1_m1_508000_235200 4.463529
R6638 n1_m1_508800_235200 n1_m1_508000_235200 0.892706
R6639 n1_m1_508800_235200 n1_m1_513600_235200 5.356235
R6640 n1_m1_513600_235200 n1_m1_518400_235200 5.356235
R6641 n1_m1_518400_235200 n1_m1_523200_235200 5.356235
R6642 n1_m1_523200_235200 n1_m1_528000_235200 5.356235
R6643 n1_m1_528000_235200 n1_m1_532800_235200 5.356235
R6644 n1_m1_532800_235200 n1_m1_536000_235200 3.570824
R6645 n1_m1_537600_235200 n1_m1_536000_235200 1.785412
R6646 n1_m1_537600_235200 n1_m1_542400_235200 5.356235
R6647 n1_m1_542400_235200 n1_m1_547200_235200 5.356235
R6648 n1_m1_547200_235200 n1_m1_552000_235200 5.356235
R6649 n1_m1_552000_235200 n1_m1_556800_235200 5.356235
R6650 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R6651 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R6652 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R6653 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R6654 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R6655 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R6656 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R6657 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R6658 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R6659 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R6660 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R6661 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R6662 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R6663 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R6664 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R6665 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R6666 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R6667 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R6668 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R6669 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R6670 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R6671 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R6672 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R6673 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R6674 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R6675 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R6676 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R6677 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R6678 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R6679 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R6680 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R6681 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R6682 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R6683 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R6684 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R6685 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R6686 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R6687 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R6688 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R6689 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R6690 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R6691 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R6692 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R6693 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R6694 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R6695 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R6696 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R6697 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R6698 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R6699 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R6700 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R6701 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R6702 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R6703 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R6704 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R6705 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R6706 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R6707 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R6708 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R6709 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R6710 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R6711 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R6712 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R6713 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R6714 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R6715 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R6716 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R6717 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R6718 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R6719 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R6720 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R6721 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R6722 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R6723 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R6724 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R6725 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R6726 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R6727 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R6728 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R6729 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R6730 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R6731 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R6732 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R6733 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R6734 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R6735 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R6736 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R6737 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R6738 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R6739 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R6740 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R6741 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R6742 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R6743 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R6744 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R6745 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R6746 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R6747 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R6748 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R6749 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R6750 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R6751 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R6752 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R6753 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R6754 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R6755 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R6756 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R6757 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R6758 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R6759 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R6760 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R6761 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R6762 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R6763 n1_m1_470400_240000 n1_m1_475200_240000 5.356235
R6764 n1_m1_475200_240000 n1_m1_480000_240000 5.356235
R6765 n1_m1_480000_240000 n1_m1_484800_240000 5.356235
R6766 n1_m1_484800_240000 n1_m1_489600_240000 5.356235
R6767 n1_m1_489600_240000 n1_m1_494400_240000 5.356235
R6768 n1_m1_494400_240000 n1_m1_499200_240000 5.356235
R6769 n1_m1_499200_240000 n1_m1_504000_240000 5.356235
R6770 n1_m1_504000_240000 n1_m1_508000_240000 4.463529
R6771 n1_m1_508800_240000 n1_m1_508000_240000 0.892706
R6772 n1_m1_508800_240000 n1_m1_513600_240000 5.356235
R6773 n1_m1_513600_240000 n1_m1_518400_240000 5.356235
R6774 n1_m1_518400_240000 n1_m1_523200_240000 5.356235
R6775 n1_m1_523200_240000 n1_m1_528000_240000 5.356235
R6776 n1_m1_528000_240000 n1_m1_532800_240000 5.356235
R6777 n1_m1_532800_240000 n1_m1_536000_240000 3.570824
R6778 n1_m1_537600_240000 n1_m1_536000_240000 1.785412
R6779 n1_m1_537600_240000 n1_m1_542400_240000 5.356235
R6780 n1_m1_542400_240000 n1_m1_547200_240000 5.356235
R6781 n1_m1_547200_240000 n1_m1_552000_240000 5.356235
R6782 n1_m1_552000_240000 n1_m1_556800_240000 5.356235
R6783 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R6784 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R6785 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R6786 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R6787 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R6788 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R6789 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R6790 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R6791 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R6792 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R6793 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R6794 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R6795 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R6796 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R6797 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R6798 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R6799 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R6800 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R6801 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R6802 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R6803 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R6804 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R6805 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R6806 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R6807 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R6808 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R6809 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R6810 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R6811 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R6812 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R6813 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R6814 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R6815 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R6816 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R6817 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R6818 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R6819 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R6820 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R6821 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R6822 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R6823 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R6824 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R6825 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R6826 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R6827 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R6828 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R6829 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R6830 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R6831 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R6832 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R6833 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R6834 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R6835 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R6836 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R6837 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R6838 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R6839 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R6840 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R6841 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R6842 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R6843 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R6844 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R6845 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R6846 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R6847 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R6848 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R6849 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R6850 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R6851 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R6852 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R6853 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R6854 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R6855 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R6856 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R6857 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R6858 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R6859 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R6860 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R6861 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R6862 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R6863 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R6864 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R6865 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R6866 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R6867 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R6868 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R6869 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R6870 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R6871 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R6872 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R6873 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R6874 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R6875 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R6876 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R6877 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R6878 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R6879 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R6880 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R6881 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R6882 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R6883 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R6884 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R6885 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R6886 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R6887 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R6888 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R6889 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R6890 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R6891 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R6892 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R6893 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R6894 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R6895 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R6896 n1_m1_470400_244800 n1_m1_475200_244800 5.356235
R6897 n1_m1_475200_244800 n1_m1_480000_244800 5.356235
R6898 n1_m1_480000_244800 n1_m1_484800_244800 5.356235
R6899 n1_m1_484800_244800 n1_m1_489600_244800 5.356235
R6900 n1_m1_489600_244800 n1_m1_494400_244800 5.356235
R6901 n1_m1_494400_244800 n1_m1_499200_244800 5.356235
R6902 n1_m1_499200_244800 n1_m1_504000_244800 5.356235
R6903 n1_m1_504000_244800 n1_m1_508000_244800 4.463529
R6904 n1_m1_508800_244800 n1_m1_508000_244800 0.892706
R6905 n1_m1_508800_244800 n1_m1_513600_244800 5.356235
R6906 n1_m1_513600_244800 n1_m1_518400_244800 5.356235
R6907 n1_m1_518400_244800 n1_m1_523200_244800 5.356235
R6908 n1_m1_523200_244800 n1_m1_528000_244800 5.356235
R6909 n1_m1_528000_244800 n1_m1_532800_244800 5.356235
R6910 n1_m1_532800_244800 n1_m1_536000_244800 3.570824
R6911 n1_m1_537600_244800 n1_m1_536000_244800 1.785412
R6912 n1_m1_537600_244800 n1_m1_542400_244800 5.356235
R6913 n1_m1_542400_244800 n1_m1_547200_244800 5.356235
R6914 n1_m1_547200_244800 n1_m1_552000_244800 5.356235
R6915 n1_m1_552000_244800 n1_m1_556800_244800 5.356235
R6916 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R6917 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R6918 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R6919 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R6920 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R6921 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R6922 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R6923 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R6924 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R6925 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R6926 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R6927 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R6928 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R6929 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R6930 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R6931 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R6932 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R6933 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R6934 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R6935 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R6936 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R6937 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R6938 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R6939 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R6940 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R6941 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R6942 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R6943 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R6944 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R6945 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R6946 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R6947 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R6948 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R6949 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R6950 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R6951 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R6952 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R6953 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R6954 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R6955 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R6956 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R6957 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R6958 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R6959 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R6960 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R6961 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R6962 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R6963 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R6964 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R6965 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R6966 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R6967 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R6968 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R6969 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R6970 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R6971 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R6972 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R6973 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R6974 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R6975 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R6976 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R6977 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R6978 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R6979 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R6980 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R6981 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R6982 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R6983 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R6984 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R6985 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R6986 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R6987 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R6988 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R6989 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R6990 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R6991 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R6992 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R6993 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R6994 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R6995 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R6996 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R6997 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R6998 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R6999 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R7000 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R7001 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R7002 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R7003 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R7004 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R7005 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R7006 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R7007 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R7008 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R7009 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R7010 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R7011 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R7012 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R7013 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R7014 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R7015 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R7016 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R7017 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R7018 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R7019 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R7020 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R7021 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R7022 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R7023 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R7024 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R7025 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R7026 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R7027 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R7028 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R7029 n1_m1_470400_249600 n1_m1_475200_249600 5.356235
R7030 n1_m1_475200_249600 n1_m1_480000_249600 5.356235
R7031 n1_m1_480000_249600 n1_m1_484800_249600 5.356235
R7032 n1_m1_484800_249600 n1_m1_489600_249600 5.356235
R7033 n1_m1_489600_249600 n1_m1_494400_249600 5.356235
R7034 n1_m1_494400_249600 n1_m1_499200_249600 5.356235
R7035 n1_m1_499200_249600 n1_m1_504000_249600 5.356235
R7036 n1_m1_504000_249600 n1_m1_508000_249600 4.463529
R7037 n1_m1_508800_249600 n1_m1_508000_249600 0.892706
R7038 n1_m1_508800_249600 n1_m1_513600_249600 5.356235
R7039 n1_m1_513600_249600 n1_m1_518400_249600 5.356235
R7040 n1_m1_518400_249600 n1_m1_523200_249600 5.356235
R7041 n1_m1_523200_249600 n1_m1_528000_249600 5.356235
R7042 n1_m1_528000_249600 n1_m1_532800_249600 5.356235
R7043 n1_m1_532800_249600 n1_m1_536000_249600 3.570824
R7044 n1_m1_537600_249600 n1_m1_536000_249600 1.785412
R7045 n1_m1_537600_249600 n1_m1_542400_249600 5.356235
R7046 n1_m1_542400_249600 n1_m1_547200_249600 5.356235
R7047 n1_m1_547200_249600 n1_m1_552000_249600 5.356235
R7048 n1_m1_552000_249600 n1_m1_556800_249600 5.356235
R7049 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R7050 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R7051 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R7052 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R7053 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R7054 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R7055 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R7056 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R7057 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R7058 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R7059 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R7060 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R7061 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R7062 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R7063 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R7064 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R7065 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R7066 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R7067 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R7068 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R7069 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R7070 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R7071 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R7072 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R7073 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R7074 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R7075 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R7076 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R7077 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R7078 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R7079 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R7080 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R7081 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R7082 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R7083 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R7084 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R7085 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R7086 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R7087 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R7088 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R7089 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R7090 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R7091 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R7092 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R7093 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R7094 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R7095 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R7096 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R7097 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R7098 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R7099 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R7100 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R7101 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R7102 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R7103 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R7104 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R7105 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R7106 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R7107 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R7108 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R7109 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R7110 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R7111 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R7112 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R7113 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R7114 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R7115 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R7116 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R7117 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R7118 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R7119 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R7120 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R7121 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R7122 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R7123 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R7124 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R7125 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R7126 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R7127 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R7128 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R7129 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R7130 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R7131 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R7132 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R7133 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R7134 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R7135 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R7136 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R7137 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R7138 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R7139 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R7140 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R7141 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R7142 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R7143 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R7144 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R7145 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R7146 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R7147 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R7148 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R7149 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R7150 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R7151 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R7152 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R7153 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R7154 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R7155 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R7156 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R7157 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R7158 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R7159 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R7160 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R7161 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R7162 n1_m1_470400_254400 n1_m1_475200_254400 5.356235
R7163 n1_m1_475200_254400 n1_m1_480000_254400 5.356235
R7164 n1_m1_480000_254400 n1_m1_484800_254400 5.356235
R7165 n1_m1_484800_254400 n1_m1_489600_254400 5.356235
R7166 n1_m1_489600_254400 n1_m1_494400_254400 5.356235
R7167 n1_m1_494400_254400 n1_m1_499200_254400 5.356235
R7168 n1_m1_499200_254400 n1_m1_504000_254400 5.356235
R7169 n1_m1_504000_254400 n1_m1_508000_254400 4.463529
R7170 n1_m1_508800_254400 n1_m1_508000_254400 0.892706
R7171 n1_m1_508800_254400 n1_m1_513600_254400 5.356235
R7172 n1_m1_513600_254400 n1_m1_518400_254400 5.356235
R7173 n1_m1_518400_254400 n1_m1_523200_254400 5.356235
R7174 n1_m1_523200_254400 n1_m1_528000_254400 5.356235
R7175 n1_m1_528000_254400 n1_m1_532800_254400 5.356235
R7176 n1_m1_532800_254400 n1_m1_536000_254400 3.570824
R7177 n1_m1_537600_254400 n1_m1_536000_254400 1.785412
R7178 n1_m1_537600_254400 n1_m1_542400_254400 5.356235
R7179 n1_m1_542400_254400 n1_m1_547200_254400 5.356235
R7180 n1_m1_547200_254400 n1_m1_552000_254400 5.356235
R7181 n1_m1_552000_254400 n1_m1_556800_254400 5.356235
R7182 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R7183 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R7184 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R7185 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R7186 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R7187 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R7188 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R7189 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R7190 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R7191 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R7192 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R7193 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R7194 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R7195 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R7196 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R7197 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R7198 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R7199 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R7200 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R7201 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R7202 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R7203 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R7204 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R7205 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R7206 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R7207 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R7208 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R7209 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R7210 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R7211 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R7212 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R7213 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R7214 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R7215 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R7216 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R7217 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R7218 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R7219 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R7220 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R7221 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R7222 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R7223 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R7224 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R7225 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R7226 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R7227 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R7228 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R7229 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R7230 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R7231 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R7232 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R7233 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R7234 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R7235 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R7236 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R7237 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R7238 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R7239 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R7240 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R7241 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R7242 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R7243 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R7244 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R7245 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R7246 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R7247 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R7248 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R7249 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R7250 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R7251 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R7252 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R7253 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R7254 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R7255 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R7256 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R7257 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R7258 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R7259 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R7260 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R7261 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R7262 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R7263 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R7264 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R7265 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R7266 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R7267 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R7268 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R7269 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R7270 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R7271 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R7272 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R7273 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R7274 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R7275 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R7276 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R7277 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R7278 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R7279 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R7280 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R7281 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R7282 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R7283 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R7284 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R7285 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R7286 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R7287 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R7288 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R7289 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R7290 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R7291 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R7292 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R7293 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R7294 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R7295 n1_m1_470400_259200 n1_m1_475200_259200 5.356235
R7296 n1_m1_475200_259200 n1_m1_480000_259200 5.356235
R7297 n1_m1_480000_259200 n1_m1_484800_259200 5.356235
R7298 n1_m1_484800_259200 n1_m1_489600_259200 5.356235
R7299 n1_m1_489600_259200 n1_m1_494400_259200 5.356235
R7300 n1_m1_494400_259200 n1_m1_499200_259200 5.356235
R7301 n1_m1_499200_259200 n1_m1_504000_259200 5.356235
R7302 n1_m1_504000_259200 n1_m1_508000_259200 4.463529
R7303 n1_m1_508800_259200 n1_m1_508000_259200 0.892706
R7304 n1_m1_508800_259200 n1_m1_513600_259200 5.356235
R7305 n1_m1_513600_259200 n1_m1_518400_259200 5.356235
R7306 n1_m1_518400_259200 n1_m1_523200_259200 5.356235
R7307 n1_m1_523200_259200 n1_m1_528000_259200 5.356235
R7308 n1_m1_528000_259200 n1_m1_532800_259200 5.356235
R7309 n1_m1_532800_259200 n1_m1_536000_259200 3.570824
R7310 n1_m1_537600_259200 n1_m1_536000_259200 1.785412
R7311 n1_m1_537600_259200 n1_m1_542400_259200 5.356235
R7312 n1_m1_542400_259200 n1_m1_547200_259200 5.356235
R7313 n1_m1_547200_259200 n1_m1_552000_259200 5.356235
R7314 n1_m1_552000_259200 n1_m1_556800_259200 5.356235
R7315 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R7316 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R7317 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R7318 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R7319 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R7320 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R7321 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R7322 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R7323 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R7324 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R7325 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R7326 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R7327 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R7328 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R7329 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R7330 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R7331 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R7332 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R7333 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R7334 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R7335 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R7336 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R7337 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R7338 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R7339 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R7340 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R7341 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R7342 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R7343 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R7344 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R7345 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R7346 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R7347 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R7348 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R7349 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R7350 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R7351 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R7352 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R7353 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R7354 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R7355 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R7356 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R7357 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R7358 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R7359 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R7360 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R7361 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R7362 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R7363 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R7364 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R7365 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R7366 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R7367 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R7368 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R7369 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R7370 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R7371 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R7372 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R7373 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R7374 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R7375 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R7376 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R7377 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R7378 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R7379 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R7380 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R7381 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R7382 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R7383 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R7384 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R7385 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R7386 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R7387 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R7388 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R7389 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R7390 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R7391 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R7392 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R7393 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R7394 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R7395 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R7396 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R7397 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R7398 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R7399 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R7400 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R7401 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R7402 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R7403 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R7404 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R7405 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R7406 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R7407 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R7408 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R7409 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R7410 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R7411 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R7412 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R7413 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R7414 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R7415 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R7416 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R7417 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R7418 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R7419 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R7420 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R7421 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R7422 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R7423 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R7424 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R7425 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R7426 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R7427 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R7428 n1_m1_470400_264000 n1_m1_475200_264000 5.356235
R7429 n1_m1_475200_264000 n1_m1_480000_264000 5.356235
R7430 n1_m1_480000_264000 n1_m1_484800_264000 5.356235
R7431 n1_m1_484800_264000 n1_m1_489600_264000 5.356235
R7432 n1_m1_489600_264000 n1_m1_494400_264000 5.356235
R7433 n1_m1_494400_264000 n1_m1_499200_264000 5.356235
R7434 n1_m1_499200_264000 n1_m1_504000_264000 5.356235
R7435 n1_m1_504000_264000 n1_m1_508000_264000 4.463529
R7436 n1_m1_508800_264000 n1_m1_508000_264000 0.892706
R7437 n1_m1_508800_264000 n1_m1_513600_264000 5.356235
R7438 n1_m1_513600_264000 n1_m1_518400_264000 5.356235
R7439 n1_m1_518400_264000 n1_m1_523200_264000 5.356235
R7440 n1_m1_523200_264000 n1_m1_528000_264000 5.356235
R7441 n1_m1_528000_264000 n1_m1_532800_264000 5.356235
R7442 n1_m1_532800_264000 n1_m1_536000_264000 3.570824
R7443 n1_m1_537600_264000 n1_m1_536000_264000 1.785412
R7444 n1_m1_537600_264000 n1_m1_542400_264000 5.356235
R7445 n1_m1_542400_264000 n1_m1_547200_264000 5.356235
R7446 n1_m1_547200_264000 n1_m1_552000_264000 5.356235
R7447 n1_m1_552000_264000 n1_m1_556800_264000 5.356235
R7448 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R7449 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R7450 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R7451 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R7452 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R7453 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R7454 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R7455 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R7456 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R7457 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R7458 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R7459 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R7460 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R7461 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R7462 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R7463 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R7464 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R7465 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R7466 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R7467 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R7468 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R7469 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R7470 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R7471 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R7472 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R7473 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R7474 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R7475 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R7476 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R7477 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R7478 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R7479 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R7480 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R7481 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R7482 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R7483 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R7484 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R7485 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R7486 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R7487 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R7488 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R7489 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R7490 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R7491 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R7492 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R7493 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R7494 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R7495 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R7496 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R7497 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R7498 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R7499 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R7500 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R7501 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R7502 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R7503 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R7504 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R7505 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R7506 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R7507 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R7508 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R7509 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R7510 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R7511 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R7512 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R7513 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R7514 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R7515 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R7516 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R7517 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R7518 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R7519 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R7520 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R7521 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R7522 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R7523 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R7524 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R7525 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R7526 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R7527 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R7528 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R7529 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R7530 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R7531 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R7532 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R7533 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R7534 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R7535 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R7536 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R7537 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R7538 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R7539 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R7540 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R7541 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R7542 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R7543 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R7544 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R7545 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R7546 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R7547 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R7548 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R7549 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R7550 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R7551 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R7552 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R7553 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R7554 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R7555 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R7556 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R7557 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R7558 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R7559 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R7560 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R7561 n1_m1_470400_268800 n1_m1_475200_268800 5.356235
R7562 n1_m1_475200_268800 n1_m1_480000_268800 5.356235
R7563 n1_m1_480000_268800 n1_m1_484800_268800 5.356235
R7564 n1_m1_484800_268800 n1_m1_489600_268800 5.356235
R7565 n1_m1_489600_268800 n1_m1_494400_268800 5.356235
R7566 n1_m1_494400_268800 n1_m1_499200_268800 5.356235
R7567 n1_m1_499200_268800 n1_m1_504000_268800 5.356235
R7568 n1_m1_504000_268800 n1_m1_508000_268800 4.463529
R7569 n1_m1_508800_268800 n1_m1_508000_268800 0.892706
R7570 n1_m1_508800_268800 n1_m1_513600_268800 5.356235
R7571 n1_m1_513600_268800 n1_m1_518400_268800 5.356235
R7572 n1_m1_518400_268800 n1_m1_523200_268800 5.356235
R7573 n1_m1_523200_268800 n1_m1_528000_268800 5.356235
R7574 n1_m1_528000_268800 n1_m1_532800_268800 5.356235
R7575 n1_m1_532800_268800 n1_m1_536000_268800 3.570824
R7576 n1_m1_537600_268800 n1_m1_536000_268800 1.785412
R7577 n1_m1_537600_268800 n1_m1_542400_268800 5.356235
R7578 n1_m1_542400_268800 n1_m1_547200_268800 5.356235
R7579 n1_m1_547200_268800 n1_m1_552000_268800 5.356235
R7580 n1_m1_552000_268800 n1_m1_556800_268800 5.356235
R7581 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R7582 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R7583 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R7584 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R7585 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R7586 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R7587 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R7588 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R7589 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R7590 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R7591 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R7592 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R7593 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R7594 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R7595 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R7596 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R7597 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R7598 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R7599 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R7600 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R7601 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R7602 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R7603 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R7604 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R7605 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R7606 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R7607 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R7608 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R7609 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R7610 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R7611 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R7612 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R7613 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R7614 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R7615 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R7616 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R7617 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R7618 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R7619 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R7620 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R7621 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R7622 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R7623 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R7624 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R7625 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R7626 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R7627 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R7628 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R7629 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R7630 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R7631 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R7632 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R7633 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R7634 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R7635 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R7636 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R7637 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R7638 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R7639 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R7640 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R7641 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R7642 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R7643 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R7644 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R7645 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R7646 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R7647 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R7648 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R7649 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R7650 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R7651 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R7652 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R7653 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R7654 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R7655 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R7656 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R7657 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R7658 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R7659 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R7660 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R7661 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R7662 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R7663 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R7664 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R7665 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R7666 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R7667 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R7668 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R7669 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R7670 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R7671 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R7672 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R7673 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R7674 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R7675 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R7676 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R7677 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R7678 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R7679 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R7680 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R7681 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R7682 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R7683 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R7684 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R7685 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R7686 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R7687 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R7688 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R7689 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R7690 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R7691 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R7692 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R7693 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R7694 n1_m1_470400_273600 n1_m1_475200_273600 5.356235
R7695 n1_m1_475200_273600 n1_m1_480000_273600 5.356235
R7696 n1_m1_480000_273600 n1_m1_484800_273600 5.356235
R7697 n1_m1_484800_273600 n1_m1_489600_273600 5.356235
R7698 n1_m1_489600_273600 n1_m1_494400_273600 5.356235
R7699 n1_m1_494400_273600 n1_m1_499200_273600 5.356235
R7700 n1_m1_499200_273600 n1_m1_504000_273600 5.356235
R7701 n1_m1_504000_273600 n1_m1_508000_273600 4.463529
R7702 n1_m1_508800_273600 n1_m1_508000_273600 0.892706
R7703 n1_m1_508800_273600 n1_m1_513600_273600 5.356235
R7704 n1_m1_513600_273600 n1_m1_518400_273600 5.356235
R7705 n1_m1_518400_273600 n1_m1_523200_273600 5.356235
R7706 n1_m1_523200_273600 n1_m1_528000_273600 5.356235
R7707 n1_m1_528000_273600 n1_m1_532800_273600 5.356235
R7708 n1_m1_532800_273600 n1_m1_536000_273600 3.570824
R7709 n1_m1_537600_273600 n1_m1_536000_273600 1.785412
R7710 n1_m1_537600_273600 n1_m1_542400_273600 5.356235
R7711 n1_m1_542400_273600 n1_m1_547200_273600 5.356235
R7712 n1_m1_547200_273600 n1_m1_552000_273600 5.356235
R7713 n1_m1_552000_273600 n1_m1_556800_273600 5.356235
R7714 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R7715 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R7716 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R7717 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R7718 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R7719 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R7720 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R7721 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R7722 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R7723 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R7724 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R7725 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R7726 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R7727 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R7728 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R7729 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R7730 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R7731 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R7732 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R7733 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R7734 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R7735 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R7736 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R7737 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R7738 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R7739 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R7740 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R7741 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R7742 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R7743 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R7744 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R7745 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R7746 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R7747 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R7748 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R7749 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R7750 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R7751 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R7752 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R7753 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R7754 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R7755 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R7756 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R7757 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R7758 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R7759 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R7760 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R7761 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R7762 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R7763 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R7764 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R7765 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R7766 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R7767 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R7768 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R7769 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R7770 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R7771 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R7772 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R7773 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R7774 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R7775 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R7776 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R7777 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R7778 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R7779 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R7780 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R7781 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R7782 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R7783 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R7784 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R7785 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R7786 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R7787 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R7788 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R7789 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R7790 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R7791 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R7792 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R7793 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R7794 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R7795 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R7796 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R7797 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R7798 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R7799 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R7800 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R7801 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R7802 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R7803 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R7804 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R7805 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R7806 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R7807 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R7808 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R7809 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R7810 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R7811 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R7812 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R7813 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R7814 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R7815 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R7816 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R7817 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R7818 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R7819 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R7820 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R7821 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R7822 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R7823 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R7824 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R7825 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R7826 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R7827 n1_m1_470400_278400 n1_m1_475200_278400 5.356235
R7828 n1_m1_475200_278400 n1_m1_480000_278400 5.356235
R7829 n1_m1_480000_278400 n1_m1_484800_278400 5.356235
R7830 n1_m1_484800_278400 n1_m1_489600_278400 5.356235
R7831 n1_m1_489600_278400 n1_m1_494400_278400 5.356235
R7832 n1_m1_494400_278400 n1_m1_499200_278400 5.356235
R7833 n1_m1_499200_278400 n1_m1_504000_278400 5.356235
R7834 n1_m1_504000_278400 n1_m1_508000_278400 4.463529
R7835 n1_m1_508800_278400 n1_m1_508000_278400 0.892706
R7836 n1_m1_508800_278400 n1_m1_513600_278400 5.356235
R7837 n1_m1_513600_278400 n1_m1_518400_278400 5.356235
R7838 n1_m1_518400_278400 n1_m1_523200_278400 5.356235
R7839 n1_m1_523200_278400 n1_m1_528000_278400 5.356235
R7840 n1_m1_528000_278400 n1_m1_532800_278400 5.356235
R7841 n1_m1_532800_278400 n1_m1_536000_278400 3.570824
R7842 n1_m1_537600_278400 n1_m1_536000_278400 1.785412
R7843 n1_m1_537600_278400 n1_m1_542400_278400 5.356235
R7844 n1_m1_542400_278400 n1_m1_547200_278400 5.356235
R7845 n1_m1_547200_278400 n1_m1_552000_278400 5.356235
R7846 n1_m1_552000_278400 n1_m1_556800_278400 5.356235
R7847 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R7848 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R7849 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R7850 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R7851 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R7852 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R7853 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R7854 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R7855 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R7856 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R7857 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R7858 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R7859 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R7860 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R7861 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R7862 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R7863 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R7864 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R7865 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R7866 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R7867 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R7868 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R7869 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R7870 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R7871 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R7872 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R7873 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R7874 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R7875 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R7876 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R7877 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R7878 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R7879 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R7880 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R7881 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R7882 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R7883 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R7884 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R7885 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R7886 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R7887 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R7888 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R7889 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R7890 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R7891 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R7892 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R7893 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R7894 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R7895 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R7896 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R7897 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R7898 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R7899 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R7900 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R7901 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R7902 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R7903 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R7904 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R7905 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R7906 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R7907 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R7908 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R7909 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R7910 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R7911 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R7912 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R7913 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R7914 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R7915 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R7916 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R7917 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R7918 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R7919 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R7920 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R7921 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R7922 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R7923 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R7924 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R7925 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R7926 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R7927 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R7928 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R7929 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R7930 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R7931 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R7932 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R7933 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R7934 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R7935 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R7936 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R7937 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R7938 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R7939 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R7940 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R7941 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R7942 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R7943 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R7944 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R7945 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R7946 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R7947 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R7948 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R7949 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R7950 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R7951 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R7952 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R7953 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R7954 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R7955 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R7956 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R7957 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R7958 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R7959 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R7960 n1_m1_470400_283200 n1_m1_475200_283200 5.356235
R7961 n1_m1_475200_283200 n1_m1_480000_283200 5.356235
R7962 n1_m1_480000_283200 n1_m1_484800_283200 5.356235
R7963 n1_m1_484800_283200 n1_m1_489600_283200 5.356235
R7964 n1_m1_489600_283200 n1_m1_494400_283200 5.356235
R7965 n1_m1_494400_283200 n1_m1_499200_283200 5.356235
R7966 n1_m1_499200_283200 n1_m1_504000_283200 5.356235
R7967 n1_m1_504000_283200 n1_m1_508000_283200 4.463529
R7968 n1_m1_508800_283200 n1_m1_508000_283200 0.892706
R7969 n1_m1_508800_283200 n1_m1_513600_283200 5.356235
R7970 n1_m1_513600_283200 n1_m1_518400_283200 5.356235
R7971 n1_m1_518400_283200 n1_m1_523200_283200 5.356235
R7972 n1_m1_523200_283200 n1_m1_528000_283200 5.356235
R7973 n1_m1_528000_283200 n1_m1_532800_283200 5.356235
R7974 n1_m1_532800_283200 n1_m1_536000_283200 3.570824
R7975 n1_m1_537600_283200 n1_m1_536000_283200 1.785412
R7976 n1_m1_537600_283200 n1_m1_542400_283200 5.356235
R7977 n1_m1_542400_283200 n1_m1_547200_283200 5.356235
R7978 n1_m1_547200_283200 n1_m1_552000_283200 5.356235
R7979 n1_m1_552000_283200 n1_m1_556800_283200 5.356235
R7980 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R7981 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R7982 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R7983 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R7984 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R7985 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R7986 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R7987 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R7988 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R7989 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R7990 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R7991 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R7992 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R7993 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R7994 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R7995 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R7996 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R7997 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R7998 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R7999 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R8000 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R8001 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R8002 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R8003 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R8004 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R8005 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R8006 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R8007 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R8008 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R8009 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R8010 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R8011 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R8012 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R8013 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R8014 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R8015 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R8016 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R8017 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R8018 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R8019 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R8020 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R8021 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R8022 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R8023 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R8024 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R8025 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R8026 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R8027 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R8028 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R8029 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R8030 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R8031 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R8032 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R8033 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R8034 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R8035 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R8036 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R8037 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R8038 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R8039 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R8040 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R8041 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R8042 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R8043 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R8044 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R8045 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R8046 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R8047 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R8048 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R8049 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R8050 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R8051 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R8052 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R8053 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R8054 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R8055 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R8056 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R8057 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R8058 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R8059 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R8060 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R8061 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R8062 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R8063 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R8064 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R8065 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R8066 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R8067 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R8068 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R8069 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R8070 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R8071 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R8072 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R8073 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R8074 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R8075 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R8076 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R8077 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R8078 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R8079 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R8080 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R8081 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R8082 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R8083 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R8084 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R8085 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R8086 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R8087 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R8088 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R8089 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R8090 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R8091 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R8092 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R8093 n1_m1_470400_288000 n1_m1_475200_288000 5.356235
R8094 n1_m1_475200_288000 n1_m1_480000_288000 5.356235
R8095 n1_m1_480000_288000 n1_m1_484800_288000 5.356235
R8096 n1_m1_484800_288000 n1_m1_489600_288000 5.356235
R8097 n1_m1_489600_288000 n1_m1_494400_288000 5.356235
R8098 n1_m1_494400_288000 n1_m1_499200_288000 5.356235
R8099 n1_m1_499200_288000 n1_m1_504000_288000 5.356235
R8100 n1_m1_504000_288000 n1_m1_508000_288000 4.463529
R8101 n1_m1_508800_288000 n1_m1_508000_288000 0.892706
R8102 n1_m1_508800_288000 n1_m1_513600_288000 5.356235
R8103 n1_m1_513600_288000 n1_m1_518400_288000 5.356235
R8104 n1_m1_518400_288000 n1_m1_523200_288000 5.356235
R8105 n1_m1_523200_288000 n1_m1_528000_288000 5.356235
R8106 n1_m1_528000_288000 n1_m1_532800_288000 5.356235
R8107 n1_m1_532800_288000 n1_m1_536000_288000 3.570824
R8108 n1_m1_537600_288000 n1_m1_536000_288000 1.785412
R8109 n1_m1_537600_288000 n1_m1_542400_288000 5.356235
R8110 n1_m1_542400_288000 n1_m1_547200_288000 5.356235
R8111 n1_m1_547200_288000 n1_m1_552000_288000 5.356235
R8112 n1_m1_552000_288000 n1_m1_556800_288000 5.356235
R8113 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R8114 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R8115 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R8116 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R8117 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R8118 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R8119 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R8120 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R8121 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R8122 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R8123 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R8124 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R8125 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R8126 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R8127 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R8128 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R8129 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R8130 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R8131 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R8132 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R8133 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R8134 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R8135 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R8136 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R8137 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R8138 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R8139 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R8140 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R8141 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R8142 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R8143 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R8144 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R8145 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R8146 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R8147 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R8148 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R8149 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R8150 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R8151 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R8152 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R8153 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R8154 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R8155 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R8156 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R8157 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R8158 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R8159 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R8160 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R8161 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R8162 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R8163 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R8164 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R8165 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R8166 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R8167 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R8168 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R8169 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R8170 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R8171 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R8172 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R8173 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R8174 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R8175 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R8176 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R8177 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R8178 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R8179 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R8180 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R8181 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R8182 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R8183 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R8184 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R8185 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R8186 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R8187 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R8188 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R8189 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R8190 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R8191 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R8192 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R8193 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R8194 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R8195 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R8196 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R8197 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R8198 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R8199 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R8200 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R8201 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R8202 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R8203 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R8204 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R8205 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R8206 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R8207 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R8208 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R8209 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R8210 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R8211 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R8212 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R8213 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R8214 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R8215 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R8216 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R8217 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R8218 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R8219 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R8220 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R8221 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R8222 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R8223 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R8224 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R8225 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R8226 n1_m1_470400_292800 n1_m1_475200_292800 5.356235
R8227 n1_m1_475200_292800 n1_m1_480000_292800 5.356235
R8228 n1_m1_480000_292800 n1_m1_484800_292800 5.356235
R8229 n1_m1_484800_292800 n1_m1_489600_292800 5.356235
R8230 n1_m1_489600_292800 n1_m1_494400_292800 5.356235
R8231 n1_m1_494400_292800 n1_m1_499200_292800 5.356235
R8232 n1_m1_499200_292800 n1_m1_504000_292800 5.356235
R8233 n1_m1_504000_292800 n1_m1_508000_292800 4.463529
R8234 n1_m1_508800_292800 n1_m1_508000_292800 0.892706
R8235 n1_m1_508800_292800 n1_m1_513600_292800 5.356235
R8236 n1_m1_513600_292800 n1_m1_518400_292800 5.356235
R8237 n1_m1_518400_292800 n1_m1_523200_292800 5.356235
R8238 n1_m1_523200_292800 n1_m1_528000_292800 5.356235
R8239 n1_m1_528000_292800 n1_m1_532800_292800 5.356235
R8240 n1_m1_532800_292800 n1_m1_536000_292800 3.570824
R8241 n1_m1_537600_292800 n1_m1_536000_292800 1.785412
R8242 n1_m1_537600_292800 n1_m1_542400_292800 5.356235
R8243 n1_m1_542400_292800 n1_m1_547200_292800 5.356235
R8244 n1_m1_547200_292800 n1_m1_552000_292800 5.356235
R8245 n1_m1_552000_292800 n1_m1_556800_292800 5.356235
R8246 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R8247 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R8248 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R8249 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R8250 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R8251 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R8252 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R8253 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R8254 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R8255 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R8256 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R8257 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R8258 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R8259 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R8260 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R8261 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R8262 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R8263 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R8264 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R8265 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R8266 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R8267 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R8268 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R8269 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R8270 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R8271 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R8272 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R8273 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R8274 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R8275 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R8276 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R8277 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R8278 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R8279 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R8280 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R8281 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R8282 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R8283 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R8284 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R8285 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R8286 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R8287 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R8288 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R8289 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R8290 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R8291 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R8292 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R8293 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R8294 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R8295 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R8296 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R8297 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R8298 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R8299 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R8300 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R8301 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R8302 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R8303 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R8304 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R8305 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R8306 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R8307 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R8308 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R8309 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R8310 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R8311 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R8312 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R8313 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R8314 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R8315 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R8316 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R8317 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R8318 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R8319 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R8320 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R8321 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R8322 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R8323 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R8324 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R8325 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R8326 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R8327 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R8328 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R8329 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R8330 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R8331 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R8332 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R8333 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R8334 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R8335 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R8336 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R8337 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R8338 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R8339 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R8340 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R8341 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R8342 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R8343 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R8344 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R8345 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R8346 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R8347 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R8348 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R8349 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R8350 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R8351 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R8352 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R8353 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R8354 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R8355 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R8356 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R8357 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R8358 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R8359 n1_m1_470400_297600 n1_m1_475200_297600 5.356235
R8360 n1_m1_475200_297600 n1_m1_480000_297600 5.356235
R8361 n1_m1_480000_297600 n1_m1_484800_297600 5.356235
R8362 n1_m1_484800_297600 n1_m1_489600_297600 5.356235
R8363 n1_m1_489600_297600 n1_m1_494400_297600 5.356235
R8364 n1_m1_494400_297600 n1_m1_499200_297600 5.356235
R8365 n1_m1_499200_297600 n1_m1_504000_297600 5.356235
R8366 n1_m1_504000_297600 n1_m1_508000_297600 4.463529
R8367 n1_m1_508800_297600 n1_m1_508000_297600 0.892706
R8368 n1_m1_508800_297600 n1_m1_513600_297600 5.356235
R8369 n1_m1_513600_297600 n1_m1_518400_297600 5.356235
R8370 n1_m1_518400_297600 n1_m1_523200_297600 5.356235
R8371 n1_m1_523200_297600 n1_m1_528000_297600 5.356235
R8372 n1_m1_528000_297600 n1_m1_532800_297600 5.356235
R8373 n1_m1_532800_297600 n1_m1_536000_297600 3.570824
R8374 n1_m1_537600_297600 n1_m1_536000_297600 1.785412
R8375 n1_m1_537600_297600 n1_m1_542400_297600 5.356235
R8376 n1_m1_542400_297600 n1_m1_547200_297600 5.356235
R8377 n1_m1_547200_297600 n1_m1_552000_297600 5.356235
R8378 n1_m1_552000_297600 n1_m1_556800_297600 5.356235
R8379 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R8380 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R8381 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R8382 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R8383 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R8384 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R8385 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R8386 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R8387 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R8388 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R8389 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R8390 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R8391 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R8392 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R8393 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R8394 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R8395 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R8396 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R8397 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R8398 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R8399 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R8400 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R8401 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R8402 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R8403 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R8404 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R8405 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R8406 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R8407 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R8408 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R8409 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R8410 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R8411 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R8412 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R8413 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R8414 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R8415 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R8416 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R8417 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R8418 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R8419 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R8420 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R8421 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R8422 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R8423 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R8424 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R8425 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R8426 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R8427 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R8428 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R8429 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R8430 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R8431 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R8432 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R8433 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R8434 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R8435 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R8436 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R8437 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R8438 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R8439 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R8440 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R8441 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R8442 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R8443 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R8444 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R8445 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R8446 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R8447 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R8448 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R8449 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R8450 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R8451 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R8452 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R8453 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R8454 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R8455 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R8456 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R8457 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R8458 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R8459 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R8460 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R8461 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R8462 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R8463 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R8464 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R8465 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R8466 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R8467 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R8468 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R8469 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R8470 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R8471 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R8472 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R8473 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R8474 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R8475 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R8476 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R8477 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R8478 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R8479 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R8480 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R8481 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R8482 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R8483 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R8484 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R8485 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R8486 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R8487 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R8488 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R8489 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R8490 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R8491 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R8492 n1_m1_470400_302400 n1_m1_475200_302400 5.356235
R8493 n1_m1_475200_302400 n1_m1_480000_302400 5.356235
R8494 n1_m1_480000_302400 n1_m1_484800_302400 5.356235
R8495 n1_m1_484800_302400 n1_m1_489600_302400 5.356235
R8496 n1_m1_489600_302400 n1_m1_494400_302400 5.356235
R8497 n1_m1_494400_302400 n1_m1_499200_302400 5.356235
R8498 n1_m1_499200_302400 n1_m1_504000_302400 5.356235
R8499 n1_m1_504000_302400 n1_m1_508000_302400 4.463529
R8500 n1_m1_508800_302400 n1_m1_508000_302400 0.892706
R8501 n1_m1_508800_302400 n1_m1_513600_302400 5.356235
R8502 n1_m1_513600_302400 n1_m1_518400_302400 5.356235
R8503 n1_m1_518400_302400 n1_m1_523200_302400 5.356235
R8504 n1_m1_523200_302400 n1_m1_528000_302400 5.356235
R8505 n1_m1_528000_302400 n1_m1_532800_302400 5.356235
R8506 n1_m1_532800_302400 n1_m1_536000_302400 3.570824
R8507 n1_m1_537600_302400 n1_m1_536000_302400 1.785412
R8508 n1_m1_537600_302400 n1_m1_542400_302400 5.356235
R8509 n1_m1_542400_302400 n1_m1_547200_302400 5.356235
R8510 n1_m1_547200_302400 n1_m1_552000_302400 5.356235
R8511 n1_m1_552000_302400 n1_m1_556800_302400 5.356235
R8512 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R8513 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R8514 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R8515 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R8516 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R8517 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R8518 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R8519 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R8520 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R8521 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R8522 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R8523 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R8524 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R8525 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R8526 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R8527 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R8528 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R8529 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R8530 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R8531 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R8532 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R8533 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R8534 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R8535 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R8536 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R8537 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R8538 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R8539 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R8540 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R8541 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R8542 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R8543 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R8544 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R8545 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R8546 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R8547 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R8548 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R8549 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R8550 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R8551 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R8552 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R8553 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R8554 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R8555 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R8556 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R8557 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R8558 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R8559 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R8560 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R8561 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R8562 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R8563 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R8564 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R8565 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R8566 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R8567 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R8568 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R8569 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R8570 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R8571 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R8572 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R8573 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R8574 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R8575 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R8576 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R8577 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R8578 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R8579 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R8580 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R8581 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R8582 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R8583 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R8584 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R8585 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R8586 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R8587 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R8588 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R8589 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R8590 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R8591 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R8592 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R8593 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R8594 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R8595 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R8596 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R8597 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R8598 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R8599 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R8600 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R8601 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R8602 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R8603 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R8604 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R8605 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R8606 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R8607 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R8608 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R8609 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R8610 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R8611 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R8612 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R8613 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R8614 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R8615 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R8616 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R8617 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R8618 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R8619 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R8620 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R8621 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R8622 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R8623 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R8624 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R8625 n1_m1_470400_307200 n1_m1_475200_307200 5.356235
R8626 n1_m1_475200_307200 n1_m1_480000_307200 5.356235
R8627 n1_m1_480000_307200 n1_m1_484800_307200 5.356235
R8628 n1_m1_484800_307200 n1_m1_489600_307200 5.356235
R8629 n1_m1_489600_307200 n1_m1_494400_307200 5.356235
R8630 n1_m1_494400_307200 n1_m1_499200_307200 5.356235
R8631 n1_m1_499200_307200 n1_m1_504000_307200 5.356235
R8632 n1_m1_504000_307200 n1_m1_508000_307200 4.463529
R8633 n1_m1_508800_307200 n1_m1_508000_307200 0.892706
R8634 n1_m1_508800_307200 n1_m1_513600_307200 5.356235
R8635 n1_m1_513600_307200 n1_m1_518400_307200 5.356235
R8636 n1_m1_518400_307200 n1_m1_523200_307200 5.356235
R8637 n1_m1_523200_307200 n1_m1_528000_307200 5.356235
R8638 n1_m1_528000_307200 n1_m1_532800_307200 5.356235
R8639 n1_m1_532800_307200 n1_m1_536000_307200 3.570824
R8640 n1_m1_537600_307200 n1_m1_536000_307200 1.785412
R8641 n1_m1_537600_307200 n1_m1_542400_307200 5.356235
R8642 n1_m1_542400_307200 n1_m1_547200_307200 5.356235
R8643 n1_m1_547200_307200 n1_m1_552000_307200 5.356235
R8644 n1_m1_552000_307200 n1_m1_556800_307200 5.356235
R8645 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R8646 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R8647 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R8648 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R8649 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R8650 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R8651 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R8652 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R8653 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R8654 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R8655 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R8656 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R8657 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R8658 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R8659 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R8660 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R8661 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R8662 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R8663 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R8664 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R8665 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R8666 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R8667 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R8668 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R8669 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R8670 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R8671 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R8672 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R8673 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R8674 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R8675 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R8676 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R8677 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R8678 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R8679 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R8680 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R8681 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R8682 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R8683 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R8684 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R8685 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R8686 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R8687 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R8688 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R8689 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R8690 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R8691 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R8692 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R8693 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R8694 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R8695 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R8696 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R8697 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R8698 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R8699 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R8700 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R8701 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R8702 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R8703 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R8704 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R8705 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R8706 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R8707 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R8708 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R8709 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R8710 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R8711 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R8712 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R8713 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R8714 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R8715 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R8716 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R8717 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R8718 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R8719 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R8720 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R8721 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R8722 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R8723 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R8724 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R8725 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R8726 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R8727 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R8728 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R8729 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R8730 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R8731 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R8732 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R8733 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R8734 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R8735 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R8736 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R8737 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R8738 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R8739 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R8740 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R8741 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R8742 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R8743 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R8744 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R8745 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R8746 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R8747 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R8748 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R8749 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R8750 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R8751 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R8752 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R8753 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R8754 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R8755 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R8756 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R8757 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R8758 n1_m1_470400_312000 n1_m1_475200_312000 5.356235
R8759 n1_m1_475200_312000 n1_m1_480000_312000 5.356235
R8760 n1_m1_480000_312000 n1_m1_484800_312000 5.356235
R8761 n1_m1_484800_312000 n1_m1_489600_312000 5.356235
R8762 n1_m1_489600_312000 n1_m1_494400_312000 5.356235
R8763 n1_m1_494400_312000 n1_m1_499200_312000 5.356235
R8764 n1_m1_499200_312000 n1_m1_504000_312000 5.356235
R8765 n1_m1_504000_312000 n1_m1_508000_312000 4.463529
R8766 n1_m1_508800_312000 n1_m1_508000_312000 0.892706
R8767 n1_m1_508800_312000 n1_m1_513600_312000 5.356235
R8768 n1_m1_513600_312000 n1_m1_518400_312000 5.356235
R8769 n1_m1_518400_312000 n1_m1_523200_312000 5.356235
R8770 n1_m1_523200_312000 n1_m1_528000_312000 5.356235
R8771 n1_m1_528000_312000 n1_m1_532800_312000 5.356235
R8772 n1_m1_532800_312000 n1_m1_536000_312000 3.570824
R8773 n1_m1_537600_312000 n1_m1_536000_312000 1.785412
R8774 n1_m1_537600_312000 n1_m1_542400_312000 5.356235
R8775 n1_m1_542400_312000 n1_m1_547200_312000 5.356235
R8776 n1_m1_547200_312000 n1_m1_552000_312000 5.356235
R8777 n1_m1_552000_312000 n1_m1_556800_312000 5.356235
R8778 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R8779 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R8780 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R8781 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R8782 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R8783 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R8784 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R8785 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R8786 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R8787 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R8788 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R8789 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R8790 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R8791 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R8792 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R8793 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R8794 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R8795 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R8796 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R8797 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R8798 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R8799 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R8800 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R8801 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R8802 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R8803 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R8804 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R8805 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R8806 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R8807 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R8808 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R8809 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R8810 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R8811 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R8812 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R8813 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R8814 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R8815 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R8816 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R8817 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R8818 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R8819 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R8820 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R8821 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R8822 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R8823 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R8824 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R8825 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R8826 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R8827 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R8828 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R8829 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R8830 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R8831 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R8832 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R8833 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R8834 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R8835 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R8836 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R8837 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R8838 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R8839 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R8840 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R8841 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R8842 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R8843 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R8844 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R8845 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R8846 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R8847 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R8848 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R8849 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R8850 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R8851 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R8852 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R8853 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R8854 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R8855 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R8856 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R8857 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R8858 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R8859 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R8860 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R8861 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R8862 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R8863 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R8864 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R8865 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R8866 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R8867 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R8868 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R8869 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R8870 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R8871 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R8872 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R8873 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R8874 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R8875 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R8876 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R8877 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R8878 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R8879 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R8880 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R8881 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R8882 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R8883 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R8884 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R8885 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R8886 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R8887 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R8888 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R8889 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R8890 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R8891 n1_m1_470400_316800 n1_m1_475200_316800 5.356235
R8892 n1_m1_475200_316800 n1_m1_480000_316800 5.356235
R8893 n1_m1_480000_316800 n1_m1_484800_316800 5.356235
R8894 n1_m1_484800_316800 n1_m1_489600_316800 5.356235
R8895 n1_m1_489600_316800 n1_m1_494400_316800 5.356235
R8896 n1_m1_494400_316800 n1_m1_499200_316800 5.356235
R8897 n1_m1_499200_316800 n1_m1_504000_316800 5.356235
R8898 n1_m1_504000_316800 n1_m1_508000_316800 4.463529
R8899 n1_m1_508800_316800 n1_m1_508000_316800 0.892706
R8900 n1_m1_508800_316800 n1_m1_513600_316800 5.356235
R8901 n1_m1_513600_316800 n1_m1_518400_316800 5.356235
R8902 n1_m1_518400_316800 n1_m1_523200_316800 5.356235
R8903 n1_m1_523200_316800 n1_m1_528000_316800 5.356235
R8904 n1_m1_528000_316800 n1_m1_532800_316800 5.356235
R8905 n1_m1_532800_316800 n1_m1_536000_316800 3.570824
R8906 n1_m1_537600_316800 n1_m1_536000_316800 1.785412
R8907 n1_m1_537600_316800 n1_m1_542400_316800 5.356235
R8908 n1_m1_542400_316800 n1_m1_547200_316800 5.356235
R8909 n1_m1_547200_316800 n1_m1_552000_316800 5.356235
R8910 n1_m1_552000_316800 n1_m1_556800_316800 5.356235
R8911 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R8912 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R8913 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R8914 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R8915 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R8916 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R8917 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R8918 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R8919 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R8920 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R8921 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R8922 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R8923 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R8924 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R8925 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R8926 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R8927 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R8928 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R8929 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R8930 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R8931 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R8932 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R8933 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R8934 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R8935 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R8936 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R8937 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R8938 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R8939 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R8940 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R8941 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R8942 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R8943 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R8944 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R8945 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R8946 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R8947 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R8948 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R8949 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R8950 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R8951 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R8952 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R8953 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R8954 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R8955 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R8956 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R8957 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R8958 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R8959 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R8960 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R8961 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R8962 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R8963 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R8964 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R8965 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R8966 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R8967 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R8968 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R8969 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R8970 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R8971 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R8972 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R8973 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R8974 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R8975 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R8976 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R8977 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R8978 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R8979 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R8980 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R8981 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R8982 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R8983 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R8984 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R8985 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R8986 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R8987 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R8988 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R8989 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R8990 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R8991 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R8992 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R8993 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R8994 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R8995 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R8996 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R8997 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R8998 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R8999 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R9000 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R9001 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R9002 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R9003 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R9004 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R9005 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R9006 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R9007 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R9008 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R9009 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R9010 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R9011 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R9012 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R9013 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R9014 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R9015 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R9016 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R9017 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R9018 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R9019 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R9020 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R9021 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R9022 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R9023 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R9024 n1_m1_470400_321600 n1_m1_475200_321600 5.356235
R9025 n1_m1_475200_321600 n1_m1_480000_321600 5.356235
R9026 n1_m1_480000_321600 n1_m1_484800_321600 5.356235
R9027 n1_m1_484800_321600 n1_m1_489600_321600 5.356235
R9028 n1_m1_489600_321600 n1_m1_494400_321600 5.356235
R9029 n1_m1_494400_321600 n1_m1_499200_321600 5.356235
R9030 n1_m1_499200_321600 n1_m1_504000_321600 5.356235
R9031 n1_m1_504000_321600 n1_m1_508000_321600 4.463529
R9032 n1_m1_508800_321600 n1_m1_508000_321600 0.892706
R9033 n1_m1_508800_321600 n1_m1_513600_321600 5.356235
R9034 n1_m1_513600_321600 n1_m1_518400_321600 5.356235
R9035 n1_m1_518400_321600 n1_m1_523200_321600 5.356235
R9036 n1_m1_523200_321600 n1_m1_528000_321600 5.356235
R9037 n1_m1_528000_321600 n1_m1_532800_321600 5.356235
R9038 n1_m1_532800_321600 n1_m1_536000_321600 3.570824
R9039 n1_m1_537600_321600 n1_m1_536000_321600 1.785412
R9040 n1_m1_537600_321600 n1_m1_542400_321600 5.356235
R9041 n1_m1_542400_321600 n1_m1_547200_321600 5.356235
R9042 n1_m1_547200_321600 n1_m1_552000_321600 5.356235
R9043 n1_m1_552000_321600 n1_m1_556800_321600 5.356235
R9044 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R9045 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R9046 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R9047 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R9048 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R9049 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R9050 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R9051 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R9052 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R9053 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R9054 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R9055 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R9056 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R9057 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R9058 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R9059 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R9060 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R9061 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R9062 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R9063 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R9064 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R9065 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R9066 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R9067 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R9068 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R9069 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R9070 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R9071 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R9072 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R9073 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R9074 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R9075 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R9076 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R9077 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R9078 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R9079 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R9080 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R9081 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R9082 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R9083 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R9084 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R9085 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R9086 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R9087 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R9088 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R9089 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R9090 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R9091 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R9092 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R9093 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R9094 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R9095 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R9096 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R9097 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R9098 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R9099 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R9100 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R9101 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R9102 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R9103 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R9104 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R9105 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R9106 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R9107 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R9108 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R9109 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R9110 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R9111 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R9112 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R9113 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R9114 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R9115 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R9116 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R9117 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R9118 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R9119 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R9120 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R9121 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R9122 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R9123 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R9124 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R9125 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R9126 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R9127 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R9128 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R9129 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R9130 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R9131 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R9132 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R9133 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R9134 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R9135 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R9136 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R9137 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R9138 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R9139 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R9140 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R9141 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R9142 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R9143 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R9144 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R9145 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R9146 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R9147 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R9148 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R9149 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R9150 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R9151 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R9152 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R9153 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R9154 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R9155 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R9156 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R9157 n1_m1_470400_326400 n1_m1_475200_326400 5.356235
R9158 n1_m1_475200_326400 n1_m1_480000_326400 5.356235
R9159 n1_m1_480000_326400 n1_m1_484800_326400 5.356235
R9160 n1_m1_484800_326400 n1_m1_489600_326400 5.356235
R9161 n1_m1_489600_326400 n1_m1_494400_326400 5.356235
R9162 n1_m1_494400_326400 n1_m1_499200_326400 5.356235
R9163 n1_m1_499200_326400 n1_m1_504000_326400 5.356235
R9164 n1_m1_504000_326400 n1_m1_508000_326400 4.463529
R9165 n1_m1_508800_326400 n1_m1_508000_326400 0.892706
R9166 n1_m1_508800_326400 n1_m1_513600_326400 5.356235
R9167 n1_m1_513600_326400 n1_m1_518400_326400 5.356235
R9168 n1_m1_518400_326400 n1_m1_523200_326400 5.356235
R9169 n1_m1_523200_326400 n1_m1_528000_326400 5.356235
R9170 n1_m1_528000_326400 n1_m1_532800_326400 5.356235
R9171 n1_m1_532800_326400 n1_m1_536000_326400 3.570824
R9172 n1_m1_537600_326400 n1_m1_536000_326400 1.785412
R9173 n1_m1_537600_326400 n1_m1_542400_326400 5.356235
R9174 n1_m1_542400_326400 n1_m1_547200_326400 5.356235
R9175 n1_m1_547200_326400 n1_m1_552000_326400 5.356235
R9176 n1_m1_552000_326400 n1_m1_556800_326400 5.356235
R9177 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R9178 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R9179 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R9180 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R9181 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R9182 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R9183 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R9184 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R9185 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R9186 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R9187 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R9188 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R9189 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R9190 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R9191 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R9192 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R9193 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R9194 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R9195 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R9196 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R9197 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R9198 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R9199 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R9200 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R9201 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R9202 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R9203 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R9204 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R9205 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R9206 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R9207 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R9208 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R9209 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R9210 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R9211 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R9212 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R9213 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R9214 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R9215 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R9216 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R9217 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R9218 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R9219 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R9220 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R9221 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R9222 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R9223 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R9224 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R9225 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R9226 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R9227 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R9228 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R9229 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R9230 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R9231 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R9232 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R9233 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R9234 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R9235 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R9236 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R9237 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R9238 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R9239 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R9240 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R9241 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R9242 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R9243 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R9244 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R9245 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R9246 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R9247 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R9248 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R9249 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R9250 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R9251 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R9252 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R9253 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R9254 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R9255 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R9256 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R9257 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R9258 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R9259 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R9260 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R9261 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R9262 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R9263 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R9264 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R9265 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R9266 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R9267 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R9268 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R9269 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R9270 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R9271 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R9272 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R9273 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R9274 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R9275 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R9276 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R9277 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R9278 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R9279 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R9280 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R9281 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R9282 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R9283 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R9284 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R9285 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R9286 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R9287 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R9288 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R9289 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R9290 n1_m1_470400_331200 n1_m1_475200_331200 5.356235
R9291 n1_m1_475200_331200 n1_m1_480000_331200 5.356235
R9292 n1_m1_480000_331200 n1_m1_484800_331200 5.356235
R9293 n1_m1_484800_331200 n1_m1_489600_331200 5.356235
R9294 n1_m1_489600_331200 n1_m1_494400_331200 5.356235
R9295 n1_m1_494400_331200 n1_m1_499200_331200 5.356235
R9296 n1_m1_499200_331200 n1_m1_504000_331200 5.356235
R9297 n1_m1_504000_331200 n1_m1_508000_331200 4.463529
R9298 n1_m1_508800_331200 n1_m1_508000_331200 0.892706
R9299 n1_m1_508800_331200 n1_m1_513600_331200 5.356235
R9300 n1_m1_513600_331200 n1_m1_518400_331200 5.356235
R9301 n1_m1_518400_331200 n1_m1_523200_331200 5.356235
R9302 n1_m1_523200_331200 n1_m1_528000_331200 5.356235
R9303 n1_m1_528000_331200 n1_m1_532800_331200 5.356235
R9304 n1_m1_532800_331200 n1_m1_536000_331200 3.570824
R9305 n1_m1_537600_331200 n1_m1_536000_331200 1.785412
R9306 n1_m1_537600_331200 n1_m1_542400_331200 5.356235
R9307 n1_m1_542400_331200 n1_m1_547200_331200 5.356235
R9308 n1_m1_547200_331200 n1_m1_552000_331200 5.356235
R9309 n1_m1_552000_331200 n1_m1_556800_331200 5.356235
R9310 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R9311 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R9312 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R9313 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R9314 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R9315 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R9316 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R9317 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R9318 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R9319 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R9320 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R9321 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R9322 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R9323 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R9324 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R9325 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R9326 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R9327 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R9328 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R9329 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R9330 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R9331 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R9332 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R9333 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R9334 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R9335 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R9336 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R9337 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R9338 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R9339 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R9340 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R9341 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R9342 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R9343 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R9344 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R9345 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R9346 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R9347 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R9348 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R9349 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R9350 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R9351 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R9352 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R9353 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R9354 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R9355 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R9356 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R9357 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R9358 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R9359 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R9360 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R9361 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R9362 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R9363 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R9364 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R9365 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R9366 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R9367 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R9368 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R9369 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R9370 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R9371 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R9372 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R9373 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R9374 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R9375 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R9376 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R9377 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R9378 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R9379 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R9380 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R9381 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R9382 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R9383 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R9384 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R9385 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R9386 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R9387 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R9388 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R9389 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R9390 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R9391 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R9392 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R9393 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R9394 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R9395 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R9396 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R9397 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R9398 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R9399 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R9400 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R9401 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R9402 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R9403 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R9404 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R9405 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R9406 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R9407 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R9408 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R9409 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R9410 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R9411 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R9412 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R9413 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R9414 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R9415 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R9416 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R9417 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R9418 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R9419 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R9420 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R9421 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R9422 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R9423 n1_m1_470400_336000 n1_m1_475200_336000 5.356235
R9424 n1_m1_475200_336000 n1_m1_480000_336000 5.356235
R9425 n1_m1_480000_336000 n1_m1_484800_336000 5.356235
R9426 n1_m1_484800_336000 n1_m1_489600_336000 5.356235
R9427 n1_m1_489600_336000 n1_m1_494400_336000 5.356235
R9428 n1_m1_494400_336000 n1_m1_499200_336000 5.356235
R9429 n1_m1_499200_336000 n1_m1_504000_336000 5.356235
R9430 n1_m1_504000_336000 n1_m1_508000_336000 4.463529
R9431 n1_m1_508800_336000 n1_m1_508000_336000 0.892706
R9432 n1_m1_508800_336000 n1_m1_513600_336000 5.356235
R9433 n1_m1_513600_336000 n1_m1_518400_336000 5.356235
R9434 n1_m1_518400_336000 n1_m1_523200_336000 5.356235
R9435 n1_m1_523200_336000 n1_m1_528000_336000 5.356235
R9436 n1_m1_528000_336000 n1_m1_532800_336000 5.356235
R9437 n1_m1_532800_336000 n1_m1_536000_336000 3.570824
R9438 n1_m1_537600_336000 n1_m1_536000_336000 1.785412
R9439 n1_m1_537600_336000 n1_m1_542400_336000 5.356235
R9440 n1_m1_542400_336000 n1_m1_547200_336000 5.356235
R9441 n1_m1_547200_336000 n1_m1_552000_336000 5.356235
R9442 n1_m1_552000_336000 n1_m1_556800_336000 5.356235
R9443 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R9444 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R9445 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R9446 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R9447 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R9448 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R9449 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R9450 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R9451 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R9452 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R9453 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R9454 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R9455 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R9456 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R9457 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R9458 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R9459 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R9460 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R9461 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R9462 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R9463 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R9464 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R9465 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R9466 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R9467 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R9468 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R9469 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R9470 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R9471 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R9472 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R9473 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R9474 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R9475 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R9476 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R9477 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R9478 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R9479 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R9480 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R9481 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R9482 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R9483 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R9484 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R9485 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R9486 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R9487 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R9488 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R9489 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R9490 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R9491 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R9492 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R9493 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R9494 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R9495 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R9496 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R9497 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R9498 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R9499 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R9500 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R9501 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R9502 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R9503 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R9504 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R9505 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R9506 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R9507 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R9508 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R9509 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R9510 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R9511 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R9512 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R9513 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R9514 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R9515 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R9516 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R9517 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R9518 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R9519 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R9520 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R9521 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R9522 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R9523 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R9524 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R9525 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R9526 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R9527 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R9528 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R9529 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R9530 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R9531 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R9532 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R9533 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R9534 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R9535 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R9536 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R9537 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R9538 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R9539 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R9540 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R9541 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R9542 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R9543 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R9544 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R9545 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R9546 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R9547 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R9548 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R9549 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R9550 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R9551 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R9552 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R9553 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R9554 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R9555 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R9556 n1_m1_470400_340800 n1_m1_475200_340800 5.356235
R9557 n1_m1_475200_340800 n1_m1_480000_340800 5.356235
R9558 n1_m1_480000_340800 n1_m1_484800_340800 5.356235
R9559 n1_m1_484800_340800 n1_m1_489600_340800 5.356235
R9560 n1_m1_489600_340800 n1_m1_494400_340800 5.356235
R9561 n1_m1_494400_340800 n1_m1_499200_340800 5.356235
R9562 n1_m1_499200_340800 n1_m1_504000_340800 5.356235
R9563 n1_m1_504000_340800 n1_m1_508000_340800 4.463529
R9564 n1_m1_508800_340800 n1_m1_508000_340800 0.892706
R9565 n1_m1_508800_340800 n1_m1_513600_340800 5.356235
R9566 n1_m1_513600_340800 n1_m1_518400_340800 5.356235
R9567 n1_m1_518400_340800 n1_m1_523200_340800 5.356235
R9568 n1_m1_523200_340800 n1_m1_528000_340800 5.356235
R9569 n1_m1_528000_340800 n1_m1_532800_340800 5.356235
R9570 n1_m1_532800_340800 n1_m1_536000_340800 3.570824
R9571 n1_m1_537600_340800 n1_m1_536000_340800 1.785412
R9572 n1_m1_537600_340800 n1_m1_542400_340800 5.356235
R9573 n1_m1_542400_340800 n1_m1_547200_340800 5.356235
R9574 n1_m1_547200_340800 n1_m1_552000_340800 5.356235
R9575 n1_m1_552000_340800 n1_m1_556800_340800 5.356235
R9576 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R9577 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R9578 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R9579 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R9580 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R9581 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R9582 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R9583 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R9584 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R9585 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R9586 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R9587 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R9588 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R9589 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R9590 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R9591 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R9592 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R9593 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R9594 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R9595 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R9596 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R9597 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R9598 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R9599 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R9600 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R9601 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R9602 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R9603 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R9604 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R9605 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R9606 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R9607 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R9608 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R9609 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R9610 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R9611 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R9612 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R9613 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R9614 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R9615 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R9616 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R9617 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R9618 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R9619 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R9620 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R9621 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R9622 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R9623 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R9624 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R9625 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R9626 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R9627 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R9628 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R9629 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R9630 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R9631 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R9632 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R9633 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R9634 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R9635 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R9636 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R9637 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R9638 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R9639 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R9640 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R9641 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R9642 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R9643 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R9644 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R9645 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R9646 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R9647 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R9648 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R9649 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R9650 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R9651 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R9652 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R9653 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R9654 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R9655 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R9656 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R9657 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R9658 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R9659 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R9660 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R9661 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R9662 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R9663 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R9664 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R9665 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R9666 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R9667 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R9668 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R9669 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R9670 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R9671 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R9672 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R9673 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R9674 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R9675 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R9676 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R9677 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R9678 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R9679 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R9680 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R9681 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R9682 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R9683 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R9684 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R9685 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R9686 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R9687 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R9688 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R9689 n1_m1_470400_345600 n1_m1_475200_345600 5.356235
R9690 n1_m1_475200_345600 n1_m1_480000_345600 5.356235
R9691 n1_m1_480000_345600 n1_m1_484800_345600 5.356235
R9692 n1_m1_484800_345600 n1_m1_489600_345600 5.356235
R9693 n1_m1_489600_345600 n1_m1_494400_345600 5.356235
R9694 n1_m1_494400_345600 n1_m1_499200_345600 5.356235
R9695 n1_m1_499200_345600 n1_m1_504000_345600 5.356235
R9696 n1_m1_504000_345600 n1_m1_508000_345600 4.463529
R9697 n1_m1_508800_345600 n1_m1_508000_345600 0.892706
R9698 n1_m1_508800_345600 n1_m1_513600_345600 5.356235
R9699 n1_m1_513600_345600 n1_m1_518400_345600 5.356235
R9700 n1_m1_518400_345600 n1_m1_523200_345600 5.356235
R9701 n1_m1_523200_345600 n1_m1_528000_345600 5.356235
R9702 n1_m1_528000_345600 n1_m1_532800_345600 5.356235
R9703 n1_m1_532800_345600 n1_m1_536000_345600 3.570824
R9704 n1_m1_537600_345600 n1_m1_536000_345600 1.785412
R9705 n1_m1_537600_345600 n1_m1_542400_345600 5.356235
R9706 n1_m1_542400_345600 n1_m1_547200_345600 5.356235
R9707 n1_m1_547200_345600 n1_m1_552000_345600 5.356235
R9708 n1_m1_552000_345600 n1_m1_556800_345600 5.356235
R9709 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R9710 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R9711 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R9712 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R9713 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R9714 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R9715 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R9716 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R9717 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R9718 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R9719 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R9720 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R9721 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R9722 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R9723 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R9724 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R9725 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R9726 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R9727 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R9728 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R9729 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R9730 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R9731 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R9732 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R9733 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R9734 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R9735 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R9736 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R9737 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R9738 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R9739 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R9740 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R9741 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R9742 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R9743 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R9744 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R9745 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R9746 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R9747 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R9748 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R9749 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R9750 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R9751 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R9752 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R9753 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R9754 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R9755 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R9756 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R9757 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R9758 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R9759 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R9760 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R9761 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R9762 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R9763 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R9764 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R9765 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R9766 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R9767 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R9768 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R9769 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R9770 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R9771 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R9772 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R9773 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R9774 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R9775 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R9776 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R9777 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R9778 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R9779 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R9780 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R9781 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R9782 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R9783 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R9784 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R9785 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R9786 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R9787 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R9788 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R9789 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R9790 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R9791 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R9792 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R9793 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R9794 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R9795 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R9796 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R9797 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R9798 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R9799 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R9800 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R9801 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R9802 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R9803 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R9804 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R9805 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R9806 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R9807 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R9808 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R9809 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R9810 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R9811 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R9812 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R9813 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R9814 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R9815 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R9816 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R9817 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R9818 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R9819 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R9820 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R9821 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R9822 n1_m1_470400_350400 n1_m1_475200_350400 5.356235
R9823 n1_m1_475200_350400 n1_m1_480000_350400 5.356235
R9824 n1_m1_480000_350400 n1_m1_484800_350400 5.356235
R9825 n1_m1_484800_350400 n1_m1_489600_350400 5.356235
R9826 n1_m1_489600_350400 n1_m1_494400_350400 5.356235
R9827 n1_m1_494400_350400 n1_m1_499200_350400 5.356235
R9828 n1_m1_499200_350400 n1_m1_504000_350400 5.356235
R9829 n1_m1_504000_350400 n1_m1_508000_350400 4.463529
R9830 n1_m1_508800_350400 n1_m1_508000_350400 0.892706
R9831 n1_m1_508800_350400 n1_m1_513600_350400 5.356235
R9832 n1_m1_513600_350400 n1_m1_518400_350400 5.356235
R9833 n1_m1_518400_350400 n1_m1_523200_350400 5.356235
R9834 n1_m1_523200_350400 n1_m1_528000_350400 5.356235
R9835 n1_m1_528000_350400 n1_m1_532800_350400 5.356235
R9836 n1_m1_532800_350400 n1_m1_536000_350400 3.570824
R9837 n1_m1_537600_350400 n1_m1_536000_350400 1.785412
R9838 n1_m1_537600_350400 n1_m1_542400_350400 5.356235
R9839 n1_m1_542400_350400 n1_m1_547200_350400 5.356235
R9840 n1_m1_547200_350400 n1_m1_552000_350400 5.356235
R9841 n1_m1_552000_350400 n1_m1_556800_350400 5.356235
R9842 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R9843 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R9844 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R9845 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R9846 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R9847 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R9848 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R9849 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R9850 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R9851 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R9852 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R9853 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R9854 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R9855 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R9856 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R9857 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R9858 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R9859 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R9860 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R9861 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R9862 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R9863 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R9864 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R9865 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R9866 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R9867 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R9868 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R9869 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R9870 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R9871 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R9872 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R9873 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R9874 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R9875 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R9876 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R9877 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R9878 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R9879 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R9880 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R9881 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R9882 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R9883 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R9884 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R9885 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R9886 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R9887 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R9888 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R9889 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R9890 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R9891 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R9892 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R9893 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R9894 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R9895 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R9896 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R9897 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R9898 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R9899 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R9900 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R9901 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R9902 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R9903 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R9904 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R9905 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R9906 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R9907 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R9908 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R9909 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R9910 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R9911 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R9912 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R9913 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R9914 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R9915 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R9916 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R9917 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R9918 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R9919 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R9920 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R9921 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R9922 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R9923 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R9924 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R9925 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R9926 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R9927 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R9928 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R9929 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R9930 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R9931 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R9932 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R9933 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R9934 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R9935 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R9936 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R9937 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R9938 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R9939 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R9940 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R9941 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R9942 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R9943 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R9944 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R9945 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R9946 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R9947 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R9948 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R9949 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R9950 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R9951 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R9952 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R9953 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R9954 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R9955 n1_m1_470400_355200 n1_m1_475200_355200 5.356235
R9956 n1_m1_475200_355200 n1_m1_480000_355200 5.356235
R9957 n1_m1_480000_355200 n1_m1_484800_355200 5.356235
R9958 n1_m1_484800_355200 n1_m1_489600_355200 5.356235
R9959 n1_m1_489600_355200 n1_m1_494400_355200 5.356235
R9960 n1_m1_494400_355200 n1_m1_499200_355200 5.356235
R9961 n1_m1_499200_355200 n1_m1_504000_355200 5.356235
R9962 n1_m1_504000_355200 n1_m1_508000_355200 4.463529
R9963 n1_m1_508800_355200 n1_m1_508000_355200 0.892706
R9964 n1_m1_508800_355200 n1_m1_513600_355200 5.356235
R9965 n1_m1_513600_355200 n1_m1_518400_355200 5.356235
R9966 n1_m1_518400_355200 n1_m1_523200_355200 5.356235
R9967 n1_m1_523200_355200 n1_m1_528000_355200 5.356235
R9968 n1_m1_528000_355200 n1_m1_532800_355200 5.356235
R9969 n1_m1_532800_355200 n1_m1_536000_355200 3.570824
R9970 n1_m1_537600_355200 n1_m1_536000_355200 1.785412
R9971 n1_m1_537600_355200 n1_m1_542400_355200 5.356235
R9972 n1_m1_542400_355200 n1_m1_547200_355200 5.356235
R9973 n1_m1_547200_355200 n1_m1_552000_355200 5.356235
R9974 n1_m1_552000_355200 n1_m1_556800_355200 5.356235
R9975 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R9976 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R9977 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R9978 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R9979 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R9980 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R9981 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R9982 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R9983 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R9984 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R9985 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R9986 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R9987 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R9988 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R9989 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R9990 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R9991 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R9992 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R9993 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R9994 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R9995 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R9996 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R9997 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R9998 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R9999 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R10000 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R10001 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R10002 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R10003 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R10004 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R10005 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R10006 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R10007 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R10008 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R10009 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R10010 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R10011 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R10012 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R10013 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R10014 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R10015 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R10016 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R10017 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R10018 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R10019 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R10020 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R10021 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R10022 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R10023 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R10024 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R10025 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R10026 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R10027 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R10028 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R10029 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R10030 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R10031 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R10032 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R10033 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R10034 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R10035 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R10036 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R10037 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R10038 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R10039 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R10040 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R10041 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R10042 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R10043 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R10044 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R10045 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R10046 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R10047 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R10048 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R10049 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R10050 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R10051 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R10052 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R10053 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R10054 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R10055 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R10056 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R10057 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R10058 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R10059 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R10060 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R10061 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R10062 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R10063 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R10064 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R10065 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R10066 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R10067 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R10068 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R10069 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R10070 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R10071 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R10072 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R10073 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R10074 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R10075 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R10076 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R10077 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R10078 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R10079 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R10080 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R10081 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R10082 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R10083 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R10084 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R10085 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R10086 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R10087 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R10088 n1_m1_470400_360000 n1_m1_475200_360000 5.356235
R10089 n1_m1_475200_360000 n1_m1_480000_360000 5.356235
R10090 n1_m1_480000_360000 n1_m1_484800_360000 5.356235
R10091 n1_m1_484800_360000 n1_m1_489600_360000 5.356235
R10092 n1_m1_489600_360000 n1_m1_494400_360000 5.356235
R10093 n1_m1_494400_360000 n1_m1_499200_360000 5.356235
R10094 n1_m1_499200_360000 n1_m1_504000_360000 5.356235
R10095 n1_m1_504000_360000 n1_m1_508000_360000 4.463529
R10096 n1_m1_508800_360000 n1_m1_508000_360000 0.892706
R10097 n1_m1_508800_360000 n1_m1_513600_360000 5.356235
R10098 n1_m1_513600_360000 n1_m1_518400_360000 5.356235
R10099 n1_m1_518400_360000 n1_m1_523200_360000 5.356235
R10100 n1_m1_523200_360000 n1_m1_528000_360000 5.356235
R10101 n1_m1_528000_360000 n1_m1_532800_360000 5.356235
R10102 n1_m1_532800_360000 n1_m1_536000_360000 3.570824
R10103 n1_m1_537600_360000 n1_m1_536000_360000 1.785412
R10104 n1_m1_537600_360000 n1_m1_542400_360000 5.356235
R10105 n1_m1_542400_360000 n1_m1_547200_360000 5.356235
R10106 n1_m1_547200_360000 n1_m1_552000_360000 5.356235
R10107 n1_m1_552000_360000 n1_m1_556800_360000 5.356235
R10108 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R10109 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R10110 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R10111 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R10112 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R10113 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R10114 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R10115 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R10116 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R10117 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R10118 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R10119 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R10120 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R10121 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R10122 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R10123 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R10124 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R10125 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R10126 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R10127 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R10128 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R10129 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R10130 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R10131 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R10132 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R10133 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R10134 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R10135 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R10136 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R10137 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R10138 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R10139 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R10140 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R10141 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R10142 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R10143 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R10144 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R10145 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R10146 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R10147 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R10148 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R10149 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R10150 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R10151 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R10152 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R10153 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R10154 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R10155 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R10156 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R10157 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R10158 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R10159 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R10160 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R10161 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R10162 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R10163 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R10164 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R10165 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R10166 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R10167 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R10168 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R10169 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R10170 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R10171 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R10172 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R10173 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R10174 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R10175 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R10176 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R10177 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R10178 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R10179 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R10180 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R10181 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R10182 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R10183 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R10184 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R10185 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R10186 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R10187 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R10188 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R10189 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R10190 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R10191 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R10192 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R10193 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R10194 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R10195 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R10196 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R10197 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R10198 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R10199 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R10200 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R10201 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R10202 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R10203 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R10204 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R10205 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R10206 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R10207 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R10208 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R10209 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R10210 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R10211 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R10212 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R10213 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R10214 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R10215 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R10216 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R10217 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R10218 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R10219 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R10220 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R10221 n1_m1_470400_364800 n1_m1_475200_364800 5.356235
R10222 n1_m1_475200_364800 n1_m1_480000_364800 5.356235
R10223 n1_m1_480000_364800 n1_m1_484800_364800 5.356235
R10224 n1_m1_484800_364800 n1_m1_489600_364800 5.356235
R10225 n1_m1_489600_364800 n1_m1_494400_364800 5.356235
R10226 n1_m1_494400_364800 n1_m1_499200_364800 5.356235
R10227 n1_m1_499200_364800 n1_m1_504000_364800 5.356235
R10228 n1_m1_504000_364800 n1_m1_508000_364800 4.463529
R10229 n1_m1_508800_364800 n1_m1_508000_364800 0.892706
R10230 n1_m1_508800_364800 n1_m1_513600_364800 5.356235
R10231 n1_m1_513600_364800 n1_m1_518400_364800 5.356235
R10232 n1_m1_518400_364800 n1_m1_523200_364800 5.356235
R10233 n1_m1_523200_364800 n1_m1_528000_364800 5.356235
R10234 n1_m1_528000_364800 n1_m1_532800_364800 5.356235
R10235 n1_m1_532800_364800 n1_m1_536000_364800 3.570824
R10236 n1_m1_537600_364800 n1_m1_536000_364800 1.785412
R10237 n1_m1_537600_364800 n1_m1_542400_364800 5.356235
R10238 n1_m1_542400_364800 n1_m1_547200_364800 5.356235
R10239 n1_m1_547200_364800 n1_m1_552000_364800 5.356235
R10240 n1_m1_552000_364800 n1_m1_556800_364800 5.356235
R10241 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R10242 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R10243 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R10244 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R10245 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R10246 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R10247 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R10248 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R10249 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R10250 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R10251 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R10252 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R10253 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R10254 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R10255 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R10256 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R10257 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R10258 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R10259 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R10260 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R10261 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R10262 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R10263 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R10264 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R10265 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R10266 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R10267 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R10268 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R10269 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R10270 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R10271 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R10272 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R10273 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R10274 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R10275 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R10276 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R10277 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R10278 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R10279 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R10280 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R10281 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R10282 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R10283 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R10284 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R10285 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R10286 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R10287 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R10288 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R10289 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R10290 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R10291 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R10292 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R10293 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R10294 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R10295 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R10296 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R10297 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R10298 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R10299 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R10300 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R10301 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R10302 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R10303 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R10304 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R10305 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R10306 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R10307 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R10308 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R10309 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R10310 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R10311 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R10312 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R10313 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R10314 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R10315 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R10316 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R10317 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R10318 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R10319 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R10320 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R10321 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R10322 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R10323 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R10324 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R10325 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R10326 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R10327 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R10328 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R10329 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R10330 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R10331 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R10332 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R10333 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R10334 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R10335 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R10336 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R10337 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R10338 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R10339 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R10340 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R10341 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R10342 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R10343 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R10344 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R10345 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R10346 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R10347 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R10348 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R10349 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R10350 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R10351 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R10352 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R10353 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R10354 n1_m1_470400_369600 n1_m1_475200_369600 5.356235
R10355 n1_m1_475200_369600 n1_m1_480000_369600 5.356235
R10356 n1_m1_480000_369600 n1_m1_484800_369600 5.356235
R10357 n1_m1_484800_369600 n1_m1_489600_369600 5.356235
R10358 n1_m1_489600_369600 n1_m1_494400_369600 5.356235
R10359 n1_m1_494400_369600 n1_m1_499200_369600 5.356235
R10360 n1_m1_499200_369600 n1_m1_504000_369600 5.356235
R10361 n1_m1_504000_369600 n1_m1_508000_369600 4.463529
R10362 n1_m1_508800_369600 n1_m1_508000_369600 0.892706
R10363 n1_m1_508800_369600 n1_m1_513600_369600 5.356235
R10364 n1_m1_513600_369600 n1_m1_518400_369600 5.356235
R10365 n1_m1_518400_369600 n1_m1_523200_369600 5.356235
R10366 n1_m1_523200_369600 n1_m1_528000_369600 5.356235
R10367 n1_m1_528000_369600 n1_m1_532800_369600 5.356235
R10368 n1_m1_532800_369600 n1_m1_536000_369600 3.570824
R10369 n1_m1_537600_369600 n1_m1_536000_369600 1.785412
R10370 n1_m1_537600_369600 n1_m1_542400_369600 5.356235
R10371 n1_m1_542400_369600 n1_m1_547200_369600 5.356235
R10372 n1_m1_547200_369600 n1_m1_552000_369600 5.356235
R10373 n1_m1_552000_369600 n1_m1_556800_369600 5.356235
R10374 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R10375 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R10376 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R10377 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R10378 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R10379 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R10380 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R10381 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R10382 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R10383 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R10384 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R10385 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R10386 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R10387 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R10388 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R10389 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R10390 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R10391 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R10392 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R10393 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R10394 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R10395 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R10396 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R10397 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R10398 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R10399 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R10400 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R10401 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R10402 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R10403 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R10404 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R10405 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R10406 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R10407 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R10408 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R10409 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R10410 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R10411 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R10412 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R10413 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R10414 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R10415 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R10416 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R10417 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R10418 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R10419 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R10420 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R10421 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R10422 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R10423 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R10424 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R10425 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R10426 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R10427 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R10428 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R10429 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R10430 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R10431 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R10432 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R10433 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R10434 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R10435 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R10436 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R10437 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R10438 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R10439 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R10440 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R10441 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R10442 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R10443 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R10444 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R10445 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R10446 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R10447 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R10448 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R10449 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R10450 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R10451 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R10452 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R10453 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R10454 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R10455 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R10456 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R10457 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R10458 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R10459 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R10460 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R10461 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R10462 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R10463 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R10464 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R10465 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R10466 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R10467 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R10468 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R10469 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R10470 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R10471 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R10472 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R10473 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R10474 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R10475 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R10476 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R10477 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R10478 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R10479 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R10480 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R10481 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R10482 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R10483 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R10484 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R10485 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R10486 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R10487 n1_m1_470400_374400 n1_m1_475200_374400 5.356235
R10488 n1_m1_475200_374400 n1_m1_480000_374400 5.356235
R10489 n1_m1_480000_374400 n1_m1_484800_374400 5.356235
R10490 n1_m1_484800_374400 n1_m1_489600_374400 5.356235
R10491 n1_m1_489600_374400 n1_m1_494400_374400 5.356235
R10492 n1_m1_494400_374400 n1_m1_499200_374400 5.356235
R10493 n1_m1_499200_374400 n1_m1_504000_374400 5.356235
R10494 n1_m1_504000_374400 n1_m1_508000_374400 4.463529
R10495 n1_m1_508800_374400 n1_m1_508000_374400 0.892706
R10496 n1_m1_508800_374400 n1_m1_513600_374400 5.356235
R10497 n1_m1_513600_374400 n1_m1_518400_374400 5.356235
R10498 n1_m1_518400_374400 n1_m1_523200_374400 5.356235
R10499 n1_m1_523200_374400 n1_m1_528000_374400 5.356235
R10500 n1_m1_528000_374400 n1_m1_532800_374400 5.356235
R10501 n1_m1_532800_374400 n1_m1_536000_374400 3.570824
R10502 n1_m1_537600_374400 n1_m1_536000_374400 1.785412
R10503 n1_m1_537600_374400 n1_m1_542400_374400 5.356235
R10504 n1_m1_542400_374400 n1_m1_547200_374400 5.356235
R10505 n1_m1_547200_374400 n1_m1_552000_374400 5.356235
R10506 n1_m1_552000_374400 n1_m1_556800_374400 5.356235
R10507 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R10508 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R10509 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R10510 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R10511 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R10512 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R10513 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R10514 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R10515 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R10516 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R10517 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R10518 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R10519 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R10520 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R10521 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R10522 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R10523 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R10524 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R10525 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R10526 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R10527 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R10528 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R10529 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R10530 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R10531 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R10532 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R10533 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R10534 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R10535 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R10536 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R10537 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R10538 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R10539 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R10540 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R10541 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R10542 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R10543 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R10544 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R10545 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R10546 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R10547 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R10548 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R10549 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R10550 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R10551 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R10552 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R10553 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R10554 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R10555 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R10556 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R10557 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R10558 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R10559 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R10560 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R10561 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R10562 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R10563 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R10564 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R10565 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R10566 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R10567 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R10568 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R10569 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R10570 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R10571 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R10572 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R10573 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R10574 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R10575 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R10576 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R10577 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R10578 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R10579 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R10580 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R10581 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R10582 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R10583 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R10584 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R10585 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R10586 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R10587 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R10588 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R10589 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R10590 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R10591 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R10592 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R10593 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R10594 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R10595 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R10596 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R10597 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R10598 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R10599 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R10600 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R10601 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R10602 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R10603 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R10604 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R10605 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R10606 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R10607 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R10608 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R10609 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R10610 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R10611 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R10612 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R10613 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R10614 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R10615 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R10616 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R10617 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R10618 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R10619 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R10620 n1_m1_470400_379200 n1_m1_475200_379200 5.356235
R10621 n1_m1_475200_379200 n1_m1_480000_379200 5.356235
R10622 n1_m1_480000_379200 n1_m1_484800_379200 5.356235
R10623 n1_m1_484800_379200 n1_m1_489600_379200 5.356235
R10624 n1_m1_489600_379200 n1_m1_494400_379200 5.356235
R10625 n1_m1_494400_379200 n1_m1_499200_379200 5.356235
R10626 n1_m1_499200_379200 n1_m1_504000_379200 5.356235
R10627 n1_m1_504000_379200 n1_m1_508000_379200 4.463529
R10628 n1_m1_508800_379200 n1_m1_508000_379200 0.892706
R10629 n1_m1_508800_379200 n1_m1_513600_379200 5.356235
R10630 n1_m1_513600_379200 n1_m1_518400_379200 5.356235
R10631 n1_m1_518400_379200 n1_m1_523200_379200 5.356235
R10632 n1_m1_523200_379200 n1_m1_528000_379200 5.356235
R10633 n1_m1_528000_379200 n1_m1_532800_379200 5.356235
R10634 n1_m1_532800_379200 n1_m1_536000_379200 3.570824
R10635 n1_m1_537600_379200 n1_m1_536000_379200 1.785412
R10636 n1_m1_537600_379200 n1_m1_542400_379200 5.356235
R10637 n1_m1_542400_379200 n1_m1_547200_379200 5.356235
R10638 n1_m1_547200_379200 n1_m1_552000_379200 5.356235
R10639 n1_m1_552000_379200 n1_m1_556800_379200 5.356235
R10640 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R10641 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R10642 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R10643 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R10644 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R10645 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R10646 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R10647 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R10648 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R10649 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R10650 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R10651 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R10652 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R10653 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R10654 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R10655 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R10656 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R10657 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R10658 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R10659 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R10660 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R10661 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R10662 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R10663 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R10664 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R10665 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R10666 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R10667 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R10668 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R10669 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R10670 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R10671 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R10672 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R10673 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R10674 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R10675 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R10676 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R10677 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R10678 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R10679 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R10680 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R10681 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R10682 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R10683 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R10684 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R10685 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R10686 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R10687 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R10688 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R10689 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R10690 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R10691 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R10692 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R10693 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R10694 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R10695 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R10696 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R10697 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R10698 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R10699 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R10700 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R10701 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R10702 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R10703 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R10704 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R10705 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R10706 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R10707 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R10708 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R10709 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R10710 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R10711 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R10712 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R10713 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R10714 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R10715 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R10716 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R10717 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R10718 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R10719 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R10720 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R10721 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R10722 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R10723 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R10724 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R10725 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R10726 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R10727 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R10728 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R10729 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R10730 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R10731 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R10732 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R10733 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R10734 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R10735 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R10736 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R10737 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R10738 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R10739 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R10740 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R10741 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R10742 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R10743 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R10744 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R10745 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R10746 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R10747 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R10748 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R10749 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R10750 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R10751 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R10752 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R10753 n1_m1_470400_384000 n1_m1_475200_384000 5.356235
R10754 n1_m1_475200_384000 n1_m1_480000_384000 5.356235
R10755 n1_m1_480000_384000 n1_m1_484800_384000 5.356235
R10756 n1_m1_484800_384000 n1_m1_489600_384000 5.356235
R10757 n1_m1_489600_384000 n1_m1_494400_384000 5.356235
R10758 n1_m1_494400_384000 n1_m1_499200_384000 5.356235
R10759 n1_m1_499200_384000 n1_m1_504000_384000 5.356235
R10760 n1_m1_504000_384000 n1_m1_508000_384000 4.463529
R10761 n1_m1_508800_384000 n1_m1_508000_384000 0.892706
R10762 n1_m1_508800_384000 n1_m1_513600_384000 5.356235
R10763 n1_m1_513600_384000 n1_m1_518400_384000 5.356235
R10764 n1_m1_518400_384000 n1_m1_523200_384000 5.356235
R10765 n1_m1_523200_384000 n1_m1_528000_384000 5.356235
R10766 n1_m1_528000_384000 n1_m1_532800_384000 5.356235
R10767 n1_m1_532800_384000 n1_m1_536000_384000 3.570824
R10768 n1_m1_537600_384000 n1_m1_536000_384000 1.785412
R10769 n1_m1_537600_384000 n1_m1_542400_384000 5.356235
R10770 n1_m1_542400_384000 n1_m1_547200_384000 5.356235
R10771 n1_m1_547200_384000 n1_m1_552000_384000 5.356235
R10772 n1_m1_552000_384000 n1_m1_556800_384000 5.356235
R10773 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R10774 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R10775 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R10776 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R10777 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R10778 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R10779 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R10780 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R10781 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R10782 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R10783 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R10784 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R10785 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R10786 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R10787 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R10788 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R10789 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R10790 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R10791 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R10792 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R10793 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R10794 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R10795 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R10796 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R10797 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R10798 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R10799 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R10800 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R10801 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R10802 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R10803 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R10804 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R10805 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R10806 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R10807 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R10808 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R10809 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R10810 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R10811 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R10812 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R10813 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R10814 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R10815 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R10816 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R10817 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R10818 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R10819 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R10820 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R10821 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R10822 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R10823 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R10824 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R10825 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R10826 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R10827 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R10828 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R10829 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R10830 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R10831 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R10832 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R10833 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R10834 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R10835 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R10836 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R10837 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R10838 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R10839 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R10840 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R10841 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R10842 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R10843 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R10844 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R10845 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R10846 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R10847 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R10848 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R10849 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R10850 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R10851 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R10852 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R10853 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R10854 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R10855 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R10856 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R10857 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R10858 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R10859 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R10860 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R10861 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R10862 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R10863 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R10864 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R10865 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R10866 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R10867 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R10868 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R10869 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R10870 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R10871 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R10872 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R10873 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R10874 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R10875 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R10876 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R10877 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R10878 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R10879 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R10880 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R10881 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R10882 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R10883 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R10884 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R10885 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R10886 n1_m1_470400_388800 n1_m1_475200_388800 5.356235
R10887 n1_m1_475200_388800 n1_m1_480000_388800 5.356235
R10888 n1_m1_480000_388800 n1_m1_484800_388800 5.356235
R10889 n1_m1_484800_388800 n1_m1_489600_388800 5.356235
R10890 n1_m1_489600_388800 n1_m1_494400_388800 5.356235
R10891 n1_m1_494400_388800 n1_m1_499200_388800 5.356235
R10892 n1_m1_499200_388800 n1_m1_504000_388800 5.356235
R10893 n1_m1_504000_388800 n1_m1_508000_388800 4.463529
R10894 n1_m1_508800_388800 n1_m1_508000_388800 0.892706
R10895 n1_m1_508800_388800 n1_m1_513600_388800 5.356235
R10896 n1_m1_513600_388800 n1_m1_518400_388800 5.356235
R10897 n1_m1_518400_388800 n1_m1_523200_388800 5.356235
R10898 n1_m1_523200_388800 n1_m1_528000_388800 5.356235
R10899 n1_m1_528000_388800 n1_m1_532800_388800 5.356235
R10900 n1_m1_532800_388800 n1_m1_536000_388800 3.570824
R10901 n1_m1_537600_388800 n1_m1_536000_388800 1.785412
R10902 n1_m1_537600_388800 n1_m1_542400_388800 5.356235
R10903 n1_m1_542400_388800 n1_m1_547200_388800 5.356235
R10904 n1_m1_547200_388800 n1_m1_552000_388800 5.356235
R10905 n1_m1_552000_388800 n1_m1_556800_388800 5.356235
R10906 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R10907 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R10908 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R10909 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R10910 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R10911 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R10912 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R10913 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R10914 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R10915 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R10916 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R10917 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R10918 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R10919 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R10920 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R10921 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R10922 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R10923 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R10924 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R10925 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R10926 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R10927 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R10928 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R10929 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R10930 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R10931 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R10932 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R10933 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R10934 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R10935 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R10936 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R10937 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R10938 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R10939 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R10940 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R10941 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R10942 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R10943 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R10944 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R10945 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R10946 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R10947 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R10948 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R10949 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R10950 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R10951 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R10952 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R10953 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R10954 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R10955 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R10956 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R10957 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R10958 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R10959 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R10960 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R10961 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R10962 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R10963 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R10964 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R10965 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R10966 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R10967 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R10968 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R10969 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R10970 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R10971 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R10972 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R10973 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R10974 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R10975 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R10976 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R10977 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R10978 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R10979 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R10980 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R10981 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R10982 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R10983 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R10984 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R10985 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R10986 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R10987 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R10988 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R10989 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R10990 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R10991 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R10992 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R10993 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R10994 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R10995 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R10996 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R10997 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R10998 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R10999 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R11000 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R11001 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R11002 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R11003 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R11004 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R11005 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R11006 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R11007 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R11008 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R11009 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R11010 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R11011 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R11012 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R11013 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R11014 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R11015 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R11016 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R11017 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R11018 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R11019 n1_m1_470400_393600 n1_m1_475200_393600 5.356235
R11020 n1_m1_475200_393600 n1_m1_480000_393600 5.356235
R11021 n1_m1_480000_393600 n1_m1_484800_393600 5.356235
R11022 n1_m1_484800_393600 n1_m1_489600_393600 5.356235
R11023 n1_m1_489600_393600 n1_m1_494400_393600 5.356235
R11024 n1_m1_494400_393600 n1_m1_499200_393600 5.356235
R11025 n1_m1_499200_393600 n1_m1_504000_393600 5.356235
R11026 n1_m1_504000_393600 n1_m1_508000_393600 4.463529
R11027 n1_m1_508800_393600 n1_m1_508000_393600 0.892706
R11028 n1_m1_508800_393600 n1_m1_513600_393600 5.356235
R11029 n1_m1_513600_393600 n1_m1_518400_393600 5.356235
R11030 n1_m1_518400_393600 n1_m1_523200_393600 5.356235
R11031 n1_m1_523200_393600 n1_m1_528000_393600 5.356235
R11032 n1_m1_528000_393600 n1_m1_532800_393600 5.356235
R11033 n1_m1_532800_393600 n1_m1_536000_393600 3.570824
R11034 n1_m1_537600_393600 n1_m1_536000_393600 1.785412
R11035 n1_m1_537600_393600 n1_m1_542400_393600 5.356235
R11036 n1_m1_542400_393600 n1_m1_547200_393600 5.356235
R11037 n1_m1_547200_393600 n1_m1_552000_393600 5.356235
R11038 n1_m1_552000_393600 n1_m1_556800_393600 5.356235
R11039 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R11040 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R11041 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R11042 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R11043 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R11044 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R11045 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R11046 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R11047 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R11048 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R11049 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R11050 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R11051 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R11052 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R11053 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R11054 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R11055 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R11056 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R11057 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R11058 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R11059 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R11060 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R11061 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R11062 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R11063 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R11064 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R11065 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R11066 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R11067 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R11068 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R11069 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R11070 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R11071 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R11072 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R11073 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R11074 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R11075 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R11076 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R11077 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R11078 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R11079 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R11080 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R11081 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R11082 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R11083 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R11084 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R11085 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R11086 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R11087 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R11088 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R11089 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R11090 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R11091 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R11092 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R11093 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R11094 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R11095 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R11096 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R11097 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R11098 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R11099 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R11100 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R11101 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R11102 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R11103 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R11104 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R11105 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R11106 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R11107 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R11108 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R11109 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R11110 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R11111 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R11112 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R11113 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R11114 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R11115 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R11116 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R11117 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R11118 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R11119 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R11120 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R11121 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R11122 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R11123 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R11124 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R11125 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R11126 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R11127 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R11128 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R11129 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R11130 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R11131 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R11132 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R11133 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R11134 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R11135 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R11136 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R11137 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R11138 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R11139 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R11140 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R11141 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R11142 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R11143 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R11144 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R11145 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R11146 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R11147 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R11148 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R11149 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R11150 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R11151 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R11152 n1_m1_470400_398400 n1_m1_475200_398400 5.356235
R11153 n1_m1_475200_398400 n1_m1_480000_398400 5.356235
R11154 n1_m1_480000_398400 n1_m1_484800_398400 5.356235
R11155 n1_m1_484800_398400 n1_m1_489600_398400 5.356235
R11156 n1_m1_489600_398400 n1_m1_494400_398400 5.356235
R11157 n1_m1_494400_398400 n1_m1_499200_398400 5.356235
R11158 n1_m1_499200_398400 n1_m1_504000_398400 5.356235
R11159 n1_m1_504000_398400 n1_m1_508000_398400 4.463529
R11160 n1_m1_508800_398400 n1_m1_508000_398400 0.892706
R11161 n1_m1_508800_398400 n1_m1_513600_398400 5.356235
R11162 n1_m1_513600_398400 n1_m1_518400_398400 5.356235
R11163 n1_m1_518400_398400 n1_m1_523200_398400 5.356235
R11164 n1_m1_523200_398400 n1_m1_528000_398400 5.356235
R11165 n1_m1_528000_398400 n1_m1_532800_398400 5.356235
R11166 n1_m1_532800_398400 n1_m1_536000_398400 3.570824
R11167 n1_m1_537600_398400 n1_m1_536000_398400 1.785412
R11168 n1_m1_537600_398400 n1_m1_542400_398400 5.356235
R11169 n1_m1_542400_398400 n1_m1_547200_398400 5.356235
R11170 n1_m1_547200_398400 n1_m1_552000_398400 5.356235
R11171 n1_m1_552000_398400 n1_m1_556800_398400 5.356235
R11172 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R11173 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R11174 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R11175 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R11176 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R11177 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R11178 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R11179 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R11180 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R11181 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R11182 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R11183 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R11184 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R11185 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R11186 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R11187 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R11188 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R11189 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R11190 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R11191 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R11192 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R11193 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R11194 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R11195 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R11196 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R11197 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R11198 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R11199 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R11200 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R11201 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R11202 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R11203 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R11204 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R11205 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R11206 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R11207 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R11208 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R11209 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R11210 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R11211 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R11212 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R11213 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R11214 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R11215 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R11216 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R11217 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R11218 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R11219 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R11220 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R11221 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R11222 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R11223 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R11224 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R11225 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R11226 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R11227 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R11228 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R11229 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R11230 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R11231 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R11232 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R11233 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R11234 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R11235 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R11236 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R11237 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R11238 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R11239 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R11240 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R11241 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R11242 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R11243 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R11244 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R11245 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R11246 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R11247 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R11248 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R11249 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R11250 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R11251 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R11252 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R11253 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R11254 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R11255 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R11256 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R11257 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R11258 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R11259 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R11260 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R11261 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R11262 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R11263 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R11264 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R11265 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R11266 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R11267 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R11268 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R11269 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R11270 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R11271 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R11272 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R11273 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R11274 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R11275 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R11276 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R11277 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R11278 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R11279 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R11280 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R11281 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R11282 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R11283 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R11284 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R11285 n1_m1_470400_403200 n1_m1_475200_403200 5.356235
R11286 n1_m1_475200_403200 n1_m1_480000_403200 5.356235
R11287 n1_m1_480000_403200 n1_m1_484800_403200 5.356235
R11288 n1_m1_484800_403200 n1_m1_489600_403200 5.356235
R11289 n1_m1_489600_403200 n1_m1_494400_403200 5.356235
R11290 n1_m1_494400_403200 n1_m1_499200_403200 5.356235
R11291 n1_m1_499200_403200 n1_m1_504000_403200 5.356235
R11292 n1_m1_504000_403200 n1_m1_508000_403200 4.463529
R11293 n1_m1_508800_403200 n1_m1_508000_403200 0.892706
R11294 n1_m1_508800_403200 n1_m1_513600_403200 5.356235
R11295 n1_m1_513600_403200 n1_m1_518400_403200 5.356235
R11296 n1_m1_518400_403200 n1_m1_523200_403200 5.356235
R11297 n1_m1_523200_403200 n1_m1_528000_403200 5.356235
R11298 n1_m1_528000_403200 n1_m1_532800_403200 5.356235
R11299 n1_m1_532800_403200 n1_m1_536000_403200 3.570824
R11300 n1_m1_537600_403200 n1_m1_536000_403200 1.785412
R11301 n1_m1_537600_403200 n1_m1_542400_403200 5.356235
R11302 n1_m1_542400_403200 n1_m1_547200_403200 5.356235
R11303 n1_m1_547200_403200 n1_m1_552000_403200 5.356235
R11304 n1_m1_552000_403200 n1_m1_556800_403200 5.356235
R11305 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R11306 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R11307 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R11308 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R11309 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R11310 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R11311 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R11312 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R11313 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R11314 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R11315 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R11316 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R11317 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R11318 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R11319 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R11320 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R11321 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R11322 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R11323 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R11324 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R11325 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R11326 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R11327 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R11328 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R11329 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R11330 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R11331 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R11332 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R11333 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R11334 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R11335 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R11336 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R11337 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R11338 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R11339 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R11340 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R11341 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R11342 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R11343 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R11344 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R11345 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R11346 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R11347 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R11348 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R11349 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R11350 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R11351 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R11352 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R11353 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R11354 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R11355 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R11356 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R11357 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R11358 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R11359 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R11360 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R11361 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R11362 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R11363 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R11364 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R11365 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R11366 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R11367 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R11368 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R11369 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R11370 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R11371 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R11372 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R11373 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R11374 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R11375 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R11376 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R11377 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R11378 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R11379 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R11380 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R11381 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R11382 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R11383 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R11384 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R11385 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R11386 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R11387 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R11388 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R11389 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R11390 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R11391 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R11392 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R11393 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R11394 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R11395 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R11396 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R11397 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R11398 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R11399 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R11400 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R11401 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R11402 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R11403 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R11404 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R11405 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R11406 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R11407 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R11408 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R11409 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R11410 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R11411 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R11412 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R11413 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R11414 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R11415 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R11416 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R11417 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R11418 n1_m1_470400_408000 n1_m1_475200_408000 5.356235
R11419 n1_m1_475200_408000 n1_m1_480000_408000 5.356235
R11420 n1_m1_480000_408000 n1_m1_484800_408000 5.356235
R11421 n1_m1_484800_408000 n1_m1_489600_408000 5.356235
R11422 n1_m1_489600_408000 n1_m1_494400_408000 5.356235
R11423 n1_m1_494400_408000 n1_m1_499200_408000 5.356235
R11424 n1_m1_499200_408000 n1_m1_504000_408000 5.356235
R11425 n1_m1_504000_408000 n1_m1_508000_408000 4.463529
R11426 n1_m1_508800_408000 n1_m1_508000_408000 0.892706
R11427 n1_m1_508800_408000 n1_m1_513600_408000 5.356235
R11428 n1_m1_513600_408000 n1_m1_518400_408000 5.356235
R11429 n1_m1_518400_408000 n1_m1_523200_408000 5.356235
R11430 n1_m1_523200_408000 n1_m1_528000_408000 5.356235
R11431 n1_m1_528000_408000 n1_m1_532800_408000 5.356235
R11432 n1_m1_532800_408000 n1_m1_536000_408000 3.570824
R11433 n1_m1_537600_408000 n1_m1_536000_408000 1.785412
R11434 n1_m1_537600_408000 n1_m1_542400_408000 5.356235
R11435 n1_m1_542400_408000 n1_m1_547200_408000 5.356235
R11436 n1_m1_547200_408000 n1_m1_552000_408000 5.356235
R11437 n1_m1_552000_408000 n1_m1_556800_408000 5.356235
R11438 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R11439 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R11440 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R11441 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R11442 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R11443 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R11444 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R11445 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R11446 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R11447 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R11448 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R11449 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R11450 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R11451 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R11452 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R11453 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R11454 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R11455 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R11456 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R11457 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R11458 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R11459 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R11460 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R11461 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R11462 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R11463 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R11464 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R11465 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R11466 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R11467 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R11468 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R11469 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R11470 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R11471 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R11472 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R11473 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R11474 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R11475 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R11476 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R11477 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R11478 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R11479 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R11480 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R11481 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R11482 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R11483 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R11484 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R11485 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R11486 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R11487 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R11488 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R11489 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R11490 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R11491 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R11492 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R11493 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R11494 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R11495 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R11496 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R11497 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R11498 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R11499 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R11500 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R11501 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R11502 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R11503 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R11504 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R11505 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R11506 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R11507 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R11508 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R11509 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R11510 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R11511 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R11512 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R11513 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R11514 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R11515 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R11516 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R11517 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R11518 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R11519 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R11520 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R11521 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R11522 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R11523 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R11524 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R11525 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R11526 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R11527 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R11528 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R11529 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R11530 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R11531 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R11532 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R11533 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R11534 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R11535 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R11536 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R11537 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R11538 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R11539 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R11540 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R11541 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R11542 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R11543 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R11544 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R11545 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R11546 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R11547 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R11548 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R11549 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R11550 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R11551 n1_m1_470400_412800 n1_m1_475200_412800 5.356235
R11552 n1_m1_475200_412800 n1_m1_480000_412800 5.356235
R11553 n1_m1_480000_412800 n1_m1_484800_412800 5.356235
R11554 n1_m1_484800_412800 n1_m1_489600_412800 5.356235
R11555 n1_m1_489600_412800 n1_m1_494400_412800 5.356235
R11556 n1_m1_494400_412800 n1_m1_499200_412800 5.356235
R11557 n1_m1_499200_412800 n1_m1_504000_412800 5.356235
R11558 n1_m1_504000_412800 n1_m1_508000_412800 4.463529
R11559 n1_m1_508800_412800 n1_m1_508000_412800 0.892706
R11560 n1_m1_508800_412800 n1_m1_513600_412800 5.356235
R11561 n1_m1_513600_412800 n1_m1_518400_412800 5.356235
R11562 n1_m1_518400_412800 n1_m1_523200_412800 5.356235
R11563 n1_m1_523200_412800 n1_m1_528000_412800 5.356235
R11564 n1_m1_528000_412800 n1_m1_532800_412800 5.356235
R11565 n1_m1_532800_412800 n1_m1_536000_412800 3.570824
R11566 n1_m1_537600_412800 n1_m1_536000_412800 1.785412
R11567 n1_m1_537600_412800 n1_m1_542400_412800 5.356235
R11568 n1_m1_542400_412800 n1_m1_547200_412800 5.356235
R11569 n1_m1_547200_412800 n1_m1_552000_412800 5.356235
R11570 n1_m1_552000_412800 n1_m1_556800_412800 5.356235
R11571 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R11572 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R11573 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R11574 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R11575 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R11576 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R11577 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R11578 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R11579 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R11580 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R11581 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R11582 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R11583 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R11584 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R11585 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R11586 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R11587 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R11588 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R11589 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R11590 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R11591 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R11592 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R11593 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R11594 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R11595 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R11596 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R11597 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R11598 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R11599 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R11600 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R11601 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R11602 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R11603 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R11604 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R11605 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R11606 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R11607 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R11608 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R11609 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R11610 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R11611 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R11612 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R11613 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R11614 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R11615 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R11616 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R11617 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R11618 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R11619 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R11620 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R11621 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R11622 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R11623 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R11624 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R11625 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R11626 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R11627 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R11628 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R11629 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R11630 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R11631 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R11632 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R11633 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R11634 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R11635 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R11636 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R11637 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R11638 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R11639 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R11640 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R11641 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R11642 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R11643 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R11644 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R11645 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R11646 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R11647 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R11648 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R11649 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R11650 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R11651 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R11652 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R11653 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R11654 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R11655 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R11656 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R11657 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R11658 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R11659 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R11660 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R11661 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R11662 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R11663 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R11664 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R11665 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R11666 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R11667 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R11668 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R11669 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R11670 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R11671 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R11672 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R11673 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R11674 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R11675 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R11676 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R11677 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R11678 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R11679 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R11680 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R11681 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R11682 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R11683 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R11684 n1_m1_470400_417600 n1_m1_475200_417600 5.356235
R11685 n1_m1_475200_417600 n1_m1_480000_417600 5.356235
R11686 n1_m1_480000_417600 n1_m1_484800_417600 5.356235
R11687 n1_m1_484800_417600 n1_m1_489600_417600 5.356235
R11688 n1_m1_489600_417600 n1_m1_494400_417600 5.356235
R11689 n1_m1_494400_417600 n1_m1_499200_417600 5.356235
R11690 n1_m1_499200_417600 n1_m1_504000_417600 5.356235
R11691 n1_m1_504000_417600 n1_m1_508000_417600 4.463529
R11692 n1_m1_508800_417600 n1_m1_508000_417600 0.892706
R11693 n1_m1_508800_417600 n1_m1_513600_417600 5.356235
R11694 n1_m1_513600_417600 n1_m1_518400_417600 5.356235
R11695 n1_m1_518400_417600 n1_m1_523200_417600 5.356235
R11696 n1_m1_523200_417600 n1_m1_528000_417600 5.356235
R11697 n1_m1_528000_417600 n1_m1_532800_417600 5.356235
R11698 n1_m1_532800_417600 n1_m1_536000_417600 3.570824
R11699 n1_m1_537600_417600 n1_m1_536000_417600 1.785412
R11700 n1_m1_537600_417600 n1_m1_542400_417600 5.356235
R11701 n1_m1_542400_417600 n1_m1_547200_417600 5.356235
R11702 n1_m1_547200_417600 n1_m1_552000_417600 5.356235
R11703 n1_m1_552000_417600 n1_m1_556800_417600 5.356235
R11704 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R11705 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R11706 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R11707 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R11708 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R11709 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R11710 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R11711 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R11712 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R11713 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R11714 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R11715 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R11716 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R11717 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R11718 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R11719 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R11720 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R11721 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R11722 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R11723 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R11724 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R11725 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R11726 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R11727 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R11728 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R11729 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R11730 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R11731 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R11732 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R11733 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R11734 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R11735 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R11736 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R11737 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R11738 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R11739 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R11740 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R11741 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R11742 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R11743 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R11744 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R11745 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R11746 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R11747 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R11748 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R11749 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R11750 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R11751 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R11752 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R11753 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R11754 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R11755 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R11756 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R11757 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R11758 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R11759 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R11760 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R11761 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R11762 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R11763 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R11764 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R11765 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R11766 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R11767 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R11768 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R11769 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R11770 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R11771 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R11772 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R11773 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R11774 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R11775 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R11776 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R11777 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R11778 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R11779 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R11780 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R11781 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R11782 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R11783 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R11784 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R11785 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R11786 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R11787 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R11788 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R11789 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R11790 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R11791 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R11792 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R11793 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R11794 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R11795 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R11796 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R11797 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R11798 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R11799 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R11800 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R11801 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R11802 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R11803 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R11804 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R11805 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R11806 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R11807 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R11808 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R11809 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R11810 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R11811 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R11812 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R11813 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R11814 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R11815 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R11816 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R11817 n1_m1_470400_422400 n1_m1_475200_422400 5.356235
R11818 n1_m1_475200_422400 n1_m1_480000_422400 5.356235
R11819 n1_m1_480000_422400 n1_m1_484800_422400 5.356235
R11820 n1_m1_484800_422400 n1_m1_489600_422400 5.356235
R11821 n1_m1_489600_422400 n1_m1_494400_422400 5.356235
R11822 n1_m1_494400_422400 n1_m1_499200_422400 5.356235
R11823 n1_m1_499200_422400 n1_m1_504000_422400 5.356235
R11824 n1_m1_504000_422400 n1_m1_508000_422400 4.463529
R11825 n1_m1_508800_422400 n1_m1_508000_422400 0.892706
R11826 n1_m1_508800_422400 n1_m1_513600_422400 5.356235
R11827 n1_m1_513600_422400 n1_m1_518400_422400 5.356235
R11828 n1_m1_518400_422400 n1_m1_523200_422400 5.356235
R11829 n1_m1_523200_422400 n1_m1_528000_422400 5.356235
R11830 n1_m1_528000_422400 n1_m1_532800_422400 5.356235
R11831 n1_m1_532800_422400 n1_m1_536000_422400 3.570824
R11832 n1_m1_537600_422400 n1_m1_536000_422400 1.785412
R11833 n1_m1_537600_422400 n1_m1_542400_422400 5.356235
R11834 n1_m1_542400_422400 n1_m1_547200_422400 5.356235
R11835 n1_m1_547200_422400 n1_m1_552000_422400 5.356235
R11836 n1_m1_552000_422400 n1_m1_556800_422400 5.356235
R11837 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R11838 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R11839 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R11840 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R11841 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R11842 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R11843 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R11844 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R11845 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R11846 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R11847 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R11848 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R11849 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R11850 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R11851 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R11852 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R11853 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R11854 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R11855 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R11856 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R11857 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R11858 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R11859 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R11860 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R11861 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R11862 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R11863 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R11864 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R11865 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R11866 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R11867 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R11868 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R11869 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R11870 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R11871 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R11872 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R11873 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R11874 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R11875 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R11876 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R11877 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R11878 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R11879 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R11880 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R11881 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R11882 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R11883 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R11884 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R11885 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R11886 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R11887 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R11888 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R11889 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R11890 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R11891 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R11892 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R11893 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R11894 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R11895 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R11896 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R11897 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R11898 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R11899 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R11900 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R11901 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R11902 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R11903 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R11904 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R11905 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R11906 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R11907 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R11908 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R11909 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R11910 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R11911 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R11912 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R11913 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R11914 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R11915 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R11916 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R11917 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R11918 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R11919 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R11920 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R11921 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R11922 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R11923 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R11924 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R11925 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R11926 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R11927 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R11928 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R11929 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R11930 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R11931 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R11932 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R11933 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R11934 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R11935 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R11936 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R11937 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R11938 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R11939 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R11940 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R11941 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R11942 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R11943 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R11944 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R11945 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R11946 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R11947 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R11948 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R11949 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R11950 n1_m1_470400_427200 n1_m1_475200_427200 5.356235
R11951 n1_m1_475200_427200 n1_m1_480000_427200 5.356235
R11952 n1_m1_480000_427200 n1_m1_484800_427200 5.356235
R11953 n1_m1_484800_427200 n1_m1_489600_427200 5.356235
R11954 n1_m1_489600_427200 n1_m1_494400_427200 5.356235
R11955 n1_m1_494400_427200 n1_m1_499200_427200 5.356235
R11956 n1_m1_499200_427200 n1_m1_504000_427200 5.356235
R11957 n1_m1_504000_427200 n1_m1_508000_427200 4.463529
R11958 n1_m1_508800_427200 n1_m1_508000_427200 0.892706
R11959 n1_m1_508800_427200 n1_m1_513600_427200 5.356235
R11960 n1_m1_513600_427200 n1_m1_518400_427200 5.356235
R11961 n1_m1_518400_427200 n1_m1_523200_427200 5.356235
R11962 n1_m1_523200_427200 n1_m1_528000_427200 5.356235
R11963 n1_m1_528000_427200 n1_m1_532800_427200 5.356235
R11964 n1_m1_532800_427200 n1_m1_536000_427200 3.570824
R11965 n1_m1_537600_427200 n1_m1_536000_427200 1.785412
R11966 n1_m1_537600_427200 n1_m1_542400_427200 5.356235
R11967 n1_m1_542400_427200 n1_m1_547200_427200 5.356235
R11968 n1_m1_547200_427200 n1_m1_552000_427200 5.356235
R11969 n1_m1_552000_427200 n1_m1_556800_427200 5.356235
R11970 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R11971 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R11972 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R11973 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R11974 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R11975 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R11976 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R11977 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R11978 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R11979 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R11980 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R11981 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R11982 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R11983 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R11984 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R11985 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R11986 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R11987 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R11988 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R11989 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R11990 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R11991 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R11992 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R11993 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R11994 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R11995 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R11996 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R11997 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R11998 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R11999 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R12000 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R12001 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R12002 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R12003 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R12004 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R12005 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R12006 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R12007 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R12008 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R12009 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R12010 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R12011 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R12012 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R12013 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R12014 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R12015 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R12016 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R12017 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R12018 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R12019 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R12020 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R12021 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R12022 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R12023 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R12024 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R12025 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R12026 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R12027 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R12028 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R12029 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R12030 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R12031 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R12032 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R12033 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R12034 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R12035 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R12036 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R12037 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R12038 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R12039 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R12040 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R12041 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R12042 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R12043 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R12044 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R12045 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R12046 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R12047 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R12048 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R12049 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R12050 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R12051 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R12052 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R12053 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R12054 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R12055 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R12056 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R12057 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R12058 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R12059 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R12060 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R12061 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R12062 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R12063 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R12064 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R12065 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R12066 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R12067 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R12068 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R12069 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R12070 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R12071 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R12072 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R12073 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R12074 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R12075 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R12076 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R12077 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R12078 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R12079 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R12080 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R12081 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R12082 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R12083 n1_m1_470400_432000 n1_m1_475200_432000 5.356235
R12084 n1_m1_475200_432000 n1_m1_480000_432000 5.356235
R12085 n1_m1_480000_432000 n1_m1_484800_432000 5.356235
R12086 n1_m1_484800_432000 n1_m1_489600_432000 5.356235
R12087 n1_m1_489600_432000 n1_m1_494400_432000 5.356235
R12088 n1_m1_494400_432000 n1_m1_499200_432000 5.356235
R12089 n1_m1_499200_432000 n1_m1_504000_432000 5.356235
R12090 n1_m1_504000_432000 n1_m1_508000_432000 4.463529
R12091 n1_m1_508800_432000 n1_m1_508000_432000 0.892706
R12092 n1_m1_508800_432000 n1_m1_513600_432000 5.356235
R12093 n1_m1_513600_432000 n1_m1_518400_432000 5.356235
R12094 n1_m1_518400_432000 n1_m1_523200_432000 5.356235
R12095 n1_m1_523200_432000 n1_m1_528000_432000 5.356235
R12096 n1_m1_528000_432000 n1_m1_532800_432000 5.356235
R12097 n1_m1_532800_432000 n1_m1_536000_432000 3.570824
R12098 n1_m1_537600_432000 n1_m1_536000_432000 1.785412
R12099 n1_m1_537600_432000 n1_m1_542400_432000 5.356235
R12100 n1_m1_542400_432000 n1_m1_547200_432000 5.356235
R12101 n1_m1_547200_432000 n1_m1_552000_432000 5.356235
R12102 n1_m1_552000_432000 n1_m1_556800_432000 5.356235
R12103 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R12104 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R12105 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R12106 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R12107 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R12108 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R12109 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R12110 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R12111 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R12112 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R12113 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R12114 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R12115 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R12116 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R12117 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R12118 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R12119 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R12120 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R12121 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R12122 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R12123 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R12124 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R12125 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R12126 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R12127 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R12128 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R12129 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R12130 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R12131 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R12132 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R12133 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R12134 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R12135 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R12136 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R12137 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R12138 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R12139 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R12140 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R12141 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R12142 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R12143 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R12144 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R12145 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R12146 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R12147 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R12148 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R12149 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R12150 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R12151 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R12152 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R12153 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R12154 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R12155 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R12156 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R12157 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R12158 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R12159 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R12160 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R12161 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R12162 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R12163 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R12164 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R12165 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R12166 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R12167 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R12168 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R12169 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R12170 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R12171 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R12172 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R12173 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R12174 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R12175 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R12176 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R12177 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R12178 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R12179 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R12180 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R12181 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R12182 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R12183 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R12184 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R12185 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R12186 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R12187 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R12188 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R12189 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R12190 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R12191 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R12192 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R12193 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R12194 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R12195 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R12196 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R12197 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R12198 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R12199 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R12200 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R12201 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R12202 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R12203 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R12204 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R12205 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R12206 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R12207 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R12208 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R12209 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R12210 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R12211 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R12212 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R12213 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R12214 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R12215 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R12216 n1_m1_470400_436800 n1_m1_475200_436800 5.356235
R12217 n1_m1_475200_436800 n1_m1_480000_436800 5.356235
R12218 n1_m1_480000_436800 n1_m1_484800_436800 5.356235
R12219 n1_m1_484800_436800 n1_m1_489600_436800 5.356235
R12220 n1_m1_489600_436800 n1_m1_494400_436800 5.356235
R12221 n1_m1_494400_436800 n1_m1_499200_436800 5.356235
R12222 n1_m1_499200_436800 n1_m1_504000_436800 5.356235
R12223 n1_m1_504000_436800 n1_m1_508000_436800 4.463529
R12224 n1_m1_508800_436800 n1_m1_508000_436800 0.892706
R12225 n1_m1_508800_436800 n1_m1_513600_436800 5.356235
R12226 n1_m1_513600_436800 n1_m1_518400_436800 5.356235
R12227 n1_m1_518400_436800 n1_m1_523200_436800 5.356235
R12228 n1_m1_523200_436800 n1_m1_528000_436800 5.356235
R12229 n1_m1_528000_436800 n1_m1_532800_436800 5.356235
R12230 n1_m1_532800_436800 n1_m1_536000_436800 3.570824
R12231 n1_m1_537600_436800 n1_m1_536000_436800 1.785412
R12232 n1_m1_537600_436800 n1_m1_542400_436800 5.356235
R12233 n1_m1_542400_436800 n1_m1_547200_436800 5.356235
R12234 n1_m1_547200_436800 n1_m1_552000_436800 5.356235
R12235 n1_m1_552000_436800 n1_m1_556800_436800 5.356235
R12236 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R12237 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R12238 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R12239 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R12240 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R12241 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R12242 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R12243 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R12244 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R12245 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R12246 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R12247 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R12248 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R12249 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R12250 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R12251 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R12252 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R12253 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R12254 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R12255 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R12256 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R12257 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R12258 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R12259 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R12260 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R12261 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R12262 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R12263 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R12264 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R12265 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R12266 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R12267 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R12268 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R12269 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R12270 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R12271 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R12272 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R12273 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R12274 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R12275 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R12276 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R12277 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R12278 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R12279 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R12280 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R12281 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R12282 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R12283 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R12284 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R12285 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R12286 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R12287 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R12288 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R12289 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R12290 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R12291 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R12292 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R12293 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R12294 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R12295 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R12296 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R12297 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R12298 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R12299 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R12300 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R12301 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R12302 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R12303 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R12304 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R12305 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R12306 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R12307 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R12308 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R12309 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R12310 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R12311 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R12312 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R12313 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R12314 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R12315 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R12316 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R12317 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R12318 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R12319 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R12320 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R12321 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R12322 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R12323 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R12324 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R12325 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R12326 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R12327 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R12328 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R12329 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R12330 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R12331 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R12332 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R12333 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R12334 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R12335 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R12336 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R12337 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R12338 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R12339 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R12340 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R12341 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R12342 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R12343 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R12344 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R12345 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R12346 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R12347 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R12348 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R12349 n1_m1_470400_441600 n1_m1_475200_441600 5.356235
R12350 n1_m1_475200_441600 n1_m1_480000_441600 5.356235
R12351 n1_m1_480000_441600 n1_m1_484800_441600 5.356235
R12352 n1_m1_484800_441600 n1_m1_489600_441600 5.356235
R12353 n1_m1_489600_441600 n1_m1_494400_441600 5.356235
R12354 n1_m1_494400_441600 n1_m1_499200_441600 5.356235
R12355 n1_m1_499200_441600 n1_m1_504000_441600 5.356235
R12356 n1_m1_504000_441600 n1_m1_508000_441600 4.463529
R12357 n1_m1_508800_441600 n1_m1_508000_441600 0.892706
R12358 n1_m1_508800_441600 n1_m1_513600_441600 5.356235
R12359 n1_m1_513600_441600 n1_m1_518400_441600 5.356235
R12360 n1_m1_518400_441600 n1_m1_523200_441600 5.356235
R12361 n1_m1_523200_441600 n1_m1_528000_441600 5.356235
R12362 n1_m1_528000_441600 n1_m1_532800_441600 5.356235
R12363 n1_m1_532800_441600 n1_m1_536000_441600 3.570824
R12364 n1_m1_537600_441600 n1_m1_536000_441600 1.785412
R12365 n1_m1_537600_441600 n1_m1_542400_441600 5.356235
R12366 n1_m1_542400_441600 n1_m1_547200_441600 5.356235
R12367 n1_m1_547200_441600 n1_m1_552000_441600 5.356235
R12368 n1_m1_552000_441600 n1_m1_556800_441600 5.356235
R12369 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R12370 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R12371 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R12372 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R12373 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R12374 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R12375 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R12376 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R12377 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R12378 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R12379 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R12380 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R12381 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R12382 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R12383 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R12384 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R12385 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R12386 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R12387 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R12388 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R12389 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R12390 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R12391 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R12392 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R12393 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R12394 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R12395 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R12396 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R12397 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R12398 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R12399 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R12400 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R12401 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R12402 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R12403 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R12404 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R12405 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R12406 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R12407 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R12408 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R12409 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R12410 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R12411 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R12412 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R12413 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R12414 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R12415 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R12416 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R12417 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R12418 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R12419 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R12420 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R12421 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R12422 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R12423 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R12424 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R12425 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R12426 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R12427 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R12428 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R12429 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R12430 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R12431 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R12432 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R12433 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R12434 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R12435 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R12436 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R12437 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R12438 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R12439 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R12440 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R12441 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R12442 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R12443 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R12444 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R12445 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R12446 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R12447 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R12448 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R12449 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R12450 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R12451 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R12452 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R12453 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R12454 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R12455 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R12456 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R12457 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R12458 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R12459 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R12460 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R12461 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R12462 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R12463 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R12464 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R12465 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R12466 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R12467 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R12468 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R12469 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R12470 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R12471 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R12472 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R12473 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R12474 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R12475 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R12476 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R12477 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R12478 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R12479 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R12480 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R12481 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R12482 n1_m1_470400_446400 n1_m1_475200_446400 5.356235
R12483 n1_m1_475200_446400 n1_m1_480000_446400 5.356235
R12484 n1_m1_480000_446400 n1_m1_484800_446400 5.356235
R12485 n1_m1_484800_446400 n1_m1_489600_446400 5.356235
R12486 n1_m1_489600_446400 n1_m1_494400_446400 5.356235
R12487 n1_m1_494400_446400 n1_m1_499200_446400 5.356235
R12488 n1_m1_499200_446400 n1_m1_504000_446400 5.356235
R12489 n1_m1_504000_446400 n1_m1_508000_446400 4.463529
R12490 n1_m1_508800_446400 n1_m1_508000_446400 0.892706
R12491 n1_m1_508800_446400 n1_m1_513600_446400 5.356235
R12492 n1_m1_513600_446400 n1_m1_518400_446400 5.356235
R12493 n1_m1_518400_446400 n1_m1_523200_446400 5.356235
R12494 n1_m1_523200_446400 n1_m1_528000_446400 5.356235
R12495 n1_m1_528000_446400 n1_m1_532800_446400 5.356235
R12496 n1_m1_532800_446400 n1_m1_536000_446400 3.570824
R12497 n1_m1_537600_446400 n1_m1_536000_446400 1.785412
R12498 n1_m1_537600_446400 n1_m1_542400_446400 5.356235
R12499 n1_m1_542400_446400 n1_m1_547200_446400 5.356235
R12500 n1_m1_547200_446400 n1_m1_552000_446400 5.356235
R12501 n1_m1_552000_446400 n1_m1_556800_446400 5.356235
R12502 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R12503 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R12504 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R12505 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R12506 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R12507 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R12508 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R12509 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R12510 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R12511 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R12512 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R12513 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R12514 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R12515 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R12516 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R12517 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R12518 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R12519 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R12520 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R12521 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R12522 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R12523 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R12524 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R12525 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R12526 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R12527 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R12528 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R12529 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R12530 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R12531 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R12532 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R12533 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R12534 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R12535 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R12536 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R12537 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R12538 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R12539 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R12540 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R12541 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R12542 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R12543 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R12544 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R12545 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R12546 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R12547 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R12548 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R12549 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R12550 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R12551 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R12552 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R12553 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R12554 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R12555 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R12556 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R12557 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R12558 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R12559 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R12560 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R12561 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R12562 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R12563 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R12564 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R12565 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R12566 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R12567 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R12568 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R12569 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R12570 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R12571 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R12572 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R12573 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R12574 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R12575 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R12576 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R12577 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R12578 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R12579 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R12580 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R12581 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R12582 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R12583 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R12584 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R12585 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R12586 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R12587 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R12588 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R12589 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R12590 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R12591 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R12592 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R12593 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R12594 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R12595 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R12596 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R12597 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R12598 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R12599 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R12600 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R12601 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R12602 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R12603 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R12604 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R12605 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R12606 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R12607 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R12608 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R12609 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R12610 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R12611 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R12612 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R12613 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R12614 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R12615 n1_m1_470400_451200 n1_m1_475200_451200 5.356235
R12616 n1_m1_475200_451200 n1_m1_480000_451200 5.356235
R12617 n1_m1_480000_451200 n1_m1_484800_451200 5.356235
R12618 n1_m1_484800_451200 n1_m1_489600_451200 5.356235
R12619 n1_m1_489600_451200 n1_m1_494400_451200 5.356235
R12620 n1_m1_494400_451200 n1_m1_499200_451200 5.356235
R12621 n1_m1_499200_451200 n1_m1_504000_451200 5.356235
R12622 n1_m1_504000_451200 n1_m1_508000_451200 4.463529
R12623 n1_m1_508800_451200 n1_m1_508000_451200 0.892706
R12624 n1_m1_508800_451200 n1_m1_513600_451200 5.356235
R12625 n1_m1_513600_451200 n1_m1_518400_451200 5.356235
R12626 n1_m1_518400_451200 n1_m1_523200_451200 5.356235
R12627 n1_m1_523200_451200 n1_m1_528000_451200 5.356235
R12628 n1_m1_528000_451200 n1_m1_532800_451200 5.356235
R12629 n1_m1_532800_451200 n1_m1_536000_451200 3.570824
R12630 n1_m1_537600_451200 n1_m1_536000_451200 1.785412
R12631 n1_m1_537600_451200 n1_m1_542400_451200 5.356235
R12632 n1_m1_542400_451200 n1_m1_547200_451200 5.356235
R12633 n1_m1_547200_451200 n1_m1_552000_451200 5.356235
R12634 n1_m1_552000_451200 n1_m1_556800_451200 5.356235
R12635 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R12636 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R12637 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R12638 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R12639 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R12640 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R12641 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R12642 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R12643 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R12644 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R12645 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R12646 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R12647 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R12648 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R12649 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R12650 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R12651 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R12652 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R12653 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R12654 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R12655 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R12656 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R12657 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R12658 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R12659 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R12660 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R12661 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R12662 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R12663 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R12664 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R12665 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R12666 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R12667 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R12668 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R12669 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R12670 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R12671 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R12672 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R12673 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R12674 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R12675 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R12676 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R12677 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R12678 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R12679 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R12680 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R12681 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R12682 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R12683 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R12684 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R12685 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R12686 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R12687 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R12688 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R12689 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R12690 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R12691 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R12692 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R12693 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R12694 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R12695 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R12696 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R12697 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R12698 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R12699 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R12700 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R12701 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R12702 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R12703 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R12704 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R12705 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R12706 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R12707 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R12708 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R12709 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R12710 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R12711 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R12712 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R12713 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R12714 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R12715 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R12716 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R12717 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R12718 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R12719 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R12720 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R12721 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R12722 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R12723 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R12724 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R12725 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R12726 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R12727 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R12728 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R12729 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R12730 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R12731 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R12732 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R12733 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R12734 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R12735 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R12736 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R12737 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R12738 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R12739 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R12740 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R12741 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R12742 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R12743 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R12744 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R12745 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R12746 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R12747 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R12748 n1_m1_470400_456000 n1_m1_475200_456000 5.356235
R12749 n1_m1_475200_456000 n1_m1_480000_456000 5.356235
R12750 n1_m1_480000_456000 n1_m1_484800_456000 5.356235
R12751 n1_m1_484800_456000 n1_m1_489600_456000 5.356235
R12752 n1_m1_489600_456000 n1_m1_494400_456000 5.356235
R12753 n1_m1_494400_456000 n1_m1_499200_456000 5.356235
R12754 n1_m1_499200_456000 n1_m1_504000_456000 5.356235
R12755 n1_m1_504000_456000 n1_m1_508000_456000 4.463529
R12756 n1_m1_508800_456000 n1_m1_508000_456000 0.892706
R12757 n1_m1_508800_456000 n1_m1_513600_456000 5.356235
R12758 n1_m1_513600_456000 n1_m1_518400_456000 5.356235
R12759 n1_m1_518400_456000 n1_m1_523200_456000 5.356235
R12760 n1_m1_523200_456000 n1_m1_528000_456000 5.356235
R12761 n1_m1_528000_456000 n1_m1_532800_456000 5.356235
R12762 n1_m1_532800_456000 n1_m1_536000_456000 3.570824
R12763 n1_m1_537600_456000 n1_m1_536000_456000 1.785412
R12764 n1_m1_537600_456000 n1_m1_542400_456000 5.356235
R12765 n1_m1_542400_456000 n1_m1_547200_456000 5.356235
R12766 n1_m1_547200_456000 n1_m1_552000_456000 5.356235
R12767 n1_m1_552000_456000 n1_m1_556800_456000 5.356235
R12768 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R12769 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R12770 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R12771 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R12772 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R12773 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R12774 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R12775 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R12776 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R12777 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R12778 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R12779 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R12780 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R12781 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R12782 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R12783 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R12784 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R12785 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R12786 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R12787 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R12788 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R12789 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R12790 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R12791 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R12792 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R12793 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R12794 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R12795 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R12796 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R12797 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R12798 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R12799 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R12800 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R12801 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R12802 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R12803 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R12804 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R12805 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R12806 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R12807 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R12808 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R12809 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R12810 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R12811 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R12812 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R12813 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R12814 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R12815 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R12816 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R12817 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R12818 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R12819 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R12820 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R12821 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R12822 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R12823 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R12824 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R12825 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R12826 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R12827 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R12828 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R12829 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R12830 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R12831 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R12832 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R12833 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R12834 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R12835 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R12836 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R12837 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R12838 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R12839 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R12840 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R12841 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R12842 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R12843 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R12844 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R12845 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R12846 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R12847 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R12848 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R12849 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R12850 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R12851 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R12852 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R12853 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R12854 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R12855 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R12856 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R12857 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R12858 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R12859 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R12860 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R12861 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R12862 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R12863 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R12864 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R12865 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R12866 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R12867 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R12868 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R12869 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R12870 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R12871 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R12872 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R12873 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R12874 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R12875 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R12876 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R12877 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R12878 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R12879 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R12880 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R12881 n1_m1_470400_460800 n1_m1_475200_460800 5.356235
R12882 n1_m1_475200_460800 n1_m1_480000_460800 5.356235
R12883 n1_m1_480000_460800 n1_m1_484800_460800 5.356235
R12884 n1_m1_484800_460800 n1_m1_489600_460800 5.356235
R12885 n1_m1_489600_460800 n1_m1_494400_460800 5.356235
R12886 n1_m1_494400_460800 n1_m1_499200_460800 5.356235
R12887 n1_m1_499200_460800 n1_m1_504000_460800 5.356235
R12888 n1_m1_504000_460800 n1_m1_508000_460800 4.463529
R12889 n1_m1_508800_460800 n1_m1_508000_460800 0.892706
R12890 n1_m1_508800_460800 n1_m1_513600_460800 5.356235
R12891 n1_m1_513600_460800 n1_m1_518400_460800 5.356235
R12892 n1_m1_518400_460800 n1_m1_523200_460800 5.356235
R12893 n1_m1_523200_460800 n1_m1_528000_460800 5.356235
R12894 n1_m1_528000_460800 n1_m1_532800_460800 5.356235
R12895 n1_m1_532800_460800 n1_m1_536000_460800 3.570824
R12896 n1_m1_537600_460800 n1_m1_536000_460800 1.785412
R12897 n1_m1_537600_460800 n1_m1_542400_460800 5.356235
R12898 n1_m1_542400_460800 n1_m1_547200_460800 5.356235
R12899 n1_m1_547200_460800 n1_m1_552000_460800 5.356235
R12900 n1_m1_552000_460800 n1_m1_556800_460800 5.356235
R12901 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R12902 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R12903 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R12904 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R12905 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R12906 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R12907 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R12908 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R12909 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R12910 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R12911 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R12912 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R12913 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R12914 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R12915 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R12916 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R12917 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R12918 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R12919 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R12920 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R12921 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R12922 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R12923 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R12924 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R12925 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R12926 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R12927 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R12928 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R12929 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R12930 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R12931 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R12932 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R12933 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R12934 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R12935 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R12936 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R12937 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R12938 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R12939 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R12940 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R12941 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R12942 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R12943 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R12944 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R12945 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R12946 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R12947 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R12948 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R12949 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R12950 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R12951 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R12952 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R12953 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R12954 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R12955 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R12956 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R12957 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R12958 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R12959 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R12960 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R12961 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R12962 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R12963 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R12964 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R12965 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R12966 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R12967 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R12968 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R12969 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R12970 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R12971 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R12972 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R12973 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R12974 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R12975 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R12976 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R12977 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R12978 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R12979 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R12980 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R12981 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R12982 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R12983 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R12984 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R12985 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R12986 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R12987 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R12988 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R12989 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R12990 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R12991 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R12992 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R12993 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R12994 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R12995 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R12996 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R12997 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R12998 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R12999 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R13000 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R13001 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R13002 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R13003 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R13004 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R13005 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R13006 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R13007 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R13008 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R13009 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R13010 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R13011 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R13012 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R13013 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R13014 n1_m1_470400_465600 n1_m1_475200_465600 5.356235
R13015 n1_m1_475200_465600 n1_m1_480000_465600 5.356235
R13016 n1_m1_480000_465600 n1_m1_484800_465600 5.356235
R13017 n1_m1_484800_465600 n1_m1_489600_465600 5.356235
R13018 n1_m1_489600_465600 n1_m1_494400_465600 5.356235
R13019 n1_m1_494400_465600 n1_m1_499200_465600 5.356235
R13020 n1_m1_499200_465600 n1_m1_504000_465600 5.356235
R13021 n1_m1_504000_465600 n1_m1_508000_465600 4.463529
R13022 n1_m1_508800_465600 n1_m1_508000_465600 0.892706
R13023 n1_m1_508800_465600 n1_m1_513600_465600 5.356235
R13024 n1_m1_513600_465600 n1_m1_518400_465600 5.356235
R13025 n1_m1_518400_465600 n1_m1_523200_465600 5.356235
R13026 n1_m1_523200_465600 n1_m1_528000_465600 5.356235
R13027 n1_m1_528000_465600 n1_m1_532800_465600 5.356235
R13028 n1_m1_532800_465600 n1_m1_536000_465600 3.570824
R13029 n1_m1_537600_465600 n1_m1_536000_465600 1.785412
R13030 n1_m1_537600_465600 n1_m1_542400_465600 5.356235
R13031 n1_m1_542400_465600 n1_m1_547200_465600 5.356235
R13032 n1_m1_547200_465600 n1_m1_552000_465600 5.356235
R13033 n1_m1_552000_465600 n1_m1_556800_465600 5.356235
R13034 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R13035 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R13036 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R13037 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R13038 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R13039 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R13040 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R13041 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R13042 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R13043 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R13044 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R13045 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R13046 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R13047 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R13048 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R13049 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R13050 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R13051 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R13052 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R13053 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R13054 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R13055 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R13056 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R13057 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R13058 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R13059 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R13060 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R13061 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R13062 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R13063 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R13064 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R13065 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R13066 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R13067 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R13068 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R13069 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R13070 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R13071 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R13072 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R13073 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R13074 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R13075 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R13076 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R13077 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R13078 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R13079 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R13080 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R13081 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R13082 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R13083 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R13084 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R13085 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R13086 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R13087 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R13088 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R13089 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R13090 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R13091 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R13092 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R13093 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R13094 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R13095 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R13096 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R13097 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R13098 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R13099 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R13100 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R13101 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R13102 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R13103 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R13104 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R13105 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R13106 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R13107 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R13108 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R13109 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R13110 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R13111 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R13112 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R13113 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R13114 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R13115 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R13116 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R13117 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R13118 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R13119 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R13120 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R13121 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R13122 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R13123 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R13124 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R13125 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R13126 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R13127 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R13128 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R13129 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R13130 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R13131 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R13132 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R13133 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R13134 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R13135 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R13136 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R13137 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R13138 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R13139 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R13140 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R13141 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R13142 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R13143 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R13144 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R13145 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R13146 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R13147 n1_m1_470400_470400 n1_m1_475200_470400 5.356235
R13148 n1_m1_475200_470400 n1_m1_480000_470400 5.356235
R13149 n1_m1_480000_470400 n1_m1_484800_470400 5.356235
R13150 n1_m1_484800_470400 n1_m1_489600_470400 5.356235
R13151 n1_m1_489600_470400 n1_m1_494400_470400 5.356235
R13152 n1_m1_494400_470400 n1_m1_499200_470400 5.356235
R13153 n1_m1_499200_470400 n1_m1_504000_470400 5.356235
R13154 n1_m1_504000_470400 n1_m1_508000_470400 4.463529
R13155 n1_m1_508800_470400 n1_m1_508000_470400 0.892706
R13156 n1_m1_508800_470400 n1_m1_513600_470400 5.356235
R13157 n1_m1_513600_470400 n1_m1_518400_470400 5.356235
R13158 n1_m1_518400_470400 n1_m1_523200_470400 5.356235
R13159 n1_m1_523200_470400 n1_m1_528000_470400 5.356235
R13160 n1_m1_528000_470400 n1_m1_532800_470400 5.356235
R13161 n1_m1_532800_470400 n1_m1_536000_470400 3.570824
R13162 n1_m1_537600_470400 n1_m1_536000_470400 1.785412
R13163 n1_m1_537600_470400 n1_m1_542400_470400 5.356235
R13164 n1_m1_542400_470400 n1_m1_547200_470400 5.356235
R13165 n1_m1_547200_470400 n1_m1_552000_470400 5.356235
R13166 n1_m1_552000_470400 n1_m1_556800_470400 5.356235
R13167 n1_m1_0_475200 n1_m1_4000_475200 4.463529
R13168 n1_m1_4800_475200 n1_m1_4000_475200 0.892706
R13169 n1_m1_4800_475200 n1_m1_9600_475200 5.356235
R13170 n1_m1_9600_475200 n1_m1_14400_475200 5.356235
R13171 n1_m1_14400_475200 n1_m1_19200_475200 5.356235
R13172 n1_m1_19200_475200 n1_m1_24000_475200 5.356235
R13173 n1_m1_24000_475200 n1_m1_28800_475200 5.356235
R13174 n1_m1_28800_475200 n1_m1_32000_475200 3.570824
R13175 n1_m1_33600_475200 n1_m1_32000_475200 1.785412
R13176 n1_m1_33600_475200 n1_m1_38400_475200 5.356235
R13177 n1_m1_38400_475200 n1_m1_43200_475200 5.356235
R13178 n1_m1_43200_475200 n1_m1_48000_475200 5.356235
R13179 n1_m1_48000_475200 n1_m1_52800_475200 5.356235
R13180 n1_m1_52800_475200 n1_m1_57600_475200 5.356235
R13181 n1_m1_57600_475200 n1_m1_60000_475200 2.678118
R13182 n1_m1_62400_475200 n1_m1_60000_475200 2.678118
R13183 n1_m1_62400_475200 n1_m1_67200_475200 5.356235
R13184 n1_m1_67200_475200 n1_m1_72000_475200 5.356235
R13185 n1_m1_72000_475200 n1_m1_76800_475200 5.356235
R13186 n1_m1_76800_475200 n1_m1_81600_475200 5.356235
R13187 n1_m1_81600_475200 n1_m1_86400_475200 5.356235
R13188 n1_m1_86400_475200 n1_m1_88000_475200 1.785412
R13189 n1_m1_91200_475200 n1_m1_88000_475200 3.570824
R13190 n1_m1_91200_475200 n1_m1_96000_475200 5.356235
R13191 n1_m1_96000_475200 n1_m1_100800_475200 5.356235
R13192 n1_m1_100800_475200 n1_m1_105600_475200 5.356235
R13193 n1_m1_105600_475200 n1_m1_110400_475200 5.356235
R13194 n1_m1_110400_475200 n1_m1_115200_475200 5.356235
R13195 n1_m1_115200_475200 n1_m1_116000_475200 0.892706
R13196 n1_m1_120000_475200 n1_m1_116000_475200 4.463529
R13197 n1_m1_120000_475200 n1_m1_124800_475200 5.356235
R13198 n1_m1_124800_475200 n1_m1_129600_475200 5.356235
R13199 n1_m1_129600_475200 n1_m1_134400_475200 5.356235
R13200 n1_m1_134400_475200 n1_m1_139200_475200 5.356235
R13201 n1_m1_139200_475200 n1_m1_144000_475200 5.356235
R13202 n1_m1_144000_475200 n1_m1_148800_475200 5.356235
R13203 n1_m1_148800_475200 n1_m1_153600_475200 5.356235
R13204 n1_m1_153600_475200 n1_m1_158400_475200 5.356235
R13205 n1_m1_158400_475200 n1_m1_163200_475200 5.356235
R13206 n1_m1_163200_475200 n1_m1_168000_475200 5.356235
R13207 n1_m1_168000_475200 n1_m1_172000_475200 4.463529
R13208 n1_m1_172800_475200 n1_m1_172000_475200 0.892706
R13209 n1_m1_172800_475200 n1_m1_177600_475200 5.356235
R13210 n1_m1_177600_475200 n1_m1_182400_475200 5.356235
R13211 n1_m1_182400_475200 n1_m1_187200_475200 5.356235
R13212 n1_m1_187200_475200 n1_m1_192000_475200 5.356235
R13213 n1_m1_192000_475200 n1_m1_196800_475200 5.356235
R13214 n1_m1_196800_475200 n1_m1_200000_475200 3.570824
R13215 n1_m1_201600_475200 n1_m1_200000_475200 1.785412
R13216 n1_m1_201600_475200 n1_m1_206400_475200 5.356235
R13217 n1_m1_206400_475200 n1_m1_211200_475200 5.356235
R13218 n1_m1_211200_475200 n1_m1_216000_475200 5.356235
R13219 n1_m1_216000_475200 n1_m1_220800_475200 5.356235
R13220 n1_m1_220800_475200 n1_m1_225600_475200 5.356235
R13221 n1_m1_225600_475200 n1_m1_228000_475200 2.678118
R13222 n1_m1_230400_475200 n1_m1_228000_475200 2.678118
R13223 n1_m1_230400_475200 n1_m1_235200_475200 5.356235
R13224 n1_m1_235200_475200 n1_m1_240000_475200 5.356235
R13225 n1_m1_240000_475200 n1_m1_244800_475200 5.356235
R13226 n1_m1_244800_475200 n1_m1_249600_475200 5.356235
R13227 n1_m1_249600_475200 n1_m1_254400_475200 5.356235
R13228 n1_m1_254400_475200 n1_m1_256000_475200 1.785412
R13229 n1_m1_259200_475200 n1_m1_256000_475200 3.570824
R13230 n1_m1_259200_475200 n1_m1_264000_475200 5.356235
R13231 n1_m1_264000_475200 n1_m1_268800_475200 5.356235
R13232 n1_m1_268800_475200 n1_m1_273600_475200 5.356235
R13233 n1_m1_273600_475200 n1_m1_278400_475200 5.356235
R13234 n1_m1_278400_475200 n1_m1_283200_475200 5.356235
R13235 n1_m1_283200_475200 n1_m1_284000_475200 0.892706
R13236 n1_m1_288000_475200 n1_m1_284000_475200 4.463529
R13237 n1_m1_288000_475200 n1_m1_292800_475200 5.356235
R13238 n1_m1_292800_475200 n1_m1_297600_475200 5.356235
R13239 n1_m1_297600_475200 n1_m1_302400_475200 5.356235
R13240 n1_m1_302400_475200 n1_m1_307200_475200 5.356235
R13241 n1_m1_307200_475200 n1_m1_312000_475200 5.356235
R13242 n1_m1_312000_475200 n1_m1_316800_475200 5.356235
R13243 n1_m1_316800_475200 n1_m1_321600_475200 5.356235
R13244 n1_m1_321600_475200 n1_m1_326400_475200 5.356235
R13245 n1_m1_326400_475200 n1_m1_331200_475200 5.356235
R13246 n1_m1_331200_475200 n1_m1_336000_475200 5.356235
R13247 n1_m1_336000_475200 n1_m1_340000_475200 4.463529
R13248 n1_m1_340800_475200 n1_m1_340000_475200 0.892706
R13249 n1_m1_340800_475200 n1_m1_345600_475200 5.356235
R13250 n1_m1_345600_475200 n1_m1_350400_475200 5.356235
R13251 n1_m1_350400_475200 n1_m1_355200_475200 5.356235
R13252 n1_m1_355200_475200 n1_m1_360000_475200 5.356235
R13253 n1_m1_360000_475200 n1_m1_364800_475200 5.356235
R13254 n1_m1_364800_475200 n1_m1_368000_475200 3.570824
R13255 n1_m1_369600_475200 n1_m1_368000_475200 1.785412
R13256 n1_m1_369600_475200 n1_m1_374400_475200 5.356235
R13257 n1_m1_374400_475200 n1_m1_379200_475200 5.356235
R13258 n1_m1_379200_475200 n1_m1_384000_475200 5.356235
R13259 n1_m1_384000_475200 n1_m1_388800_475200 5.356235
R13260 n1_m1_388800_475200 n1_m1_393600_475200 5.356235
R13261 n1_m1_393600_475200 n1_m1_396000_475200 2.678118
R13262 n1_m1_398400_475200 n1_m1_396000_475200 2.678118
R13263 n1_m1_398400_475200 n1_m1_403200_475200 5.356235
R13264 n1_m1_403200_475200 n1_m1_408000_475200 5.356235
R13265 n1_m1_408000_475200 n1_m1_412800_475200 5.356235
R13266 n1_m1_412800_475200 n1_m1_417600_475200 5.356235
R13267 n1_m1_417600_475200 n1_m1_422400_475200 5.356235
R13268 n1_m1_422400_475200 n1_m1_424000_475200 1.785412
R13269 n1_m1_427200_475200 n1_m1_424000_475200 3.570824
R13270 n1_m1_427200_475200 n1_m1_432000_475200 5.356235
R13271 n1_m1_432000_475200 n1_m1_436800_475200 5.356235
R13272 n1_m1_436800_475200 n1_m1_441600_475200 5.356235
R13273 n1_m1_441600_475200 n1_m1_446400_475200 5.356235
R13274 n1_m1_446400_475200 n1_m1_451200_475200 5.356235
R13275 n1_m1_451200_475200 n1_m1_452000_475200 0.892706
R13276 n1_m1_456000_475200 n1_m1_452000_475200 4.463529
R13277 n1_m1_456000_475200 n1_m1_460800_475200 5.356235
R13278 n1_m1_460800_475200 n1_m1_465600_475200 5.356235
R13279 n1_m1_465600_475200 n1_m1_470400_475200 5.356235
R13280 n1_m1_470400_475200 n1_m1_475200_475200 5.356235
R13281 n1_m1_475200_475200 n1_m1_480000_475200 5.356235
R13282 n1_m1_480000_475200 n1_m1_484800_475200 5.356235
R13283 n1_m1_484800_475200 n1_m1_489600_475200 5.356235
R13284 n1_m1_489600_475200 n1_m1_494400_475200 5.356235
R13285 n1_m1_494400_475200 n1_m1_499200_475200 5.356235
R13286 n1_m1_499200_475200 n1_m1_504000_475200 5.356235
R13287 n1_m1_504000_475200 n1_m1_508000_475200 4.463529
R13288 n1_m1_508800_475200 n1_m1_508000_475200 0.892706
R13289 n1_m1_508800_475200 n1_m1_513600_475200 5.356235
R13290 n1_m1_513600_475200 n1_m1_518400_475200 5.356235
R13291 n1_m1_518400_475200 n1_m1_523200_475200 5.356235
R13292 n1_m1_523200_475200 n1_m1_528000_475200 5.356235
R13293 n1_m1_528000_475200 n1_m1_532800_475200 5.356235
R13294 n1_m1_532800_475200 n1_m1_536000_475200 3.570824
R13295 n1_m1_537600_475200 n1_m1_536000_475200 1.785412
R13296 n1_m1_537600_475200 n1_m1_542400_475200 5.356235
R13297 n1_m1_542400_475200 n1_m1_547200_475200 5.356235
R13298 n1_m1_547200_475200 n1_m1_552000_475200 5.356235
R13299 n1_m1_552000_475200 n1_m1_556800_475200 5.356235
R13300 n1_m1_0_480000 n1_m1_4000_480000 4.463529
R13301 n1_m1_4800_480000 n1_m1_4000_480000 0.892706
R13302 n1_m1_4800_480000 n1_m1_9600_480000 5.356235
R13303 n1_m1_9600_480000 n1_m1_14400_480000 5.356235
R13304 n1_m1_14400_480000 n1_m1_19200_480000 5.356235
R13305 n1_m1_19200_480000 n1_m1_24000_480000 5.356235
R13306 n1_m1_24000_480000 n1_m1_28800_480000 5.356235
R13307 n1_m1_28800_480000 n1_m1_32000_480000 3.570824
R13308 n1_m1_33600_480000 n1_m1_32000_480000 1.785412
R13309 n1_m1_33600_480000 n1_m1_38400_480000 5.356235
R13310 n1_m1_38400_480000 n1_m1_43200_480000 5.356235
R13311 n1_m1_43200_480000 n1_m1_48000_480000 5.356235
R13312 n1_m1_48000_480000 n1_m1_52800_480000 5.356235
R13313 n1_m1_52800_480000 n1_m1_57600_480000 5.356235
R13314 n1_m1_57600_480000 n1_m1_60000_480000 2.678118
R13315 n1_m1_62400_480000 n1_m1_60000_480000 2.678118
R13316 n1_m1_62400_480000 n1_m1_67200_480000 5.356235
R13317 n1_m1_67200_480000 n1_m1_72000_480000 5.356235
R13318 n1_m1_72000_480000 n1_m1_76800_480000 5.356235
R13319 n1_m1_76800_480000 n1_m1_81600_480000 5.356235
R13320 n1_m1_81600_480000 n1_m1_86400_480000 5.356235
R13321 n1_m1_86400_480000 n1_m1_88000_480000 1.785412
R13322 n1_m1_91200_480000 n1_m1_88000_480000 3.570824
R13323 n1_m1_91200_480000 n1_m1_96000_480000 5.356235
R13324 n1_m1_96000_480000 n1_m1_100800_480000 5.356235
R13325 n1_m1_100800_480000 n1_m1_105600_480000 5.356235
R13326 n1_m1_105600_480000 n1_m1_110400_480000 5.356235
R13327 n1_m1_110400_480000 n1_m1_115200_480000 5.356235
R13328 n1_m1_115200_480000 n1_m1_116000_480000 0.892706
R13329 n1_m1_120000_480000 n1_m1_116000_480000 4.463529
R13330 n1_m1_120000_480000 n1_m1_124800_480000 5.356235
R13331 n1_m1_124800_480000 n1_m1_129600_480000 5.356235
R13332 n1_m1_129600_480000 n1_m1_134400_480000 5.356235
R13333 n1_m1_134400_480000 n1_m1_139200_480000 5.356235
R13334 n1_m1_139200_480000 n1_m1_144000_480000 5.356235
R13335 n1_m1_144000_480000 n1_m1_148800_480000 5.356235
R13336 n1_m1_148800_480000 n1_m1_153600_480000 5.356235
R13337 n1_m1_153600_480000 n1_m1_158400_480000 5.356235
R13338 n1_m1_158400_480000 n1_m1_163200_480000 5.356235
R13339 n1_m1_163200_480000 n1_m1_168000_480000 5.356235
R13340 n1_m1_168000_480000 n1_m1_172000_480000 4.463529
R13341 n1_m1_172800_480000 n1_m1_172000_480000 0.892706
R13342 n1_m1_172800_480000 n1_m1_177600_480000 5.356235
R13343 n1_m1_177600_480000 n1_m1_182400_480000 5.356235
R13344 n1_m1_182400_480000 n1_m1_187200_480000 5.356235
R13345 n1_m1_187200_480000 n1_m1_192000_480000 5.356235
R13346 n1_m1_192000_480000 n1_m1_196800_480000 5.356235
R13347 n1_m1_196800_480000 n1_m1_200000_480000 3.570824
R13348 n1_m1_201600_480000 n1_m1_200000_480000 1.785412
R13349 n1_m1_201600_480000 n1_m1_206400_480000 5.356235
R13350 n1_m1_206400_480000 n1_m1_211200_480000 5.356235
R13351 n1_m1_211200_480000 n1_m1_216000_480000 5.356235
R13352 n1_m1_216000_480000 n1_m1_220800_480000 5.356235
R13353 n1_m1_220800_480000 n1_m1_225600_480000 5.356235
R13354 n1_m1_225600_480000 n1_m1_228000_480000 2.678118
R13355 n1_m1_230400_480000 n1_m1_228000_480000 2.678118
R13356 n1_m1_230400_480000 n1_m1_235200_480000 5.356235
R13357 n1_m1_235200_480000 n1_m1_240000_480000 5.356235
R13358 n1_m1_240000_480000 n1_m1_244800_480000 5.356235
R13359 n1_m1_244800_480000 n1_m1_249600_480000 5.356235
R13360 n1_m1_249600_480000 n1_m1_254400_480000 5.356235
R13361 n1_m1_254400_480000 n1_m1_256000_480000 1.785412
R13362 n1_m1_259200_480000 n1_m1_256000_480000 3.570824
R13363 n1_m1_259200_480000 n1_m1_264000_480000 5.356235
R13364 n1_m1_264000_480000 n1_m1_268800_480000 5.356235
R13365 n1_m1_268800_480000 n1_m1_273600_480000 5.356235
R13366 n1_m1_273600_480000 n1_m1_278400_480000 5.356235
R13367 n1_m1_278400_480000 n1_m1_283200_480000 5.356235
R13368 n1_m1_283200_480000 n1_m1_284000_480000 0.892706
R13369 n1_m1_288000_480000 n1_m1_284000_480000 4.463529
R13370 n1_m1_288000_480000 n1_m1_292800_480000 5.356235
R13371 n1_m1_292800_480000 n1_m1_297600_480000 5.356235
R13372 n1_m1_297600_480000 n1_m1_302400_480000 5.356235
R13373 n1_m1_302400_480000 n1_m1_307200_480000 5.356235
R13374 n1_m1_307200_480000 n1_m1_312000_480000 5.356235
R13375 n1_m1_312000_480000 n1_m1_316800_480000 5.356235
R13376 n1_m1_316800_480000 n1_m1_321600_480000 5.356235
R13377 n1_m1_321600_480000 n1_m1_326400_480000 5.356235
R13378 n1_m1_326400_480000 n1_m1_331200_480000 5.356235
R13379 n1_m1_331200_480000 n1_m1_336000_480000 5.356235
R13380 n1_m1_336000_480000 n1_m1_340000_480000 4.463529
R13381 n1_m1_340800_480000 n1_m1_340000_480000 0.892706
R13382 n1_m1_340800_480000 n1_m1_345600_480000 5.356235
R13383 n1_m1_345600_480000 n1_m1_350400_480000 5.356235
R13384 n1_m1_350400_480000 n1_m1_355200_480000 5.356235
R13385 n1_m1_355200_480000 n1_m1_360000_480000 5.356235
R13386 n1_m1_360000_480000 n1_m1_364800_480000 5.356235
R13387 n1_m1_364800_480000 n1_m1_368000_480000 3.570824
R13388 n1_m1_369600_480000 n1_m1_368000_480000 1.785412
R13389 n1_m1_369600_480000 n1_m1_374400_480000 5.356235
R13390 n1_m1_374400_480000 n1_m1_379200_480000 5.356235
R13391 n1_m1_379200_480000 n1_m1_384000_480000 5.356235
R13392 n1_m1_384000_480000 n1_m1_388800_480000 5.356235
R13393 n1_m1_388800_480000 n1_m1_393600_480000 5.356235
R13394 n1_m1_393600_480000 n1_m1_396000_480000 2.678118
R13395 n1_m1_398400_480000 n1_m1_396000_480000 2.678118
R13396 n1_m1_398400_480000 n1_m1_403200_480000 5.356235
R13397 n1_m1_403200_480000 n1_m1_408000_480000 5.356235
R13398 n1_m1_408000_480000 n1_m1_412800_480000 5.356235
R13399 n1_m1_412800_480000 n1_m1_417600_480000 5.356235
R13400 n1_m1_417600_480000 n1_m1_422400_480000 5.356235
R13401 n1_m1_422400_480000 n1_m1_424000_480000 1.785412
R13402 n1_m1_427200_480000 n1_m1_424000_480000 3.570824
R13403 n1_m1_427200_480000 n1_m1_432000_480000 5.356235
R13404 n1_m1_432000_480000 n1_m1_436800_480000 5.356235
R13405 n1_m1_436800_480000 n1_m1_441600_480000 5.356235
R13406 n1_m1_441600_480000 n1_m1_446400_480000 5.356235
R13407 n1_m1_446400_480000 n1_m1_451200_480000 5.356235
R13408 n1_m1_451200_480000 n1_m1_452000_480000 0.892706
R13409 n1_m1_456000_480000 n1_m1_452000_480000 4.463529
R13410 n1_m1_456000_480000 n1_m1_460800_480000 5.356235
R13411 n1_m1_460800_480000 n1_m1_465600_480000 5.356235
R13412 n1_m1_465600_480000 n1_m1_470400_480000 5.356235
R13413 n1_m1_470400_480000 n1_m1_475200_480000 5.356235
R13414 n1_m1_475200_480000 n1_m1_480000_480000 5.356235
R13415 n1_m1_480000_480000 n1_m1_484800_480000 5.356235
R13416 n1_m1_484800_480000 n1_m1_489600_480000 5.356235
R13417 n1_m1_489600_480000 n1_m1_494400_480000 5.356235
R13418 n1_m1_494400_480000 n1_m1_499200_480000 5.356235
R13419 n1_m1_499200_480000 n1_m1_504000_480000 5.356235
R13420 n1_m1_504000_480000 n1_m1_508000_480000 4.463529
R13421 n1_m1_508800_480000 n1_m1_508000_480000 0.892706
R13422 n1_m1_508800_480000 n1_m1_513600_480000 5.356235
R13423 n1_m1_513600_480000 n1_m1_518400_480000 5.356235
R13424 n1_m1_518400_480000 n1_m1_523200_480000 5.356235
R13425 n1_m1_523200_480000 n1_m1_528000_480000 5.356235
R13426 n1_m1_528000_480000 n1_m1_532800_480000 5.356235
R13427 n1_m1_532800_480000 n1_m1_536000_480000 3.570824
R13428 n1_m1_537600_480000 n1_m1_536000_480000 1.785412
R13429 n1_m1_537600_480000 n1_m1_542400_480000 5.356235
R13430 n1_m1_542400_480000 n1_m1_547200_480000 5.356235
R13431 n1_m1_547200_480000 n1_m1_552000_480000 5.356235
R13432 n1_m1_552000_480000 n1_m1_556800_480000 5.356235
R13433 n1_m1_0_484800 n1_m1_4000_484800 4.463529
R13434 n1_m1_4800_484800 n1_m1_4000_484800 0.892706
R13435 n1_m1_4800_484800 n1_m1_9600_484800 5.356235
R13436 n1_m1_9600_484800 n1_m1_14400_484800 5.356235
R13437 n1_m1_14400_484800 n1_m1_19200_484800 5.356235
R13438 n1_m1_19200_484800 n1_m1_24000_484800 5.356235
R13439 n1_m1_24000_484800 n1_m1_28800_484800 5.356235
R13440 n1_m1_28800_484800 n1_m1_32000_484800 3.570824
R13441 n1_m1_33600_484800 n1_m1_32000_484800 1.785412
R13442 n1_m1_33600_484800 n1_m1_38400_484800 5.356235
R13443 n1_m1_38400_484800 n1_m1_43200_484800 5.356235
R13444 n1_m1_43200_484800 n1_m1_48000_484800 5.356235
R13445 n1_m1_48000_484800 n1_m1_52800_484800 5.356235
R13446 n1_m1_52800_484800 n1_m1_57600_484800 5.356235
R13447 n1_m1_57600_484800 n1_m1_60000_484800 2.678118
R13448 n1_m1_62400_484800 n1_m1_60000_484800 2.678118
R13449 n1_m1_62400_484800 n1_m1_67200_484800 5.356235
R13450 n1_m1_67200_484800 n1_m1_72000_484800 5.356235
R13451 n1_m1_72000_484800 n1_m1_76800_484800 5.356235
R13452 n1_m1_76800_484800 n1_m1_81600_484800 5.356235
R13453 n1_m1_81600_484800 n1_m1_86400_484800 5.356235
R13454 n1_m1_86400_484800 n1_m1_88000_484800 1.785412
R13455 n1_m1_91200_484800 n1_m1_88000_484800 3.570824
R13456 n1_m1_91200_484800 n1_m1_96000_484800 5.356235
R13457 n1_m1_96000_484800 n1_m1_100800_484800 5.356235
R13458 n1_m1_100800_484800 n1_m1_105600_484800 5.356235
R13459 n1_m1_105600_484800 n1_m1_110400_484800 5.356235
R13460 n1_m1_110400_484800 n1_m1_115200_484800 5.356235
R13461 n1_m1_115200_484800 n1_m1_116000_484800 0.892706
R13462 n1_m1_120000_484800 n1_m1_116000_484800 4.463529
R13463 n1_m1_120000_484800 n1_m1_124800_484800 5.356235
R13464 n1_m1_124800_484800 n1_m1_129600_484800 5.356235
R13465 n1_m1_129600_484800 n1_m1_134400_484800 5.356235
R13466 n1_m1_134400_484800 n1_m1_139200_484800 5.356235
R13467 n1_m1_139200_484800 n1_m1_144000_484800 5.356235
R13468 n1_m1_144000_484800 n1_m1_148800_484800 5.356235
R13469 n1_m1_148800_484800 n1_m1_153600_484800 5.356235
R13470 n1_m1_153600_484800 n1_m1_158400_484800 5.356235
R13471 n1_m1_158400_484800 n1_m1_163200_484800 5.356235
R13472 n1_m1_163200_484800 n1_m1_168000_484800 5.356235
R13473 n1_m1_168000_484800 n1_m1_172000_484800 4.463529
R13474 n1_m1_172800_484800 n1_m1_172000_484800 0.892706
R13475 n1_m1_172800_484800 n1_m1_177600_484800 5.356235
R13476 n1_m1_177600_484800 n1_m1_182400_484800 5.356235
R13477 n1_m1_182400_484800 n1_m1_187200_484800 5.356235
R13478 n1_m1_187200_484800 n1_m1_192000_484800 5.356235
R13479 n1_m1_192000_484800 n1_m1_196800_484800 5.356235
R13480 n1_m1_196800_484800 n1_m1_200000_484800 3.570824
R13481 n1_m1_201600_484800 n1_m1_200000_484800 1.785412
R13482 n1_m1_201600_484800 n1_m1_206400_484800 5.356235
R13483 n1_m1_206400_484800 n1_m1_211200_484800 5.356235
R13484 n1_m1_211200_484800 n1_m1_216000_484800 5.356235
R13485 n1_m1_216000_484800 n1_m1_220800_484800 5.356235
R13486 n1_m1_220800_484800 n1_m1_225600_484800 5.356235
R13487 n1_m1_225600_484800 n1_m1_228000_484800 2.678118
R13488 n1_m1_230400_484800 n1_m1_228000_484800 2.678118
R13489 n1_m1_230400_484800 n1_m1_235200_484800 5.356235
R13490 n1_m1_235200_484800 n1_m1_240000_484800 5.356235
R13491 n1_m1_240000_484800 n1_m1_244800_484800 5.356235
R13492 n1_m1_244800_484800 n1_m1_249600_484800 5.356235
R13493 n1_m1_249600_484800 n1_m1_254400_484800 5.356235
R13494 n1_m1_254400_484800 n1_m1_256000_484800 1.785412
R13495 n1_m1_259200_484800 n1_m1_256000_484800 3.570824
R13496 n1_m1_259200_484800 n1_m1_264000_484800 5.356235
R13497 n1_m1_264000_484800 n1_m1_268800_484800 5.356235
R13498 n1_m1_268800_484800 n1_m1_273600_484800 5.356235
R13499 n1_m1_273600_484800 n1_m1_278400_484800 5.356235
R13500 n1_m1_278400_484800 n1_m1_283200_484800 5.356235
R13501 n1_m1_283200_484800 n1_m1_284000_484800 0.892706
R13502 n1_m1_288000_484800 n1_m1_284000_484800 4.463529
R13503 n1_m1_288000_484800 n1_m1_292800_484800 5.356235
R13504 n1_m1_292800_484800 n1_m1_297600_484800 5.356235
R13505 n1_m1_297600_484800 n1_m1_302400_484800 5.356235
R13506 n1_m1_302400_484800 n1_m1_307200_484800 5.356235
R13507 n1_m1_307200_484800 n1_m1_312000_484800 5.356235
R13508 n1_m1_312000_484800 n1_m1_316800_484800 5.356235
R13509 n1_m1_316800_484800 n1_m1_321600_484800 5.356235
R13510 n1_m1_321600_484800 n1_m1_326400_484800 5.356235
R13511 n1_m1_326400_484800 n1_m1_331200_484800 5.356235
R13512 n1_m1_331200_484800 n1_m1_336000_484800 5.356235
R13513 n1_m1_336000_484800 n1_m1_340000_484800 4.463529
R13514 n1_m1_340800_484800 n1_m1_340000_484800 0.892706
R13515 n1_m1_340800_484800 n1_m1_345600_484800 5.356235
R13516 n1_m1_345600_484800 n1_m1_350400_484800 5.356235
R13517 n1_m1_350400_484800 n1_m1_355200_484800 5.356235
R13518 n1_m1_355200_484800 n1_m1_360000_484800 5.356235
R13519 n1_m1_360000_484800 n1_m1_364800_484800 5.356235
R13520 n1_m1_364800_484800 n1_m1_368000_484800 3.570824
R13521 n1_m1_369600_484800 n1_m1_368000_484800 1.785412
R13522 n1_m1_369600_484800 n1_m1_374400_484800 5.356235
R13523 n1_m1_374400_484800 n1_m1_379200_484800 5.356235
R13524 n1_m1_379200_484800 n1_m1_384000_484800 5.356235
R13525 n1_m1_384000_484800 n1_m1_388800_484800 5.356235
R13526 n1_m1_388800_484800 n1_m1_393600_484800 5.356235
R13527 n1_m1_393600_484800 n1_m1_396000_484800 2.678118
R13528 n1_m1_398400_484800 n1_m1_396000_484800 2.678118
R13529 n1_m1_398400_484800 n1_m1_403200_484800 5.356235
R13530 n1_m1_403200_484800 n1_m1_408000_484800 5.356235
R13531 n1_m1_408000_484800 n1_m1_412800_484800 5.356235
R13532 n1_m1_412800_484800 n1_m1_417600_484800 5.356235
R13533 n1_m1_417600_484800 n1_m1_422400_484800 5.356235
R13534 n1_m1_422400_484800 n1_m1_424000_484800 1.785412
R13535 n1_m1_427200_484800 n1_m1_424000_484800 3.570824
R13536 n1_m1_427200_484800 n1_m1_432000_484800 5.356235
R13537 n1_m1_432000_484800 n1_m1_436800_484800 5.356235
R13538 n1_m1_436800_484800 n1_m1_441600_484800 5.356235
R13539 n1_m1_441600_484800 n1_m1_446400_484800 5.356235
R13540 n1_m1_446400_484800 n1_m1_451200_484800 5.356235
R13541 n1_m1_451200_484800 n1_m1_452000_484800 0.892706
R13542 n1_m1_456000_484800 n1_m1_452000_484800 4.463529
R13543 n1_m1_456000_484800 n1_m1_460800_484800 5.356235
R13544 n1_m1_460800_484800 n1_m1_465600_484800 5.356235
R13545 n1_m1_465600_484800 n1_m1_470400_484800 5.356235
R13546 n1_m1_470400_484800 n1_m1_475200_484800 5.356235
R13547 n1_m1_475200_484800 n1_m1_480000_484800 5.356235
R13548 n1_m1_480000_484800 n1_m1_484800_484800 5.356235
R13549 n1_m1_484800_484800 n1_m1_489600_484800 5.356235
R13550 n1_m1_489600_484800 n1_m1_494400_484800 5.356235
R13551 n1_m1_494400_484800 n1_m1_499200_484800 5.356235
R13552 n1_m1_499200_484800 n1_m1_504000_484800 5.356235
R13553 n1_m1_504000_484800 n1_m1_508000_484800 4.463529
R13554 n1_m1_508800_484800 n1_m1_508000_484800 0.892706
R13555 n1_m1_508800_484800 n1_m1_513600_484800 5.356235
R13556 n1_m1_513600_484800 n1_m1_518400_484800 5.356235
R13557 n1_m1_518400_484800 n1_m1_523200_484800 5.356235
R13558 n1_m1_523200_484800 n1_m1_528000_484800 5.356235
R13559 n1_m1_528000_484800 n1_m1_532800_484800 5.356235
R13560 n1_m1_532800_484800 n1_m1_536000_484800 3.570824
R13561 n1_m1_537600_484800 n1_m1_536000_484800 1.785412
R13562 n1_m1_537600_484800 n1_m1_542400_484800 5.356235
R13563 n1_m1_542400_484800 n1_m1_547200_484800 5.356235
R13564 n1_m1_547200_484800 n1_m1_552000_484800 5.356235
R13565 n1_m1_552000_484800 n1_m1_556800_484800 5.356235
R13566 n1_m1_0_489600 n1_m1_4000_489600 4.463529
R13567 n1_m1_4800_489600 n1_m1_4000_489600 0.892706
R13568 n1_m1_4800_489600 n1_m1_9600_489600 5.356235
R13569 n1_m1_9600_489600 n1_m1_14400_489600 5.356235
R13570 n1_m1_14400_489600 n1_m1_19200_489600 5.356235
R13571 n1_m1_19200_489600 n1_m1_24000_489600 5.356235
R13572 n1_m1_24000_489600 n1_m1_28800_489600 5.356235
R13573 n1_m1_28800_489600 n1_m1_32000_489600 3.570824
R13574 n1_m1_33600_489600 n1_m1_32000_489600 1.785412
R13575 n1_m1_33600_489600 n1_m1_38400_489600 5.356235
R13576 n1_m1_38400_489600 n1_m1_43200_489600 5.356235
R13577 n1_m1_43200_489600 n1_m1_48000_489600 5.356235
R13578 n1_m1_48000_489600 n1_m1_52800_489600 5.356235
R13579 n1_m1_52800_489600 n1_m1_57600_489600 5.356235
R13580 n1_m1_57600_489600 n1_m1_60000_489600 2.678118
R13581 n1_m1_62400_489600 n1_m1_60000_489600 2.678118
R13582 n1_m1_62400_489600 n1_m1_67200_489600 5.356235
R13583 n1_m1_67200_489600 n1_m1_72000_489600 5.356235
R13584 n1_m1_72000_489600 n1_m1_76800_489600 5.356235
R13585 n1_m1_76800_489600 n1_m1_81600_489600 5.356235
R13586 n1_m1_81600_489600 n1_m1_86400_489600 5.356235
R13587 n1_m1_86400_489600 n1_m1_88000_489600 1.785412
R13588 n1_m1_91200_489600 n1_m1_88000_489600 3.570824
R13589 n1_m1_91200_489600 n1_m1_96000_489600 5.356235
R13590 n1_m1_96000_489600 n1_m1_100800_489600 5.356235
R13591 n1_m1_100800_489600 n1_m1_105600_489600 5.356235
R13592 n1_m1_105600_489600 n1_m1_110400_489600 5.356235
R13593 n1_m1_110400_489600 n1_m1_115200_489600 5.356235
R13594 n1_m1_115200_489600 n1_m1_116000_489600 0.892706
R13595 n1_m1_120000_489600 n1_m1_116000_489600 4.463529
R13596 n1_m1_120000_489600 n1_m1_124800_489600 5.356235
R13597 n1_m1_124800_489600 n1_m1_129600_489600 5.356235
R13598 n1_m1_129600_489600 n1_m1_134400_489600 5.356235
R13599 n1_m1_134400_489600 n1_m1_139200_489600 5.356235
R13600 n1_m1_139200_489600 n1_m1_144000_489600 5.356235
R13601 n1_m1_144000_489600 n1_m1_148800_489600 5.356235
R13602 n1_m1_148800_489600 n1_m1_153600_489600 5.356235
R13603 n1_m1_153600_489600 n1_m1_158400_489600 5.356235
R13604 n1_m1_158400_489600 n1_m1_163200_489600 5.356235
R13605 n1_m1_163200_489600 n1_m1_168000_489600 5.356235
R13606 n1_m1_168000_489600 n1_m1_172000_489600 4.463529
R13607 n1_m1_172800_489600 n1_m1_172000_489600 0.892706
R13608 n1_m1_172800_489600 n1_m1_177600_489600 5.356235
R13609 n1_m1_177600_489600 n1_m1_182400_489600 5.356235
R13610 n1_m1_182400_489600 n1_m1_187200_489600 5.356235
R13611 n1_m1_187200_489600 n1_m1_192000_489600 5.356235
R13612 n1_m1_192000_489600 n1_m1_196800_489600 5.356235
R13613 n1_m1_196800_489600 n1_m1_200000_489600 3.570824
R13614 n1_m1_201600_489600 n1_m1_200000_489600 1.785412
R13615 n1_m1_201600_489600 n1_m1_206400_489600 5.356235
R13616 n1_m1_206400_489600 n1_m1_211200_489600 5.356235
R13617 n1_m1_211200_489600 n1_m1_216000_489600 5.356235
R13618 n1_m1_216000_489600 n1_m1_220800_489600 5.356235
R13619 n1_m1_220800_489600 n1_m1_225600_489600 5.356235
R13620 n1_m1_225600_489600 n1_m1_228000_489600 2.678118
R13621 n1_m1_230400_489600 n1_m1_228000_489600 2.678118
R13622 n1_m1_230400_489600 n1_m1_235200_489600 5.356235
R13623 n1_m1_235200_489600 n1_m1_240000_489600 5.356235
R13624 n1_m1_240000_489600 n1_m1_244800_489600 5.356235
R13625 n1_m1_244800_489600 n1_m1_249600_489600 5.356235
R13626 n1_m1_249600_489600 n1_m1_254400_489600 5.356235
R13627 n1_m1_254400_489600 n1_m1_256000_489600 1.785412
R13628 n1_m1_259200_489600 n1_m1_256000_489600 3.570824
R13629 n1_m1_259200_489600 n1_m1_264000_489600 5.356235
R13630 n1_m1_264000_489600 n1_m1_268800_489600 5.356235
R13631 n1_m1_268800_489600 n1_m1_273600_489600 5.356235
R13632 n1_m1_273600_489600 n1_m1_278400_489600 5.356235
R13633 n1_m1_278400_489600 n1_m1_283200_489600 5.356235
R13634 n1_m1_283200_489600 n1_m1_284000_489600 0.892706
R13635 n1_m1_288000_489600 n1_m1_284000_489600 4.463529
R13636 n1_m1_288000_489600 n1_m1_292800_489600 5.356235
R13637 n1_m1_292800_489600 n1_m1_297600_489600 5.356235
R13638 n1_m1_297600_489600 n1_m1_302400_489600 5.356235
R13639 n1_m1_302400_489600 n1_m1_307200_489600 5.356235
R13640 n1_m1_307200_489600 n1_m1_312000_489600 5.356235
R13641 n1_m1_312000_489600 n1_m1_316800_489600 5.356235
R13642 n1_m1_316800_489600 n1_m1_321600_489600 5.356235
R13643 n1_m1_321600_489600 n1_m1_326400_489600 5.356235
R13644 n1_m1_326400_489600 n1_m1_331200_489600 5.356235
R13645 n1_m1_331200_489600 n1_m1_336000_489600 5.356235
R13646 n1_m1_336000_489600 n1_m1_340000_489600 4.463529
R13647 n1_m1_340800_489600 n1_m1_340000_489600 0.892706
R13648 n1_m1_340800_489600 n1_m1_345600_489600 5.356235
R13649 n1_m1_345600_489600 n1_m1_350400_489600 5.356235
R13650 n1_m1_350400_489600 n1_m1_355200_489600 5.356235
R13651 n1_m1_355200_489600 n1_m1_360000_489600 5.356235
R13652 n1_m1_360000_489600 n1_m1_364800_489600 5.356235
R13653 n1_m1_364800_489600 n1_m1_368000_489600 3.570824
R13654 n1_m1_369600_489600 n1_m1_368000_489600 1.785412
R13655 n1_m1_369600_489600 n1_m1_374400_489600 5.356235
R13656 n1_m1_374400_489600 n1_m1_379200_489600 5.356235
R13657 n1_m1_379200_489600 n1_m1_384000_489600 5.356235
R13658 n1_m1_384000_489600 n1_m1_388800_489600 5.356235
R13659 n1_m1_388800_489600 n1_m1_393600_489600 5.356235
R13660 n1_m1_393600_489600 n1_m1_396000_489600 2.678118
R13661 n1_m1_398400_489600 n1_m1_396000_489600 2.678118
R13662 n1_m1_398400_489600 n1_m1_403200_489600 5.356235
R13663 n1_m1_403200_489600 n1_m1_408000_489600 5.356235
R13664 n1_m1_408000_489600 n1_m1_412800_489600 5.356235
R13665 n1_m1_412800_489600 n1_m1_417600_489600 5.356235
R13666 n1_m1_417600_489600 n1_m1_422400_489600 5.356235
R13667 n1_m1_422400_489600 n1_m1_424000_489600 1.785412
R13668 n1_m1_427200_489600 n1_m1_424000_489600 3.570824
R13669 n1_m1_427200_489600 n1_m1_432000_489600 5.356235
R13670 n1_m1_432000_489600 n1_m1_436800_489600 5.356235
R13671 n1_m1_436800_489600 n1_m1_441600_489600 5.356235
R13672 n1_m1_441600_489600 n1_m1_446400_489600 5.356235
R13673 n1_m1_446400_489600 n1_m1_451200_489600 5.356235
R13674 n1_m1_451200_489600 n1_m1_452000_489600 0.892706
R13675 n1_m1_456000_489600 n1_m1_452000_489600 4.463529
R13676 n1_m1_456000_489600 n1_m1_460800_489600 5.356235
R13677 n1_m1_460800_489600 n1_m1_465600_489600 5.356235
R13678 n1_m1_465600_489600 n1_m1_470400_489600 5.356235
R13679 n1_m1_470400_489600 n1_m1_475200_489600 5.356235
R13680 n1_m1_475200_489600 n1_m1_480000_489600 5.356235
R13681 n1_m1_480000_489600 n1_m1_484800_489600 5.356235
R13682 n1_m1_484800_489600 n1_m1_489600_489600 5.356235
R13683 n1_m1_489600_489600 n1_m1_494400_489600 5.356235
R13684 n1_m1_494400_489600 n1_m1_499200_489600 5.356235
R13685 n1_m1_499200_489600 n1_m1_504000_489600 5.356235
R13686 n1_m1_504000_489600 n1_m1_508000_489600 4.463529
R13687 n1_m1_508800_489600 n1_m1_508000_489600 0.892706
R13688 n1_m1_508800_489600 n1_m1_513600_489600 5.356235
R13689 n1_m1_513600_489600 n1_m1_518400_489600 5.356235
R13690 n1_m1_518400_489600 n1_m1_523200_489600 5.356235
R13691 n1_m1_523200_489600 n1_m1_528000_489600 5.356235
R13692 n1_m1_528000_489600 n1_m1_532800_489600 5.356235
R13693 n1_m1_532800_489600 n1_m1_536000_489600 3.570824
R13694 n1_m1_537600_489600 n1_m1_536000_489600 1.785412
R13695 n1_m1_537600_489600 n1_m1_542400_489600 5.356235
R13696 n1_m1_542400_489600 n1_m1_547200_489600 5.356235
R13697 n1_m1_547200_489600 n1_m1_552000_489600 5.356235
R13698 n1_m1_552000_489600 n1_m1_556800_489600 5.356235
R13699 n1_m1_0_494400 n1_m1_4000_494400 4.463529
R13700 n1_m1_4800_494400 n1_m1_4000_494400 0.892706
R13701 n1_m1_4800_494400 n1_m1_9600_494400 5.356235
R13702 n1_m1_9600_494400 n1_m1_14400_494400 5.356235
R13703 n1_m1_14400_494400 n1_m1_19200_494400 5.356235
R13704 n1_m1_19200_494400 n1_m1_24000_494400 5.356235
R13705 n1_m1_24000_494400 n1_m1_28800_494400 5.356235
R13706 n1_m1_28800_494400 n1_m1_32000_494400 3.570824
R13707 n1_m1_33600_494400 n1_m1_32000_494400 1.785412
R13708 n1_m1_33600_494400 n1_m1_38400_494400 5.356235
R13709 n1_m1_38400_494400 n1_m1_43200_494400 5.356235
R13710 n1_m1_43200_494400 n1_m1_48000_494400 5.356235
R13711 n1_m1_48000_494400 n1_m1_52800_494400 5.356235
R13712 n1_m1_52800_494400 n1_m1_57600_494400 5.356235
R13713 n1_m1_57600_494400 n1_m1_60000_494400 2.678118
R13714 n1_m1_62400_494400 n1_m1_60000_494400 2.678118
R13715 n1_m1_62400_494400 n1_m1_67200_494400 5.356235
R13716 n1_m1_67200_494400 n1_m1_72000_494400 5.356235
R13717 n1_m1_72000_494400 n1_m1_76800_494400 5.356235
R13718 n1_m1_76800_494400 n1_m1_81600_494400 5.356235
R13719 n1_m1_81600_494400 n1_m1_86400_494400 5.356235
R13720 n1_m1_86400_494400 n1_m1_88000_494400 1.785412
R13721 n1_m1_91200_494400 n1_m1_88000_494400 3.570824
R13722 n1_m1_91200_494400 n1_m1_96000_494400 5.356235
R13723 n1_m1_96000_494400 n1_m1_100800_494400 5.356235
R13724 n1_m1_100800_494400 n1_m1_105600_494400 5.356235
R13725 n1_m1_105600_494400 n1_m1_110400_494400 5.356235
R13726 n1_m1_110400_494400 n1_m1_115200_494400 5.356235
R13727 n1_m1_115200_494400 n1_m1_116000_494400 0.892706
R13728 n1_m1_120000_494400 n1_m1_116000_494400 4.463529
R13729 n1_m1_120000_494400 n1_m1_124800_494400 5.356235
R13730 n1_m1_124800_494400 n1_m1_129600_494400 5.356235
R13731 n1_m1_129600_494400 n1_m1_134400_494400 5.356235
R13732 n1_m1_134400_494400 n1_m1_139200_494400 5.356235
R13733 n1_m1_139200_494400 n1_m1_144000_494400 5.356235
R13734 n1_m1_144000_494400 n1_m1_148800_494400 5.356235
R13735 n1_m1_148800_494400 n1_m1_153600_494400 5.356235
R13736 n1_m1_153600_494400 n1_m1_158400_494400 5.356235
R13737 n1_m1_158400_494400 n1_m1_163200_494400 5.356235
R13738 n1_m1_163200_494400 n1_m1_168000_494400 5.356235
R13739 n1_m1_168000_494400 n1_m1_172000_494400 4.463529
R13740 n1_m1_172800_494400 n1_m1_172000_494400 0.892706
R13741 n1_m1_172800_494400 n1_m1_177600_494400 5.356235
R13742 n1_m1_177600_494400 n1_m1_182400_494400 5.356235
R13743 n1_m1_182400_494400 n1_m1_187200_494400 5.356235
R13744 n1_m1_187200_494400 n1_m1_192000_494400 5.356235
R13745 n1_m1_192000_494400 n1_m1_196800_494400 5.356235
R13746 n1_m1_196800_494400 n1_m1_200000_494400 3.570824
R13747 n1_m1_201600_494400 n1_m1_200000_494400 1.785412
R13748 n1_m1_201600_494400 n1_m1_206400_494400 5.356235
R13749 n1_m1_206400_494400 n1_m1_211200_494400 5.356235
R13750 n1_m1_211200_494400 n1_m1_216000_494400 5.356235
R13751 n1_m1_216000_494400 n1_m1_220800_494400 5.356235
R13752 n1_m1_220800_494400 n1_m1_225600_494400 5.356235
R13753 n1_m1_225600_494400 n1_m1_228000_494400 2.678118
R13754 n1_m1_230400_494400 n1_m1_228000_494400 2.678118
R13755 n1_m1_230400_494400 n1_m1_235200_494400 5.356235
R13756 n1_m1_235200_494400 n1_m1_240000_494400 5.356235
R13757 n1_m1_240000_494400 n1_m1_244800_494400 5.356235
R13758 n1_m1_244800_494400 n1_m1_249600_494400 5.356235
R13759 n1_m1_249600_494400 n1_m1_254400_494400 5.356235
R13760 n1_m1_254400_494400 n1_m1_256000_494400 1.785412
R13761 n1_m1_259200_494400 n1_m1_256000_494400 3.570824
R13762 n1_m1_259200_494400 n1_m1_264000_494400 5.356235
R13763 n1_m1_264000_494400 n1_m1_268800_494400 5.356235
R13764 n1_m1_268800_494400 n1_m1_273600_494400 5.356235
R13765 n1_m1_273600_494400 n1_m1_278400_494400 5.356235
R13766 n1_m1_278400_494400 n1_m1_283200_494400 5.356235
R13767 n1_m1_283200_494400 n1_m1_284000_494400 0.892706
R13768 n1_m1_288000_494400 n1_m1_284000_494400 4.463529
R13769 n1_m1_288000_494400 n1_m1_292800_494400 5.356235
R13770 n1_m1_292800_494400 n1_m1_297600_494400 5.356235
R13771 n1_m1_297600_494400 n1_m1_302400_494400 5.356235
R13772 n1_m1_302400_494400 n1_m1_307200_494400 5.356235
R13773 n1_m1_307200_494400 n1_m1_312000_494400 5.356235
R13774 n1_m1_312000_494400 n1_m1_316800_494400 5.356235
R13775 n1_m1_316800_494400 n1_m1_321600_494400 5.356235
R13776 n1_m1_321600_494400 n1_m1_326400_494400 5.356235
R13777 n1_m1_326400_494400 n1_m1_331200_494400 5.356235
R13778 n1_m1_331200_494400 n1_m1_336000_494400 5.356235
R13779 n1_m1_336000_494400 n1_m1_340000_494400 4.463529
R13780 n1_m1_340800_494400 n1_m1_340000_494400 0.892706
R13781 n1_m1_340800_494400 n1_m1_345600_494400 5.356235
R13782 n1_m1_345600_494400 n1_m1_350400_494400 5.356235
R13783 n1_m1_350400_494400 n1_m1_355200_494400 5.356235
R13784 n1_m1_355200_494400 n1_m1_360000_494400 5.356235
R13785 n1_m1_360000_494400 n1_m1_364800_494400 5.356235
R13786 n1_m1_364800_494400 n1_m1_368000_494400 3.570824
R13787 n1_m1_369600_494400 n1_m1_368000_494400 1.785412
R13788 n1_m1_369600_494400 n1_m1_374400_494400 5.356235
R13789 n1_m1_374400_494400 n1_m1_379200_494400 5.356235
R13790 n1_m1_379200_494400 n1_m1_384000_494400 5.356235
R13791 n1_m1_384000_494400 n1_m1_388800_494400 5.356235
R13792 n1_m1_388800_494400 n1_m1_393600_494400 5.356235
R13793 n1_m1_393600_494400 n1_m1_396000_494400 2.678118
R13794 n1_m1_398400_494400 n1_m1_396000_494400 2.678118
R13795 n1_m1_398400_494400 n1_m1_403200_494400 5.356235
R13796 n1_m1_403200_494400 n1_m1_408000_494400 5.356235
R13797 n1_m1_408000_494400 n1_m1_412800_494400 5.356235
R13798 n1_m1_412800_494400 n1_m1_417600_494400 5.356235
R13799 n1_m1_417600_494400 n1_m1_422400_494400 5.356235
R13800 n1_m1_422400_494400 n1_m1_424000_494400 1.785412
R13801 n1_m1_427200_494400 n1_m1_424000_494400 3.570824
R13802 n1_m1_427200_494400 n1_m1_432000_494400 5.356235
R13803 n1_m1_432000_494400 n1_m1_436800_494400 5.356235
R13804 n1_m1_436800_494400 n1_m1_441600_494400 5.356235
R13805 n1_m1_441600_494400 n1_m1_446400_494400 5.356235
R13806 n1_m1_446400_494400 n1_m1_451200_494400 5.356235
R13807 n1_m1_451200_494400 n1_m1_452000_494400 0.892706
R13808 n1_m1_456000_494400 n1_m1_452000_494400 4.463529
R13809 n1_m1_456000_494400 n1_m1_460800_494400 5.356235
R13810 n1_m1_460800_494400 n1_m1_465600_494400 5.356235
R13811 n1_m1_465600_494400 n1_m1_470400_494400 5.356235
R13812 n1_m1_470400_494400 n1_m1_475200_494400 5.356235
R13813 n1_m1_475200_494400 n1_m1_480000_494400 5.356235
R13814 n1_m1_480000_494400 n1_m1_484800_494400 5.356235
R13815 n1_m1_484800_494400 n1_m1_489600_494400 5.356235
R13816 n1_m1_489600_494400 n1_m1_494400_494400 5.356235
R13817 n1_m1_494400_494400 n1_m1_499200_494400 5.356235
R13818 n1_m1_499200_494400 n1_m1_504000_494400 5.356235
R13819 n1_m1_504000_494400 n1_m1_508000_494400 4.463529
R13820 n1_m1_508800_494400 n1_m1_508000_494400 0.892706
R13821 n1_m1_508800_494400 n1_m1_513600_494400 5.356235
R13822 n1_m1_513600_494400 n1_m1_518400_494400 5.356235
R13823 n1_m1_518400_494400 n1_m1_523200_494400 5.356235
R13824 n1_m1_523200_494400 n1_m1_528000_494400 5.356235
R13825 n1_m1_528000_494400 n1_m1_532800_494400 5.356235
R13826 n1_m1_532800_494400 n1_m1_536000_494400 3.570824
R13827 n1_m1_537600_494400 n1_m1_536000_494400 1.785412
R13828 n1_m1_537600_494400 n1_m1_542400_494400 5.356235
R13829 n1_m1_542400_494400 n1_m1_547200_494400 5.356235
R13830 n1_m1_547200_494400 n1_m1_552000_494400 5.356235
R13831 n1_m1_552000_494400 n1_m1_556800_494400 5.356235
R13832 n1_m1_0_499200 n1_m1_4000_499200 4.463529
R13833 n1_m1_4800_499200 n1_m1_4000_499200 0.892706
R13834 n1_m1_4800_499200 n1_m1_9600_499200 5.356235
R13835 n1_m1_9600_499200 n1_m1_14400_499200 5.356235
R13836 n1_m1_14400_499200 n1_m1_19200_499200 5.356235
R13837 n1_m1_19200_499200 n1_m1_24000_499200 5.356235
R13838 n1_m1_24000_499200 n1_m1_28800_499200 5.356235
R13839 n1_m1_28800_499200 n1_m1_32000_499200 3.570824
R13840 n1_m1_33600_499200 n1_m1_32000_499200 1.785412
R13841 n1_m1_33600_499200 n1_m1_38400_499200 5.356235
R13842 n1_m1_38400_499200 n1_m1_43200_499200 5.356235
R13843 n1_m1_43200_499200 n1_m1_48000_499200 5.356235
R13844 n1_m1_48000_499200 n1_m1_52800_499200 5.356235
R13845 n1_m1_52800_499200 n1_m1_57600_499200 5.356235
R13846 n1_m1_57600_499200 n1_m1_60000_499200 2.678118
R13847 n1_m1_62400_499200 n1_m1_60000_499200 2.678118
R13848 n1_m1_62400_499200 n1_m1_67200_499200 5.356235
R13849 n1_m1_67200_499200 n1_m1_72000_499200 5.356235
R13850 n1_m1_72000_499200 n1_m1_76800_499200 5.356235
R13851 n1_m1_76800_499200 n1_m1_81600_499200 5.356235
R13852 n1_m1_81600_499200 n1_m1_86400_499200 5.356235
R13853 n1_m1_86400_499200 n1_m1_88000_499200 1.785412
R13854 n1_m1_91200_499200 n1_m1_88000_499200 3.570824
R13855 n1_m1_91200_499200 n1_m1_96000_499200 5.356235
R13856 n1_m1_96000_499200 n1_m1_100800_499200 5.356235
R13857 n1_m1_100800_499200 n1_m1_105600_499200 5.356235
R13858 n1_m1_105600_499200 n1_m1_110400_499200 5.356235
R13859 n1_m1_110400_499200 n1_m1_115200_499200 5.356235
R13860 n1_m1_115200_499200 n1_m1_116000_499200 0.892706
R13861 n1_m1_120000_499200 n1_m1_116000_499200 4.463529
R13862 n1_m1_120000_499200 n1_m1_124800_499200 5.356235
R13863 n1_m1_124800_499200 n1_m1_129600_499200 5.356235
R13864 n1_m1_129600_499200 n1_m1_134400_499200 5.356235
R13865 n1_m1_134400_499200 n1_m1_139200_499200 5.356235
R13866 n1_m1_139200_499200 n1_m1_144000_499200 5.356235
R13867 n1_m1_144000_499200 n1_m1_148800_499200 5.356235
R13868 n1_m1_148800_499200 n1_m1_153600_499200 5.356235
R13869 n1_m1_153600_499200 n1_m1_158400_499200 5.356235
R13870 n1_m1_158400_499200 n1_m1_163200_499200 5.356235
R13871 n1_m1_163200_499200 n1_m1_168000_499200 5.356235
R13872 n1_m1_168000_499200 n1_m1_172000_499200 4.463529
R13873 n1_m1_172800_499200 n1_m1_172000_499200 0.892706
R13874 n1_m1_172800_499200 n1_m1_177600_499200 5.356235
R13875 n1_m1_177600_499200 n1_m1_182400_499200 5.356235
R13876 n1_m1_182400_499200 n1_m1_187200_499200 5.356235
R13877 n1_m1_187200_499200 n1_m1_192000_499200 5.356235
R13878 n1_m1_192000_499200 n1_m1_196800_499200 5.356235
R13879 n1_m1_196800_499200 n1_m1_200000_499200 3.570824
R13880 n1_m1_201600_499200 n1_m1_200000_499200 1.785412
R13881 n1_m1_201600_499200 n1_m1_206400_499200 5.356235
R13882 n1_m1_206400_499200 n1_m1_211200_499200 5.356235
R13883 n1_m1_211200_499200 n1_m1_216000_499200 5.356235
R13884 n1_m1_216000_499200 n1_m1_220800_499200 5.356235
R13885 n1_m1_220800_499200 n1_m1_225600_499200 5.356235
R13886 n1_m1_225600_499200 n1_m1_228000_499200 2.678118
R13887 n1_m1_230400_499200 n1_m1_228000_499200 2.678118
R13888 n1_m1_230400_499200 n1_m1_235200_499200 5.356235
R13889 n1_m1_235200_499200 n1_m1_240000_499200 5.356235
R13890 n1_m1_240000_499200 n1_m1_244800_499200 5.356235
R13891 n1_m1_244800_499200 n1_m1_249600_499200 5.356235
R13892 n1_m1_249600_499200 n1_m1_254400_499200 5.356235
R13893 n1_m1_254400_499200 n1_m1_256000_499200 1.785412
R13894 n1_m1_259200_499200 n1_m1_256000_499200 3.570824
R13895 n1_m1_259200_499200 n1_m1_264000_499200 5.356235
R13896 n1_m1_264000_499200 n1_m1_268800_499200 5.356235
R13897 n1_m1_268800_499200 n1_m1_273600_499200 5.356235
R13898 n1_m1_273600_499200 n1_m1_278400_499200 5.356235
R13899 n1_m1_278400_499200 n1_m1_283200_499200 5.356235
R13900 n1_m1_283200_499200 n1_m1_284000_499200 0.892706
R13901 n1_m1_288000_499200 n1_m1_284000_499200 4.463529
R13902 n1_m1_288000_499200 n1_m1_292800_499200 5.356235
R13903 n1_m1_292800_499200 n1_m1_297600_499200 5.356235
R13904 n1_m1_297600_499200 n1_m1_302400_499200 5.356235
R13905 n1_m1_302400_499200 n1_m1_307200_499200 5.356235
R13906 n1_m1_307200_499200 n1_m1_312000_499200 5.356235
R13907 n1_m1_312000_499200 n1_m1_316800_499200 5.356235
R13908 n1_m1_316800_499200 n1_m1_321600_499200 5.356235
R13909 n1_m1_321600_499200 n1_m1_326400_499200 5.356235
R13910 n1_m1_326400_499200 n1_m1_331200_499200 5.356235
R13911 n1_m1_331200_499200 n1_m1_336000_499200 5.356235
R13912 n1_m1_336000_499200 n1_m1_340000_499200 4.463529
R13913 n1_m1_340800_499200 n1_m1_340000_499200 0.892706
R13914 n1_m1_340800_499200 n1_m1_345600_499200 5.356235
R13915 n1_m1_345600_499200 n1_m1_350400_499200 5.356235
R13916 n1_m1_350400_499200 n1_m1_355200_499200 5.356235
R13917 n1_m1_355200_499200 n1_m1_360000_499200 5.356235
R13918 n1_m1_360000_499200 n1_m1_364800_499200 5.356235
R13919 n1_m1_364800_499200 n1_m1_368000_499200 3.570824
R13920 n1_m1_369600_499200 n1_m1_368000_499200 1.785412
R13921 n1_m1_369600_499200 n1_m1_374400_499200 5.356235
R13922 n1_m1_374400_499200 n1_m1_379200_499200 5.356235
R13923 n1_m1_379200_499200 n1_m1_384000_499200 5.356235
R13924 n1_m1_384000_499200 n1_m1_388800_499200 5.356235
R13925 n1_m1_388800_499200 n1_m1_393600_499200 5.356235
R13926 n1_m1_393600_499200 n1_m1_396000_499200 2.678118
R13927 n1_m1_398400_499200 n1_m1_396000_499200 2.678118
R13928 n1_m1_398400_499200 n1_m1_403200_499200 5.356235
R13929 n1_m1_403200_499200 n1_m1_408000_499200 5.356235
R13930 n1_m1_408000_499200 n1_m1_412800_499200 5.356235
R13931 n1_m1_412800_499200 n1_m1_417600_499200 5.356235
R13932 n1_m1_417600_499200 n1_m1_422400_499200 5.356235
R13933 n1_m1_422400_499200 n1_m1_424000_499200 1.785412
R13934 n1_m1_427200_499200 n1_m1_424000_499200 3.570824
R13935 n1_m1_427200_499200 n1_m1_432000_499200 5.356235
R13936 n1_m1_432000_499200 n1_m1_436800_499200 5.356235
R13937 n1_m1_436800_499200 n1_m1_441600_499200 5.356235
R13938 n1_m1_441600_499200 n1_m1_446400_499200 5.356235
R13939 n1_m1_446400_499200 n1_m1_451200_499200 5.356235
R13940 n1_m1_451200_499200 n1_m1_452000_499200 0.892706
R13941 n1_m1_456000_499200 n1_m1_452000_499200 4.463529
R13942 n1_m1_456000_499200 n1_m1_460800_499200 5.356235
R13943 n1_m1_460800_499200 n1_m1_465600_499200 5.356235
R13944 n1_m1_465600_499200 n1_m1_470400_499200 5.356235
R13945 n1_m1_470400_499200 n1_m1_475200_499200 5.356235
R13946 n1_m1_475200_499200 n1_m1_480000_499200 5.356235
R13947 n1_m1_480000_499200 n1_m1_484800_499200 5.356235
R13948 n1_m1_484800_499200 n1_m1_489600_499200 5.356235
R13949 n1_m1_489600_499200 n1_m1_494400_499200 5.356235
R13950 n1_m1_494400_499200 n1_m1_499200_499200 5.356235
R13951 n1_m1_499200_499200 n1_m1_504000_499200 5.356235
R13952 n1_m1_504000_499200 n1_m1_508000_499200 4.463529
R13953 n1_m1_508800_499200 n1_m1_508000_499200 0.892706
R13954 n1_m1_508800_499200 n1_m1_513600_499200 5.356235
R13955 n1_m1_513600_499200 n1_m1_518400_499200 5.356235
R13956 n1_m1_518400_499200 n1_m1_523200_499200 5.356235
R13957 n1_m1_523200_499200 n1_m1_528000_499200 5.356235
R13958 n1_m1_528000_499200 n1_m1_532800_499200 5.356235
R13959 n1_m1_532800_499200 n1_m1_536000_499200 3.570824
R13960 n1_m1_537600_499200 n1_m1_536000_499200 1.785412
R13961 n1_m1_537600_499200 n1_m1_542400_499200 5.356235
R13962 n1_m1_542400_499200 n1_m1_547200_499200 5.356235
R13963 n1_m1_547200_499200 n1_m1_552000_499200 5.356235
R13964 n1_m1_552000_499200 n1_m1_556800_499200 5.356235
R13965 n1_m1_0_504000 n1_m1_4000_504000 4.463529
R13966 n1_m1_4800_504000 n1_m1_4000_504000 0.892706
R13967 n1_m1_4800_504000 n1_m1_9600_504000 5.356235
R13968 n1_m1_9600_504000 n1_m1_14400_504000 5.356235
R13969 n1_m1_14400_504000 n1_m1_19200_504000 5.356235
R13970 n1_m1_19200_504000 n1_m1_24000_504000 5.356235
R13971 n1_m1_24000_504000 n1_m1_28800_504000 5.356235
R13972 n1_m1_28800_504000 n1_m1_32000_504000 3.570824
R13973 n1_m1_33600_504000 n1_m1_32000_504000 1.785412
R13974 n1_m1_33600_504000 n1_m1_38400_504000 5.356235
R13975 n1_m1_38400_504000 n1_m1_43200_504000 5.356235
R13976 n1_m1_43200_504000 n1_m1_48000_504000 5.356235
R13977 n1_m1_48000_504000 n1_m1_52800_504000 5.356235
R13978 n1_m1_52800_504000 n1_m1_57600_504000 5.356235
R13979 n1_m1_57600_504000 n1_m1_60000_504000 2.678118
R13980 n1_m1_62400_504000 n1_m1_60000_504000 2.678118
R13981 n1_m1_62400_504000 n1_m1_67200_504000 5.356235
R13982 n1_m1_67200_504000 n1_m1_72000_504000 5.356235
R13983 n1_m1_72000_504000 n1_m1_76800_504000 5.356235
R13984 n1_m1_76800_504000 n1_m1_81600_504000 5.356235
R13985 n1_m1_81600_504000 n1_m1_86400_504000 5.356235
R13986 n1_m1_86400_504000 n1_m1_88000_504000 1.785412
R13987 n1_m1_91200_504000 n1_m1_88000_504000 3.570824
R13988 n1_m1_91200_504000 n1_m1_96000_504000 5.356235
R13989 n1_m1_96000_504000 n1_m1_100800_504000 5.356235
R13990 n1_m1_100800_504000 n1_m1_105600_504000 5.356235
R13991 n1_m1_105600_504000 n1_m1_110400_504000 5.356235
R13992 n1_m1_110400_504000 n1_m1_115200_504000 5.356235
R13993 n1_m1_115200_504000 n1_m1_116000_504000 0.892706
R13994 n1_m1_120000_504000 n1_m1_116000_504000 4.463529
R13995 n1_m1_120000_504000 n1_m1_124800_504000 5.356235
R13996 n1_m1_124800_504000 n1_m1_129600_504000 5.356235
R13997 n1_m1_129600_504000 n1_m1_134400_504000 5.356235
R13998 n1_m1_134400_504000 n1_m1_139200_504000 5.356235
R13999 n1_m1_139200_504000 n1_m1_144000_504000 5.356235
R14000 n1_m1_144000_504000 n1_m1_148800_504000 5.356235
R14001 n1_m1_148800_504000 n1_m1_153600_504000 5.356235
R14002 n1_m1_153600_504000 n1_m1_158400_504000 5.356235
R14003 n1_m1_158400_504000 n1_m1_163200_504000 5.356235
R14004 n1_m1_163200_504000 n1_m1_168000_504000 5.356235
R14005 n1_m1_168000_504000 n1_m1_172000_504000 4.463529
R14006 n1_m1_172800_504000 n1_m1_172000_504000 0.892706
R14007 n1_m1_172800_504000 n1_m1_177600_504000 5.356235
R14008 n1_m1_177600_504000 n1_m1_182400_504000 5.356235
R14009 n1_m1_182400_504000 n1_m1_187200_504000 5.356235
R14010 n1_m1_187200_504000 n1_m1_192000_504000 5.356235
R14011 n1_m1_192000_504000 n1_m1_196800_504000 5.356235
R14012 n1_m1_196800_504000 n1_m1_200000_504000 3.570824
R14013 n1_m1_201600_504000 n1_m1_200000_504000 1.785412
R14014 n1_m1_201600_504000 n1_m1_206400_504000 5.356235
R14015 n1_m1_206400_504000 n1_m1_211200_504000 5.356235
R14016 n1_m1_211200_504000 n1_m1_216000_504000 5.356235
R14017 n1_m1_216000_504000 n1_m1_220800_504000 5.356235
R14018 n1_m1_220800_504000 n1_m1_225600_504000 5.356235
R14019 n1_m1_225600_504000 n1_m1_228000_504000 2.678118
R14020 n1_m1_230400_504000 n1_m1_228000_504000 2.678118
R14021 n1_m1_230400_504000 n1_m1_235200_504000 5.356235
R14022 n1_m1_235200_504000 n1_m1_240000_504000 5.356235
R14023 n1_m1_240000_504000 n1_m1_244800_504000 5.356235
R14024 n1_m1_244800_504000 n1_m1_249600_504000 5.356235
R14025 n1_m1_249600_504000 n1_m1_254400_504000 5.356235
R14026 n1_m1_254400_504000 n1_m1_256000_504000 1.785412
R14027 n1_m1_259200_504000 n1_m1_256000_504000 3.570824
R14028 n1_m1_259200_504000 n1_m1_264000_504000 5.356235
R14029 n1_m1_264000_504000 n1_m1_268800_504000 5.356235
R14030 n1_m1_268800_504000 n1_m1_273600_504000 5.356235
R14031 n1_m1_273600_504000 n1_m1_278400_504000 5.356235
R14032 n1_m1_278400_504000 n1_m1_283200_504000 5.356235
R14033 n1_m1_283200_504000 n1_m1_284000_504000 0.892706
R14034 n1_m1_288000_504000 n1_m1_284000_504000 4.463529
R14035 n1_m1_288000_504000 n1_m1_292800_504000 5.356235
R14036 n1_m1_292800_504000 n1_m1_297600_504000 5.356235
R14037 n1_m1_297600_504000 n1_m1_302400_504000 5.356235
R14038 n1_m1_302400_504000 n1_m1_307200_504000 5.356235
R14039 n1_m1_307200_504000 n1_m1_312000_504000 5.356235
R14040 n1_m1_312000_504000 n1_m1_316800_504000 5.356235
R14041 n1_m1_316800_504000 n1_m1_321600_504000 5.356235
R14042 n1_m1_321600_504000 n1_m1_326400_504000 5.356235
R14043 n1_m1_326400_504000 n1_m1_331200_504000 5.356235
R14044 n1_m1_331200_504000 n1_m1_336000_504000 5.356235
R14045 n1_m1_336000_504000 n1_m1_340000_504000 4.463529
R14046 n1_m1_340800_504000 n1_m1_340000_504000 0.892706
R14047 n1_m1_340800_504000 n1_m1_345600_504000 5.356235
R14048 n1_m1_345600_504000 n1_m1_350400_504000 5.356235
R14049 n1_m1_350400_504000 n1_m1_355200_504000 5.356235
R14050 n1_m1_355200_504000 n1_m1_360000_504000 5.356235
R14051 n1_m1_360000_504000 n1_m1_364800_504000 5.356235
R14052 n1_m1_364800_504000 n1_m1_368000_504000 3.570824
R14053 n1_m1_369600_504000 n1_m1_368000_504000 1.785412
R14054 n1_m1_369600_504000 n1_m1_374400_504000 5.356235
R14055 n1_m1_374400_504000 n1_m1_379200_504000 5.356235
R14056 n1_m1_379200_504000 n1_m1_384000_504000 5.356235
R14057 n1_m1_384000_504000 n1_m1_388800_504000 5.356235
R14058 n1_m1_388800_504000 n1_m1_393600_504000 5.356235
R14059 n1_m1_393600_504000 n1_m1_396000_504000 2.678118
R14060 n1_m1_398400_504000 n1_m1_396000_504000 2.678118
R14061 n1_m1_398400_504000 n1_m1_403200_504000 5.356235
R14062 n1_m1_403200_504000 n1_m1_408000_504000 5.356235
R14063 n1_m1_408000_504000 n1_m1_412800_504000 5.356235
R14064 n1_m1_412800_504000 n1_m1_417600_504000 5.356235
R14065 n1_m1_417600_504000 n1_m1_422400_504000 5.356235
R14066 n1_m1_422400_504000 n1_m1_424000_504000 1.785412
R14067 n1_m1_427200_504000 n1_m1_424000_504000 3.570824
R14068 n1_m1_427200_504000 n1_m1_432000_504000 5.356235
R14069 n1_m1_432000_504000 n1_m1_436800_504000 5.356235
R14070 n1_m1_436800_504000 n1_m1_441600_504000 5.356235
R14071 n1_m1_441600_504000 n1_m1_446400_504000 5.356235
R14072 n1_m1_446400_504000 n1_m1_451200_504000 5.356235
R14073 n1_m1_451200_504000 n1_m1_452000_504000 0.892706
R14074 n1_m1_456000_504000 n1_m1_452000_504000 4.463529
R14075 n1_m1_456000_504000 n1_m1_460800_504000 5.356235
R14076 n1_m1_460800_504000 n1_m1_465600_504000 5.356235
R14077 n1_m1_465600_504000 n1_m1_470400_504000 5.356235
R14078 n1_m1_470400_504000 n1_m1_475200_504000 5.356235
R14079 n1_m1_475200_504000 n1_m1_480000_504000 5.356235
R14080 n1_m1_480000_504000 n1_m1_484800_504000 5.356235
R14081 n1_m1_484800_504000 n1_m1_489600_504000 5.356235
R14082 n1_m1_489600_504000 n1_m1_494400_504000 5.356235
R14083 n1_m1_494400_504000 n1_m1_499200_504000 5.356235
R14084 n1_m1_499200_504000 n1_m1_504000_504000 5.356235
R14085 n1_m1_504000_504000 n1_m1_508000_504000 4.463529
R14086 n1_m1_508800_504000 n1_m1_508000_504000 0.892706
R14087 n1_m1_508800_504000 n1_m1_513600_504000 5.356235
R14088 n1_m1_513600_504000 n1_m1_518400_504000 5.356235
R14089 n1_m1_518400_504000 n1_m1_523200_504000 5.356235
R14090 n1_m1_523200_504000 n1_m1_528000_504000 5.356235
R14091 n1_m1_528000_504000 n1_m1_532800_504000 5.356235
R14092 n1_m1_532800_504000 n1_m1_536000_504000 3.570824
R14093 n1_m1_537600_504000 n1_m1_536000_504000 1.785412
R14094 n1_m1_537600_504000 n1_m1_542400_504000 5.356235
R14095 n1_m1_542400_504000 n1_m1_547200_504000 5.356235
R14096 n1_m1_547200_504000 n1_m1_552000_504000 5.356235
R14097 n1_m1_552000_504000 n1_m1_556800_504000 5.356235
R14098 n1_m1_0_508800 n1_m1_4000_508800 4.463529
R14099 n1_m1_4800_508800 n1_m1_4000_508800 0.892706
R14100 n1_m1_4800_508800 n1_m1_9600_508800 5.356235
R14101 n1_m1_9600_508800 n1_m1_14400_508800 5.356235
R14102 n1_m1_14400_508800 n1_m1_19200_508800 5.356235
R14103 n1_m1_19200_508800 n1_m1_24000_508800 5.356235
R14104 n1_m1_24000_508800 n1_m1_28800_508800 5.356235
R14105 n1_m1_28800_508800 n1_m1_32000_508800 3.570824
R14106 n1_m1_33600_508800 n1_m1_32000_508800 1.785412
R14107 n1_m1_33600_508800 n1_m1_38400_508800 5.356235
R14108 n1_m1_38400_508800 n1_m1_43200_508800 5.356235
R14109 n1_m1_43200_508800 n1_m1_48000_508800 5.356235
R14110 n1_m1_48000_508800 n1_m1_52800_508800 5.356235
R14111 n1_m1_52800_508800 n1_m1_57600_508800 5.356235
R14112 n1_m1_57600_508800 n1_m1_60000_508800 2.678118
R14113 n1_m1_62400_508800 n1_m1_60000_508800 2.678118
R14114 n1_m1_62400_508800 n1_m1_67200_508800 5.356235
R14115 n1_m1_67200_508800 n1_m1_72000_508800 5.356235
R14116 n1_m1_72000_508800 n1_m1_76800_508800 5.356235
R14117 n1_m1_76800_508800 n1_m1_81600_508800 5.356235
R14118 n1_m1_81600_508800 n1_m1_86400_508800 5.356235
R14119 n1_m1_86400_508800 n1_m1_88000_508800 1.785412
R14120 n1_m1_91200_508800 n1_m1_88000_508800 3.570824
R14121 n1_m1_91200_508800 n1_m1_96000_508800 5.356235
R14122 n1_m1_96000_508800 n1_m1_100800_508800 5.356235
R14123 n1_m1_100800_508800 n1_m1_105600_508800 5.356235
R14124 n1_m1_105600_508800 n1_m1_110400_508800 5.356235
R14125 n1_m1_110400_508800 n1_m1_115200_508800 5.356235
R14126 n1_m1_115200_508800 n1_m1_116000_508800 0.892706
R14127 n1_m1_120000_508800 n1_m1_116000_508800 4.463529
R14128 n1_m1_120000_508800 n1_m1_124800_508800 5.356235
R14129 n1_m1_124800_508800 n1_m1_129600_508800 5.356235
R14130 n1_m1_129600_508800 n1_m1_134400_508800 5.356235
R14131 n1_m1_134400_508800 n1_m1_139200_508800 5.356235
R14132 n1_m1_139200_508800 n1_m1_144000_508800 5.356235
R14133 n1_m1_144000_508800 n1_m1_148800_508800 5.356235
R14134 n1_m1_148800_508800 n1_m1_153600_508800 5.356235
R14135 n1_m1_153600_508800 n1_m1_158400_508800 5.356235
R14136 n1_m1_158400_508800 n1_m1_163200_508800 5.356235
R14137 n1_m1_163200_508800 n1_m1_168000_508800 5.356235
R14138 n1_m1_168000_508800 n1_m1_172000_508800 4.463529
R14139 n1_m1_172800_508800 n1_m1_172000_508800 0.892706
R14140 n1_m1_172800_508800 n1_m1_177600_508800 5.356235
R14141 n1_m1_177600_508800 n1_m1_182400_508800 5.356235
R14142 n1_m1_182400_508800 n1_m1_187200_508800 5.356235
R14143 n1_m1_187200_508800 n1_m1_192000_508800 5.356235
R14144 n1_m1_192000_508800 n1_m1_196800_508800 5.356235
R14145 n1_m1_196800_508800 n1_m1_200000_508800 3.570824
R14146 n1_m1_201600_508800 n1_m1_200000_508800 1.785412
R14147 n1_m1_201600_508800 n1_m1_206400_508800 5.356235
R14148 n1_m1_206400_508800 n1_m1_211200_508800 5.356235
R14149 n1_m1_211200_508800 n1_m1_216000_508800 5.356235
R14150 n1_m1_216000_508800 n1_m1_220800_508800 5.356235
R14151 n1_m1_220800_508800 n1_m1_225600_508800 5.356235
R14152 n1_m1_225600_508800 n1_m1_228000_508800 2.678118
R14153 n1_m1_230400_508800 n1_m1_228000_508800 2.678118
R14154 n1_m1_230400_508800 n1_m1_235200_508800 5.356235
R14155 n1_m1_235200_508800 n1_m1_240000_508800 5.356235
R14156 n1_m1_240000_508800 n1_m1_244800_508800 5.356235
R14157 n1_m1_244800_508800 n1_m1_249600_508800 5.356235
R14158 n1_m1_249600_508800 n1_m1_254400_508800 5.356235
R14159 n1_m1_254400_508800 n1_m1_256000_508800 1.785412
R14160 n1_m1_259200_508800 n1_m1_256000_508800 3.570824
R14161 n1_m1_259200_508800 n1_m1_264000_508800 5.356235
R14162 n1_m1_264000_508800 n1_m1_268800_508800 5.356235
R14163 n1_m1_268800_508800 n1_m1_273600_508800 5.356235
R14164 n1_m1_273600_508800 n1_m1_278400_508800 5.356235
R14165 n1_m1_278400_508800 n1_m1_283200_508800 5.356235
R14166 n1_m1_283200_508800 n1_m1_284000_508800 0.892706
R14167 n1_m1_288000_508800 n1_m1_284000_508800 4.463529
R14168 n1_m1_288000_508800 n1_m1_292800_508800 5.356235
R14169 n1_m1_292800_508800 n1_m1_297600_508800 5.356235
R14170 n1_m1_297600_508800 n1_m1_302400_508800 5.356235
R14171 n1_m1_302400_508800 n1_m1_307200_508800 5.356235
R14172 n1_m1_307200_508800 n1_m1_312000_508800 5.356235
R14173 n1_m1_312000_508800 n1_m1_316800_508800 5.356235
R14174 n1_m1_316800_508800 n1_m1_321600_508800 5.356235
R14175 n1_m1_321600_508800 n1_m1_326400_508800 5.356235
R14176 n1_m1_326400_508800 n1_m1_331200_508800 5.356235
R14177 n1_m1_331200_508800 n1_m1_336000_508800 5.356235
R14178 n1_m1_336000_508800 n1_m1_340000_508800 4.463529
R14179 n1_m1_340800_508800 n1_m1_340000_508800 0.892706
R14180 n1_m1_340800_508800 n1_m1_345600_508800 5.356235
R14181 n1_m1_345600_508800 n1_m1_350400_508800 5.356235
R14182 n1_m1_350400_508800 n1_m1_355200_508800 5.356235
R14183 n1_m1_355200_508800 n1_m1_360000_508800 5.356235
R14184 n1_m1_360000_508800 n1_m1_364800_508800 5.356235
R14185 n1_m1_364800_508800 n1_m1_368000_508800 3.570824
R14186 n1_m1_369600_508800 n1_m1_368000_508800 1.785412
R14187 n1_m1_369600_508800 n1_m1_374400_508800 5.356235
R14188 n1_m1_374400_508800 n1_m1_379200_508800 5.356235
R14189 n1_m1_379200_508800 n1_m1_384000_508800 5.356235
R14190 n1_m1_384000_508800 n1_m1_388800_508800 5.356235
R14191 n1_m1_388800_508800 n1_m1_393600_508800 5.356235
R14192 n1_m1_393600_508800 n1_m1_396000_508800 2.678118
R14193 n1_m1_398400_508800 n1_m1_396000_508800 2.678118
R14194 n1_m1_398400_508800 n1_m1_403200_508800 5.356235
R14195 n1_m1_403200_508800 n1_m1_408000_508800 5.356235
R14196 n1_m1_408000_508800 n1_m1_412800_508800 5.356235
R14197 n1_m1_412800_508800 n1_m1_417600_508800 5.356235
R14198 n1_m1_417600_508800 n1_m1_422400_508800 5.356235
R14199 n1_m1_422400_508800 n1_m1_424000_508800 1.785412
R14200 n1_m1_427200_508800 n1_m1_424000_508800 3.570824
R14201 n1_m1_427200_508800 n1_m1_432000_508800 5.356235
R14202 n1_m1_432000_508800 n1_m1_436800_508800 5.356235
R14203 n1_m1_436800_508800 n1_m1_441600_508800 5.356235
R14204 n1_m1_441600_508800 n1_m1_446400_508800 5.356235
R14205 n1_m1_446400_508800 n1_m1_451200_508800 5.356235
R14206 n1_m1_451200_508800 n1_m1_452000_508800 0.892706
R14207 n1_m1_456000_508800 n1_m1_452000_508800 4.463529
R14208 n1_m1_456000_508800 n1_m1_460800_508800 5.356235
R14209 n1_m1_460800_508800 n1_m1_465600_508800 5.356235
R14210 n1_m1_465600_508800 n1_m1_470400_508800 5.356235
R14211 n1_m1_470400_508800 n1_m1_475200_508800 5.356235
R14212 n1_m1_475200_508800 n1_m1_480000_508800 5.356235
R14213 n1_m1_480000_508800 n1_m1_484800_508800 5.356235
R14214 n1_m1_484800_508800 n1_m1_489600_508800 5.356235
R14215 n1_m1_489600_508800 n1_m1_494400_508800 5.356235
R14216 n1_m1_494400_508800 n1_m1_499200_508800 5.356235
R14217 n1_m1_499200_508800 n1_m1_504000_508800 5.356235
R14218 n1_m1_504000_508800 n1_m1_508000_508800 4.463529
R14219 n1_m1_508800_508800 n1_m1_508000_508800 0.892706
R14220 n1_m1_508800_508800 n1_m1_513600_508800 5.356235
R14221 n1_m1_513600_508800 n1_m1_518400_508800 5.356235
R14222 n1_m1_518400_508800 n1_m1_523200_508800 5.356235
R14223 n1_m1_523200_508800 n1_m1_528000_508800 5.356235
R14224 n1_m1_528000_508800 n1_m1_532800_508800 5.356235
R14225 n1_m1_532800_508800 n1_m1_536000_508800 3.570824
R14226 n1_m1_537600_508800 n1_m1_536000_508800 1.785412
R14227 n1_m1_537600_508800 n1_m1_542400_508800 5.356235
R14228 n1_m1_542400_508800 n1_m1_547200_508800 5.356235
R14229 n1_m1_547200_508800 n1_m1_552000_508800 5.356235
R14230 n1_m1_552000_508800 n1_m1_556800_508800 5.356235
R14231 n1_m1_0_513600 n1_m1_4000_513600 4.463529
R14232 n1_m1_4800_513600 n1_m1_4000_513600 0.892706
R14233 n1_m1_4800_513600 n1_m1_9600_513600 5.356235
R14234 n1_m1_9600_513600 n1_m1_14400_513600 5.356235
R14235 n1_m1_14400_513600 n1_m1_19200_513600 5.356235
R14236 n1_m1_19200_513600 n1_m1_24000_513600 5.356235
R14237 n1_m1_24000_513600 n1_m1_28800_513600 5.356235
R14238 n1_m1_28800_513600 n1_m1_32000_513600 3.570824
R14239 n1_m1_33600_513600 n1_m1_32000_513600 1.785412
R14240 n1_m1_33600_513600 n1_m1_38400_513600 5.356235
R14241 n1_m1_38400_513600 n1_m1_43200_513600 5.356235
R14242 n1_m1_43200_513600 n1_m1_48000_513600 5.356235
R14243 n1_m1_48000_513600 n1_m1_52800_513600 5.356235
R14244 n1_m1_52800_513600 n1_m1_57600_513600 5.356235
R14245 n1_m1_57600_513600 n1_m1_60000_513600 2.678118
R14246 n1_m1_62400_513600 n1_m1_60000_513600 2.678118
R14247 n1_m1_62400_513600 n1_m1_67200_513600 5.356235
R14248 n1_m1_67200_513600 n1_m1_72000_513600 5.356235
R14249 n1_m1_72000_513600 n1_m1_76800_513600 5.356235
R14250 n1_m1_76800_513600 n1_m1_81600_513600 5.356235
R14251 n1_m1_81600_513600 n1_m1_86400_513600 5.356235
R14252 n1_m1_86400_513600 n1_m1_88000_513600 1.785412
R14253 n1_m1_91200_513600 n1_m1_88000_513600 3.570824
R14254 n1_m1_91200_513600 n1_m1_96000_513600 5.356235
R14255 n1_m1_96000_513600 n1_m1_100800_513600 5.356235
R14256 n1_m1_100800_513600 n1_m1_105600_513600 5.356235
R14257 n1_m1_105600_513600 n1_m1_110400_513600 5.356235
R14258 n1_m1_110400_513600 n1_m1_115200_513600 5.356235
R14259 n1_m1_115200_513600 n1_m1_116000_513600 0.892706
R14260 n1_m1_120000_513600 n1_m1_116000_513600 4.463529
R14261 n1_m1_120000_513600 n1_m1_124800_513600 5.356235
R14262 n1_m1_124800_513600 n1_m1_129600_513600 5.356235
R14263 n1_m1_129600_513600 n1_m1_134400_513600 5.356235
R14264 n1_m1_134400_513600 n1_m1_139200_513600 5.356235
R14265 n1_m1_139200_513600 n1_m1_144000_513600 5.356235
R14266 n1_m1_144000_513600 n1_m1_148800_513600 5.356235
R14267 n1_m1_148800_513600 n1_m1_153600_513600 5.356235
R14268 n1_m1_153600_513600 n1_m1_158400_513600 5.356235
R14269 n1_m1_158400_513600 n1_m1_163200_513600 5.356235
R14270 n1_m1_163200_513600 n1_m1_168000_513600 5.356235
R14271 n1_m1_168000_513600 n1_m1_172000_513600 4.463529
R14272 n1_m1_172800_513600 n1_m1_172000_513600 0.892706
R14273 n1_m1_172800_513600 n1_m1_177600_513600 5.356235
R14274 n1_m1_177600_513600 n1_m1_182400_513600 5.356235
R14275 n1_m1_182400_513600 n1_m1_187200_513600 5.356235
R14276 n1_m1_187200_513600 n1_m1_192000_513600 5.356235
R14277 n1_m1_192000_513600 n1_m1_196800_513600 5.356235
R14278 n1_m1_196800_513600 n1_m1_200000_513600 3.570824
R14279 n1_m1_201600_513600 n1_m1_200000_513600 1.785412
R14280 n1_m1_201600_513600 n1_m1_206400_513600 5.356235
R14281 n1_m1_206400_513600 n1_m1_211200_513600 5.356235
R14282 n1_m1_211200_513600 n1_m1_216000_513600 5.356235
R14283 n1_m1_216000_513600 n1_m1_220800_513600 5.356235
R14284 n1_m1_220800_513600 n1_m1_225600_513600 5.356235
R14285 n1_m1_225600_513600 n1_m1_228000_513600 2.678118
R14286 n1_m1_230400_513600 n1_m1_228000_513600 2.678118
R14287 n1_m1_230400_513600 n1_m1_235200_513600 5.356235
R14288 n1_m1_235200_513600 n1_m1_240000_513600 5.356235
R14289 n1_m1_240000_513600 n1_m1_244800_513600 5.356235
R14290 n1_m1_244800_513600 n1_m1_249600_513600 5.356235
R14291 n1_m1_249600_513600 n1_m1_254400_513600 5.356235
R14292 n1_m1_254400_513600 n1_m1_256000_513600 1.785412
R14293 n1_m1_259200_513600 n1_m1_256000_513600 3.570824
R14294 n1_m1_259200_513600 n1_m1_264000_513600 5.356235
R14295 n1_m1_264000_513600 n1_m1_268800_513600 5.356235
R14296 n1_m1_268800_513600 n1_m1_273600_513600 5.356235
R14297 n1_m1_273600_513600 n1_m1_278400_513600 5.356235
R14298 n1_m1_278400_513600 n1_m1_283200_513600 5.356235
R14299 n1_m1_283200_513600 n1_m1_284000_513600 0.892706
R14300 n1_m1_288000_513600 n1_m1_284000_513600 4.463529
R14301 n1_m1_288000_513600 n1_m1_292800_513600 5.356235
R14302 n1_m1_292800_513600 n1_m1_297600_513600 5.356235
R14303 n1_m1_297600_513600 n1_m1_302400_513600 5.356235
R14304 n1_m1_302400_513600 n1_m1_307200_513600 5.356235
R14305 n1_m1_307200_513600 n1_m1_312000_513600 5.356235
R14306 n1_m1_312000_513600 n1_m1_316800_513600 5.356235
R14307 n1_m1_316800_513600 n1_m1_321600_513600 5.356235
R14308 n1_m1_321600_513600 n1_m1_326400_513600 5.356235
R14309 n1_m1_326400_513600 n1_m1_331200_513600 5.356235
R14310 n1_m1_331200_513600 n1_m1_336000_513600 5.356235
R14311 n1_m1_336000_513600 n1_m1_340000_513600 4.463529
R14312 n1_m1_340800_513600 n1_m1_340000_513600 0.892706
R14313 n1_m1_340800_513600 n1_m1_345600_513600 5.356235
R14314 n1_m1_345600_513600 n1_m1_350400_513600 5.356235
R14315 n1_m1_350400_513600 n1_m1_355200_513600 5.356235
R14316 n1_m1_355200_513600 n1_m1_360000_513600 5.356235
R14317 n1_m1_360000_513600 n1_m1_364800_513600 5.356235
R14318 n1_m1_364800_513600 n1_m1_368000_513600 3.570824
R14319 n1_m1_369600_513600 n1_m1_368000_513600 1.785412
R14320 n1_m1_369600_513600 n1_m1_374400_513600 5.356235
R14321 n1_m1_374400_513600 n1_m1_379200_513600 5.356235
R14322 n1_m1_379200_513600 n1_m1_384000_513600 5.356235
R14323 n1_m1_384000_513600 n1_m1_388800_513600 5.356235
R14324 n1_m1_388800_513600 n1_m1_393600_513600 5.356235
R14325 n1_m1_393600_513600 n1_m1_396000_513600 2.678118
R14326 n1_m1_398400_513600 n1_m1_396000_513600 2.678118
R14327 n1_m1_398400_513600 n1_m1_403200_513600 5.356235
R14328 n1_m1_403200_513600 n1_m1_408000_513600 5.356235
R14329 n1_m1_408000_513600 n1_m1_412800_513600 5.356235
R14330 n1_m1_412800_513600 n1_m1_417600_513600 5.356235
R14331 n1_m1_417600_513600 n1_m1_422400_513600 5.356235
R14332 n1_m1_422400_513600 n1_m1_424000_513600 1.785412
R14333 n1_m1_427200_513600 n1_m1_424000_513600 3.570824
R14334 n1_m1_427200_513600 n1_m1_432000_513600 5.356235
R14335 n1_m1_432000_513600 n1_m1_436800_513600 5.356235
R14336 n1_m1_436800_513600 n1_m1_441600_513600 5.356235
R14337 n1_m1_441600_513600 n1_m1_446400_513600 5.356235
R14338 n1_m1_446400_513600 n1_m1_451200_513600 5.356235
R14339 n1_m1_451200_513600 n1_m1_452000_513600 0.892706
R14340 n1_m1_456000_513600 n1_m1_452000_513600 4.463529
R14341 n1_m1_456000_513600 n1_m1_460800_513600 5.356235
R14342 n1_m1_460800_513600 n1_m1_465600_513600 5.356235
R14343 n1_m1_465600_513600 n1_m1_470400_513600 5.356235
R14344 n1_m1_470400_513600 n1_m1_475200_513600 5.356235
R14345 n1_m1_475200_513600 n1_m1_480000_513600 5.356235
R14346 n1_m1_480000_513600 n1_m1_484800_513600 5.356235
R14347 n1_m1_484800_513600 n1_m1_489600_513600 5.356235
R14348 n1_m1_489600_513600 n1_m1_494400_513600 5.356235
R14349 n1_m1_494400_513600 n1_m1_499200_513600 5.356235
R14350 n1_m1_499200_513600 n1_m1_504000_513600 5.356235
R14351 n1_m1_504000_513600 n1_m1_508000_513600 4.463529
R14352 n1_m1_508800_513600 n1_m1_508000_513600 0.892706
R14353 n1_m1_508800_513600 n1_m1_513600_513600 5.356235
R14354 n1_m1_513600_513600 n1_m1_518400_513600 5.356235
R14355 n1_m1_518400_513600 n1_m1_523200_513600 5.356235
R14356 n1_m1_523200_513600 n1_m1_528000_513600 5.356235
R14357 n1_m1_528000_513600 n1_m1_532800_513600 5.356235
R14358 n1_m1_532800_513600 n1_m1_536000_513600 3.570824
R14359 n1_m1_537600_513600 n1_m1_536000_513600 1.785412
R14360 n1_m1_537600_513600 n1_m1_542400_513600 5.356235
R14361 n1_m1_542400_513600 n1_m1_547200_513600 5.356235
R14362 n1_m1_547200_513600 n1_m1_552000_513600 5.356235
R14363 n1_m1_552000_513600 n1_m1_556800_513600 5.356235
R14364 n1_m1_0_518400 n1_m1_4000_518400 4.463529
R14365 n1_m1_4800_518400 n1_m1_4000_518400 0.892706
R14366 n1_m1_4800_518400 n1_m1_9600_518400 5.356235
R14367 n1_m1_9600_518400 n1_m1_14400_518400 5.356235
R14368 n1_m1_14400_518400 n1_m1_19200_518400 5.356235
R14369 n1_m1_19200_518400 n1_m1_24000_518400 5.356235
R14370 n1_m1_24000_518400 n1_m1_28800_518400 5.356235
R14371 n1_m1_28800_518400 n1_m1_32000_518400 3.570824
R14372 n1_m1_33600_518400 n1_m1_32000_518400 1.785412
R14373 n1_m1_33600_518400 n1_m1_38400_518400 5.356235
R14374 n1_m1_38400_518400 n1_m1_43200_518400 5.356235
R14375 n1_m1_43200_518400 n1_m1_48000_518400 5.356235
R14376 n1_m1_48000_518400 n1_m1_52800_518400 5.356235
R14377 n1_m1_52800_518400 n1_m1_57600_518400 5.356235
R14378 n1_m1_57600_518400 n1_m1_60000_518400 2.678118
R14379 n1_m1_62400_518400 n1_m1_60000_518400 2.678118
R14380 n1_m1_62400_518400 n1_m1_67200_518400 5.356235
R14381 n1_m1_67200_518400 n1_m1_72000_518400 5.356235
R14382 n1_m1_72000_518400 n1_m1_76800_518400 5.356235
R14383 n1_m1_76800_518400 n1_m1_81600_518400 5.356235
R14384 n1_m1_81600_518400 n1_m1_86400_518400 5.356235
R14385 n1_m1_86400_518400 n1_m1_88000_518400 1.785412
R14386 n1_m1_91200_518400 n1_m1_88000_518400 3.570824
R14387 n1_m1_91200_518400 n1_m1_96000_518400 5.356235
R14388 n1_m1_96000_518400 n1_m1_100800_518400 5.356235
R14389 n1_m1_100800_518400 n1_m1_105600_518400 5.356235
R14390 n1_m1_105600_518400 n1_m1_110400_518400 5.356235
R14391 n1_m1_110400_518400 n1_m1_115200_518400 5.356235
R14392 n1_m1_115200_518400 n1_m1_116000_518400 0.892706
R14393 n1_m1_120000_518400 n1_m1_116000_518400 4.463529
R14394 n1_m1_120000_518400 n1_m1_124800_518400 5.356235
R14395 n1_m1_124800_518400 n1_m1_129600_518400 5.356235
R14396 n1_m1_129600_518400 n1_m1_134400_518400 5.356235
R14397 n1_m1_134400_518400 n1_m1_139200_518400 5.356235
R14398 n1_m1_139200_518400 n1_m1_144000_518400 5.356235
R14399 n1_m1_144000_518400 n1_m1_148800_518400 5.356235
R14400 n1_m1_148800_518400 n1_m1_153600_518400 5.356235
R14401 n1_m1_153600_518400 n1_m1_158400_518400 5.356235
R14402 n1_m1_158400_518400 n1_m1_163200_518400 5.356235
R14403 n1_m1_163200_518400 n1_m1_168000_518400 5.356235
R14404 n1_m1_168000_518400 n1_m1_172000_518400 4.463529
R14405 n1_m1_172800_518400 n1_m1_172000_518400 0.892706
R14406 n1_m1_172800_518400 n1_m1_177600_518400 5.356235
R14407 n1_m1_177600_518400 n1_m1_182400_518400 5.356235
R14408 n1_m1_182400_518400 n1_m1_187200_518400 5.356235
R14409 n1_m1_187200_518400 n1_m1_192000_518400 5.356235
R14410 n1_m1_192000_518400 n1_m1_196800_518400 5.356235
R14411 n1_m1_196800_518400 n1_m1_200000_518400 3.570824
R14412 n1_m1_201600_518400 n1_m1_200000_518400 1.785412
R14413 n1_m1_201600_518400 n1_m1_206400_518400 5.356235
R14414 n1_m1_206400_518400 n1_m1_211200_518400 5.356235
R14415 n1_m1_211200_518400 n1_m1_216000_518400 5.356235
R14416 n1_m1_216000_518400 n1_m1_220800_518400 5.356235
R14417 n1_m1_220800_518400 n1_m1_225600_518400 5.356235
R14418 n1_m1_225600_518400 n1_m1_228000_518400 2.678118
R14419 n1_m1_230400_518400 n1_m1_228000_518400 2.678118
R14420 n1_m1_230400_518400 n1_m1_235200_518400 5.356235
R14421 n1_m1_235200_518400 n1_m1_240000_518400 5.356235
R14422 n1_m1_240000_518400 n1_m1_244800_518400 5.356235
R14423 n1_m1_244800_518400 n1_m1_249600_518400 5.356235
R14424 n1_m1_249600_518400 n1_m1_254400_518400 5.356235
R14425 n1_m1_254400_518400 n1_m1_256000_518400 1.785412
R14426 n1_m1_259200_518400 n1_m1_256000_518400 3.570824
R14427 n1_m1_259200_518400 n1_m1_264000_518400 5.356235
R14428 n1_m1_264000_518400 n1_m1_268800_518400 5.356235
R14429 n1_m1_268800_518400 n1_m1_273600_518400 5.356235
R14430 n1_m1_273600_518400 n1_m1_278400_518400 5.356235
R14431 n1_m1_278400_518400 n1_m1_283200_518400 5.356235
R14432 n1_m1_283200_518400 n1_m1_284000_518400 0.892706
R14433 n1_m1_288000_518400 n1_m1_284000_518400 4.463529
R14434 n1_m1_288000_518400 n1_m1_292800_518400 5.356235
R14435 n1_m1_292800_518400 n1_m1_297600_518400 5.356235
R14436 n1_m1_297600_518400 n1_m1_302400_518400 5.356235
R14437 n1_m1_302400_518400 n1_m1_307200_518400 5.356235
R14438 n1_m1_307200_518400 n1_m1_312000_518400 5.356235
R14439 n1_m1_312000_518400 n1_m1_316800_518400 5.356235
R14440 n1_m1_316800_518400 n1_m1_321600_518400 5.356235
R14441 n1_m1_321600_518400 n1_m1_326400_518400 5.356235
R14442 n1_m1_326400_518400 n1_m1_331200_518400 5.356235
R14443 n1_m1_331200_518400 n1_m1_336000_518400 5.356235
R14444 n1_m1_336000_518400 n1_m1_340000_518400 4.463529
R14445 n1_m1_340800_518400 n1_m1_340000_518400 0.892706
R14446 n1_m1_340800_518400 n1_m1_345600_518400 5.356235
R14447 n1_m1_345600_518400 n1_m1_350400_518400 5.356235
R14448 n1_m1_350400_518400 n1_m1_355200_518400 5.356235
R14449 n1_m1_355200_518400 n1_m1_360000_518400 5.356235
R14450 n1_m1_360000_518400 n1_m1_364800_518400 5.356235
R14451 n1_m1_364800_518400 n1_m1_368000_518400 3.570824
R14452 n1_m1_369600_518400 n1_m1_368000_518400 1.785412
R14453 n1_m1_369600_518400 n1_m1_374400_518400 5.356235
R14454 n1_m1_374400_518400 n1_m1_379200_518400 5.356235
R14455 n1_m1_379200_518400 n1_m1_384000_518400 5.356235
R14456 n1_m1_384000_518400 n1_m1_388800_518400 5.356235
R14457 n1_m1_388800_518400 n1_m1_393600_518400 5.356235
R14458 n1_m1_393600_518400 n1_m1_396000_518400 2.678118
R14459 n1_m1_398400_518400 n1_m1_396000_518400 2.678118
R14460 n1_m1_398400_518400 n1_m1_403200_518400 5.356235
R14461 n1_m1_403200_518400 n1_m1_408000_518400 5.356235
R14462 n1_m1_408000_518400 n1_m1_412800_518400 5.356235
R14463 n1_m1_412800_518400 n1_m1_417600_518400 5.356235
R14464 n1_m1_417600_518400 n1_m1_422400_518400 5.356235
R14465 n1_m1_422400_518400 n1_m1_424000_518400 1.785412
R14466 n1_m1_427200_518400 n1_m1_424000_518400 3.570824
R14467 n1_m1_427200_518400 n1_m1_432000_518400 5.356235
R14468 n1_m1_432000_518400 n1_m1_436800_518400 5.356235
R14469 n1_m1_436800_518400 n1_m1_441600_518400 5.356235
R14470 n1_m1_441600_518400 n1_m1_446400_518400 5.356235
R14471 n1_m1_446400_518400 n1_m1_451200_518400 5.356235
R14472 n1_m1_451200_518400 n1_m1_452000_518400 0.892706
R14473 n1_m1_456000_518400 n1_m1_452000_518400 4.463529
R14474 n1_m1_456000_518400 n1_m1_460800_518400 5.356235
R14475 n1_m1_460800_518400 n1_m1_465600_518400 5.356235
R14476 n1_m1_465600_518400 n1_m1_470400_518400 5.356235
R14477 n1_m1_470400_518400 n1_m1_475200_518400 5.356235
R14478 n1_m1_475200_518400 n1_m1_480000_518400 5.356235
R14479 n1_m1_480000_518400 n1_m1_484800_518400 5.356235
R14480 n1_m1_484800_518400 n1_m1_489600_518400 5.356235
R14481 n1_m1_489600_518400 n1_m1_494400_518400 5.356235
R14482 n1_m1_494400_518400 n1_m1_499200_518400 5.356235
R14483 n1_m1_499200_518400 n1_m1_504000_518400 5.356235
R14484 n1_m1_504000_518400 n1_m1_508000_518400 4.463529
R14485 n1_m1_508800_518400 n1_m1_508000_518400 0.892706
R14486 n1_m1_508800_518400 n1_m1_513600_518400 5.356235
R14487 n1_m1_513600_518400 n1_m1_518400_518400 5.356235
R14488 n1_m1_518400_518400 n1_m1_523200_518400 5.356235
R14489 n1_m1_523200_518400 n1_m1_528000_518400 5.356235
R14490 n1_m1_528000_518400 n1_m1_532800_518400 5.356235
R14491 n1_m1_532800_518400 n1_m1_536000_518400 3.570824
R14492 n1_m1_537600_518400 n1_m1_536000_518400 1.785412
R14493 n1_m1_537600_518400 n1_m1_542400_518400 5.356235
R14494 n1_m1_542400_518400 n1_m1_547200_518400 5.356235
R14495 n1_m1_547200_518400 n1_m1_552000_518400 5.356235
R14496 n1_m1_552000_518400 n1_m1_556800_518400 5.356235
R14497 n1_m1_0_523200 n1_m1_4000_523200 4.463529
R14498 n1_m1_4800_523200 n1_m1_4000_523200 0.892706
R14499 n1_m1_4800_523200 n1_m1_9600_523200 5.356235
R14500 n1_m1_9600_523200 n1_m1_14400_523200 5.356235
R14501 n1_m1_14400_523200 n1_m1_19200_523200 5.356235
R14502 n1_m1_19200_523200 n1_m1_24000_523200 5.356235
R14503 n1_m1_24000_523200 n1_m1_28800_523200 5.356235
R14504 n1_m1_28800_523200 n1_m1_32000_523200 3.570824
R14505 n1_m1_33600_523200 n1_m1_32000_523200 1.785412
R14506 n1_m1_33600_523200 n1_m1_38400_523200 5.356235
R14507 n1_m1_38400_523200 n1_m1_43200_523200 5.356235
R14508 n1_m1_43200_523200 n1_m1_48000_523200 5.356235
R14509 n1_m1_48000_523200 n1_m1_52800_523200 5.356235
R14510 n1_m1_52800_523200 n1_m1_57600_523200 5.356235
R14511 n1_m1_57600_523200 n1_m1_60000_523200 2.678118
R14512 n1_m1_62400_523200 n1_m1_60000_523200 2.678118
R14513 n1_m1_62400_523200 n1_m1_67200_523200 5.356235
R14514 n1_m1_67200_523200 n1_m1_72000_523200 5.356235
R14515 n1_m1_72000_523200 n1_m1_76800_523200 5.356235
R14516 n1_m1_76800_523200 n1_m1_81600_523200 5.356235
R14517 n1_m1_81600_523200 n1_m1_86400_523200 5.356235
R14518 n1_m1_86400_523200 n1_m1_88000_523200 1.785412
R14519 n1_m1_91200_523200 n1_m1_88000_523200 3.570824
R14520 n1_m1_91200_523200 n1_m1_96000_523200 5.356235
R14521 n1_m1_96000_523200 n1_m1_100800_523200 5.356235
R14522 n1_m1_100800_523200 n1_m1_105600_523200 5.356235
R14523 n1_m1_105600_523200 n1_m1_110400_523200 5.356235
R14524 n1_m1_110400_523200 n1_m1_115200_523200 5.356235
R14525 n1_m1_115200_523200 n1_m1_116000_523200 0.892706
R14526 n1_m1_120000_523200 n1_m1_116000_523200 4.463529
R14527 n1_m1_120000_523200 n1_m1_124800_523200 5.356235
R14528 n1_m1_124800_523200 n1_m1_129600_523200 5.356235
R14529 n1_m1_129600_523200 n1_m1_134400_523200 5.356235
R14530 n1_m1_134400_523200 n1_m1_139200_523200 5.356235
R14531 n1_m1_139200_523200 n1_m1_144000_523200 5.356235
R14532 n1_m1_144000_523200 n1_m1_148800_523200 5.356235
R14533 n1_m1_148800_523200 n1_m1_153600_523200 5.356235
R14534 n1_m1_153600_523200 n1_m1_158400_523200 5.356235
R14535 n1_m1_158400_523200 n1_m1_163200_523200 5.356235
R14536 n1_m1_163200_523200 n1_m1_168000_523200 5.356235
R14537 n1_m1_168000_523200 n1_m1_172000_523200 4.463529
R14538 n1_m1_172800_523200 n1_m1_172000_523200 0.892706
R14539 n1_m1_172800_523200 n1_m1_177600_523200 5.356235
R14540 n1_m1_177600_523200 n1_m1_182400_523200 5.356235
R14541 n1_m1_182400_523200 n1_m1_187200_523200 5.356235
R14542 n1_m1_187200_523200 n1_m1_192000_523200 5.356235
R14543 n1_m1_192000_523200 n1_m1_196800_523200 5.356235
R14544 n1_m1_196800_523200 n1_m1_200000_523200 3.570824
R14545 n1_m1_201600_523200 n1_m1_200000_523200 1.785412
R14546 n1_m1_201600_523200 n1_m1_206400_523200 5.356235
R14547 n1_m1_206400_523200 n1_m1_211200_523200 5.356235
R14548 n1_m1_211200_523200 n1_m1_216000_523200 5.356235
R14549 n1_m1_216000_523200 n1_m1_220800_523200 5.356235
R14550 n1_m1_220800_523200 n1_m1_225600_523200 5.356235
R14551 n1_m1_225600_523200 n1_m1_228000_523200 2.678118
R14552 n1_m1_230400_523200 n1_m1_228000_523200 2.678118
R14553 n1_m1_230400_523200 n1_m1_235200_523200 5.356235
R14554 n1_m1_235200_523200 n1_m1_240000_523200 5.356235
R14555 n1_m1_240000_523200 n1_m1_244800_523200 5.356235
R14556 n1_m1_244800_523200 n1_m1_249600_523200 5.356235
R14557 n1_m1_249600_523200 n1_m1_254400_523200 5.356235
R14558 n1_m1_254400_523200 n1_m1_256000_523200 1.785412
R14559 n1_m1_259200_523200 n1_m1_256000_523200 3.570824
R14560 n1_m1_259200_523200 n1_m1_264000_523200 5.356235
R14561 n1_m1_264000_523200 n1_m1_268800_523200 5.356235
R14562 n1_m1_268800_523200 n1_m1_273600_523200 5.356235
R14563 n1_m1_273600_523200 n1_m1_278400_523200 5.356235
R14564 n1_m1_278400_523200 n1_m1_283200_523200 5.356235
R14565 n1_m1_283200_523200 n1_m1_284000_523200 0.892706
R14566 n1_m1_288000_523200 n1_m1_284000_523200 4.463529
R14567 n1_m1_288000_523200 n1_m1_292800_523200 5.356235
R14568 n1_m1_292800_523200 n1_m1_297600_523200 5.356235
R14569 n1_m1_297600_523200 n1_m1_302400_523200 5.356235
R14570 n1_m1_302400_523200 n1_m1_307200_523200 5.356235
R14571 n1_m1_307200_523200 n1_m1_312000_523200 5.356235
R14572 n1_m1_312000_523200 n1_m1_316800_523200 5.356235
R14573 n1_m1_316800_523200 n1_m1_321600_523200 5.356235
R14574 n1_m1_321600_523200 n1_m1_326400_523200 5.356235
R14575 n1_m1_326400_523200 n1_m1_331200_523200 5.356235
R14576 n1_m1_331200_523200 n1_m1_336000_523200 5.356235
R14577 n1_m1_336000_523200 n1_m1_340000_523200 4.463529
R14578 n1_m1_340800_523200 n1_m1_340000_523200 0.892706
R14579 n1_m1_340800_523200 n1_m1_345600_523200 5.356235
R14580 n1_m1_345600_523200 n1_m1_350400_523200 5.356235
R14581 n1_m1_350400_523200 n1_m1_355200_523200 5.356235
R14582 n1_m1_355200_523200 n1_m1_360000_523200 5.356235
R14583 n1_m1_360000_523200 n1_m1_364800_523200 5.356235
R14584 n1_m1_364800_523200 n1_m1_368000_523200 3.570824
R14585 n1_m1_369600_523200 n1_m1_368000_523200 1.785412
R14586 n1_m1_369600_523200 n1_m1_374400_523200 5.356235
R14587 n1_m1_374400_523200 n1_m1_379200_523200 5.356235
R14588 n1_m1_379200_523200 n1_m1_384000_523200 5.356235
R14589 n1_m1_384000_523200 n1_m1_388800_523200 5.356235
R14590 n1_m1_388800_523200 n1_m1_393600_523200 5.356235
R14591 n1_m1_393600_523200 n1_m1_396000_523200 2.678118
R14592 n1_m1_398400_523200 n1_m1_396000_523200 2.678118
R14593 n1_m1_398400_523200 n1_m1_403200_523200 5.356235
R14594 n1_m1_403200_523200 n1_m1_408000_523200 5.356235
R14595 n1_m1_408000_523200 n1_m1_412800_523200 5.356235
R14596 n1_m1_412800_523200 n1_m1_417600_523200 5.356235
R14597 n1_m1_417600_523200 n1_m1_422400_523200 5.356235
R14598 n1_m1_422400_523200 n1_m1_424000_523200 1.785412
R14599 n1_m1_427200_523200 n1_m1_424000_523200 3.570824
R14600 n1_m1_427200_523200 n1_m1_432000_523200 5.356235
R14601 n1_m1_432000_523200 n1_m1_436800_523200 5.356235
R14602 n1_m1_436800_523200 n1_m1_441600_523200 5.356235
R14603 n1_m1_441600_523200 n1_m1_446400_523200 5.356235
R14604 n1_m1_446400_523200 n1_m1_451200_523200 5.356235
R14605 n1_m1_451200_523200 n1_m1_452000_523200 0.892706
R14606 n1_m1_456000_523200 n1_m1_452000_523200 4.463529
R14607 n1_m1_456000_523200 n1_m1_460800_523200 5.356235
R14608 n1_m1_460800_523200 n1_m1_465600_523200 5.356235
R14609 n1_m1_465600_523200 n1_m1_470400_523200 5.356235
R14610 n1_m1_470400_523200 n1_m1_475200_523200 5.356235
R14611 n1_m1_475200_523200 n1_m1_480000_523200 5.356235
R14612 n1_m1_480000_523200 n1_m1_484800_523200 5.356235
R14613 n1_m1_484800_523200 n1_m1_489600_523200 5.356235
R14614 n1_m1_489600_523200 n1_m1_494400_523200 5.356235
R14615 n1_m1_494400_523200 n1_m1_499200_523200 5.356235
R14616 n1_m1_499200_523200 n1_m1_504000_523200 5.356235
R14617 n1_m1_504000_523200 n1_m1_508000_523200 4.463529
R14618 n1_m1_508800_523200 n1_m1_508000_523200 0.892706
R14619 n1_m1_508800_523200 n1_m1_513600_523200 5.356235
R14620 n1_m1_513600_523200 n1_m1_518400_523200 5.356235
R14621 n1_m1_518400_523200 n1_m1_523200_523200 5.356235
R14622 n1_m1_523200_523200 n1_m1_528000_523200 5.356235
R14623 n1_m1_528000_523200 n1_m1_532800_523200 5.356235
R14624 n1_m1_532800_523200 n1_m1_536000_523200 3.570824
R14625 n1_m1_537600_523200 n1_m1_536000_523200 1.785412
R14626 n1_m1_537600_523200 n1_m1_542400_523200 5.356235
R14627 n1_m1_542400_523200 n1_m1_547200_523200 5.356235
R14628 n1_m1_547200_523200 n1_m1_552000_523200 5.356235
R14629 n1_m1_552000_523200 n1_m1_556800_523200 5.356235
R14630 n1_m1_0_528000 n1_m1_4000_528000 4.463529
R14631 n1_m1_4800_528000 n1_m1_4000_528000 0.892706
R14632 n1_m1_4800_528000 n1_m1_9600_528000 5.356235
R14633 n1_m1_9600_528000 n1_m1_14400_528000 5.356235
R14634 n1_m1_14400_528000 n1_m1_19200_528000 5.356235
R14635 n1_m1_19200_528000 n1_m1_24000_528000 5.356235
R14636 n1_m1_24000_528000 n1_m1_28800_528000 5.356235
R14637 n1_m1_28800_528000 n1_m1_32000_528000 3.570824
R14638 n1_m1_33600_528000 n1_m1_32000_528000 1.785412
R14639 n1_m1_33600_528000 n1_m1_38400_528000 5.356235
R14640 n1_m1_38400_528000 n1_m1_43200_528000 5.356235
R14641 n1_m1_43200_528000 n1_m1_48000_528000 5.356235
R14642 n1_m1_48000_528000 n1_m1_52800_528000 5.356235
R14643 n1_m1_52800_528000 n1_m1_57600_528000 5.356235
R14644 n1_m1_57600_528000 n1_m1_60000_528000 2.678118
R14645 n1_m1_62400_528000 n1_m1_60000_528000 2.678118
R14646 n1_m1_62400_528000 n1_m1_67200_528000 5.356235
R14647 n1_m1_67200_528000 n1_m1_72000_528000 5.356235
R14648 n1_m1_72000_528000 n1_m1_76800_528000 5.356235
R14649 n1_m1_76800_528000 n1_m1_81600_528000 5.356235
R14650 n1_m1_81600_528000 n1_m1_86400_528000 5.356235
R14651 n1_m1_86400_528000 n1_m1_88000_528000 1.785412
R14652 n1_m1_91200_528000 n1_m1_88000_528000 3.570824
R14653 n1_m1_91200_528000 n1_m1_96000_528000 5.356235
R14654 n1_m1_96000_528000 n1_m1_100800_528000 5.356235
R14655 n1_m1_100800_528000 n1_m1_105600_528000 5.356235
R14656 n1_m1_105600_528000 n1_m1_110400_528000 5.356235
R14657 n1_m1_110400_528000 n1_m1_115200_528000 5.356235
R14658 n1_m1_115200_528000 n1_m1_116000_528000 0.892706
R14659 n1_m1_120000_528000 n1_m1_116000_528000 4.463529
R14660 n1_m1_120000_528000 n1_m1_124800_528000 5.356235
R14661 n1_m1_124800_528000 n1_m1_129600_528000 5.356235
R14662 n1_m1_129600_528000 n1_m1_134400_528000 5.356235
R14663 n1_m1_134400_528000 n1_m1_139200_528000 5.356235
R14664 n1_m1_139200_528000 n1_m1_144000_528000 5.356235
R14665 n1_m1_144000_528000 n1_m1_148800_528000 5.356235
R14666 n1_m1_148800_528000 n1_m1_153600_528000 5.356235
R14667 n1_m1_153600_528000 n1_m1_158400_528000 5.356235
R14668 n1_m1_158400_528000 n1_m1_163200_528000 5.356235
R14669 n1_m1_163200_528000 n1_m1_168000_528000 5.356235
R14670 n1_m1_168000_528000 n1_m1_172000_528000 4.463529
R14671 n1_m1_172800_528000 n1_m1_172000_528000 0.892706
R14672 n1_m1_172800_528000 n1_m1_177600_528000 5.356235
R14673 n1_m1_177600_528000 n1_m1_182400_528000 5.356235
R14674 n1_m1_182400_528000 n1_m1_187200_528000 5.356235
R14675 n1_m1_187200_528000 n1_m1_192000_528000 5.356235
R14676 n1_m1_192000_528000 n1_m1_196800_528000 5.356235
R14677 n1_m1_196800_528000 n1_m1_200000_528000 3.570824
R14678 n1_m1_201600_528000 n1_m1_200000_528000 1.785412
R14679 n1_m1_201600_528000 n1_m1_206400_528000 5.356235
R14680 n1_m1_206400_528000 n1_m1_211200_528000 5.356235
R14681 n1_m1_211200_528000 n1_m1_216000_528000 5.356235
R14682 n1_m1_216000_528000 n1_m1_220800_528000 5.356235
R14683 n1_m1_220800_528000 n1_m1_225600_528000 5.356235
R14684 n1_m1_225600_528000 n1_m1_228000_528000 2.678118
R14685 n1_m1_230400_528000 n1_m1_228000_528000 2.678118
R14686 n1_m1_230400_528000 n1_m1_235200_528000 5.356235
R14687 n1_m1_235200_528000 n1_m1_240000_528000 5.356235
R14688 n1_m1_240000_528000 n1_m1_244800_528000 5.356235
R14689 n1_m1_244800_528000 n1_m1_249600_528000 5.356235
R14690 n1_m1_249600_528000 n1_m1_254400_528000 5.356235
R14691 n1_m1_254400_528000 n1_m1_256000_528000 1.785412
R14692 n1_m1_259200_528000 n1_m1_256000_528000 3.570824
R14693 n1_m1_259200_528000 n1_m1_264000_528000 5.356235
R14694 n1_m1_264000_528000 n1_m1_268800_528000 5.356235
R14695 n1_m1_268800_528000 n1_m1_273600_528000 5.356235
R14696 n1_m1_273600_528000 n1_m1_278400_528000 5.356235
R14697 n1_m1_278400_528000 n1_m1_283200_528000 5.356235
R14698 n1_m1_283200_528000 n1_m1_284000_528000 0.892706
R14699 n1_m1_288000_528000 n1_m1_284000_528000 4.463529
R14700 n1_m1_288000_528000 n1_m1_292800_528000 5.356235
R14701 n1_m1_292800_528000 n1_m1_297600_528000 5.356235
R14702 n1_m1_297600_528000 n1_m1_302400_528000 5.356235
R14703 n1_m1_302400_528000 n1_m1_307200_528000 5.356235
R14704 n1_m1_307200_528000 n1_m1_312000_528000 5.356235
R14705 n1_m1_312000_528000 n1_m1_316800_528000 5.356235
R14706 n1_m1_316800_528000 n1_m1_321600_528000 5.356235
R14707 n1_m1_321600_528000 n1_m1_326400_528000 5.356235
R14708 n1_m1_326400_528000 n1_m1_331200_528000 5.356235
R14709 n1_m1_331200_528000 n1_m1_336000_528000 5.356235
R14710 n1_m1_336000_528000 n1_m1_340000_528000 4.463529
R14711 n1_m1_340800_528000 n1_m1_340000_528000 0.892706
R14712 n1_m1_340800_528000 n1_m1_345600_528000 5.356235
R14713 n1_m1_345600_528000 n1_m1_350400_528000 5.356235
R14714 n1_m1_350400_528000 n1_m1_355200_528000 5.356235
R14715 n1_m1_355200_528000 n1_m1_360000_528000 5.356235
R14716 n1_m1_360000_528000 n1_m1_364800_528000 5.356235
R14717 n1_m1_364800_528000 n1_m1_368000_528000 3.570824
R14718 n1_m1_369600_528000 n1_m1_368000_528000 1.785412
R14719 n1_m1_369600_528000 n1_m1_374400_528000 5.356235
R14720 n1_m1_374400_528000 n1_m1_379200_528000 5.356235
R14721 n1_m1_379200_528000 n1_m1_384000_528000 5.356235
R14722 n1_m1_384000_528000 n1_m1_388800_528000 5.356235
R14723 n1_m1_388800_528000 n1_m1_393600_528000 5.356235
R14724 n1_m1_393600_528000 n1_m1_396000_528000 2.678118
R14725 n1_m1_398400_528000 n1_m1_396000_528000 2.678118
R14726 n1_m1_398400_528000 n1_m1_403200_528000 5.356235
R14727 n1_m1_403200_528000 n1_m1_408000_528000 5.356235
R14728 n1_m1_408000_528000 n1_m1_412800_528000 5.356235
R14729 n1_m1_412800_528000 n1_m1_417600_528000 5.356235
R14730 n1_m1_417600_528000 n1_m1_422400_528000 5.356235
R14731 n1_m1_422400_528000 n1_m1_424000_528000 1.785412
R14732 n1_m1_427200_528000 n1_m1_424000_528000 3.570824
R14733 n1_m1_427200_528000 n1_m1_432000_528000 5.356235
R14734 n1_m1_432000_528000 n1_m1_436800_528000 5.356235
R14735 n1_m1_436800_528000 n1_m1_441600_528000 5.356235
R14736 n1_m1_441600_528000 n1_m1_446400_528000 5.356235
R14737 n1_m1_446400_528000 n1_m1_451200_528000 5.356235
R14738 n1_m1_451200_528000 n1_m1_452000_528000 0.892706
R14739 n1_m1_456000_528000 n1_m1_452000_528000 4.463529
R14740 n1_m1_456000_528000 n1_m1_460800_528000 5.356235
R14741 n1_m1_460800_528000 n1_m1_465600_528000 5.356235
R14742 n1_m1_465600_528000 n1_m1_470400_528000 5.356235
R14743 n1_m1_470400_528000 n1_m1_475200_528000 5.356235
R14744 n1_m1_475200_528000 n1_m1_480000_528000 5.356235
R14745 n1_m1_480000_528000 n1_m1_484800_528000 5.356235
R14746 n1_m1_484800_528000 n1_m1_489600_528000 5.356235
R14747 n1_m1_489600_528000 n1_m1_494400_528000 5.356235
R14748 n1_m1_494400_528000 n1_m1_499200_528000 5.356235
R14749 n1_m1_499200_528000 n1_m1_504000_528000 5.356235
R14750 n1_m1_504000_528000 n1_m1_508000_528000 4.463529
R14751 n1_m1_508800_528000 n1_m1_508000_528000 0.892706
R14752 n1_m1_508800_528000 n1_m1_513600_528000 5.356235
R14753 n1_m1_513600_528000 n1_m1_518400_528000 5.356235
R14754 n1_m1_518400_528000 n1_m1_523200_528000 5.356235
R14755 n1_m1_523200_528000 n1_m1_528000_528000 5.356235
R14756 n1_m1_528000_528000 n1_m1_532800_528000 5.356235
R14757 n1_m1_532800_528000 n1_m1_536000_528000 3.570824
R14758 n1_m1_537600_528000 n1_m1_536000_528000 1.785412
R14759 n1_m1_537600_528000 n1_m1_542400_528000 5.356235
R14760 n1_m1_542400_528000 n1_m1_547200_528000 5.356235
R14761 n1_m1_547200_528000 n1_m1_552000_528000 5.356235
R14762 n1_m1_552000_528000 n1_m1_556800_528000 5.356235
R14763 n1_m1_0_532800 n1_m1_4000_532800 4.463529
R14764 n1_m1_4800_532800 n1_m1_4000_532800 0.892706
R14765 n1_m1_4800_532800 n1_m1_9600_532800 5.356235
R14766 n1_m1_9600_532800 n1_m1_14400_532800 5.356235
R14767 n1_m1_14400_532800 n1_m1_19200_532800 5.356235
R14768 n1_m1_19200_532800 n1_m1_24000_532800 5.356235
R14769 n1_m1_24000_532800 n1_m1_28800_532800 5.356235
R14770 n1_m1_28800_532800 n1_m1_32000_532800 3.570824
R14771 n1_m1_33600_532800 n1_m1_32000_532800 1.785412
R14772 n1_m1_33600_532800 n1_m1_38400_532800 5.356235
R14773 n1_m1_38400_532800 n1_m1_43200_532800 5.356235
R14774 n1_m1_43200_532800 n1_m1_48000_532800 5.356235
R14775 n1_m1_48000_532800 n1_m1_52800_532800 5.356235
R14776 n1_m1_52800_532800 n1_m1_57600_532800 5.356235
R14777 n1_m1_57600_532800 n1_m1_60000_532800 2.678118
R14778 n1_m1_62400_532800 n1_m1_60000_532800 2.678118
R14779 n1_m1_62400_532800 n1_m1_67200_532800 5.356235
R14780 n1_m1_67200_532800 n1_m1_72000_532800 5.356235
R14781 n1_m1_72000_532800 n1_m1_76800_532800 5.356235
R14782 n1_m1_76800_532800 n1_m1_81600_532800 5.356235
R14783 n1_m1_81600_532800 n1_m1_86400_532800 5.356235
R14784 n1_m1_86400_532800 n1_m1_88000_532800 1.785412
R14785 n1_m1_91200_532800 n1_m1_88000_532800 3.570824
R14786 n1_m1_91200_532800 n1_m1_96000_532800 5.356235
R14787 n1_m1_96000_532800 n1_m1_100800_532800 5.356235
R14788 n1_m1_100800_532800 n1_m1_105600_532800 5.356235
R14789 n1_m1_105600_532800 n1_m1_110400_532800 5.356235
R14790 n1_m1_110400_532800 n1_m1_115200_532800 5.356235
R14791 n1_m1_115200_532800 n1_m1_116000_532800 0.892706
R14792 n1_m1_120000_532800 n1_m1_116000_532800 4.463529
R14793 n1_m1_120000_532800 n1_m1_124800_532800 5.356235
R14794 n1_m1_124800_532800 n1_m1_129600_532800 5.356235
R14795 n1_m1_129600_532800 n1_m1_134400_532800 5.356235
R14796 n1_m1_134400_532800 n1_m1_139200_532800 5.356235
R14797 n1_m1_139200_532800 n1_m1_144000_532800 5.356235
R14798 n1_m1_144000_532800 n1_m1_148800_532800 5.356235
R14799 n1_m1_148800_532800 n1_m1_153600_532800 5.356235
R14800 n1_m1_153600_532800 n1_m1_158400_532800 5.356235
R14801 n1_m1_158400_532800 n1_m1_163200_532800 5.356235
R14802 n1_m1_163200_532800 n1_m1_168000_532800 5.356235
R14803 n1_m1_168000_532800 n1_m1_172000_532800 4.463529
R14804 n1_m1_172800_532800 n1_m1_172000_532800 0.892706
R14805 n1_m1_172800_532800 n1_m1_177600_532800 5.356235
R14806 n1_m1_177600_532800 n1_m1_182400_532800 5.356235
R14807 n1_m1_182400_532800 n1_m1_187200_532800 5.356235
R14808 n1_m1_187200_532800 n1_m1_192000_532800 5.356235
R14809 n1_m1_192000_532800 n1_m1_196800_532800 5.356235
R14810 n1_m1_196800_532800 n1_m1_200000_532800 3.570824
R14811 n1_m1_201600_532800 n1_m1_200000_532800 1.785412
R14812 n1_m1_201600_532800 n1_m1_206400_532800 5.356235
R14813 n1_m1_206400_532800 n1_m1_211200_532800 5.356235
R14814 n1_m1_211200_532800 n1_m1_216000_532800 5.356235
R14815 n1_m1_216000_532800 n1_m1_220800_532800 5.356235
R14816 n1_m1_220800_532800 n1_m1_225600_532800 5.356235
R14817 n1_m1_225600_532800 n1_m1_228000_532800 2.678118
R14818 n1_m1_230400_532800 n1_m1_228000_532800 2.678118
R14819 n1_m1_230400_532800 n1_m1_235200_532800 5.356235
R14820 n1_m1_235200_532800 n1_m1_240000_532800 5.356235
R14821 n1_m1_240000_532800 n1_m1_244800_532800 5.356235
R14822 n1_m1_244800_532800 n1_m1_249600_532800 5.356235
R14823 n1_m1_249600_532800 n1_m1_254400_532800 5.356235
R14824 n1_m1_254400_532800 n1_m1_256000_532800 1.785412
R14825 n1_m1_259200_532800 n1_m1_256000_532800 3.570824
R14826 n1_m1_259200_532800 n1_m1_264000_532800 5.356235
R14827 n1_m1_264000_532800 n1_m1_268800_532800 5.356235
R14828 n1_m1_268800_532800 n1_m1_273600_532800 5.356235
R14829 n1_m1_273600_532800 n1_m1_278400_532800 5.356235
R14830 n1_m1_278400_532800 n1_m1_283200_532800 5.356235
R14831 n1_m1_283200_532800 n1_m1_284000_532800 0.892706
R14832 n1_m1_288000_532800 n1_m1_284000_532800 4.463529
R14833 n1_m1_288000_532800 n1_m1_292800_532800 5.356235
R14834 n1_m1_292800_532800 n1_m1_297600_532800 5.356235
R14835 n1_m1_297600_532800 n1_m1_302400_532800 5.356235
R14836 n1_m1_302400_532800 n1_m1_307200_532800 5.356235
R14837 n1_m1_307200_532800 n1_m1_312000_532800 5.356235
R14838 n1_m1_312000_532800 n1_m1_316800_532800 5.356235
R14839 n1_m1_316800_532800 n1_m1_321600_532800 5.356235
R14840 n1_m1_321600_532800 n1_m1_326400_532800 5.356235
R14841 n1_m1_326400_532800 n1_m1_331200_532800 5.356235
R14842 n1_m1_331200_532800 n1_m1_336000_532800 5.356235
R14843 n1_m1_336000_532800 n1_m1_340000_532800 4.463529
R14844 n1_m1_340800_532800 n1_m1_340000_532800 0.892706
R14845 n1_m1_340800_532800 n1_m1_345600_532800 5.356235
R14846 n1_m1_345600_532800 n1_m1_350400_532800 5.356235
R14847 n1_m1_350400_532800 n1_m1_355200_532800 5.356235
R14848 n1_m1_355200_532800 n1_m1_360000_532800 5.356235
R14849 n1_m1_360000_532800 n1_m1_364800_532800 5.356235
R14850 n1_m1_364800_532800 n1_m1_368000_532800 3.570824
R14851 n1_m1_369600_532800 n1_m1_368000_532800 1.785412
R14852 n1_m1_369600_532800 n1_m1_374400_532800 5.356235
R14853 n1_m1_374400_532800 n1_m1_379200_532800 5.356235
R14854 n1_m1_379200_532800 n1_m1_384000_532800 5.356235
R14855 n1_m1_384000_532800 n1_m1_388800_532800 5.356235
R14856 n1_m1_388800_532800 n1_m1_393600_532800 5.356235
R14857 n1_m1_393600_532800 n1_m1_396000_532800 2.678118
R14858 n1_m1_398400_532800 n1_m1_396000_532800 2.678118
R14859 n1_m1_398400_532800 n1_m1_403200_532800 5.356235
R14860 n1_m1_403200_532800 n1_m1_408000_532800 5.356235
R14861 n1_m1_408000_532800 n1_m1_412800_532800 5.356235
R14862 n1_m1_412800_532800 n1_m1_417600_532800 5.356235
R14863 n1_m1_417600_532800 n1_m1_422400_532800 5.356235
R14864 n1_m1_422400_532800 n1_m1_424000_532800 1.785412
R14865 n1_m1_427200_532800 n1_m1_424000_532800 3.570824
R14866 n1_m1_427200_532800 n1_m1_432000_532800 5.356235
R14867 n1_m1_432000_532800 n1_m1_436800_532800 5.356235
R14868 n1_m1_436800_532800 n1_m1_441600_532800 5.356235
R14869 n1_m1_441600_532800 n1_m1_446400_532800 5.356235
R14870 n1_m1_446400_532800 n1_m1_451200_532800 5.356235
R14871 n1_m1_451200_532800 n1_m1_452000_532800 0.892706
R14872 n1_m1_456000_532800 n1_m1_452000_532800 4.463529
R14873 n1_m1_456000_532800 n1_m1_460800_532800 5.356235
R14874 n1_m1_460800_532800 n1_m1_465600_532800 5.356235
R14875 n1_m1_465600_532800 n1_m1_470400_532800 5.356235
R14876 n1_m1_470400_532800 n1_m1_475200_532800 5.356235
R14877 n1_m1_475200_532800 n1_m1_480000_532800 5.356235
R14878 n1_m1_480000_532800 n1_m1_484800_532800 5.356235
R14879 n1_m1_484800_532800 n1_m1_489600_532800 5.356235
R14880 n1_m1_489600_532800 n1_m1_494400_532800 5.356235
R14881 n1_m1_494400_532800 n1_m1_499200_532800 5.356235
R14882 n1_m1_499200_532800 n1_m1_504000_532800 5.356235
R14883 n1_m1_504000_532800 n1_m1_508000_532800 4.463529
R14884 n1_m1_508800_532800 n1_m1_508000_532800 0.892706
R14885 n1_m1_508800_532800 n1_m1_513600_532800 5.356235
R14886 n1_m1_513600_532800 n1_m1_518400_532800 5.356235
R14887 n1_m1_518400_532800 n1_m1_523200_532800 5.356235
R14888 n1_m1_523200_532800 n1_m1_528000_532800 5.356235
R14889 n1_m1_528000_532800 n1_m1_532800_532800 5.356235
R14890 n1_m1_532800_532800 n1_m1_536000_532800 3.570824
R14891 n1_m1_537600_532800 n1_m1_536000_532800 1.785412
R14892 n1_m1_537600_532800 n1_m1_542400_532800 5.356235
R14893 n1_m1_542400_532800 n1_m1_547200_532800 5.356235
R14894 n1_m1_547200_532800 n1_m1_552000_532800 5.356235
R14895 n1_m1_552000_532800 n1_m1_556800_532800 5.356235
R14896 n1_m1_0_537600 n1_m1_4000_537600 4.463529
R14897 n1_m1_4800_537600 n1_m1_4000_537600 0.892706
R14898 n1_m1_4800_537600 n1_m1_9600_537600 5.356235
R14899 n1_m1_9600_537600 n1_m1_14400_537600 5.356235
R14900 n1_m1_14400_537600 n1_m1_19200_537600 5.356235
R14901 n1_m1_19200_537600 n1_m1_24000_537600 5.356235
R14902 n1_m1_24000_537600 n1_m1_28800_537600 5.356235
R14903 n1_m1_28800_537600 n1_m1_32000_537600 3.570824
R14904 n1_m1_33600_537600 n1_m1_32000_537600 1.785412
R14905 n1_m1_33600_537600 n1_m1_38400_537600 5.356235
R14906 n1_m1_38400_537600 n1_m1_43200_537600 5.356235
R14907 n1_m1_43200_537600 n1_m1_48000_537600 5.356235
R14908 n1_m1_48000_537600 n1_m1_52800_537600 5.356235
R14909 n1_m1_52800_537600 n1_m1_57600_537600 5.356235
R14910 n1_m1_57600_537600 n1_m1_60000_537600 2.678118
R14911 n1_m1_62400_537600 n1_m1_60000_537600 2.678118
R14912 n1_m1_62400_537600 n1_m1_67200_537600 5.356235
R14913 n1_m1_67200_537600 n1_m1_72000_537600 5.356235
R14914 n1_m1_72000_537600 n1_m1_76800_537600 5.356235
R14915 n1_m1_76800_537600 n1_m1_81600_537600 5.356235
R14916 n1_m1_81600_537600 n1_m1_86400_537600 5.356235
R14917 n1_m1_86400_537600 n1_m1_88000_537600 1.785412
R14918 n1_m1_91200_537600 n1_m1_88000_537600 3.570824
R14919 n1_m1_91200_537600 n1_m1_96000_537600 5.356235
R14920 n1_m1_96000_537600 n1_m1_100800_537600 5.356235
R14921 n1_m1_100800_537600 n1_m1_105600_537600 5.356235
R14922 n1_m1_105600_537600 n1_m1_110400_537600 5.356235
R14923 n1_m1_110400_537600 n1_m1_115200_537600 5.356235
R14924 n1_m1_115200_537600 n1_m1_116000_537600 0.892706
R14925 n1_m1_120000_537600 n1_m1_116000_537600 4.463529
R14926 n1_m1_120000_537600 n1_m1_124800_537600 5.356235
R14927 n1_m1_124800_537600 n1_m1_129600_537600 5.356235
R14928 n1_m1_129600_537600 n1_m1_134400_537600 5.356235
R14929 n1_m1_134400_537600 n1_m1_139200_537600 5.356235
R14930 n1_m1_139200_537600 n1_m1_144000_537600 5.356235
R14931 n1_m1_144000_537600 n1_m1_148800_537600 5.356235
R14932 n1_m1_148800_537600 n1_m1_153600_537600 5.356235
R14933 n1_m1_153600_537600 n1_m1_158400_537600 5.356235
R14934 n1_m1_158400_537600 n1_m1_163200_537600 5.356235
R14935 n1_m1_163200_537600 n1_m1_168000_537600 5.356235
R14936 n1_m1_168000_537600 n1_m1_172000_537600 4.463529
R14937 n1_m1_172800_537600 n1_m1_172000_537600 0.892706
R14938 n1_m1_172800_537600 n1_m1_177600_537600 5.356235
R14939 n1_m1_177600_537600 n1_m1_182400_537600 5.356235
R14940 n1_m1_182400_537600 n1_m1_187200_537600 5.356235
R14941 n1_m1_187200_537600 n1_m1_192000_537600 5.356235
R14942 n1_m1_192000_537600 n1_m1_196800_537600 5.356235
R14943 n1_m1_196800_537600 n1_m1_200000_537600 3.570824
R14944 n1_m1_201600_537600 n1_m1_200000_537600 1.785412
R14945 n1_m1_201600_537600 n1_m1_206400_537600 5.356235
R14946 n1_m1_206400_537600 n1_m1_211200_537600 5.356235
R14947 n1_m1_211200_537600 n1_m1_216000_537600 5.356235
R14948 n1_m1_216000_537600 n1_m1_220800_537600 5.356235
R14949 n1_m1_220800_537600 n1_m1_225600_537600 5.356235
R14950 n1_m1_225600_537600 n1_m1_228000_537600 2.678118
R14951 n1_m1_230400_537600 n1_m1_228000_537600 2.678118
R14952 n1_m1_230400_537600 n1_m1_235200_537600 5.356235
R14953 n1_m1_235200_537600 n1_m1_240000_537600 5.356235
R14954 n1_m1_240000_537600 n1_m1_244800_537600 5.356235
R14955 n1_m1_244800_537600 n1_m1_249600_537600 5.356235
R14956 n1_m1_249600_537600 n1_m1_254400_537600 5.356235
R14957 n1_m1_254400_537600 n1_m1_256000_537600 1.785412
R14958 n1_m1_259200_537600 n1_m1_256000_537600 3.570824
R14959 n1_m1_259200_537600 n1_m1_264000_537600 5.356235
R14960 n1_m1_264000_537600 n1_m1_268800_537600 5.356235
R14961 n1_m1_268800_537600 n1_m1_273600_537600 5.356235
R14962 n1_m1_273600_537600 n1_m1_278400_537600 5.356235
R14963 n1_m1_278400_537600 n1_m1_283200_537600 5.356235
R14964 n1_m1_283200_537600 n1_m1_284000_537600 0.892706
R14965 n1_m1_288000_537600 n1_m1_284000_537600 4.463529
R14966 n1_m1_288000_537600 n1_m1_292800_537600 5.356235
R14967 n1_m1_292800_537600 n1_m1_297600_537600 5.356235
R14968 n1_m1_297600_537600 n1_m1_302400_537600 5.356235
R14969 n1_m1_302400_537600 n1_m1_307200_537600 5.356235
R14970 n1_m1_307200_537600 n1_m1_312000_537600 5.356235
R14971 n1_m1_312000_537600 n1_m1_316800_537600 5.356235
R14972 n1_m1_316800_537600 n1_m1_321600_537600 5.356235
R14973 n1_m1_321600_537600 n1_m1_326400_537600 5.356235
R14974 n1_m1_326400_537600 n1_m1_331200_537600 5.356235
R14975 n1_m1_331200_537600 n1_m1_336000_537600 5.356235
R14976 n1_m1_336000_537600 n1_m1_340000_537600 4.463529
R14977 n1_m1_340800_537600 n1_m1_340000_537600 0.892706
R14978 n1_m1_340800_537600 n1_m1_345600_537600 5.356235
R14979 n1_m1_345600_537600 n1_m1_350400_537600 5.356235
R14980 n1_m1_350400_537600 n1_m1_355200_537600 5.356235
R14981 n1_m1_355200_537600 n1_m1_360000_537600 5.356235
R14982 n1_m1_360000_537600 n1_m1_364800_537600 5.356235
R14983 n1_m1_364800_537600 n1_m1_368000_537600 3.570824
R14984 n1_m1_369600_537600 n1_m1_368000_537600 1.785412
R14985 n1_m1_369600_537600 n1_m1_374400_537600 5.356235
R14986 n1_m1_374400_537600 n1_m1_379200_537600 5.356235
R14987 n1_m1_379200_537600 n1_m1_384000_537600 5.356235
R14988 n1_m1_384000_537600 n1_m1_388800_537600 5.356235
R14989 n1_m1_388800_537600 n1_m1_393600_537600 5.356235
R14990 n1_m1_393600_537600 n1_m1_396000_537600 2.678118
R14991 n1_m1_398400_537600 n1_m1_396000_537600 2.678118
R14992 n1_m1_398400_537600 n1_m1_403200_537600 5.356235
R14993 n1_m1_403200_537600 n1_m1_408000_537600 5.356235
R14994 n1_m1_408000_537600 n1_m1_412800_537600 5.356235
R14995 n1_m1_412800_537600 n1_m1_417600_537600 5.356235
R14996 n1_m1_417600_537600 n1_m1_422400_537600 5.356235
R14997 n1_m1_422400_537600 n1_m1_424000_537600 1.785412
R14998 n1_m1_427200_537600 n1_m1_424000_537600 3.570824
R14999 n1_m1_427200_537600 n1_m1_432000_537600 5.356235
R15000 n1_m1_432000_537600 n1_m1_436800_537600 5.356235
R15001 n1_m1_436800_537600 n1_m1_441600_537600 5.356235
R15002 n1_m1_441600_537600 n1_m1_446400_537600 5.356235
R15003 n1_m1_446400_537600 n1_m1_451200_537600 5.356235
R15004 n1_m1_451200_537600 n1_m1_452000_537600 0.892706
R15005 n1_m1_456000_537600 n1_m1_452000_537600 4.463529
R15006 n1_m1_456000_537600 n1_m1_460800_537600 5.356235
R15007 n1_m1_460800_537600 n1_m1_465600_537600 5.356235
R15008 n1_m1_465600_537600 n1_m1_470400_537600 5.356235
R15009 n1_m1_470400_537600 n1_m1_475200_537600 5.356235
R15010 n1_m1_475200_537600 n1_m1_480000_537600 5.356235
R15011 n1_m1_480000_537600 n1_m1_484800_537600 5.356235
R15012 n1_m1_484800_537600 n1_m1_489600_537600 5.356235
R15013 n1_m1_489600_537600 n1_m1_494400_537600 5.356235
R15014 n1_m1_494400_537600 n1_m1_499200_537600 5.356235
R15015 n1_m1_499200_537600 n1_m1_504000_537600 5.356235
R15016 n1_m1_504000_537600 n1_m1_508000_537600 4.463529
R15017 n1_m1_508800_537600 n1_m1_508000_537600 0.892706
R15018 n1_m1_508800_537600 n1_m1_513600_537600 5.356235
R15019 n1_m1_513600_537600 n1_m1_518400_537600 5.356235
R15020 n1_m1_518400_537600 n1_m1_523200_537600 5.356235
R15021 n1_m1_523200_537600 n1_m1_528000_537600 5.356235
R15022 n1_m1_528000_537600 n1_m1_532800_537600 5.356235
R15023 n1_m1_532800_537600 n1_m1_536000_537600 3.570824
R15024 n1_m1_537600_537600 n1_m1_536000_537600 1.785412
R15025 n1_m1_537600_537600 n1_m1_542400_537600 5.356235
R15026 n1_m1_542400_537600 n1_m1_547200_537600 5.356235
R15027 n1_m1_547200_537600 n1_m1_552000_537600 5.356235
R15028 n1_m1_552000_537600 n1_m1_556800_537600 5.356235
R15029 n1_m1_0_542400 n1_m1_4000_542400 4.463529
R15030 n1_m1_4800_542400 n1_m1_4000_542400 0.892706
R15031 n1_m1_4800_542400 n1_m1_9600_542400 5.356235
R15032 n1_m1_9600_542400 n1_m1_14400_542400 5.356235
R15033 n1_m1_14400_542400 n1_m1_19200_542400 5.356235
R15034 n1_m1_19200_542400 n1_m1_24000_542400 5.356235
R15035 n1_m1_24000_542400 n1_m1_28800_542400 5.356235
R15036 n1_m1_28800_542400 n1_m1_32000_542400 3.570824
R15037 n1_m1_33600_542400 n1_m1_32000_542400 1.785412
R15038 n1_m1_33600_542400 n1_m1_38400_542400 5.356235
R15039 n1_m1_38400_542400 n1_m1_43200_542400 5.356235
R15040 n1_m1_43200_542400 n1_m1_48000_542400 5.356235
R15041 n1_m1_48000_542400 n1_m1_52800_542400 5.356235
R15042 n1_m1_52800_542400 n1_m1_57600_542400 5.356235
R15043 n1_m1_57600_542400 n1_m1_60000_542400 2.678118
R15044 n1_m1_62400_542400 n1_m1_60000_542400 2.678118
R15045 n1_m1_62400_542400 n1_m1_67200_542400 5.356235
R15046 n1_m1_67200_542400 n1_m1_72000_542400 5.356235
R15047 n1_m1_72000_542400 n1_m1_76800_542400 5.356235
R15048 n1_m1_76800_542400 n1_m1_81600_542400 5.356235
R15049 n1_m1_81600_542400 n1_m1_86400_542400 5.356235
R15050 n1_m1_86400_542400 n1_m1_88000_542400 1.785412
R15051 n1_m1_91200_542400 n1_m1_88000_542400 3.570824
R15052 n1_m1_91200_542400 n1_m1_96000_542400 5.356235
R15053 n1_m1_96000_542400 n1_m1_100800_542400 5.356235
R15054 n1_m1_100800_542400 n1_m1_105600_542400 5.356235
R15055 n1_m1_105600_542400 n1_m1_110400_542400 5.356235
R15056 n1_m1_110400_542400 n1_m1_115200_542400 5.356235
R15057 n1_m1_115200_542400 n1_m1_116000_542400 0.892706
R15058 n1_m1_120000_542400 n1_m1_116000_542400 4.463529
R15059 n1_m1_120000_542400 n1_m1_124800_542400 5.356235
R15060 n1_m1_124800_542400 n1_m1_129600_542400 5.356235
R15061 n1_m1_129600_542400 n1_m1_134400_542400 5.356235
R15062 n1_m1_134400_542400 n1_m1_139200_542400 5.356235
R15063 n1_m1_139200_542400 n1_m1_144000_542400 5.356235
R15064 n1_m1_144000_542400 n1_m1_148800_542400 5.356235
R15065 n1_m1_148800_542400 n1_m1_153600_542400 5.356235
R15066 n1_m1_153600_542400 n1_m1_158400_542400 5.356235
R15067 n1_m1_158400_542400 n1_m1_163200_542400 5.356235
R15068 n1_m1_163200_542400 n1_m1_168000_542400 5.356235
R15069 n1_m1_168000_542400 n1_m1_172000_542400 4.463529
R15070 n1_m1_172800_542400 n1_m1_172000_542400 0.892706
R15071 n1_m1_172800_542400 n1_m1_177600_542400 5.356235
R15072 n1_m1_177600_542400 n1_m1_182400_542400 5.356235
R15073 n1_m1_182400_542400 n1_m1_187200_542400 5.356235
R15074 n1_m1_187200_542400 n1_m1_192000_542400 5.356235
R15075 n1_m1_192000_542400 n1_m1_196800_542400 5.356235
R15076 n1_m1_196800_542400 n1_m1_200000_542400 3.570824
R15077 n1_m1_201600_542400 n1_m1_200000_542400 1.785412
R15078 n1_m1_201600_542400 n1_m1_206400_542400 5.356235
R15079 n1_m1_206400_542400 n1_m1_211200_542400 5.356235
R15080 n1_m1_211200_542400 n1_m1_216000_542400 5.356235
R15081 n1_m1_216000_542400 n1_m1_220800_542400 5.356235
R15082 n1_m1_220800_542400 n1_m1_225600_542400 5.356235
R15083 n1_m1_225600_542400 n1_m1_228000_542400 2.678118
R15084 n1_m1_230400_542400 n1_m1_228000_542400 2.678118
R15085 n1_m1_230400_542400 n1_m1_235200_542400 5.356235
R15086 n1_m1_235200_542400 n1_m1_240000_542400 5.356235
R15087 n1_m1_240000_542400 n1_m1_244800_542400 5.356235
R15088 n1_m1_244800_542400 n1_m1_249600_542400 5.356235
R15089 n1_m1_249600_542400 n1_m1_254400_542400 5.356235
R15090 n1_m1_254400_542400 n1_m1_256000_542400 1.785412
R15091 n1_m1_259200_542400 n1_m1_256000_542400 3.570824
R15092 n1_m1_259200_542400 n1_m1_264000_542400 5.356235
R15093 n1_m1_264000_542400 n1_m1_268800_542400 5.356235
R15094 n1_m1_268800_542400 n1_m1_273600_542400 5.356235
R15095 n1_m1_273600_542400 n1_m1_278400_542400 5.356235
R15096 n1_m1_278400_542400 n1_m1_283200_542400 5.356235
R15097 n1_m1_283200_542400 n1_m1_284000_542400 0.892706
R15098 n1_m1_288000_542400 n1_m1_284000_542400 4.463529
R15099 n1_m1_288000_542400 n1_m1_292800_542400 5.356235
R15100 n1_m1_292800_542400 n1_m1_297600_542400 5.356235
R15101 n1_m1_297600_542400 n1_m1_302400_542400 5.356235
R15102 n1_m1_302400_542400 n1_m1_307200_542400 5.356235
R15103 n1_m1_307200_542400 n1_m1_312000_542400 5.356235
R15104 n1_m1_312000_542400 n1_m1_316800_542400 5.356235
R15105 n1_m1_316800_542400 n1_m1_321600_542400 5.356235
R15106 n1_m1_321600_542400 n1_m1_326400_542400 5.356235
R15107 n1_m1_326400_542400 n1_m1_331200_542400 5.356235
R15108 n1_m1_331200_542400 n1_m1_336000_542400 5.356235
R15109 n1_m1_336000_542400 n1_m1_340000_542400 4.463529
R15110 n1_m1_340800_542400 n1_m1_340000_542400 0.892706
R15111 n1_m1_340800_542400 n1_m1_345600_542400 5.356235
R15112 n1_m1_345600_542400 n1_m1_350400_542400 5.356235
R15113 n1_m1_350400_542400 n1_m1_355200_542400 5.356235
R15114 n1_m1_355200_542400 n1_m1_360000_542400 5.356235
R15115 n1_m1_360000_542400 n1_m1_364800_542400 5.356235
R15116 n1_m1_364800_542400 n1_m1_368000_542400 3.570824
R15117 n1_m1_369600_542400 n1_m1_368000_542400 1.785412
R15118 n1_m1_369600_542400 n1_m1_374400_542400 5.356235
R15119 n1_m1_374400_542400 n1_m1_379200_542400 5.356235
R15120 n1_m1_379200_542400 n1_m1_384000_542400 5.356235
R15121 n1_m1_384000_542400 n1_m1_388800_542400 5.356235
R15122 n1_m1_388800_542400 n1_m1_393600_542400 5.356235
R15123 n1_m1_393600_542400 n1_m1_396000_542400 2.678118
R15124 n1_m1_398400_542400 n1_m1_396000_542400 2.678118
R15125 n1_m1_398400_542400 n1_m1_403200_542400 5.356235
R15126 n1_m1_403200_542400 n1_m1_408000_542400 5.356235
R15127 n1_m1_408000_542400 n1_m1_412800_542400 5.356235
R15128 n1_m1_412800_542400 n1_m1_417600_542400 5.356235
R15129 n1_m1_417600_542400 n1_m1_422400_542400 5.356235
R15130 n1_m1_422400_542400 n1_m1_424000_542400 1.785412
R15131 n1_m1_427200_542400 n1_m1_424000_542400 3.570824
R15132 n1_m1_427200_542400 n1_m1_432000_542400 5.356235
R15133 n1_m1_432000_542400 n1_m1_436800_542400 5.356235
R15134 n1_m1_436800_542400 n1_m1_441600_542400 5.356235
R15135 n1_m1_441600_542400 n1_m1_446400_542400 5.356235
R15136 n1_m1_446400_542400 n1_m1_451200_542400 5.356235
R15137 n1_m1_451200_542400 n1_m1_452000_542400 0.892706
R15138 n1_m1_456000_542400 n1_m1_452000_542400 4.463529
R15139 n1_m1_456000_542400 n1_m1_460800_542400 5.356235
R15140 n1_m1_460800_542400 n1_m1_465600_542400 5.356235
R15141 n1_m1_465600_542400 n1_m1_470400_542400 5.356235
R15142 n1_m1_470400_542400 n1_m1_475200_542400 5.356235
R15143 n1_m1_475200_542400 n1_m1_480000_542400 5.356235
R15144 n1_m1_480000_542400 n1_m1_484800_542400 5.356235
R15145 n1_m1_484800_542400 n1_m1_489600_542400 5.356235
R15146 n1_m1_489600_542400 n1_m1_494400_542400 5.356235
R15147 n1_m1_494400_542400 n1_m1_499200_542400 5.356235
R15148 n1_m1_499200_542400 n1_m1_504000_542400 5.356235
R15149 n1_m1_504000_542400 n1_m1_508000_542400 4.463529
R15150 n1_m1_508800_542400 n1_m1_508000_542400 0.892706
R15151 n1_m1_508800_542400 n1_m1_513600_542400 5.356235
R15152 n1_m1_513600_542400 n1_m1_518400_542400 5.356235
R15153 n1_m1_518400_542400 n1_m1_523200_542400 5.356235
R15154 n1_m1_523200_542400 n1_m1_528000_542400 5.356235
R15155 n1_m1_528000_542400 n1_m1_532800_542400 5.356235
R15156 n1_m1_532800_542400 n1_m1_536000_542400 3.570824
R15157 n1_m1_537600_542400 n1_m1_536000_542400 1.785412
R15158 n1_m1_537600_542400 n1_m1_542400_542400 5.356235
R15159 n1_m1_542400_542400 n1_m1_547200_542400 5.356235
R15160 n1_m1_547200_542400 n1_m1_552000_542400 5.356235
R15161 n1_m1_552000_542400 n1_m1_556800_542400 5.356235
R15162 n1_m1_0_547200 n1_m1_4000_547200 4.463529
R15163 n1_m1_4800_547200 n1_m1_4000_547200 0.892706
R15164 n1_m1_4800_547200 n1_m1_9600_547200 5.356235
R15165 n1_m1_9600_547200 n1_m1_14400_547200 5.356235
R15166 n1_m1_14400_547200 n1_m1_19200_547200 5.356235
R15167 n1_m1_19200_547200 n1_m1_24000_547200 5.356235
R15168 n1_m1_24000_547200 n1_m1_28800_547200 5.356235
R15169 n1_m1_28800_547200 n1_m1_32000_547200 3.570824
R15170 n1_m1_33600_547200 n1_m1_32000_547200 1.785412
R15171 n1_m1_33600_547200 n1_m1_38400_547200 5.356235
R15172 n1_m1_38400_547200 n1_m1_43200_547200 5.356235
R15173 n1_m1_43200_547200 n1_m1_48000_547200 5.356235
R15174 n1_m1_48000_547200 n1_m1_52800_547200 5.356235
R15175 n1_m1_52800_547200 n1_m1_57600_547200 5.356235
R15176 n1_m1_57600_547200 n1_m1_60000_547200 2.678118
R15177 n1_m1_62400_547200 n1_m1_60000_547200 2.678118
R15178 n1_m1_62400_547200 n1_m1_67200_547200 5.356235
R15179 n1_m1_67200_547200 n1_m1_72000_547200 5.356235
R15180 n1_m1_72000_547200 n1_m1_76800_547200 5.356235
R15181 n1_m1_76800_547200 n1_m1_81600_547200 5.356235
R15182 n1_m1_81600_547200 n1_m1_86400_547200 5.356235
R15183 n1_m1_86400_547200 n1_m1_88000_547200 1.785412
R15184 n1_m1_91200_547200 n1_m1_88000_547200 3.570824
R15185 n1_m1_91200_547200 n1_m1_96000_547200 5.356235
R15186 n1_m1_96000_547200 n1_m1_100800_547200 5.356235
R15187 n1_m1_100800_547200 n1_m1_105600_547200 5.356235
R15188 n1_m1_105600_547200 n1_m1_110400_547200 5.356235
R15189 n1_m1_110400_547200 n1_m1_115200_547200 5.356235
R15190 n1_m1_115200_547200 n1_m1_116000_547200 0.892706
R15191 n1_m1_120000_547200 n1_m1_116000_547200 4.463529
R15192 n1_m1_120000_547200 n1_m1_124800_547200 5.356235
R15193 n1_m1_124800_547200 n1_m1_129600_547200 5.356235
R15194 n1_m1_129600_547200 n1_m1_134400_547200 5.356235
R15195 n1_m1_134400_547200 n1_m1_139200_547200 5.356235
R15196 n1_m1_139200_547200 n1_m1_144000_547200 5.356235
R15197 n1_m1_144000_547200 n1_m1_148800_547200 5.356235
R15198 n1_m1_148800_547200 n1_m1_153600_547200 5.356235
R15199 n1_m1_153600_547200 n1_m1_158400_547200 5.356235
R15200 n1_m1_158400_547200 n1_m1_163200_547200 5.356235
R15201 n1_m1_163200_547200 n1_m1_168000_547200 5.356235
R15202 n1_m1_168000_547200 n1_m1_172000_547200 4.463529
R15203 n1_m1_172800_547200 n1_m1_172000_547200 0.892706
R15204 n1_m1_172800_547200 n1_m1_177600_547200 5.356235
R15205 n1_m1_177600_547200 n1_m1_182400_547200 5.356235
R15206 n1_m1_182400_547200 n1_m1_187200_547200 5.356235
R15207 n1_m1_187200_547200 n1_m1_192000_547200 5.356235
R15208 n1_m1_192000_547200 n1_m1_196800_547200 5.356235
R15209 n1_m1_196800_547200 n1_m1_200000_547200 3.570824
R15210 n1_m1_201600_547200 n1_m1_200000_547200 1.785412
R15211 n1_m1_201600_547200 n1_m1_206400_547200 5.356235
R15212 n1_m1_206400_547200 n1_m1_211200_547200 5.356235
R15213 n1_m1_211200_547200 n1_m1_216000_547200 5.356235
R15214 n1_m1_216000_547200 n1_m1_220800_547200 5.356235
R15215 n1_m1_220800_547200 n1_m1_225600_547200 5.356235
R15216 n1_m1_225600_547200 n1_m1_228000_547200 2.678118
R15217 n1_m1_230400_547200 n1_m1_228000_547200 2.678118
R15218 n1_m1_230400_547200 n1_m1_235200_547200 5.356235
R15219 n1_m1_235200_547200 n1_m1_240000_547200 5.356235
R15220 n1_m1_240000_547200 n1_m1_244800_547200 5.356235
R15221 n1_m1_244800_547200 n1_m1_249600_547200 5.356235
R15222 n1_m1_249600_547200 n1_m1_254400_547200 5.356235
R15223 n1_m1_254400_547200 n1_m1_256000_547200 1.785412
R15224 n1_m1_259200_547200 n1_m1_256000_547200 3.570824
R15225 n1_m1_259200_547200 n1_m1_264000_547200 5.356235
R15226 n1_m1_264000_547200 n1_m1_268800_547200 5.356235
R15227 n1_m1_268800_547200 n1_m1_273600_547200 5.356235
R15228 n1_m1_273600_547200 n1_m1_278400_547200 5.356235
R15229 n1_m1_278400_547200 n1_m1_283200_547200 5.356235
R15230 n1_m1_283200_547200 n1_m1_284000_547200 0.892706
R15231 n1_m1_288000_547200 n1_m1_284000_547200 4.463529
R15232 n1_m1_288000_547200 n1_m1_292800_547200 5.356235
R15233 n1_m1_292800_547200 n1_m1_297600_547200 5.356235
R15234 n1_m1_297600_547200 n1_m1_302400_547200 5.356235
R15235 n1_m1_302400_547200 n1_m1_307200_547200 5.356235
R15236 n1_m1_307200_547200 n1_m1_312000_547200 5.356235
R15237 n1_m1_312000_547200 n1_m1_316800_547200 5.356235
R15238 n1_m1_316800_547200 n1_m1_321600_547200 5.356235
R15239 n1_m1_321600_547200 n1_m1_326400_547200 5.356235
R15240 n1_m1_326400_547200 n1_m1_331200_547200 5.356235
R15241 n1_m1_331200_547200 n1_m1_336000_547200 5.356235
R15242 n1_m1_336000_547200 n1_m1_340000_547200 4.463529
R15243 n1_m1_340800_547200 n1_m1_340000_547200 0.892706
R15244 n1_m1_340800_547200 n1_m1_345600_547200 5.356235
R15245 n1_m1_345600_547200 n1_m1_350400_547200 5.356235
R15246 n1_m1_350400_547200 n1_m1_355200_547200 5.356235
R15247 n1_m1_355200_547200 n1_m1_360000_547200 5.356235
R15248 n1_m1_360000_547200 n1_m1_364800_547200 5.356235
R15249 n1_m1_364800_547200 n1_m1_368000_547200 3.570824
R15250 n1_m1_369600_547200 n1_m1_368000_547200 1.785412
R15251 n1_m1_369600_547200 n1_m1_374400_547200 5.356235
R15252 n1_m1_374400_547200 n1_m1_379200_547200 5.356235
R15253 n1_m1_379200_547200 n1_m1_384000_547200 5.356235
R15254 n1_m1_384000_547200 n1_m1_388800_547200 5.356235
R15255 n1_m1_388800_547200 n1_m1_393600_547200 5.356235
R15256 n1_m1_393600_547200 n1_m1_396000_547200 2.678118
R15257 n1_m1_398400_547200 n1_m1_396000_547200 2.678118
R15258 n1_m1_398400_547200 n1_m1_403200_547200 5.356235
R15259 n1_m1_403200_547200 n1_m1_408000_547200 5.356235
R15260 n1_m1_408000_547200 n1_m1_412800_547200 5.356235
R15261 n1_m1_412800_547200 n1_m1_417600_547200 5.356235
R15262 n1_m1_417600_547200 n1_m1_422400_547200 5.356235
R15263 n1_m1_422400_547200 n1_m1_424000_547200 1.785412
R15264 n1_m1_427200_547200 n1_m1_424000_547200 3.570824
R15265 n1_m1_427200_547200 n1_m1_432000_547200 5.356235
R15266 n1_m1_432000_547200 n1_m1_436800_547200 5.356235
R15267 n1_m1_436800_547200 n1_m1_441600_547200 5.356235
R15268 n1_m1_441600_547200 n1_m1_446400_547200 5.356235
R15269 n1_m1_446400_547200 n1_m1_451200_547200 5.356235
R15270 n1_m1_451200_547200 n1_m1_452000_547200 0.892706
R15271 n1_m1_456000_547200 n1_m1_452000_547200 4.463529
R15272 n1_m1_456000_547200 n1_m1_460800_547200 5.356235
R15273 n1_m1_460800_547200 n1_m1_465600_547200 5.356235
R15274 n1_m1_465600_547200 n1_m1_470400_547200 5.356235
R15275 n1_m1_470400_547200 n1_m1_475200_547200 5.356235
R15276 n1_m1_475200_547200 n1_m1_480000_547200 5.356235
R15277 n1_m1_480000_547200 n1_m1_484800_547200 5.356235
R15278 n1_m1_484800_547200 n1_m1_489600_547200 5.356235
R15279 n1_m1_489600_547200 n1_m1_494400_547200 5.356235
R15280 n1_m1_494400_547200 n1_m1_499200_547200 5.356235
R15281 n1_m1_499200_547200 n1_m1_504000_547200 5.356235
R15282 n1_m1_504000_547200 n1_m1_508000_547200 4.463529
R15283 n1_m1_508800_547200 n1_m1_508000_547200 0.892706
R15284 n1_m1_508800_547200 n1_m1_513600_547200 5.356235
R15285 n1_m1_513600_547200 n1_m1_518400_547200 5.356235
R15286 n1_m1_518400_547200 n1_m1_523200_547200 5.356235
R15287 n1_m1_523200_547200 n1_m1_528000_547200 5.356235
R15288 n1_m1_528000_547200 n1_m1_532800_547200 5.356235
R15289 n1_m1_532800_547200 n1_m1_536000_547200 3.570824
R15290 n1_m1_537600_547200 n1_m1_536000_547200 1.785412
R15291 n1_m1_537600_547200 n1_m1_542400_547200 5.356235
R15292 n1_m1_542400_547200 n1_m1_547200_547200 5.356235
R15293 n1_m1_547200_547200 n1_m1_552000_547200 5.356235
R15294 n1_m1_552000_547200 n1_m1_556800_547200 5.356235
R15295 n1_m1_0_552000 n1_m1_4000_552000 4.463529
R15296 n1_m1_4800_552000 n1_m1_4000_552000 0.892706
R15297 n1_m1_4800_552000 n1_m1_9600_552000 5.356235
R15298 n1_m1_9600_552000 n1_m1_14400_552000 5.356235
R15299 n1_m1_14400_552000 n1_m1_19200_552000 5.356235
R15300 n1_m1_19200_552000 n1_m1_24000_552000 5.356235
R15301 n1_m1_24000_552000 n1_m1_28800_552000 5.356235
R15302 n1_m1_28800_552000 n1_m1_32000_552000 3.570824
R15303 n1_m1_33600_552000 n1_m1_32000_552000 1.785412
R15304 n1_m1_33600_552000 n1_m1_38400_552000 5.356235
R15305 n1_m1_38400_552000 n1_m1_43200_552000 5.356235
R15306 n1_m1_43200_552000 n1_m1_48000_552000 5.356235
R15307 n1_m1_48000_552000 n1_m1_52800_552000 5.356235
R15308 n1_m1_52800_552000 n1_m1_57600_552000 5.356235
R15309 n1_m1_57600_552000 n1_m1_60000_552000 2.678118
R15310 n1_m1_62400_552000 n1_m1_60000_552000 2.678118
R15311 n1_m1_62400_552000 n1_m1_67200_552000 5.356235
R15312 n1_m1_67200_552000 n1_m1_72000_552000 5.356235
R15313 n1_m1_72000_552000 n1_m1_76800_552000 5.356235
R15314 n1_m1_76800_552000 n1_m1_81600_552000 5.356235
R15315 n1_m1_81600_552000 n1_m1_86400_552000 5.356235
R15316 n1_m1_86400_552000 n1_m1_88000_552000 1.785412
R15317 n1_m1_91200_552000 n1_m1_88000_552000 3.570824
R15318 n1_m1_91200_552000 n1_m1_96000_552000 5.356235
R15319 n1_m1_96000_552000 n1_m1_100800_552000 5.356235
R15320 n1_m1_100800_552000 n1_m1_105600_552000 5.356235
R15321 n1_m1_105600_552000 n1_m1_110400_552000 5.356235
R15322 n1_m1_110400_552000 n1_m1_115200_552000 5.356235
R15323 n1_m1_115200_552000 n1_m1_116000_552000 0.892706
R15324 n1_m1_120000_552000 n1_m1_116000_552000 4.463529
R15325 n1_m1_120000_552000 n1_m1_124800_552000 5.356235
R15326 n1_m1_124800_552000 n1_m1_129600_552000 5.356235
R15327 n1_m1_129600_552000 n1_m1_134400_552000 5.356235
R15328 n1_m1_134400_552000 n1_m1_139200_552000 5.356235
R15329 n1_m1_139200_552000 n1_m1_144000_552000 5.356235
R15330 n1_m1_144000_552000 n1_m1_148800_552000 5.356235
R15331 n1_m1_148800_552000 n1_m1_153600_552000 5.356235
R15332 n1_m1_153600_552000 n1_m1_158400_552000 5.356235
R15333 n1_m1_158400_552000 n1_m1_163200_552000 5.356235
R15334 n1_m1_163200_552000 n1_m1_168000_552000 5.356235
R15335 n1_m1_168000_552000 n1_m1_172000_552000 4.463529
R15336 n1_m1_172800_552000 n1_m1_172000_552000 0.892706
R15337 n1_m1_172800_552000 n1_m1_177600_552000 5.356235
R15338 n1_m1_177600_552000 n1_m1_182400_552000 5.356235
R15339 n1_m1_182400_552000 n1_m1_187200_552000 5.356235
R15340 n1_m1_187200_552000 n1_m1_192000_552000 5.356235
R15341 n1_m1_192000_552000 n1_m1_196800_552000 5.356235
R15342 n1_m1_196800_552000 n1_m1_200000_552000 3.570824
R15343 n1_m1_201600_552000 n1_m1_200000_552000 1.785412
R15344 n1_m1_201600_552000 n1_m1_206400_552000 5.356235
R15345 n1_m1_206400_552000 n1_m1_211200_552000 5.356235
R15346 n1_m1_211200_552000 n1_m1_216000_552000 5.356235
R15347 n1_m1_216000_552000 n1_m1_220800_552000 5.356235
R15348 n1_m1_220800_552000 n1_m1_225600_552000 5.356235
R15349 n1_m1_225600_552000 n1_m1_228000_552000 2.678118
R15350 n1_m1_230400_552000 n1_m1_228000_552000 2.678118
R15351 n1_m1_230400_552000 n1_m1_235200_552000 5.356235
R15352 n1_m1_235200_552000 n1_m1_240000_552000 5.356235
R15353 n1_m1_240000_552000 n1_m1_244800_552000 5.356235
R15354 n1_m1_244800_552000 n1_m1_249600_552000 5.356235
R15355 n1_m1_249600_552000 n1_m1_254400_552000 5.356235
R15356 n1_m1_254400_552000 n1_m1_256000_552000 1.785412
R15357 n1_m1_259200_552000 n1_m1_256000_552000 3.570824
R15358 n1_m1_259200_552000 n1_m1_264000_552000 5.356235
R15359 n1_m1_264000_552000 n1_m1_268800_552000 5.356235
R15360 n1_m1_268800_552000 n1_m1_273600_552000 5.356235
R15361 n1_m1_273600_552000 n1_m1_278400_552000 5.356235
R15362 n1_m1_278400_552000 n1_m1_283200_552000 5.356235
R15363 n1_m1_283200_552000 n1_m1_284000_552000 0.892706
R15364 n1_m1_288000_552000 n1_m1_284000_552000 4.463529
R15365 n1_m1_288000_552000 n1_m1_292800_552000 5.356235
R15366 n1_m1_292800_552000 n1_m1_297600_552000 5.356235
R15367 n1_m1_297600_552000 n1_m1_302400_552000 5.356235
R15368 n1_m1_302400_552000 n1_m1_307200_552000 5.356235
R15369 n1_m1_307200_552000 n1_m1_312000_552000 5.356235
R15370 n1_m1_312000_552000 n1_m1_316800_552000 5.356235
R15371 n1_m1_316800_552000 n1_m1_321600_552000 5.356235
R15372 n1_m1_321600_552000 n1_m1_326400_552000 5.356235
R15373 n1_m1_326400_552000 n1_m1_331200_552000 5.356235
R15374 n1_m1_331200_552000 n1_m1_336000_552000 5.356235
R15375 n1_m1_336000_552000 n1_m1_340000_552000 4.463529
R15376 n1_m1_340800_552000 n1_m1_340000_552000 0.892706
R15377 n1_m1_340800_552000 n1_m1_345600_552000 5.356235
R15378 n1_m1_345600_552000 n1_m1_350400_552000 5.356235
R15379 n1_m1_350400_552000 n1_m1_355200_552000 5.356235
R15380 n1_m1_355200_552000 n1_m1_360000_552000 5.356235
R15381 n1_m1_360000_552000 n1_m1_364800_552000 5.356235
R15382 n1_m1_364800_552000 n1_m1_368000_552000 3.570824
R15383 n1_m1_369600_552000 n1_m1_368000_552000 1.785412
R15384 n1_m1_369600_552000 n1_m1_374400_552000 5.356235
R15385 n1_m1_374400_552000 n1_m1_379200_552000 5.356235
R15386 n1_m1_379200_552000 n1_m1_384000_552000 5.356235
R15387 n1_m1_384000_552000 n1_m1_388800_552000 5.356235
R15388 n1_m1_388800_552000 n1_m1_393600_552000 5.356235
R15389 n1_m1_393600_552000 n1_m1_396000_552000 2.678118
R15390 n1_m1_398400_552000 n1_m1_396000_552000 2.678118
R15391 n1_m1_398400_552000 n1_m1_403200_552000 5.356235
R15392 n1_m1_403200_552000 n1_m1_408000_552000 5.356235
R15393 n1_m1_408000_552000 n1_m1_412800_552000 5.356235
R15394 n1_m1_412800_552000 n1_m1_417600_552000 5.356235
R15395 n1_m1_417600_552000 n1_m1_422400_552000 5.356235
R15396 n1_m1_422400_552000 n1_m1_424000_552000 1.785412
R15397 n1_m1_427200_552000 n1_m1_424000_552000 3.570824
R15398 n1_m1_427200_552000 n1_m1_432000_552000 5.356235
R15399 n1_m1_432000_552000 n1_m1_436800_552000 5.356235
R15400 n1_m1_436800_552000 n1_m1_441600_552000 5.356235
R15401 n1_m1_441600_552000 n1_m1_446400_552000 5.356235
R15402 n1_m1_446400_552000 n1_m1_451200_552000 5.356235
R15403 n1_m1_451200_552000 n1_m1_452000_552000 0.892706
R15404 n1_m1_456000_552000 n1_m1_452000_552000 4.463529
R15405 n1_m1_456000_552000 n1_m1_460800_552000 5.356235
R15406 n1_m1_460800_552000 n1_m1_465600_552000 5.356235
R15407 n1_m1_465600_552000 n1_m1_470400_552000 5.356235
R15408 n1_m1_470400_552000 n1_m1_475200_552000 5.356235
R15409 n1_m1_475200_552000 n1_m1_480000_552000 5.356235
R15410 n1_m1_480000_552000 n1_m1_484800_552000 5.356235
R15411 n1_m1_484800_552000 n1_m1_489600_552000 5.356235
R15412 n1_m1_489600_552000 n1_m1_494400_552000 5.356235
R15413 n1_m1_494400_552000 n1_m1_499200_552000 5.356235
R15414 n1_m1_499200_552000 n1_m1_504000_552000 5.356235
R15415 n1_m1_504000_552000 n1_m1_508000_552000 4.463529
R15416 n1_m1_508800_552000 n1_m1_508000_552000 0.892706
R15417 n1_m1_508800_552000 n1_m1_513600_552000 5.356235
R15418 n1_m1_513600_552000 n1_m1_518400_552000 5.356235
R15419 n1_m1_518400_552000 n1_m1_523200_552000 5.356235
R15420 n1_m1_523200_552000 n1_m1_528000_552000 5.356235
R15421 n1_m1_528000_552000 n1_m1_532800_552000 5.356235
R15422 n1_m1_532800_552000 n1_m1_536000_552000 3.570824
R15423 n1_m1_537600_552000 n1_m1_536000_552000 1.785412
R15424 n1_m1_537600_552000 n1_m1_542400_552000 5.356235
R15425 n1_m1_542400_552000 n1_m1_547200_552000 5.356235
R15426 n1_m1_547200_552000 n1_m1_552000_552000 5.356235
R15427 n1_m1_552000_552000 n1_m1_556800_552000 5.356235
R15428 n1_m1_0_556800 n1_m1_4000_556800 4.463529
R15429 n1_m1_4800_556800 n1_m1_4000_556800 0.892706
R15430 n1_m1_4800_556800 n1_m1_9600_556800 5.356235
R15431 n1_m1_9600_556800 n1_m1_14400_556800 5.356235
R15432 n1_m1_14400_556800 n1_m1_19200_556800 5.356235
R15433 n1_m1_19200_556800 n1_m1_24000_556800 5.356235
R15434 n1_m1_24000_556800 n1_m1_28800_556800 5.356235
R15435 n1_m1_28800_556800 n1_m1_32000_556800 3.570824
R15436 n1_m1_33600_556800 n1_m1_32000_556800 1.785412
R15437 n1_m1_33600_556800 n1_m1_38400_556800 5.356235
R15438 n1_m1_38400_556800 n1_m1_43200_556800 5.356235
R15439 n1_m1_43200_556800 n1_m1_48000_556800 5.356235
R15440 n1_m1_48000_556800 n1_m1_52800_556800 5.356235
R15441 n1_m1_52800_556800 n1_m1_57600_556800 5.356235
R15442 n1_m1_57600_556800 n1_m1_60000_556800 2.678118
R15443 n1_m1_62400_556800 n1_m1_60000_556800 2.678118
R15444 n1_m1_62400_556800 n1_m1_67200_556800 5.356235
R15445 n1_m1_67200_556800 n1_m1_72000_556800 5.356235
R15446 n1_m1_72000_556800 n1_m1_76800_556800 5.356235
R15447 n1_m1_76800_556800 n1_m1_81600_556800 5.356235
R15448 n1_m1_81600_556800 n1_m1_86400_556800 5.356235
R15449 n1_m1_86400_556800 n1_m1_88000_556800 1.785412
R15450 n1_m1_91200_556800 n1_m1_88000_556800 3.570824
R15451 n1_m1_91200_556800 n1_m1_96000_556800 5.356235
R15452 n1_m1_96000_556800 n1_m1_100800_556800 5.356235
R15453 n1_m1_100800_556800 n1_m1_105600_556800 5.356235
R15454 n1_m1_105600_556800 n1_m1_110400_556800 5.356235
R15455 n1_m1_110400_556800 n1_m1_115200_556800 5.356235
R15456 n1_m1_115200_556800 n1_m1_116000_556800 0.892706
R15457 n1_m1_120000_556800 n1_m1_116000_556800 4.463529
R15458 n1_m1_120000_556800 n1_m1_124800_556800 5.356235
R15459 n1_m1_124800_556800 n1_m1_129600_556800 5.356235
R15460 n1_m1_129600_556800 n1_m1_134400_556800 5.356235
R15461 n1_m1_134400_556800 n1_m1_139200_556800 5.356235
R15462 n1_m1_139200_556800 n1_m1_144000_556800 5.356235
R15463 n1_m1_144000_556800 n1_m1_148800_556800 5.356235
R15464 n1_m1_148800_556800 n1_m1_153600_556800 5.356235
R15465 n1_m1_153600_556800 n1_m1_158400_556800 5.356235
R15466 n1_m1_158400_556800 n1_m1_163200_556800 5.356235
R15467 n1_m1_163200_556800 n1_m1_168000_556800 5.356235
R15468 n1_m1_168000_556800 n1_m1_172000_556800 4.463529
R15469 n1_m1_172800_556800 n1_m1_172000_556800 0.892706
R15470 n1_m1_172800_556800 n1_m1_177600_556800 5.356235
R15471 n1_m1_177600_556800 n1_m1_182400_556800 5.356235
R15472 n1_m1_182400_556800 n1_m1_187200_556800 5.356235
R15473 n1_m1_187200_556800 n1_m1_192000_556800 5.356235
R15474 n1_m1_192000_556800 n1_m1_196800_556800 5.356235
R15475 n1_m1_196800_556800 n1_m1_200000_556800 3.570824
R15476 n1_m1_201600_556800 n1_m1_200000_556800 1.785412
R15477 n1_m1_201600_556800 n1_m1_206400_556800 5.356235
R15478 n1_m1_206400_556800 n1_m1_211200_556800 5.356235
R15479 n1_m1_211200_556800 n1_m1_216000_556800 5.356235
R15480 n1_m1_216000_556800 n1_m1_220800_556800 5.356235
R15481 n1_m1_220800_556800 n1_m1_225600_556800 5.356235
R15482 n1_m1_225600_556800 n1_m1_228000_556800 2.678118
R15483 n1_m1_230400_556800 n1_m1_228000_556800 2.678118
R15484 n1_m1_230400_556800 n1_m1_235200_556800 5.356235
R15485 n1_m1_235200_556800 n1_m1_240000_556800 5.356235
R15486 n1_m1_240000_556800 n1_m1_244800_556800 5.356235
R15487 n1_m1_244800_556800 n1_m1_249600_556800 5.356235
R15488 n1_m1_249600_556800 n1_m1_254400_556800 5.356235
R15489 n1_m1_254400_556800 n1_m1_256000_556800 1.785412
R15490 n1_m1_259200_556800 n1_m1_256000_556800 3.570824
R15491 n1_m1_259200_556800 n1_m1_264000_556800 5.356235
R15492 n1_m1_264000_556800 n1_m1_268800_556800 5.356235
R15493 n1_m1_268800_556800 n1_m1_273600_556800 5.356235
R15494 n1_m1_273600_556800 n1_m1_278400_556800 5.356235
R15495 n1_m1_278400_556800 n1_m1_283200_556800 5.356235
R15496 n1_m1_283200_556800 n1_m1_284000_556800 0.892706
R15497 n1_m1_288000_556800 n1_m1_284000_556800 4.463529
R15498 n1_m1_288000_556800 n1_m1_292800_556800 5.356235
R15499 n1_m1_292800_556800 n1_m1_297600_556800 5.356235
R15500 n1_m1_297600_556800 n1_m1_302400_556800 5.356235
R15501 n1_m1_302400_556800 n1_m1_307200_556800 5.356235
R15502 n1_m1_307200_556800 n1_m1_312000_556800 5.356235
R15503 n1_m1_312000_556800 n1_m1_316800_556800 5.356235
R15504 n1_m1_316800_556800 n1_m1_321600_556800 5.356235
R15505 n1_m1_321600_556800 n1_m1_326400_556800 5.356235
R15506 n1_m1_326400_556800 n1_m1_331200_556800 5.356235
R15507 n1_m1_331200_556800 n1_m1_336000_556800 5.356235
R15508 n1_m1_336000_556800 n1_m1_340000_556800 4.463529
R15509 n1_m1_340800_556800 n1_m1_340000_556800 0.892706
R15510 n1_m1_340800_556800 n1_m1_345600_556800 5.356235
R15511 n1_m1_345600_556800 n1_m1_350400_556800 5.356235
R15512 n1_m1_350400_556800 n1_m1_355200_556800 5.356235
R15513 n1_m1_355200_556800 n1_m1_360000_556800 5.356235
R15514 n1_m1_360000_556800 n1_m1_364800_556800 5.356235
R15515 n1_m1_364800_556800 n1_m1_368000_556800 3.570824
R15516 n1_m1_369600_556800 n1_m1_368000_556800 1.785412
R15517 n1_m1_369600_556800 n1_m1_374400_556800 5.356235
R15518 n1_m1_374400_556800 n1_m1_379200_556800 5.356235
R15519 n1_m1_379200_556800 n1_m1_384000_556800 5.356235
R15520 n1_m1_384000_556800 n1_m1_388800_556800 5.356235
R15521 n1_m1_388800_556800 n1_m1_393600_556800 5.356235
R15522 n1_m1_393600_556800 n1_m1_396000_556800 2.678118
R15523 n1_m1_398400_556800 n1_m1_396000_556800 2.678118
R15524 n1_m1_398400_556800 n1_m1_403200_556800 5.356235
R15525 n1_m1_403200_556800 n1_m1_408000_556800 5.356235
R15526 n1_m1_408000_556800 n1_m1_412800_556800 5.356235
R15527 n1_m1_412800_556800 n1_m1_417600_556800 5.356235
R15528 n1_m1_417600_556800 n1_m1_422400_556800 5.356235
R15529 n1_m1_422400_556800 n1_m1_424000_556800 1.785412
R15530 n1_m1_427200_556800 n1_m1_424000_556800 3.570824
R15531 n1_m1_427200_556800 n1_m1_432000_556800 5.356235
R15532 n1_m1_432000_556800 n1_m1_436800_556800 5.356235
R15533 n1_m1_436800_556800 n1_m1_441600_556800 5.356235
R15534 n1_m1_441600_556800 n1_m1_446400_556800 5.356235
R15535 n1_m1_446400_556800 n1_m1_451200_556800 5.356235
R15536 n1_m1_451200_556800 n1_m1_452000_556800 0.892706
R15537 n1_m1_456000_556800 n1_m1_452000_556800 4.463529
R15538 n1_m1_456000_556800 n1_m1_460800_556800 5.356235
R15539 n1_m1_460800_556800 n1_m1_465600_556800 5.356235
R15540 n1_m1_465600_556800 n1_m1_470400_556800 5.356235
R15541 n1_m1_470400_556800 n1_m1_475200_556800 5.356235
R15542 n1_m1_475200_556800 n1_m1_480000_556800 5.356235
R15543 n1_m1_480000_556800 n1_m1_484800_556800 5.356235
R15544 n1_m1_484800_556800 n1_m1_489600_556800 5.356235
R15545 n1_m1_489600_556800 n1_m1_494400_556800 5.356235
R15546 n1_m1_494400_556800 n1_m1_499200_556800 5.356235
R15547 n1_m1_499200_556800 n1_m1_504000_556800 5.356235
R15548 n1_m1_504000_556800 n1_m1_508000_556800 4.463529
R15549 n1_m1_508800_556800 n1_m1_508000_556800 0.892706
R15550 n1_m1_508800_556800 n1_m1_513600_556800 5.356235
R15551 n1_m1_513600_556800 n1_m1_518400_556800 5.356235
R15552 n1_m1_518400_556800 n1_m1_523200_556800 5.356235
R15553 n1_m1_523200_556800 n1_m1_528000_556800 5.356235
R15554 n1_m1_528000_556800 n1_m1_532800_556800 5.356235
R15555 n1_m1_532800_556800 n1_m1_536000_556800 3.570824
R15556 n1_m1_537600_556800 n1_m1_536000_556800 1.785412
R15557 n1_m1_537600_556800 n1_m1_542400_556800 5.356235
R15558 n1_m1_542400_556800 n1_m1_547200_556800 5.356235
R15559 n1_m1_547200_556800 n1_m1_552000_556800 5.356235
R15560 n1_m1_552000_556800 n1_m1_556800_556800 5.356235
R15561 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R15562 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R15563 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R15564 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R15565 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R15566 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R15567 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R15568 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R15569 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R15570 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R15571 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R15572 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R15573 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R15574 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R15575 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R15576 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R15577 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R15578 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R15579 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R15580 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R15581 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R15582 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R15583 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R15584 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R15585 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R15586 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R15587 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R15588 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R15589 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R15590 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R15591 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R15592 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R15593 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R15594 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R15595 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R15596 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R15597 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R15598 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R15599 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R15600 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R15601 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R15602 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R15603 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R15604 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R15605 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R15606 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R15607 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R15608 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R15609 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R15610 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R15611 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R15612 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R15613 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R15614 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R15615 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R15616 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R15617 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R15618 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R15619 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R15620 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R15621 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R15622 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R15623 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R15624 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R15625 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R15626 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R15627 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R15628 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R15629 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R15630 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R15631 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R15632 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R15633 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R15634 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R15635 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R15636 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R15637 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R15638 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R15639 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R15640 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R15641 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R15642 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R15643 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R15644 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R15645 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R15646 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R15647 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R15648 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R15649 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R15650 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R15651 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R15652 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R15653 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R15654 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R15655 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R15656 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R15657 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R15658 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R15659 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R15660 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R15661 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R15662 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R15663 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R15664 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R15665 n1_m4_4000_470400 n1_m4_4000_475200 1.400000
R15666 n1_m4_4000_475200 n1_m4_4000_480000 1.400000
R15667 n1_m4_4000_480000 n1_m4_4000_484000 1.166667
R15668 n1_m4_4000_484800 n1_m4_4000_484000 0.233333
R15669 n1_m4_4000_484800 n1_m4_4000_489600 1.400000
R15670 n1_m4_4000_489600 n1_m4_4000_494400 1.400000
R15671 n1_m4_4000_494400 n1_m4_4000_499200 1.400000
R15672 n1_m4_4000_499200 n1_m4_4000_504000 1.400000
R15673 n1_m4_4000_504000 n1_m4_4000_508800 1.400000
R15674 n1_m4_4000_508800 n1_m4_4000_513600 1.400000
R15675 n1_m4_4000_513600 n1_m4_4000_518400 1.400000
R15676 n1_m4_4000_518400 n1_m4_4000_523200 1.400000
R15677 n1_m4_4000_523200 n1_m4_4000_528000 1.400000
R15678 n1_m4_4000_528000 n1_m4_4000_532800 1.400000
R15679 n1_m4_4000_532800 n1_m4_4000_537600 1.400000
R15680 n1_m4_4000_537600 n1_m4_4000_542400 1.400000
R15681 n1_m4_4000_542400 n1_m4_4000_547200 1.400000
R15682 n1_m4_4000_547200 n1_m4_4000_552000 1.400000
R15683 n1_m4_4000_552000 n1_m4_4000_556800 1.400000
R15684 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R15685 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R15686 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R15687 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R15688 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R15689 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R15690 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R15691 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R15692 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R15693 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R15694 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R15695 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R15696 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R15697 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R15698 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R15699 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R15700 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R15701 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R15702 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R15703 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R15704 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R15705 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R15706 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R15707 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R15708 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R15709 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R15710 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R15711 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R15712 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R15713 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R15714 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R15715 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R15716 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R15717 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R15718 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R15719 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R15720 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R15721 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R15722 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R15723 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R15724 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R15725 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R15726 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R15727 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R15728 n1_m4_32000_196800 n1_m4_32000_201600 1.400000
R15729 n1_m4_32000_201600 n1_m4_32000_206400 1.400000
R15730 n1_m4_32000_206400 n1_m4_32000_211200 1.400000
R15731 n1_m4_32000_211200 n1_m4_32000_216000 1.400000
R15732 n1_m4_32000_216000 n1_m4_32000_220800 1.400000
R15733 n1_m4_32000_220800 n1_m4_32000_225600 1.400000
R15734 n1_m4_32000_225600 n1_m4_32000_230400 1.400000
R15735 n1_m4_32000_230400 n1_m4_32000_235200 1.400000
R15736 n1_m4_32000_235200 n1_m4_32000_240000 1.400000
R15737 n1_m4_32000_240000 n1_m4_32000_244000 1.166667
R15738 n1_m4_32000_244800 n1_m4_32000_244000 0.233333
R15739 n1_m4_32000_244800 n1_m4_32000_249600 1.400000
R15740 n1_m4_32000_249600 n1_m4_32000_254400 1.400000
R15741 n1_m4_32000_254400 n1_m4_32000_259200 1.400000
R15742 n1_m4_32000_259200 n1_m4_32000_264000 1.400000
R15743 n1_m4_32000_264000 n1_m4_32000_268800 1.400000
R15744 n1_m4_32000_268800 n1_m4_32000_273600 1.400000
R15745 n1_m4_32000_273600 n1_m4_32000_278400 1.400000
R15746 n1_m4_32000_278400 n1_m4_32000_283200 1.400000
R15747 n1_m4_32000_283200 n1_m4_32000_288000 1.400000
R15748 n1_m4_32000_288000 n1_m4_32000_292800 1.400000
R15749 n1_m4_32000_292800 n1_m4_32000_297600 1.400000
R15750 n1_m4_32000_297600 n1_m4_32000_302400 1.400000
R15751 n1_m4_32000_302400 n1_m4_32000_307200 1.400000
R15752 n1_m4_32000_307200 n1_m4_32000_312000 1.400000
R15753 n1_m4_32000_312000 n1_m4_32000_316800 1.400000
R15754 n1_m4_32000_316800 n1_m4_32000_321600 1.400000
R15755 n1_m4_32000_321600 n1_m4_32000_324000 0.700000
R15756 n1_m4_32000_326400 n1_m4_32000_324000 0.700000
R15757 n1_m4_32000_326400 n1_m4_32000_331200 1.400000
R15758 n1_m4_32000_331200 n1_m4_32000_336000 1.400000
R15759 n1_m4_32000_336000 n1_m4_32000_340800 1.400000
R15760 n1_m4_32000_340800 n1_m4_32000_345600 1.400000
R15761 n1_m4_32000_345600 n1_m4_32000_350400 1.400000
R15762 n1_m4_32000_350400 n1_m4_32000_355200 1.400000
R15763 n1_m4_32000_355200 n1_m4_32000_360000 1.400000
R15764 n1_m4_32000_360000 n1_m4_32000_364800 1.400000
R15765 n1_m4_32000_364800 n1_m4_32000_369600 1.400000
R15766 n1_m4_32000_369600 n1_m4_32000_374400 1.400000
R15767 n1_m4_32000_374400 n1_m4_32000_379200 1.400000
R15768 n1_m4_32000_379200 n1_m4_32000_384000 1.400000
R15769 n1_m4_32000_384000 n1_m4_32000_388800 1.400000
R15770 n1_m4_32000_388800 n1_m4_32000_393600 1.400000
R15771 n1_m4_32000_393600 n1_m4_32000_398400 1.400000
R15772 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R15773 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R15774 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R15775 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R15776 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R15777 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R15778 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R15779 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R15780 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R15781 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R15782 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R15783 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R15784 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R15785 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R15786 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R15787 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R15788 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R15789 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R15790 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R15791 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R15792 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R15793 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R15794 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R15795 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R15796 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R15797 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R15798 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R15799 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R15800 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R15801 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R15802 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R15803 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R15804 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R15805 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R15806 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R15807 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R15808 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R15809 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R15810 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R15811 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R15812 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R15813 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R15814 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R15815 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R15816 n1_m4_60000_196800 n1_m4_60000_201600 1.400000
R15817 n1_m4_60000_201600 n1_m4_60000_206400 1.400000
R15818 n1_m4_60000_206400 n1_m4_60000_211200 1.400000
R15819 n1_m4_60000_211200 n1_m4_60000_216000 1.400000
R15820 n1_m4_60000_216000 n1_m4_60000_220800 1.400000
R15821 n1_m4_60000_220800 n1_m4_60000_225600 1.400000
R15822 n1_m4_60000_225600 n1_m4_60000_230400 1.400000
R15823 n1_m4_60000_230400 n1_m4_60000_235200 1.400000
R15824 n1_m4_60000_235200 n1_m4_60000_240000 1.400000
R15825 n1_m4_60000_240000 n1_m4_60000_244000 1.166667
R15826 n1_m4_60000_244800 n1_m4_60000_244000 0.233333
R15827 n1_m4_60000_244800 n1_m4_60000_249600 1.400000
R15828 n1_m4_60000_249600 n1_m4_60000_254400 1.400000
R15829 n1_m4_60000_254400 n1_m4_60000_259200 1.400000
R15830 n1_m4_60000_259200 n1_m4_60000_264000 1.400000
R15831 n1_m4_60000_264000 n1_m4_60000_268800 1.400000
R15832 n1_m4_60000_268800 n1_m4_60000_273600 1.400000
R15833 n1_m4_60000_273600 n1_m4_60000_278400 1.400000
R15834 n1_m4_60000_278400 n1_m4_60000_283200 1.400000
R15835 n1_m4_60000_283200 n1_m4_60000_288000 1.400000
R15836 n1_m4_60000_288000 n1_m4_60000_292800 1.400000
R15837 n1_m4_60000_292800 n1_m4_60000_297600 1.400000
R15838 n1_m4_60000_297600 n1_m4_60000_302400 1.400000
R15839 n1_m4_60000_302400 n1_m4_60000_307200 1.400000
R15840 n1_m4_60000_307200 n1_m4_60000_312000 1.400000
R15841 n1_m4_60000_312000 n1_m4_60000_316800 1.400000
R15842 n1_m4_60000_316800 n1_m4_60000_321600 1.400000
R15843 n1_m4_60000_321600 n1_m4_60000_324000 0.700000
R15844 n1_m4_60000_326400 n1_m4_60000_324000 0.700000
R15845 n1_m4_60000_326400 n1_m4_60000_331200 1.400000
R15846 n1_m4_60000_331200 n1_m4_60000_336000 1.400000
R15847 n1_m4_60000_336000 n1_m4_60000_340800 1.400000
R15848 n1_m4_60000_340800 n1_m4_60000_345600 1.400000
R15849 n1_m4_60000_345600 n1_m4_60000_350400 1.400000
R15850 n1_m4_60000_350400 n1_m4_60000_355200 1.400000
R15851 n1_m4_60000_355200 n1_m4_60000_360000 1.400000
R15852 n1_m4_60000_360000 n1_m4_60000_364800 1.400000
R15853 n1_m4_60000_364800 n1_m4_60000_369600 1.400000
R15854 n1_m4_60000_369600 n1_m4_60000_374400 1.400000
R15855 n1_m4_60000_374400 n1_m4_60000_379200 1.400000
R15856 n1_m4_60000_379200 n1_m4_60000_384000 1.400000
R15857 n1_m4_60000_384000 n1_m4_60000_388800 1.400000
R15858 n1_m4_60000_388800 n1_m4_60000_393600 1.400000
R15859 n1_m4_60000_393600 n1_m4_60000_398400 1.400000
R15860 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R15861 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R15862 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R15863 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R15864 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R15865 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R15866 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R15867 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R15868 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R15869 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R15870 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R15871 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R15872 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R15873 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R15874 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R15875 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R15876 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R15877 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R15878 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R15879 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R15880 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R15881 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R15882 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R15883 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R15884 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R15885 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R15886 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R15887 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R15888 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R15889 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R15890 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R15891 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R15892 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R15893 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R15894 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R15895 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R15896 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R15897 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R15898 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R15899 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R15900 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R15901 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R15902 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R15903 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R15904 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R15905 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R15906 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R15907 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R15908 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R15909 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R15910 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R15911 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R15912 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R15913 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R15914 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R15915 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R15916 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R15917 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R15918 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R15919 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R15920 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R15921 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R15922 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R15923 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R15924 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R15925 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R15926 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R15927 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R15928 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R15929 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R15930 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R15931 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R15932 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R15933 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R15934 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R15935 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R15936 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R15937 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R15938 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R15939 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R15940 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R15941 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R15942 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R15943 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R15944 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R15945 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R15946 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R15947 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R15948 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R15949 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R15950 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R15951 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R15952 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R15953 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R15954 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R15955 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R15956 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R15957 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R15958 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R15959 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R15960 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R15961 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R15962 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R15963 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R15964 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R15965 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R15966 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R15967 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R15968 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R15969 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R15970 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R15971 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R15972 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R15973 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R15974 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R15975 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R15976 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R15977 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R15978 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R15979 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R15980 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R15981 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R15982 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R15983 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R15984 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R15985 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R15986 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R15987 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R15988 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R15989 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R15990 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R15991 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R15992 n1_m4_116000_196800 n1_m4_116000_201600 1.400000
R15993 n1_m4_116000_201600 n1_m4_116000_206400 1.400000
R15994 n1_m4_116000_206400 n1_m4_116000_211200 1.400000
R15995 n1_m4_116000_211200 n1_m4_116000_216000 1.400000
R15996 n1_m4_116000_216000 n1_m4_116000_220800 1.400000
R15997 n1_m4_116000_220800 n1_m4_116000_225600 1.400000
R15998 n1_m4_116000_225600 n1_m4_116000_230400 1.400000
R15999 n1_m4_116000_230400 n1_m4_116000_235200 1.400000
R16000 n1_m4_116000_235200 n1_m4_116000_240000 1.400000
R16001 n1_m4_116000_240000 n1_m4_116000_244000 1.166667
R16002 n1_m4_116000_244800 n1_m4_116000_244000 0.233333
R16003 n1_m4_116000_244800 n1_m4_116000_249600 1.400000
R16004 n1_m4_116000_249600 n1_m4_116000_254400 1.400000
R16005 n1_m4_116000_254400 n1_m4_116000_259200 1.400000
R16006 n1_m4_116000_259200 n1_m4_116000_264000 1.400000
R16007 n1_m4_116000_264000 n1_m4_116000_268800 1.400000
R16008 n1_m4_116000_268800 n1_m4_116000_273600 1.400000
R16009 n1_m4_116000_273600 n1_m4_116000_278400 1.400000
R16010 n1_m4_116000_278400 n1_m4_116000_283200 1.400000
R16011 n1_m4_116000_283200 n1_m4_116000_288000 1.400000
R16012 n1_m4_116000_288000 n1_m4_116000_292800 1.400000
R16013 n1_m4_116000_292800 n1_m4_116000_297600 1.400000
R16014 n1_m4_116000_297600 n1_m4_116000_302400 1.400000
R16015 n1_m4_116000_302400 n1_m4_116000_307200 1.400000
R16016 n1_m4_116000_307200 n1_m4_116000_312000 1.400000
R16017 n1_m4_116000_312000 n1_m4_116000_316800 1.400000
R16018 n1_m4_116000_316800 n1_m4_116000_321600 1.400000
R16019 n1_m4_116000_321600 n1_m4_116000_324000 0.700000
R16020 n1_m4_116000_326400 n1_m4_116000_324000 0.700000
R16021 n1_m4_116000_326400 n1_m4_116000_331200 1.400000
R16022 n1_m4_116000_331200 n1_m4_116000_336000 1.400000
R16023 n1_m4_116000_336000 n1_m4_116000_340800 1.400000
R16024 n1_m4_116000_340800 n1_m4_116000_345600 1.400000
R16025 n1_m4_116000_345600 n1_m4_116000_350400 1.400000
R16026 n1_m4_116000_350400 n1_m4_116000_355200 1.400000
R16027 n1_m4_116000_355200 n1_m4_116000_360000 1.400000
R16028 n1_m4_116000_360000 n1_m4_116000_364800 1.400000
R16029 n1_m4_116000_364800 n1_m4_116000_369600 1.400000
R16030 n1_m4_116000_369600 n1_m4_116000_374400 1.400000
R16031 n1_m4_116000_374400 n1_m4_116000_379200 1.400000
R16032 n1_m4_116000_379200 n1_m4_116000_384000 1.400000
R16033 n1_m4_116000_384000 n1_m4_116000_388800 1.400000
R16034 n1_m4_116000_388800 n1_m4_116000_393600 1.400000
R16035 n1_m4_116000_393600 n1_m4_116000_398400 1.400000
R16036 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R16037 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R16038 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R16039 n1_m4_116000_408000 n1_m4_116000_412800 1.400000
R16040 n1_m4_116000_412800 n1_m4_116000_417600 1.400000
R16041 n1_m4_116000_417600 n1_m4_116000_422400 1.400000
R16042 n1_m4_116000_422400 n1_m4_116000_427200 1.400000
R16043 n1_m4_116000_427200 n1_m4_116000_432000 1.400000
R16044 n1_m4_116000_432000 n1_m4_116000_436800 1.400000
R16045 n1_m4_116000_436800 n1_m4_116000_441600 1.400000
R16046 n1_m4_116000_441600 n1_m4_116000_446400 1.400000
R16047 n1_m4_116000_446400 n1_m4_116000_451200 1.400000
R16048 n1_m4_116000_451200 n1_m4_116000_456000 1.400000
R16049 n1_m4_116000_456000 n1_m4_116000_460800 1.400000
R16050 n1_m4_116000_460800 n1_m4_116000_465600 1.400000
R16051 n1_m4_116000_465600 n1_m4_116000_470400 1.400000
R16052 n1_m4_116000_470400 n1_m4_116000_475200 1.400000
R16053 n1_m4_116000_475200 n1_m4_116000_480000 1.400000
R16054 n1_m4_116000_480000 n1_m4_116000_484000 1.166667
R16055 n1_m4_116000_484800 n1_m4_116000_484000 0.233333
R16056 n1_m4_116000_484800 n1_m4_116000_489600 1.400000
R16057 n1_m4_116000_489600 n1_m4_116000_494400 1.400000
R16058 n1_m4_116000_494400 n1_m4_116000_499200 1.400000
R16059 n1_m4_116000_499200 n1_m4_116000_504000 1.400000
R16060 n1_m4_116000_504000 n1_m4_116000_508800 1.400000
R16061 n1_m4_116000_508800 n1_m4_116000_513600 1.400000
R16062 n1_m4_116000_513600 n1_m4_116000_518400 1.400000
R16063 n1_m4_116000_518400 n1_m4_116000_523200 1.400000
R16064 n1_m4_116000_523200 n1_m4_116000_528000 1.400000
R16065 n1_m4_116000_528000 n1_m4_116000_532800 1.400000
R16066 n1_m4_116000_532800 n1_m4_116000_537600 1.400000
R16067 n1_m4_116000_537600 n1_m4_116000_542400 1.400000
R16068 n1_m4_116000_542400 n1_m4_116000_547200 1.400000
R16069 n1_m4_116000_547200 n1_m4_116000_552000 1.400000
R16070 n1_m4_116000_552000 n1_m4_116000_556800 1.400000
R16071 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R16072 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R16073 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R16074 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R16075 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R16076 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R16077 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R16078 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R16079 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R16080 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R16081 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R16082 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R16083 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R16084 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R16085 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R16086 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R16087 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R16088 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R16089 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R16090 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R16091 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R16092 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R16093 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R16094 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R16095 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R16096 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R16097 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R16098 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R16099 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R16100 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R16101 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R16102 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R16103 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R16104 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R16105 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R16106 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R16107 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R16108 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R16109 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R16110 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R16111 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R16112 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R16113 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R16114 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R16115 n1_m4_144000_196800 n1_m4_144000_201600 1.400000
R16116 n1_m4_144000_201600 n1_m4_144000_206400 1.400000
R16117 n1_m4_144000_206400 n1_m4_144000_211200 1.400000
R16118 n1_m4_144000_211200 n1_m4_144000_216000 1.400000
R16119 n1_m4_144000_216000 n1_m4_144000_220800 1.400000
R16120 n1_m4_144000_220800 n1_m4_144000_225600 1.400000
R16121 n1_m4_144000_225600 n1_m4_144000_230400 1.400000
R16122 n1_m4_144000_230400 n1_m4_144000_235200 1.400000
R16123 n1_m4_144000_235200 n1_m4_144000_240000 1.400000
R16124 n1_m4_144000_240000 n1_m4_144000_244000 1.166667
R16125 n1_m4_144000_244800 n1_m4_144000_244000 0.233333
R16126 n1_m4_144000_244800 n1_m4_144000_249600 1.400000
R16127 n1_m4_144000_249600 n1_m4_144000_254400 1.400000
R16128 n1_m4_144000_254400 n1_m4_144000_259200 1.400000
R16129 n1_m4_144000_259200 n1_m4_144000_264000 1.400000
R16130 n1_m4_144000_264000 n1_m4_144000_268800 1.400000
R16131 n1_m4_144000_268800 n1_m4_144000_273600 1.400000
R16132 n1_m4_144000_273600 n1_m4_144000_278400 1.400000
R16133 n1_m4_144000_278400 n1_m4_144000_283200 1.400000
R16134 n1_m4_144000_283200 n1_m4_144000_288000 1.400000
R16135 n1_m4_144000_288000 n1_m4_144000_292800 1.400000
R16136 n1_m4_144000_292800 n1_m4_144000_297600 1.400000
R16137 n1_m4_144000_297600 n1_m4_144000_302400 1.400000
R16138 n1_m4_144000_302400 n1_m4_144000_307200 1.400000
R16139 n1_m4_144000_307200 n1_m4_144000_312000 1.400000
R16140 n1_m4_144000_312000 n1_m4_144000_316800 1.400000
R16141 n1_m4_144000_316800 n1_m4_144000_321600 1.400000
R16142 n1_m4_144000_321600 n1_m4_144000_324000 0.700000
R16143 n1_m4_144000_326400 n1_m4_144000_324000 0.700000
R16144 n1_m4_144000_326400 n1_m4_144000_331200 1.400000
R16145 n1_m4_144000_331200 n1_m4_144000_336000 1.400000
R16146 n1_m4_144000_336000 n1_m4_144000_340800 1.400000
R16147 n1_m4_144000_340800 n1_m4_144000_345600 1.400000
R16148 n1_m4_144000_345600 n1_m4_144000_350400 1.400000
R16149 n1_m4_144000_350400 n1_m4_144000_355200 1.400000
R16150 n1_m4_144000_355200 n1_m4_144000_360000 1.400000
R16151 n1_m4_144000_360000 n1_m4_144000_364800 1.400000
R16152 n1_m4_144000_364800 n1_m4_144000_369600 1.400000
R16153 n1_m4_144000_369600 n1_m4_144000_374400 1.400000
R16154 n1_m4_144000_374400 n1_m4_144000_379200 1.400000
R16155 n1_m4_144000_379200 n1_m4_144000_384000 1.400000
R16156 n1_m4_144000_384000 n1_m4_144000_388800 1.400000
R16157 n1_m4_144000_388800 n1_m4_144000_393600 1.400000
R16158 n1_m4_144000_393600 n1_m4_144000_398400 1.400000
R16159 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R16160 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R16161 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R16162 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R16163 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R16164 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R16165 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R16166 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R16167 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R16168 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R16169 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R16170 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R16171 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R16172 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R16173 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R16174 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R16175 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R16176 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R16177 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R16178 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R16179 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R16180 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R16181 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R16182 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R16183 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R16184 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R16185 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R16186 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R16187 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R16188 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R16189 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R16190 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R16191 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R16192 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R16193 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R16194 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R16195 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R16196 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R16197 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R16198 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R16199 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R16200 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R16201 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R16202 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R16203 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R16204 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R16205 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R16206 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R16207 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R16208 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R16209 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R16210 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R16211 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R16212 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R16213 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R16214 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R16215 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R16216 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R16217 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R16218 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R16219 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R16220 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R16221 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R16222 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R16223 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R16224 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R16225 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R16226 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R16227 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R16228 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R16229 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R16230 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R16231 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R16232 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R16233 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R16234 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R16235 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R16236 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R16237 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R16238 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R16239 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R16240 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R16241 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R16242 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R16243 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R16244 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R16245 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R16246 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R16247 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R16248 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R16249 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R16250 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R16251 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R16252 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R16253 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R16254 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R16255 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R16256 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R16257 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R16258 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R16259 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R16260 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R16261 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R16262 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R16263 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R16264 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R16265 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R16266 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R16267 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R16268 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R16269 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R16270 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R16271 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R16272 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R16273 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R16274 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R16275 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R16276 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R16277 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R16278 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R16279 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R16280 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R16281 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R16282 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R16283 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R16284 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R16285 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R16286 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R16287 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R16288 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R16289 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R16290 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R16291 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R16292 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R16293 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R16294 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R16295 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R16296 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R16297 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R16298 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R16299 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R16300 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R16301 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R16302 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R16303 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R16304 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R16305 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R16306 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R16307 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R16308 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R16309 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R16310 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R16311 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R16312 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R16313 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R16314 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R16315 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R16316 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R16317 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R16318 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R16319 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R16320 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R16321 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R16322 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R16323 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R16324 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R16325 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R16326 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R16327 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R16328 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R16329 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R16330 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R16331 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R16332 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R16333 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R16334 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R16335 n1_m4_228000_398400 n1_m4_228000_403200 1.400000
R16336 n1_m4_228000_403200 n1_m4_228000_404000 0.233333
R16337 n1_m4_228000_408000 n1_m4_228000_404000 1.166667
R16338 n1_m4_228000_408000 n1_m4_228000_412800 1.400000
R16339 n1_m4_228000_412800 n1_m4_228000_417600 1.400000
R16340 n1_m4_228000_417600 n1_m4_228000_422400 1.400000
R16341 n1_m4_228000_422400 n1_m4_228000_427200 1.400000
R16342 n1_m4_228000_427200 n1_m4_228000_432000 1.400000
R16343 n1_m4_228000_432000 n1_m4_228000_436800 1.400000
R16344 n1_m4_228000_436800 n1_m4_228000_441600 1.400000
R16345 n1_m4_228000_441600 n1_m4_228000_446400 1.400000
R16346 n1_m4_228000_446400 n1_m4_228000_451200 1.400000
R16347 n1_m4_228000_451200 n1_m4_228000_456000 1.400000
R16348 n1_m4_228000_456000 n1_m4_228000_460800 1.400000
R16349 n1_m4_228000_460800 n1_m4_228000_465600 1.400000
R16350 n1_m4_228000_465600 n1_m4_228000_470400 1.400000
R16351 n1_m4_228000_470400 n1_m4_228000_475200 1.400000
R16352 n1_m4_228000_475200 n1_m4_228000_480000 1.400000
R16353 n1_m4_228000_480000 n1_m4_228000_484000 1.166667
R16354 n1_m4_228000_484800 n1_m4_228000_484000 0.233333
R16355 n1_m4_228000_484800 n1_m4_228000_489600 1.400000
R16356 n1_m4_228000_489600 n1_m4_228000_494400 1.400000
R16357 n1_m4_228000_494400 n1_m4_228000_499200 1.400000
R16358 n1_m4_228000_499200 n1_m4_228000_504000 1.400000
R16359 n1_m4_228000_504000 n1_m4_228000_508800 1.400000
R16360 n1_m4_228000_508800 n1_m4_228000_513600 1.400000
R16361 n1_m4_228000_513600 n1_m4_228000_518400 1.400000
R16362 n1_m4_228000_518400 n1_m4_228000_523200 1.400000
R16363 n1_m4_228000_523200 n1_m4_228000_528000 1.400000
R16364 n1_m4_228000_528000 n1_m4_228000_532800 1.400000
R16365 n1_m4_228000_532800 n1_m4_228000_537600 1.400000
R16366 n1_m4_228000_537600 n1_m4_228000_542400 1.400000
R16367 n1_m4_228000_542400 n1_m4_228000_547200 1.400000
R16368 n1_m4_228000_547200 n1_m4_228000_552000 1.400000
R16369 n1_m4_228000_552000 n1_m4_228000_556800 1.400000
R16370 n1_m4_256000_0 n1_m4_256000_4000 1.166667
R16371 n1_m4_256000_4800 n1_m4_256000_4000 0.233333
R16372 n1_m4_256000_4800 n1_m4_256000_9600 1.400000
R16373 n1_m4_256000_9600 n1_m4_256000_14400 1.400000
R16374 n1_m4_256000_14400 n1_m4_256000_19200 1.400000
R16375 n1_m4_256000_19200 n1_m4_256000_24000 1.400000
R16376 n1_m4_256000_24000 n1_m4_256000_28800 1.400000
R16377 n1_m4_256000_28800 n1_m4_256000_33600 1.400000
R16378 n1_m4_256000_33600 n1_m4_256000_38400 1.400000
R16379 n1_m4_256000_38400 n1_m4_256000_43200 1.400000
R16380 n1_m4_256000_43200 n1_m4_256000_48000 1.400000
R16381 n1_m4_256000_48000 n1_m4_256000_52800 1.400000
R16382 n1_m4_256000_52800 n1_m4_256000_57600 1.400000
R16383 n1_m4_256000_57600 n1_m4_256000_62400 1.400000
R16384 n1_m4_256000_62400 n1_m4_256000_67200 1.400000
R16385 n1_m4_256000_67200 n1_m4_256000_72000 1.400000
R16386 n1_m4_256000_72000 n1_m4_256000_76800 1.400000
R16387 n1_m4_256000_76800 n1_m4_256000_81600 1.400000
R16388 n1_m4_256000_81600 n1_m4_256000_84000 0.700000
R16389 n1_m4_256000_86400 n1_m4_256000_84000 0.700000
R16390 n1_m4_256000_86400 n1_m4_256000_91200 1.400000
R16391 n1_m4_256000_91200 n1_m4_256000_96000 1.400000
R16392 n1_m4_256000_96000 n1_m4_256000_100800 1.400000
R16393 n1_m4_256000_100800 n1_m4_256000_105600 1.400000
R16394 n1_m4_256000_105600 n1_m4_256000_110400 1.400000
R16395 n1_m4_256000_110400 n1_m4_256000_115200 1.400000
R16396 n1_m4_256000_115200 n1_m4_256000_120000 1.400000
R16397 n1_m4_256000_120000 n1_m4_256000_124800 1.400000
R16398 n1_m4_256000_124800 n1_m4_256000_129600 1.400000
R16399 n1_m4_256000_129600 n1_m4_256000_134400 1.400000
R16400 n1_m4_256000_134400 n1_m4_256000_139200 1.400000
R16401 n1_m4_256000_139200 n1_m4_256000_144000 1.400000
R16402 n1_m4_256000_144000 n1_m4_256000_148800 1.400000
R16403 n1_m4_256000_148800 n1_m4_256000_153600 1.400000
R16404 n1_m4_256000_153600 n1_m4_256000_158400 1.400000
R16405 n1_m4_256000_158400 n1_m4_256000_163200 1.400000
R16406 n1_m4_256000_163200 n1_m4_256000_164000 0.233333
R16407 n1_m4_256000_168000 n1_m4_256000_164000 1.166667
R16408 n1_m4_256000_168000 n1_m4_256000_172800 1.400000
R16409 n1_m4_256000_172800 n1_m4_256000_177600 1.400000
R16410 n1_m4_256000_177600 n1_m4_256000_182400 1.400000
R16411 n1_m4_256000_182400 n1_m4_256000_187200 1.400000
R16412 n1_m4_256000_187200 n1_m4_256000_192000 1.400000
R16413 n1_m4_256000_192000 n1_m4_256000_196800 1.400000
R16414 n1_m4_256000_196800 n1_m4_256000_201600 1.400000
R16415 n1_m4_256000_201600 n1_m4_256000_206400 1.400000
R16416 n1_m4_256000_206400 n1_m4_256000_211200 1.400000
R16417 n1_m4_256000_211200 n1_m4_256000_216000 1.400000
R16418 n1_m4_256000_216000 n1_m4_256000_220800 1.400000
R16419 n1_m4_256000_220800 n1_m4_256000_225600 1.400000
R16420 n1_m4_256000_225600 n1_m4_256000_230400 1.400000
R16421 n1_m4_256000_230400 n1_m4_256000_235200 1.400000
R16422 n1_m4_256000_235200 n1_m4_256000_240000 1.400000
R16423 n1_m4_256000_240000 n1_m4_256000_244000 1.166667
R16424 n1_m4_256000_244800 n1_m4_256000_244000 0.233333
R16425 n1_m4_256000_244800 n1_m4_256000_249600 1.400000
R16426 n1_m4_256000_249600 n1_m4_256000_254400 1.400000
R16427 n1_m4_256000_254400 n1_m4_256000_259200 1.400000
R16428 n1_m4_256000_259200 n1_m4_256000_264000 1.400000
R16429 n1_m4_256000_264000 n1_m4_256000_268800 1.400000
R16430 n1_m4_256000_268800 n1_m4_256000_273600 1.400000
R16431 n1_m4_256000_273600 n1_m4_256000_278400 1.400000
R16432 n1_m4_256000_278400 n1_m4_256000_283200 1.400000
R16433 n1_m4_256000_283200 n1_m4_256000_288000 1.400000
R16434 n1_m4_256000_288000 n1_m4_256000_292800 1.400000
R16435 n1_m4_256000_292800 n1_m4_256000_297600 1.400000
R16436 n1_m4_256000_297600 n1_m4_256000_302400 1.400000
R16437 n1_m4_256000_302400 n1_m4_256000_307200 1.400000
R16438 n1_m4_256000_307200 n1_m4_256000_312000 1.400000
R16439 n1_m4_256000_312000 n1_m4_256000_316800 1.400000
R16440 n1_m4_256000_316800 n1_m4_256000_321600 1.400000
R16441 n1_m4_256000_321600 n1_m4_256000_324000 0.700000
R16442 n1_m4_256000_326400 n1_m4_256000_324000 0.700000
R16443 n1_m4_256000_326400 n1_m4_256000_331200 1.400000
R16444 n1_m4_256000_331200 n1_m4_256000_336000 1.400000
R16445 n1_m4_256000_336000 n1_m4_256000_340800 1.400000
R16446 n1_m4_256000_340800 n1_m4_256000_345600 1.400000
R16447 n1_m4_256000_345600 n1_m4_256000_350400 1.400000
R16448 n1_m4_256000_350400 n1_m4_256000_355200 1.400000
R16449 n1_m4_256000_355200 n1_m4_256000_360000 1.400000
R16450 n1_m4_256000_360000 n1_m4_256000_364800 1.400000
R16451 n1_m4_256000_364800 n1_m4_256000_369600 1.400000
R16452 n1_m4_256000_369600 n1_m4_256000_374400 1.400000
R16453 n1_m4_256000_374400 n1_m4_256000_379200 1.400000
R16454 n1_m4_256000_379200 n1_m4_256000_384000 1.400000
R16455 n1_m4_256000_384000 n1_m4_256000_388800 1.400000
R16456 n1_m4_256000_388800 n1_m4_256000_393600 1.400000
R16457 n1_m4_256000_393600 n1_m4_256000_398400 1.400000
R16458 n1_m4_256000_398400 n1_m4_256000_403200 1.400000
R16459 n1_m4_256000_403200 n1_m4_256000_404000 0.233333
R16460 n1_m4_256000_408000 n1_m4_256000_404000 1.166667
R16461 n1_m4_256000_408000 n1_m4_256000_412800 1.400000
R16462 n1_m4_256000_412800 n1_m4_256000_417600 1.400000
R16463 n1_m4_256000_417600 n1_m4_256000_422400 1.400000
R16464 n1_m4_256000_422400 n1_m4_256000_427200 1.400000
R16465 n1_m4_256000_427200 n1_m4_256000_432000 1.400000
R16466 n1_m4_256000_432000 n1_m4_256000_436800 1.400000
R16467 n1_m4_256000_436800 n1_m4_256000_441600 1.400000
R16468 n1_m4_256000_441600 n1_m4_256000_446400 1.400000
R16469 n1_m4_256000_446400 n1_m4_256000_451200 1.400000
R16470 n1_m4_256000_451200 n1_m4_256000_456000 1.400000
R16471 n1_m4_256000_456000 n1_m4_256000_460800 1.400000
R16472 n1_m4_256000_460800 n1_m4_256000_465600 1.400000
R16473 n1_m4_256000_465600 n1_m4_256000_470400 1.400000
R16474 n1_m4_256000_470400 n1_m4_256000_475200 1.400000
R16475 n1_m4_256000_475200 n1_m4_256000_480000 1.400000
R16476 n1_m4_256000_480000 n1_m4_256000_484000 1.166667
R16477 n1_m4_256000_484800 n1_m4_256000_484000 0.233333
R16478 n1_m4_256000_484800 n1_m4_256000_489600 1.400000
R16479 n1_m4_256000_489600 n1_m4_256000_494400 1.400000
R16480 n1_m4_256000_494400 n1_m4_256000_499200 1.400000
R16481 n1_m4_256000_499200 n1_m4_256000_504000 1.400000
R16482 n1_m4_256000_504000 n1_m4_256000_508800 1.400000
R16483 n1_m4_256000_508800 n1_m4_256000_513600 1.400000
R16484 n1_m4_256000_513600 n1_m4_256000_518400 1.400000
R16485 n1_m4_256000_518400 n1_m4_256000_523200 1.400000
R16486 n1_m4_256000_523200 n1_m4_256000_528000 1.400000
R16487 n1_m4_256000_528000 n1_m4_256000_532800 1.400000
R16488 n1_m4_256000_532800 n1_m4_256000_537600 1.400000
R16489 n1_m4_256000_537600 n1_m4_256000_542400 1.400000
R16490 n1_m4_256000_542400 n1_m4_256000_547200 1.400000
R16491 n1_m4_256000_547200 n1_m4_256000_552000 1.400000
R16492 n1_m4_256000_552000 n1_m4_256000_556800 1.400000
R16493 n1_m4_284000_398400 n1_m4_284000_403200 1.400000
R16494 n1_m4_284000_403200 n1_m4_284000_404000 0.233333
R16495 n1_m4_284000_408000 n1_m4_284000_404000 1.166667
R16496 n1_m4_284000_408000 n1_m4_284000_412800 1.400000
R16497 n1_m4_284000_412800 n1_m4_284000_417600 1.400000
R16498 n1_m4_284000_417600 n1_m4_284000_422400 1.400000
R16499 n1_m4_284000_422400 n1_m4_284000_427200 1.400000
R16500 n1_m4_284000_427200 n1_m4_284000_432000 1.400000
R16501 n1_m4_284000_432000 n1_m4_284000_436800 1.400000
R16502 n1_m4_284000_436800 n1_m4_284000_441600 1.400000
R16503 n1_m4_284000_441600 n1_m4_284000_446400 1.400000
R16504 n1_m4_284000_446400 n1_m4_284000_451200 1.400000
R16505 n1_m4_284000_451200 n1_m4_284000_456000 1.400000
R16506 n1_m4_284000_456000 n1_m4_284000_460800 1.400000
R16507 n1_m4_284000_460800 n1_m4_284000_465600 1.400000
R16508 n1_m4_284000_465600 n1_m4_284000_470400 1.400000
R16509 n1_m4_284000_470400 n1_m4_284000_475200 1.400000
R16510 n1_m4_284000_475200 n1_m4_284000_480000 1.400000
R16511 n1_m4_284000_480000 n1_m4_284000_484000 1.166667
R16512 n1_m4_284000_484800 n1_m4_284000_484000 0.233333
R16513 n1_m4_284000_484800 n1_m4_284000_489600 1.400000
R16514 n1_m4_284000_489600 n1_m4_284000_494400 1.400000
R16515 n1_m4_284000_494400 n1_m4_284000_499200 1.400000
R16516 n1_m4_284000_499200 n1_m4_284000_504000 1.400000
R16517 n1_m4_284000_504000 n1_m4_284000_508800 1.400000
R16518 n1_m4_284000_508800 n1_m4_284000_513600 1.400000
R16519 n1_m4_284000_513600 n1_m4_284000_518400 1.400000
R16520 n1_m4_284000_518400 n1_m4_284000_523200 1.400000
R16521 n1_m4_284000_523200 n1_m4_284000_528000 1.400000
R16522 n1_m4_284000_528000 n1_m4_284000_532800 1.400000
R16523 n1_m4_284000_532800 n1_m4_284000_537600 1.400000
R16524 n1_m4_284000_537600 n1_m4_284000_542400 1.400000
R16525 n1_m4_284000_542400 n1_m4_284000_547200 1.400000
R16526 n1_m4_284000_547200 n1_m4_284000_552000 1.400000
R16527 n1_m4_284000_552000 n1_m4_284000_556800 1.400000
R16528 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R16529 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R16530 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R16531 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R16532 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R16533 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R16534 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R16535 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R16536 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R16537 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R16538 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R16539 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R16540 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R16541 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R16542 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R16543 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R16544 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R16545 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R16546 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R16547 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R16548 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R16549 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R16550 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R16551 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R16552 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R16553 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R16554 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R16555 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R16556 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R16557 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R16558 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R16559 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R16560 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R16561 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R16562 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R16563 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R16564 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R16565 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R16566 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R16567 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R16568 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R16569 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R16570 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R16571 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R16572 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R16573 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R16574 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R16575 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R16576 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R16577 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R16578 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R16579 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R16580 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R16581 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R16582 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R16583 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R16584 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R16585 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R16586 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R16587 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R16588 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R16589 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R16590 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R16591 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R16592 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R16593 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R16594 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R16595 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R16596 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R16597 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R16598 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R16599 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R16600 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R16601 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R16602 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R16603 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R16604 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R16605 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R16606 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R16607 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R16608 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R16609 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R16610 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R16611 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R16612 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R16613 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R16614 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R16615 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R16616 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R16617 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R16618 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R16619 n1_m4_312000_408000 n1_m4_312000_412800 1.400000
R16620 n1_m4_312000_412800 n1_m4_312000_417600 1.400000
R16621 n1_m4_312000_417600 n1_m4_312000_422400 1.400000
R16622 n1_m4_312000_422400 n1_m4_312000_427200 1.400000
R16623 n1_m4_312000_427200 n1_m4_312000_432000 1.400000
R16624 n1_m4_312000_432000 n1_m4_312000_436800 1.400000
R16625 n1_m4_312000_436800 n1_m4_312000_441600 1.400000
R16626 n1_m4_312000_441600 n1_m4_312000_446400 1.400000
R16627 n1_m4_312000_446400 n1_m4_312000_451200 1.400000
R16628 n1_m4_312000_451200 n1_m4_312000_456000 1.400000
R16629 n1_m4_312000_456000 n1_m4_312000_460800 1.400000
R16630 n1_m4_312000_460800 n1_m4_312000_465600 1.400000
R16631 n1_m4_312000_465600 n1_m4_312000_470400 1.400000
R16632 n1_m4_312000_470400 n1_m4_312000_475200 1.400000
R16633 n1_m4_312000_475200 n1_m4_312000_480000 1.400000
R16634 n1_m4_312000_480000 n1_m4_312000_484000 1.166667
R16635 n1_m4_312000_484800 n1_m4_312000_484000 0.233333
R16636 n1_m4_312000_484800 n1_m4_312000_489600 1.400000
R16637 n1_m4_312000_489600 n1_m4_312000_494400 1.400000
R16638 n1_m4_312000_494400 n1_m4_312000_499200 1.400000
R16639 n1_m4_312000_499200 n1_m4_312000_504000 1.400000
R16640 n1_m4_312000_504000 n1_m4_312000_508800 1.400000
R16641 n1_m4_312000_508800 n1_m4_312000_513600 1.400000
R16642 n1_m4_312000_513600 n1_m4_312000_518400 1.400000
R16643 n1_m4_312000_518400 n1_m4_312000_523200 1.400000
R16644 n1_m4_312000_523200 n1_m4_312000_528000 1.400000
R16645 n1_m4_312000_528000 n1_m4_312000_532800 1.400000
R16646 n1_m4_312000_532800 n1_m4_312000_537600 1.400000
R16647 n1_m4_312000_537600 n1_m4_312000_542400 1.400000
R16648 n1_m4_312000_542400 n1_m4_312000_547200 1.400000
R16649 n1_m4_312000_547200 n1_m4_312000_552000 1.400000
R16650 n1_m4_312000_552000 n1_m4_312000_556800 1.400000
R16651 n1_m4_340000_398400 n1_m4_340000_403200 1.400000
R16652 n1_m4_340000_403200 n1_m4_340000_404000 0.233333
R16653 n1_m4_340000_408000 n1_m4_340000_404000 1.166667
R16654 n1_m4_340000_408000 n1_m4_340000_412800 1.400000
R16655 n1_m4_340000_412800 n1_m4_340000_417600 1.400000
R16656 n1_m4_340000_417600 n1_m4_340000_422400 1.400000
R16657 n1_m4_340000_422400 n1_m4_340000_427200 1.400000
R16658 n1_m4_340000_427200 n1_m4_340000_432000 1.400000
R16659 n1_m4_340000_432000 n1_m4_340000_436800 1.400000
R16660 n1_m4_340000_436800 n1_m4_340000_441600 1.400000
R16661 n1_m4_340000_441600 n1_m4_340000_446400 1.400000
R16662 n1_m4_340000_446400 n1_m4_340000_451200 1.400000
R16663 n1_m4_340000_451200 n1_m4_340000_456000 1.400000
R16664 n1_m4_340000_456000 n1_m4_340000_460800 1.400000
R16665 n1_m4_340000_460800 n1_m4_340000_465600 1.400000
R16666 n1_m4_340000_465600 n1_m4_340000_470400 1.400000
R16667 n1_m4_340000_470400 n1_m4_340000_475200 1.400000
R16668 n1_m4_340000_475200 n1_m4_340000_480000 1.400000
R16669 n1_m4_340000_480000 n1_m4_340000_484000 1.166667
R16670 n1_m4_340000_484800 n1_m4_340000_484000 0.233333
R16671 n1_m4_340000_484800 n1_m4_340000_489600 1.400000
R16672 n1_m4_340000_489600 n1_m4_340000_494400 1.400000
R16673 n1_m4_340000_494400 n1_m4_340000_499200 1.400000
R16674 n1_m4_340000_499200 n1_m4_340000_504000 1.400000
R16675 n1_m4_340000_504000 n1_m4_340000_508800 1.400000
R16676 n1_m4_340000_508800 n1_m4_340000_513600 1.400000
R16677 n1_m4_340000_513600 n1_m4_340000_518400 1.400000
R16678 n1_m4_340000_518400 n1_m4_340000_523200 1.400000
R16679 n1_m4_340000_523200 n1_m4_340000_528000 1.400000
R16680 n1_m4_340000_528000 n1_m4_340000_532800 1.400000
R16681 n1_m4_340000_532800 n1_m4_340000_537600 1.400000
R16682 n1_m4_340000_537600 n1_m4_340000_542400 1.400000
R16683 n1_m4_340000_542400 n1_m4_340000_547200 1.400000
R16684 n1_m4_340000_547200 n1_m4_340000_552000 1.400000
R16685 n1_m4_340000_552000 n1_m4_340000_556800 1.400000
R16686 n1_m4_368000_0 n1_m4_368000_4000 1.166667
R16687 n1_m4_368000_4800 n1_m4_368000_4000 0.233333
R16688 n1_m4_368000_4800 n1_m4_368000_9600 1.400000
R16689 n1_m4_368000_9600 n1_m4_368000_14400 1.400000
R16690 n1_m4_368000_14400 n1_m4_368000_19200 1.400000
R16691 n1_m4_368000_19200 n1_m4_368000_24000 1.400000
R16692 n1_m4_368000_24000 n1_m4_368000_28800 1.400000
R16693 n1_m4_368000_28800 n1_m4_368000_33600 1.400000
R16694 n1_m4_368000_33600 n1_m4_368000_38400 1.400000
R16695 n1_m4_368000_38400 n1_m4_368000_43200 1.400000
R16696 n1_m4_368000_43200 n1_m4_368000_48000 1.400000
R16697 n1_m4_368000_48000 n1_m4_368000_52800 1.400000
R16698 n1_m4_368000_52800 n1_m4_368000_57600 1.400000
R16699 n1_m4_368000_57600 n1_m4_368000_62400 1.400000
R16700 n1_m4_368000_62400 n1_m4_368000_67200 1.400000
R16701 n1_m4_368000_67200 n1_m4_368000_72000 1.400000
R16702 n1_m4_368000_72000 n1_m4_368000_76800 1.400000
R16703 n1_m4_368000_76800 n1_m4_368000_81600 1.400000
R16704 n1_m4_368000_81600 n1_m4_368000_84000 0.700000
R16705 n1_m4_368000_86400 n1_m4_368000_84000 0.700000
R16706 n1_m4_368000_86400 n1_m4_368000_91200 1.400000
R16707 n1_m4_368000_91200 n1_m4_368000_96000 1.400000
R16708 n1_m4_368000_96000 n1_m4_368000_100800 1.400000
R16709 n1_m4_368000_100800 n1_m4_368000_105600 1.400000
R16710 n1_m4_368000_105600 n1_m4_368000_110400 1.400000
R16711 n1_m4_368000_110400 n1_m4_368000_115200 1.400000
R16712 n1_m4_368000_115200 n1_m4_368000_120000 1.400000
R16713 n1_m4_368000_120000 n1_m4_368000_124800 1.400000
R16714 n1_m4_368000_124800 n1_m4_368000_129600 1.400000
R16715 n1_m4_368000_129600 n1_m4_368000_134400 1.400000
R16716 n1_m4_368000_134400 n1_m4_368000_139200 1.400000
R16717 n1_m4_368000_139200 n1_m4_368000_144000 1.400000
R16718 n1_m4_368000_144000 n1_m4_368000_148800 1.400000
R16719 n1_m4_368000_148800 n1_m4_368000_153600 1.400000
R16720 n1_m4_368000_153600 n1_m4_368000_158400 1.400000
R16721 n1_m4_368000_158400 n1_m4_368000_163200 1.400000
R16722 n1_m4_368000_163200 n1_m4_368000_164000 0.233333
R16723 n1_m4_368000_168000 n1_m4_368000_164000 1.166667
R16724 n1_m4_368000_168000 n1_m4_368000_172800 1.400000
R16725 n1_m4_368000_172800 n1_m4_368000_177600 1.400000
R16726 n1_m4_368000_177600 n1_m4_368000_182400 1.400000
R16727 n1_m4_368000_182400 n1_m4_368000_187200 1.400000
R16728 n1_m4_368000_187200 n1_m4_368000_192000 1.400000
R16729 n1_m4_368000_192000 n1_m4_368000_196800 1.400000
R16730 n1_m4_368000_196800 n1_m4_368000_201600 1.400000
R16731 n1_m4_368000_201600 n1_m4_368000_206400 1.400000
R16732 n1_m4_368000_206400 n1_m4_368000_211200 1.400000
R16733 n1_m4_368000_211200 n1_m4_368000_216000 1.400000
R16734 n1_m4_368000_216000 n1_m4_368000_220800 1.400000
R16735 n1_m4_368000_220800 n1_m4_368000_225600 1.400000
R16736 n1_m4_368000_225600 n1_m4_368000_230400 1.400000
R16737 n1_m4_368000_230400 n1_m4_368000_235200 1.400000
R16738 n1_m4_368000_235200 n1_m4_368000_240000 1.400000
R16739 n1_m4_368000_240000 n1_m4_368000_244000 1.166667
R16740 n1_m4_368000_244800 n1_m4_368000_244000 0.233333
R16741 n1_m4_368000_244800 n1_m4_368000_249600 1.400000
R16742 n1_m4_368000_249600 n1_m4_368000_254400 1.400000
R16743 n1_m4_368000_254400 n1_m4_368000_259200 1.400000
R16744 n1_m4_368000_259200 n1_m4_368000_264000 1.400000
R16745 n1_m4_368000_264000 n1_m4_368000_268800 1.400000
R16746 n1_m4_368000_268800 n1_m4_368000_273600 1.400000
R16747 n1_m4_368000_273600 n1_m4_368000_278400 1.400000
R16748 n1_m4_368000_278400 n1_m4_368000_283200 1.400000
R16749 n1_m4_368000_283200 n1_m4_368000_288000 1.400000
R16750 n1_m4_368000_288000 n1_m4_368000_292800 1.400000
R16751 n1_m4_368000_292800 n1_m4_368000_297600 1.400000
R16752 n1_m4_368000_297600 n1_m4_368000_302400 1.400000
R16753 n1_m4_368000_302400 n1_m4_368000_307200 1.400000
R16754 n1_m4_368000_307200 n1_m4_368000_312000 1.400000
R16755 n1_m4_368000_312000 n1_m4_368000_316800 1.400000
R16756 n1_m4_368000_316800 n1_m4_368000_321600 1.400000
R16757 n1_m4_368000_321600 n1_m4_368000_324000 0.700000
R16758 n1_m4_368000_326400 n1_m4_368000_324000 0.700000
R16759 n1_m4_368000_326400 n1_m4_368000_331200 1.400000
R16760 n1_m4_368000_331200 n1_m4_368000_336000 1.400000
R16761 n1_m4_368000_336000 n1_m4_368000_340800 1.400000
R16762 n1_m4_368000_340800 n1_m4_368000_345600 1.400000
R16763 n1_m4_368000_345600 n1_m4_368000_350400 1.400000
R16764 n1_m4_368000_350400 n1_m4_368000_355200 1.400000
R16765 n1_m4_368000_355200 n1_m4_368000_360000 1.400000
R16766 n1_m4_368000_360000 n1_m4_368000_364800 1.400000
R16767 n1_m4_368000_364800 n1_m4_368000_369600 1.400000
R16768 n1_m4_368000_369600 n1_m4_368000_374400 1.400000
R16769 n1_m4_368000_374400 n1_m4_368000_379200 1.400000
R16770 n1_m4_368000_379200 n1_m4_368000_384000 1.400000
R16771 n1_m4_368000_384000 n1_m4_368000_388800 1.400000
R16772 n1_m4_368000_388800 n1_m4_368000_393600 1.400000
R16773 n1_m4_368000_393600 n1_m4_368000_398400 1.400000
R16774 n1_m4_368000_398400 n1_m4_368000_403200 1.400000
R16775 n1_m4_368000_403200 n1_m4_368000_404000 0.233333
R16776 n1_m4_368000_408000 n1_m4_368000_404000 1.166667
R16777 n1_m4_368000_408000 n1_m4_368000_412800 1.400000
R16778 n1_m4_368000_412800 n1_m4_368000_417600 1.400000
R16779 n1_m4_368000_417600 n1_m4_368000_422400 1.400000
R16780 n1_m4_368000_422400 n1_m4_368000_427200 1.400000
R16781 n1_m4_368000_427200 n1_m4_368000_432000 1.400000
R16782 n1_m4_368000_432000 n1_m4_368000_436800 1.400000
R16783 n1_m4_368000_436800 n1_m4_368000_441600 1.400000
R16784 n1_m4_368000_441600 n1_m4_368000_446400 1.400000
R16785 n1_m4_368000_446400 n1_m4_368000_451200 1.400000
R16786 n1_m4_368000_451200 n1_m4_368000_456000 1.400000
R16787 n1_m4_368000_456000 n1_m4_368000_460800 1.400000
R16788 n1_m4_368000_460800 n1_m4_368000_465600 1.400000
R16789 n1_m4_368000_465600 n1_m4_368000_470400 1.400000
R16790 n1_m4_368000_470400 n1_m4_368000_475200 1.400000
R16791 n1_m4_368000_475200 n1_m4_368000_480000 1.400000
R16792 n1_m4_368000_480000 n1_m4_368000_484000 1.166667
R16793 n1_m4_368000_484800 n1_m4_368000_484000 0.233333
R16794 n1_m4_368000_484800 n1_m4_368000_489600 1.400000
R16795 n1_m4_368000_489600 n1_m4_368000_494400 1.400000
R16796 n1_m4_368000_494400 n1_m4_368000_499200 1.400000
R16797 n1_m4_368000_499200 n1_m4_368000_504000 1.400000
R16798 n1_m4_368000_504000 n1_m4_368000_508800 1.400000
R16799 n1_m4_368000_508800 n1_m4_368000_513600 1.400000
R16800 n1_m4_368000_513600 n1_m4_368000_518400 1.400000
R16801 n1_m4_368000_518400 n1_m4_368000_523200 1.400000
R16802 n1_m4_368000_523200 n1_m4_368000_528000 1.400000
R16803 n1_m4_368000_528000 n1_m4_368000_532800 1.400000
R16804 n1_m4_368000_532800 n1_m4_368000_537600 1.400000
R16805 n1_m4_368000_537600 n1_m4_368000_542400 1.400000
R16806 n1_m4_368000_542400 n1_m4_368000_547200 1.400000
R16807 n1_m4_368000_547200 n1_m4_368000_552000 1.400000
R16808 n1_m4_368000_552000 n1_m4_368000_556800 1.400000
R16809 n1_m4_396000_398400 n1_m4_396000_403200 1.400000
R16810 n1_m4_396000_403200 n1_m4_396000_404000 0.233333
R16811 n1_m4_396000_408000 n1_m4_396000_404000 1.166667
R16812 n1_m4_396000_408000 n1_m4_396000_412800 1.400000
R16813 n1_m4_396000_412800 n1_m4_396000_417600 1.400000
R16814 n1_m4_396000_417600 n1_m4_396000_422400 1.400000
R16815 n1_m4_396000_422400 n1_m4_396000_427200 1.400000
R16816 n1_m4_396000_427200 n1_m4_396000_432000 1.400000
R16817 n1_m4_396000_432000 n1_m4_396000_436800 1.400000
R16818 n1_m4_396000_436800 n1_m4_396000_441600 1.400000
R16819 n1_m4_396000_441600 n1_m4_396000_446400 1.400000
R16820 n1_m4_396000_446400 n1_m4_396000_451200 1.400000
R16821 n1_m4_396000_451200 n1_m4_396000_456000 1.400000
R16822 n1_m4_396000_456000 n1_m4_396000_460800 1.400000
R16823 n1_m4_396000_460800 n1_m4_396000_465600 1.400000
R16824 n1_m4_396000_465600 n1_m4_396000_470400 1.400000
R16825 n1_m4_396000_470400 n1_m4_396000_475200 1.400000
R16826 n1_m4_396000_475200 n1_m4_396000_480000 1.400000
R16827 n1_m4_396000_480000 n1_m4_396000_484000 1.166667
R16828 n1_m4_396000_484800 n1_m4_396000_484000 0.233333
R16829 n1_m4_396000_484800 n1_m4_396000_489600 1.400000
R16830 n1_m4_396000_489600 n1_m4_396000_494400 1.400000
R16831 n1_m4_396000_494400 n1_m4_396000_499200 1.400000
R16832 n1_m4_396000_499200 n1_m4_396000_504000 1.400000
R16833 n1_m4_396000_504000 n1_m4_396000_508800 1.400000
R16834 n1_m4_396000_508800 n1_m4_396000_513600 1.400000
R16835 n1_m4_396000_513600 n1_m4_396000_518400 1.400000
R16836 n1_m4_396000_518400 n1_m4_396000_523200 1.400000
R16837 n1_m4_396000_523200 n1_m4_396000_528000 1.400000
R16838 n1_m4_396000_528000 n1_m4_396000_532800 1.400000
R16839 n1_m4_396000_532800 n1_m4_396000_537600 1.400000
R16840 n1_m4_396000_537600 n1_m4_396000_542400 1.400000
R16841 n1_m4_396000_542400 n1_m4_396000_547200 1.400000
R16842 n1_m4_396000_547200 n1_m4_396000_552000 1.400000
R16843 n1_m4_396000_552000 n1_m4_396000_556800 1.400000
R16844 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R16845 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R16846 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R16847 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R16848 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R16849 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R16850 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R16851 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R16852 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R16853 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R16854 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R16855 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R16856 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R16857 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R16858 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R16859 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R16860 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R16861 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R16862 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R16863 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R16864 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R16865 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R16866 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R16867 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R16868 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R16869 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R16870 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R16871 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R16872 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R16873 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R16874 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R16875 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R16876 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R16877 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R16878 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R16879 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R16880 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R16881 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R16882 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R16883 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R16884 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R16885 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R16886 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R16887 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R16888 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R16889 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R16890 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R16891 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R16892 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R16893 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R16894 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R16895 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R16896 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R16897 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R16898 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R16899 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R16900 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R16901 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R16902 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R16903 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R16904 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R16905 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R16906 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R16907 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R16908 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R16909 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R16910 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R16911 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R16912 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R16913 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R16914 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R16915 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R16916 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R16917 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R16918 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R16919 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R16920 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R16921 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R16922 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R16923 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R16924 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R16925 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R16926 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R16927 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R16928 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R16929 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R16930 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R16931 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R16932 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R16933 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R16934 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R16935 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R16936 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R16937 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R16938 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R16939 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R16940 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R16941 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R16942 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R16943 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R16944 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R16945 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R16946 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R16947 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R16948 n1_m4_424000_470400 n1_m4_424000_475200 1.400000
R16949 n1_m4_424000_475200 n1_m4_424000_480000 1.400000
R16950 n1_m4_424000_480000 n1_m4_424000_484000 1.166667
R16951 n1_m4_424000_484800 n1_m4_424000_484000 0.233333
R16952 n1_m4_424000_484800 n1_m4_424000_489600 1.400000
R16953 n1_m4_424000_489600 n1_m4_424000_494400 1.400000
R16954 n1_m4_424000_494400 n1_m4_424000_499200 1.400000
R16955 n1_m4_424000_499200 n1_m4_424000_504000 1.400000
R16956 n1_m4_424000_504000 n1_m4_424000_508800 1.400000
R16957 n1_m4_424000_508800 n1_m4_424000_513600 1.400000
R16958 n1_m4_424000_513600 n1_m4_424000_518400 1.400000
R16959 n1_m4_424000_518400 n1_m4_424000_523200 1.400000
R16960 n1_m4_424000_523200 n1_m4_424000_528000 1.400000
R16961 n1_m4_424000_528000 n1_m4_424000_532800 1.400000
R16962 n1_m4_424000_532800 n1_m4_424000_537600 1.400000
R16963 n1_m4_424000_537600 n1_m4_424000_542400 1.400000
R16964 n1_m4_424000_542400 n1_m4_424000_547200 1.400000
R16965 n1_m4_424000_547200 n1_m4_424000_552000 1.400000
R16966 n1_m4_424000_552000 n1_m4_424000_556800 1.400000
R16967 n1_m4_452000_398400 n1_m4_452000_403200 1.400000
R16968 n1_m4_452000_403200 n1_m4_452000_404000 0.233333
R16969 n1_m4_452000_408000 n1_m4_452000_404000 1.166667
R16970 n1_m4_452000_408000 n1_m4_452000_412800 1.400000
R16971 n1_m4_452000_412800 n1_m4_452000_417600 1.400000
R16972 n1_m4_452000_417600 n1_m4_452000_422400 1.400000
R16973 n1_m4_452000_422400 n1_m4_452000_427200 1.400000
R16974 n1_m4_452000_427200 n1_m4_452000_432000 1.400000
R16975 n1_m4_452000_432000 n1_m4_452000_436800 1.400000
R16976 n1_m4_452000_436800 n1_m4_452000_441600 1.400000
R16977 n1_m4_452000_441600 n1_m4_452000_446400 1.400000
R16978 n1_m4_452000_446400 n1_m4_452000_451200 1.400000
R16979 n1_m4_452000_451200 n1_m4_452000_456000 1.400000
R16980 n1_m4_452000_456000 n1_m4_452000_460800 1.400000
R16981 n1_m4_452000_460800 n1_m4_452000_465600 1.400000
R16982 n1_m4_452000_465600 n1_m4_452000_470400 1.400000
R16983 n1_m4_452000_470400 n1_m4_452000_475200 1.400000
R16984 n1_m4_452000_475200 n1_m4_452000_480000 1.400000
R16985 n1_m4_452000_480000 n1_m4_452000_484000 1.166667
R16986 n1_m4_452000_484800 n1_m4_452000_484000 0.233333
R16987 n1_m4_452000_484800 n1_m4_452000_489600 1.400000
R16988 n1_m4_452000_489600 n1_m4_452000_494400 1.400000
R16989 n1_m4_452000_494400 n1_m4_452000_499200 1.400000
R16990 n1_m4_452000_499200 n1_m4_452000_504000 1.400000
R16991 n1_m4_452000_504000 n1_m4_452000_508800 1.400000
R16992 n1_m4_452000_508800 n1_m4_452000_513600 1.400000
R16993 n1_m4_452000_513600 n1_m4_452000_518400 1.400000
R16994 n1_m4_452000_518400 n1_m4_452000_523200 1.400000
R16995 n1_m4_452000_523200 n1_m4_452000_528000 1.400000
R16996 n1_m4_452000_528000 n1_m4_452000_532800 1.400000
R16997 n1_m4_452000_532800 n1_m4_452000_537600 1.400000
R16998 n1_m4_452000_537600 n1_m4_452000_542400 1.400000
R16999 n1_m4_452000_542400 n1_m4_452000_547200 1.400000
R17000 n1_m4_452000_547200 n1_m4_452000_552000 1.400000
R17001 n1_m4_452000_552000 n1_m4_452000_556800 1.400000
R17002 n1_m4_480000_398400 n1_m4_480000_403200 1.400000
R17003 n1_m4_480000_403200 n1_m4_480000_404000 0.233333
R17004 n1_m4_480000_408000 n1_m4_480000_404000 1.166667
R17005 n1_m4_480000_408000 n1_m4_480000_412800 1.400000
R17006 n1_m4_480000_412800 n1_m4_480000_417600 1.400000
R17007 n1_m4_480000_417600 n1_m4_480000_422400 1.400000
R17008 n1_m4_480000_422400 n1_m4_480000_427200 1.400000
R17009 n1_m4_480000_427200 n1_m4_480000_432000 1.400000
R17010 n1_m4_480000_432000 n1_m4_480000_436800 1.400000
R17011 n1_m4_480000_436800 n1_m4_480000_441600 1.400000
R17012 n1_m4_480000_441600 n1_m4_480000_446400 1.400000
R17013 n1_m4_480000_446400 n1_m4_480000_451200 1.400000
R17014 n1_m4_480000_451200 n1_m4_480000_456000 1.400000
R17015 n1_m4_480000_456000 n1_m4_480000_460800 1.400000
R17016 n1_m4_480000_460800 n1_m4_480000_465600 1.400000
R17017 n1_m4_480000_465600 n1_m4_480000_470400 1.400000
R17018 n1_m4_480000_470400 n1_m4_480000_475200 1.400000
R17019 n1_m4_480000_475200 n1_m4_480000_480000 1.400000
R17020 n1_m4_480000_480000 n1_m4_480000_484000 1.166667
R17021 n1_m4_480000_484800 n1_m4_480000_484000 0.233333
R17022 n1_m4_480000_484800 n1_m4_480000_489600 1.400000
R17023 n1_m4_480000_489600 n1_m4_480000_494400 1.400000
R17024 n1_m4_480000_494400 n1_m4_480000_499200 1.400000
R17025 n1_m4_480000_499200 n1_m4_480000_504000 1.400000
R17026 n1_m4_480000_504000 n1_m4_480000_508800 1.400000
R17027 n1_m4_480000_508800 n1_m4_480000_513600 1.400000
R17028 n1_m4_480000_513600 n1_m4_480000_518400 1.400000
R17029 n1_m4_480000_518400 n1_m4_480000_523200 1.400000
R17030 n1_m4_480000_523200 n1_m4_480000_528000 1.400000
R17031 n1_m4_480000_528000 n1_m4_480000_532800 1.400000
R17032 n1_m4_480000_532800 n1_m4_480000_537600 1.400000
R17033 n1_m4_480000_537600 n1_m4_480000_542400 1.400000
R17034 n1_m4_480000_542400 n1_m4_480000_547200 1.400000
R17035 n1_m4_480000_547200 n1_m4_480000_552000 1.400000
R17036 n1_m4_480000_552000 n1_m4_480000_556800 1.400000
R17037 n1_m4_508000_0 n1_m4_508000_4000 1.166667
R17038 n1_m4_508000_4800 n1_m4_508000_4000 0.233333
R17039 n1_m4_508000_4800 n1_m4_508000_9600 1.400000
R17040 n1_m4_508000_9600 n1_m4_508000_14400 1.400000
R17041 n1_m4_508000_14400 n1_m4_508000_19200 1.400000
R17042 n1_m4_508000_19200 n1_m4_508000_24000 1.400000
R17043 n1_m4_508000_24000 n1_m4_508000_28800 1.400000
R17044 n1_m4_508000_28800 n1_m4_508000_33600 1.400000
R17045 n1_m4_508000_33600 n1_m4_508000_38400 1.400000
R17046 n1_m4_508000_38400 n1_m4_508000_43200 1.400000
R17047 n1_m4_508000_43200 n1_m4_508000_48000 1.400000
R17048 n1_m4_508000_48000 n1_m4_508000_52800 1.400000
R17049 n1_m4_508000_52800 n1_m4_508000_57600 1.400000
R17050 n1_m4_508000_57600 n1_m4_508000_62400 1.400000
R17051 n1_m4_508000_62400 n1_m4_508000_67200 1.400000
R17052 n1_m4_508000_67200 n1_m4_508000_72000 1.400000
R17053 n1_m4_508000_72000 n1_m4_508000_76800 1.400000
R17054 n1_m4_508000_76800 n1_m4_508000_81600 1.400000
R17055 n1_m4_508000_81600 n1_m4_508000_84000 0.700000
R17056 n1_m4_508000_86400 n1_m4_508000_84000 0.700000
R17057 n1_m4_508000_86400 n1_m4_508000_91200 1.400000
R17058 n1_m4_508000_91200 n1_m4_508000_96000 1.400000
R17059 n1_m4_508000_96000 n1_m4_508000_100800 1.400000
R17060 n1_m4_508000_100800 n1_m4_508000_105600 1.400000
R17061 n1_m4_508000_105600 n1_m4_508000_110400 1.400000
R17062 n1_m4_508000_110400 n1_m4_508000_115200 1.400000
R17063 n1_m4_508000_115200 n1_m4_508000_120000 1.400000
R17064 n1_m4_508000_120000 n1_m4_508000_124800 1.400000
R17065 n1_m4_508000_124800 n1_m4_508000_129600 1.400000
R17066 n1_m4_508000_129600 n1_m4_508000_134400 1.400000
R17067 n1_m4_508000_134400 n1_m4_508000_139200 1.400000
R17068 n1_m4_508000_139200 n1_m4_508000_144000 1.400000
R17069 n1_m4_508000_144000 n1_m4_508000_148800 1.400000
R17070 n1_m4_508000_148800 n1_m4_508000_153600 1.400000
R17071 n1_m4_508000_153600 n1_m4_508000_158400 1.400000
R17072 n1_m4_508000_158400 n1_m4_508000_163200 1.400000
R17073 n1_m4_508000_163200 n1_m4_508000_164000 0.233333
R17074 n1_m4_508000_168000 n1_m4_508000_164000 1.166667
R17075 n1_m4_508000_168000 n1_m4_508000_172800 1.400000
R17076 n1_m4_508000_172800 n1_m4_508000_177600 1.400000
R17077 n1_m4_508000_177600 n1_m4_508000_182400 1.400000
R17078 n1_m4_508000_182400 n1_m4_508000_187200 1.400000
R17079 n1_m4_508000_187200 n1_m4_508000_192000 1.400000
R17080 n1_m4_508000_192000 n1_m4_508000_196800 1.400000
R17081 n1_m4_508000_196800 n1_m4_508000_201600 1.400000
R17082 n1_m4_508000_201600 n1_m4_508000_206400 1.400000
R17083 n1_m4_508000_206400 n1_m4_508000_211200 1.400000
R17084 n1_m4_508000_211200 n1_m4_508000_216000 1.400000
R17085 n1_m4_508000_216000 n1_m4_508000_220800 1.400000
R17086 n1_m4_508000_220800 n1_m4_508000_225600 1.400000
R17087 n1_m4_508000_225600 n1_m4_508000_230400 1.400000
R17088 n1_m4_508000_230400 n1_m4_508000_235200 1.400000
R17089 n1_m4_508000_235200 n1_m4_508000_240000 1.400000
R17090 n1_m4_508000_240000 n1_m4_508000_244000 1.166667
R17091 n1_m4_508000_244800 n1_m4_508000_244000 0.233333
R17092 n1_m4_508000_244800 n1_m4_508000_249600 1.400000
R17093 n1_m4_508000_249600 n1_m4_508000_254400 1.400000
R17094 n1_m4_508000_254400 n1_m4_508000_259200 1.400000
R17095 n1_m4_508000_259200 n1_m4_508000_264000 1.400000
R17096 n1_m4_508000_264000 n1_m4_508000_268800 1.400000
R17097 n1_m4_508000_268800 n1_m4_508000_273600 1.400000
R17098 n1_m4_508000_273600 n1_m4_508000_278400 1.400000
R17099 n1_m4_508000_278400 n1_m4_508000_283200 1.400000
R17100 n1_m4_508000_283200 n1_m4_508000_288000 1.400000
R17101 n1_m4_508000_288000 n1_m4_508000_292800 1.400000
R17102 n1_m4_508000_292800 n1_m4_508000_297600 1.400000
R17103 n1_m4_508000_297600 n1_m4_508000_302400 1.400000
R17104 n1_m4_508000_302400 n1_m4_508000_307200 1.400000
R17105 n1_m4_508000_307200 n1_m4_508000_312000 1.400000
R17106 n1_m4_508000_312000 n1_m4_508000_316800 1.400000
R17107 n1_m4_508000_316800 n1_m4_508000_321600 1.400000
R17108 n1_m4_508000_321600 n1_m4_508000_324000 0.700000
R17109 n1_m4_508000_326400 n1_m4_508000_324000 0.700000
R17110 n1_m4_508000_326400 n1_m4_508000_331200 1.400000
R17111 n1_m4_508000_331200 n1_m4_508000_336000 1.400000
R17112 n1_m4_508000_336000 n1_m4_508000_340800 1.400000
R17113 n1_m4_508000_340800 n1_m4_508000_345600 1.400000
R17114 n1_m4_508000_345600 n1_m4_508000_350400 1.400000
R17115 n1_m4_508000_350400 n1_m4_508000_355200 1.400000
R17116 n1_m4_508000_355200 n1_m4_508000_360000 1.400000
R17117 n1_m4_508000_360000 n1_m4_508000_364800 1.400000
R17118 n1_m4_508000_364800 n1_m4_508000_369600 1.400000
R17119 n1_m4_508000_369600 n1_m4_508000_374400 1.400000
R17120 n1_m4_508000_374400 n1_m4_508000_379200 1.400000
R17121 n1_m4_508000_379200 n1_m4_508000_384000 1.400000
R17122 n1_m4_508000_384000 n1_m4_508000_388800 1.400000
R17123 n1_m4_508000_388800 n1_m4_508000_393600 1.400000
R17124 n1_m4_508000_393600 n1_m4_508000_398400 1.400000
R17125 n1_m4_508000_398400 n1_m4_508000_403200 1.400000
R17126 n1_m4_508000_403200 n1_m4_508000_404000 0.233333
R17127 n1_m4_508000_408000 n1_m4_508000_404000 1.166667
R17128 n1_m4_508000_408000 n1_m4_508000_412800 1.400000
R17129 n1_m4_508000_412800 n1_m4_508000_417600 1.400000
R17130 n1_m4_508000_417600 n1_m4_508000_422400 1.400000
R17131 n1_m4_508000_422400 n1_m4_508000_427200 1.400000
R17132 n1_m4_508000_427200 n1_m4_508000_432000 1.400000
R17133 n1_m4_508000_432000 n1_m4_508000_436800 1.400000
R17134 n1_m4_508000_436800 n1_m4_508000_441600 1.400000
R17135 n1_m4_508000_441600 n1_m4_508000_446400 1.400000
R17136 n1_m4_508000_446400 n1_m4_508000_451200 1.400000
R17137 n1_m4_508000_451200 n1_m4_508000_456000 1.400000
R17138 n1_m4_508000_456000 n1_m4_508000_460800 1.400000
R17139 n1_m4_508000_460800 n1_m4_508000_465600 1.400000
R17140 n1_m4_508000_465600 n1_m4_508000_470400 1.400000
R17141 n1_m4_508000_470400 n1_m4_508000_475200 1.400000
R17142 n1_m4_508000_475200 n1_m4_508000_480000 1.400000
R17143 n1_m4_508000_480000 n1_m4_508000_484000 1.166667
R17144 n1_m4_508000_484800 n1_m4_508000_484000 0.233333
R17145 n1_m4_508000_484800 n1_m4_508000_489600 1.400000
R17146 n1_m4_508000_489600 n1_m4_508000_494400 1.400000
R17147 n1_m4_508000_494400 n1_m4_508000_499200 1.400000
R17148 n1_m4_508000_499200 n1_m4_508000_504000 1.400000
R17149 n1_m4_508000_504000 n1_m4_508000_508800 1.400000
R17150 n1_m4_508000_508800 n1_m4_508000_513600 1.400000
R17151 n1_m4_508000_513600 n1_m4_508000_518400 1.400000
R17152 n1_m4_508000_518400 n1_m4_508000_523200 1.400000
R17153 n1_m4_508000_523200 n1_m4_508000_528000 1.400000
R17154 n1_m4_508000_528000 n1_m4_508000_532800 1.400000
R17155 n1_m4_508000_532800 n1_m4_508000_537600 1.400000
R17156 n1_m4_508000_537600 n1_m4_508000_542400 1.400000
R17157 n1_m4_508000_542400 n1_m4_508000_547200 1.400000
R17158 n1_m4_508000_547200 n1_m4_508000_552000 1.400000
R17159 n1_m4_508000_552000 n1_m4_508000_556800 1.400000
R17160 n1_m4_536000_398400 n1_m4_536000_403200 1.400000
R17161 n1_m4_536000_403200 n1_m4_536000_404000 0.233333
R17162 n1_m4_536000_408000 n1_m4_536000_404000 1.166667
R17163 n1_m4_536000_408000 n1_m4_536000_412800 1.400000
R17164 n1_m4_536000_412800 n1_m4_536000_417600 1.400000
R17165 n1_m4_536000_417600 n1_m4_536000_422400 1.400000
R17166 n1_m4_536000_422400 n1_m4_536000_427200 1.400000
R17167 n1_m4_536000_427200 n1_m4_536000_432000 1.400000
R17168 n1_m4_536000_432000 n1_m4_536000_436800 1.400000
R17169 n1_m4_536000_436800 n1_m4_536000_441600 1.400000
R17170 n1_m4_536000_441600 n1_m4_536000_446400 1.400000
R17171 n1_m4_536000_446400 n1_m4_536000_451200 1.400000
R17172 n1_m4_536000_451200 n1_m4_536000_456000 1.400000
R17173 n1_m4_536000_456000 n1_m4_536000_460800 1.400000
R17174 n1_m4_536000_460800 n1_m4_536000_465600 1.400000
R17175 n1_m4_536000_465600 n1_m4_536000_470400 1.400000
R17176 n1_m4_536000_470400 n1_m4_536000_475200 1.400000
R17177 n1_m4_536000_475200 n1_m4_536000_480000 1.400000
R17178 n1_m4_536000_480000 n1_m4_536000_484000 1.166667
R17179 n1_m4_536000_484800 n1_m4_536000_484000 0.233333
R17180 n1_m4_536000_484800 n1_m4_536000_489600 1.400000
R17181 n1_m4_536000_489600 n1_m4_536000_494400 1.400000
R17182 n1_m4_536000_494400 n1_m4_536000_499200 1.400000
R17183 n1_m4_536000_499200 n1_m4_536000_504000 1.400000
R17184 n1_m4_536000_504000 n1_m4_536000_508800 1.400000
R17185 n1_m4_536000_508800 n1_m4_536000_513600 1.400000
R17186 n1_m4_536000_513600 n1_m4_536000_518400 1.400000
R17187 n1_m4_536000_518400 n1_m4_536000_523200 1.400000
R17188 n1_m4_536000_523200 n1_m4_536000_528000 1.400000
R17189 n1_m4_536000_528000 n1_m4_536000_532800 1.400000
R17190 n1_m4_536000_532800 n1_m4_536000_537600 1.400000
R17191 n1_m4_536000_537600 n1_m4_536000_542400 1.400000
R17192 n1_m4_536000_542400 n1_m4_536000_547200 1.400000
R17193 n1_m4_536000_547200 n1_m4_536000_552000 1.400000
R17194 n1_m4_536000_552000 n1_m4_536000_556800 1.400000
R17195 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R17196 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R17197 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R17198 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R17199 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R17200 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R17201 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R17202 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R17203 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R17204 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R17205 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R17206 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R17207 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R17208 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R17209 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R17210 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R17211 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R17212 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R17213 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R17214 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R17215 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R17216 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R17217 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R17218 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R17219 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R17220 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R17221 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R17222 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R17223 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R17224 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R17225 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R17226 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R17227 n1_m7_452000_4000 n1_m7_474400_4000 0.594240
R17228 n1_m7_480000_4000 n1_m7_474400_4000 0.148560
R17229 n1_m7_480000_4000 n1_m7_496800_4000 0.445680
R17230 n1_m7_508000_4000 n1_m7_496800_4000 0.297120
R17231 n1_m7_508000_4000 n1_m7_519200_4000 0.297120
R17232 n1_m7_536000_4000 n1_m7_519200_4000 0.445680
R17233 n1_m7_536000_4000 n1_m7_541600_4000 0.148560
R17234 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R17235 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R17236 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R17237 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R17238 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R17239 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R17240 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R17241 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R17242 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R17243 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R17244 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R17245 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R17246 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R17247 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R17248 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R17249 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R17250 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R17251 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R17252 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R17253 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R17254 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R17255 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R17256 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R17257 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R17258 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R17259 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R17260 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R17261 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R17262 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R17263 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R17264 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R17265 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R17266 n1_m7_452000_84000 n1_m7_474400_84000 0.594240
R17267 n1_m7_480000_84000 n1_m7_474400_84000 0.148560
R17268 n1_m7_480000_84000 n1_m7_496800_84000 0.445680
R17269 n1_m7_508000_84000 n1_m7_496800_84000 0.297120
R17270 n1_m7_508000_84000 n1_m7_519200_84000 0.297120
R17271 n1_m7_536000_84000 n1_m7_519200_84000 0.445680
R17272 n1_m7_536000_84000 n1_m7_541600_84000 0.148560
R17273 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R17274 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R17275 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R17276 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R17277 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R17278 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R17279 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R17280 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R17281 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R17282 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R17283 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R17284 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R17285 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R17286 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R17287 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R17288 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R17289 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R17290 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R17291 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R17292 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R17293 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R17294 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R17295 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R17296 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R17297 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R17298 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R17299 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R17300 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R17301 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R17302 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R17303 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R17304 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R17305 n1_m7_452000_164000 n1_m7_474400_164000 0.594240
R17306 n1_m7_480000_164000 n1_m7_474400_164000 0.148560
R17307 n1_m7_480000_164000 n1_m7_496800_164000 0.445680
R17308 n1_m7_508000_164000 n1_m7_496800_164000 0.297120
R17309 n1_m7_508000_164000 n1_m7_519200_164000 0.297120
R17310 n1_m7_536000_164000 n1_m7_519200_164000 0.445680
R17311 n1_m7_536000_164000 n1_m7_541600_164000 0.148560
R17312 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R17313 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R17314 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R17315 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R17316 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R17317 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R17318 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R17319 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R17320 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R17321 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R17322 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R17323 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R17324 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R17325 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R17326 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R17327 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R17328 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R17329 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R17330 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R17331 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R17332 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R17333 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R17334 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R17335 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R17336 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R17337 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R17338 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R17339 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R17340 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R17341 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R17342 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R17343 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R17344 n1_m7_452000_244000 n1_m7_474400_244000 0.594240
R17345 n1_m7_480000_244000 n1_m7_474400_244000 0.148560
R17346 n1_m7_480000_244000 n1_m7_496800_244000 0.445680
R17347 n1_m7_508000_244000 n1_m7_496800_244000 0.297120
R17348 n1_m7_508000_244000 n1_m7_519200_244000 0.297120
R17349 n1_m7_536000_244000 n1_m7_519200_244000 0.445680
R17350 n1_m7_536000_244000 n1_m7_541600_244000 0.148560
R17351 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R17352 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R17353 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R17354 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R17355 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R17356 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R17357 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R17358 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R17359 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R17360 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R17361 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R17362 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R17363 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R17364 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R17365 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R17366 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R17367 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R17368 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R17369 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R17370 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R17371 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R17372 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R17373 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R17374 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R17375 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R17376 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R17377 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R17378 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R17379 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R17380 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R17381 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R17382 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R17383 n1_m7_452000_324000 n1_m7_474400_324000 0.594240
R17384 n1_m7_480000_324000 n1_m7_474400_324000 0.148560
R17385 n1_m7_480000_324000 n1_m7_496800_324000 0.445680
R17386 n1_m7_508000_324000 n1_m7_496800_324000 0.297120
R17387 n1_m7_508000_324000 n1_m7_519200_324000 0.297120
R17388 n1_m7_536000_324000 n1_m7_519200_324000 0.445680
R17389 n1_m7_536000_324000 n1_m7_541600_324000 0.148560
R17390 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R17391 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R17392 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R17393 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R17394 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R17395 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R17396 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R17397 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R17398 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R17399 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R17400 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R17401 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R17402 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R17403 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R17404 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R17405 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R17406 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R17407 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R17408 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R17409 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R17410 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R17411 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R17412 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R17413 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R17414 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R17415 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R17416 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R17417 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R17418 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R17419 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R17420 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R17421 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R17422 n1_m7_452000_404000 n1_m7_474400_404000 0.594240
R17423 n1_m7_480000_404000 n1_m7_474400_404000 0.148560
R17424 n1_m7_480000_404000 n1_m7_496800_404000 0.445680
R17425 n1_m7_508000_404000 n1_m7_496800_404000 0.297120
R17426 n1_m7_508000_404000 n1_m7_519200_404000 0.297120
R17427 n1_m7_536000_404000 n1_m7_519200_404000 0.445680
R17428 n1_m7_536000_404000 n1_m7_541600_404000 0.148560
R17429 n1_m7_4000_484000 n1_m7_26400_484000 0.594240
R17430 n1_m7_32000_484000 n1_m7_26400_484000 0.148560
R17431 n1_m7_32000_484000 n1_m7_48800_484000 0.445680
R17432 n1_m7_60000_484000 n1_m7_48800_484000 0.297120
R17433 n1_m7_60000_484000 n1_m7_71200_484000 0.297120
R17434 n1_m7_88000_484000 n1_m7_71200_484000 0.445680
R17435 n1_m7_88000_484000 n1_m7_93600_484000 0.148560
R17436 n1_m7_116000_484000 n1_m7_93600_484000 0.594240
R17437 n1_m7_116000_484000 n1_m7_138400_484000 0.594240
R17438 n1_m7_144000_484000 n1_m7_138400_484000 0.148560
R17439 n1_m7_144000_484000 n1_m7_160800_484000 0.445680
R17440 n1_m7_172000_484000 n1_m7_160800_484000 0.297120
R17441 n1_m7_172000_484000 n1_m7_183200_484000 0.297120
R17442 n1_m7_200000_484000 n1_m7_183200_484000 0.445680
R17443 n1_m7_200000_484000 n1_m7_205600_484000 0.148560
R17444 n1_m7_228000_484000 n1_m7_205600_484000 0.594240
R17445 n1_m7_228000_484000 n1_m7_250400_484000 0.594240
R17446 n1_m7_256000_484000 n1_m7_250400_484000 0.148560
R17447 n1_m7_256000_484000 n1_m7_272800_484000 0.445680
R17448 n1_m7_284000_484000 n1_m7_272800_484000 0.297120
R17449 n1_m7_284000_484000 n1_m7_295200_484000 0.297120
R17450 n1_m7_312000_484000 n1_m7_295200_484000 0.445680
R17451 n1_m7_312000_484000 n1_m7_317600_484000 0.148560
R17452 n1_m7_340000_484000 n1_m7_317600_484000 0.594240
R17453 n1_m7_340000_484000 n1_m7_362400_484000 0.594240
R17454 n1_m7_368000_484000 n1_m7_362400_484000 0.148560
R17455 n1_m7_368000_484000 n1_m7_384800_484000 0.445680
R17456 n1_m7_396000_484000 n1_m7_384800_484000 0.297120
R17457 n1_m7_396000_484000 n1_m7_407200_484000 0.297120
R17458 n1_m7_424000_484000 n1_m7_407200_484000 0.445680
R17459 n1_m7_424000_484000 n1_m7_429600_484000 0.148560
R17460 n1_m7_452000_484000 n1_m7_429600_484000 0.594240
R17461 n1_m7_452000_484000 n1_m7_474400_484000 0.594240
R17462 n1_m7_480000_484000 n1_m7_474400_484000 0.148560
R17463 n1_m7_480000_484000 n1_m7_496800_484000 0.445680
R17464 n1_m7_508000_484000 n1_m7_496800_484000 0.297120
R17465 n1_m7_508000_484000 n1_m7_519200_484000 0.297120
R17466 n1_m7_536000_484000 n1_m7_519200_484000 0.445680
R17467 n1_m7_536000_484000 n1_m7_541600_484000 0.148560
R17468 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R17469 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R17470 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R17471 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R17472 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R17473 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R17474 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R17475 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R17476 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R17477 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R17478 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R17479 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R17480 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R17481 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R17482 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R17483 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R17484 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R17485 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R17486 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R17487 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R17488 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R17489 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R17490 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R17491 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R17492 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R17493 n1_m8_4000_452000 n1_m8_4000_474400 0.120000
R17494 n1_m8_4000_484000 n1_m8_4000_474400 0.051429
R17495 n1_m8_4000_484000 n1_m8_4000_496800 0.068571
R17496 n1_m8_4000_496800 n1_m8_4000_519200 0.120000
R17497 n1_m8_4000_519200 n1_m8_4000_541600 0.120000
R17498 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R17499 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R17500 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R17501 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R17502 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R17503 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R17504 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R17505 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R17506 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R17507 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R17508 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R17509 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R17510 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R17511 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R17512 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R17513 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R17514 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R17515 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R17516 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R17517 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R17518 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R17519 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R17520 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R17521 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R17522 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R17523 n1_m8_26400_452000 n1_m8_26400_474400 0.120000
R17524 n1_m8_26400_484000 n1_m8_26400_474400 0.051429
R17525 n1_m8_26400_484000 n1_m8_26400_496800 0.068571
R17526 n1_m8_26400_496800 n1_m8_26400_519200 0.120000
R17527 n1_m8_26400_519200 n1_m8_26400_541600 0.120000
R17528 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R17529 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R17530 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R17531 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R17532 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R17533 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R17534 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R17535 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R17536 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R17537 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R17538 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R17539 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R17540 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R17541 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R17542 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R17543 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R17544 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R17545 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R17546 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R17547 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R17548 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R17549 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R17550 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R17551 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R17552 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R17553 n1_m8_48800_452000 n1_m8_48800_474400 0.120000
R17554 n1_m8_48800_484000 n1_m8_48800_474400 0.051429
R17555 n1_m8_48800_484000 n1_m8_48800_496800 0.068571
R17556 n1_m8_48800_496800 n1_m8_48800_519200 0.120000
R17557 n1_m8_48800_519200 n1_m8_48800_541600 0.120000
R17558 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R17559 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R17560 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R17561 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R17562 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R17563 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R17564 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R17565 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R17566 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R17567 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R17568 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R17569 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R17570 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R17571 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R17572 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R17573 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R17574 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R17575 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R17576 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R17577 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R17578 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R17579 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R17580 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R17581 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R17582 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R17583 n1_m8_71200_452000 n1_m8_71200_474400 0.120000
R17584 n1_m8_71200_484000 n1_m8_71200_474400 0.051429
R17585 n1_m8_71200_484000 n1_m8_71200_496800 0.068571
R17586 n1_m8_71200_496800 n1_m8_71200_519200 0.120000
R17587 n1_m8_71200_519200 n1_m8_71200_541600 0.120000
R17588 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R17589 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R17590 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R17591 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R17592 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R17593 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R17594 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R17595 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R17596 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R17597 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R17598 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R17599 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R17600 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R17601 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R17602 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R17603 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R17604 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R17605 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R17606 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R17607 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R17608 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R17609 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R17610 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R17611 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R17612 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R17613 n1_m8_93600_452000 n1_m8_93600_474400 0.120000
R17614 n1_m8_93600_484000 n1_m8_93600_474400 0.051429
R17615 n1_m8_93600_484000 n1_m8_93600_496800 0.068571
R17616 n1_m8_93600_496800 n1_m8_93600_519200 0.120000
R17617 n1_m8_93600_519200 n1_m8_93600_541600 0.120000
R17618 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R17619 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R17620 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R17621 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R17622 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R17623 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R17624 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R17625 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R17626 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R17627 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R17628 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R17629 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R17630 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R17631 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R17632 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R17633 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R17634 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R17635 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R17636 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R17637 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R17638 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R17639 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R17640 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R17641 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R17642 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R17643 n1_m8_116000_452000 n1_m8_116000_474400 0.120000
R17644 n1_m8_116000_484000 n1_m8_116000_474400 0.051429
R17645 n1_m8_116000_484000 n1_m8_116000_496800 0.068571
R17646 n1_m8_116000_496800 n1_m8_116000_519200 0.120000
R17647 n1_m8_116000_519200 n1_m8_116000_541600 0.120000
R17648 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R17649 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R17650 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R17651 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R17652 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R17653 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R17654 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R17655 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R17656 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R17657 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R17658 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R17659 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R17660 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R17661 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R17662 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R17663 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R17664 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R17665 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R17666 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R17667 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R17668 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R17669 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R17670 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R17671 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R17672 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R17673 n1_m8_138400_452000 n1_m8_138400_474400 0.120000
R17674 n1_m8_138400_484000 n1_m8_138400_474400 0.051429
R17675 n1_m8_138400_484000 n1_m8_138400_496800 0.068571
R17676 n1_m8_138400_496800 n1_m8_138400_519200 0.120000
R17677 n1_m8_138400_519200 n1_m8_138400_541600 0.120000
R17678 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R17679 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R17680 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R17681 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R17682 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R17683 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R17684 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R17685 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R17686 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R17687 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R17688 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R17689 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R17690 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R17691 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R17692 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R17693 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R17694 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R17695 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R17696 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R17697 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R17698 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R17699 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R17700 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R17701 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R17702 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R17703 n1_m8_160800_452000 n1_m8_160800_474400 0.120000
R17704 n1_m8_160800_484000 n1_m8_160800_474400 0.051429
R17705 n1_m8_160800_484000 n1_m8_160800_496800 0.068571
R17706 n1_m8_160800_496800 n1_m8_160800_519200 0.120000
R17707 n1_m8_160800_519200 n1_m8_160800_541600 0.120000
R17708 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R17709 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R17710 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R17711 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R17712 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R17713 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R17714 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R17715 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R17716 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R17717 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R17718 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R17719 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R17720 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R17721 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R17722 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R17723 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R17724 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R17725 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R17726 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R17727 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R17728 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R17729 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R17730 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R17731 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R17732 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R17733 n1_m8_183200_452000 n1_m8_183200_474400 0.120000
R17734 n1_m8_183200_484000 n1_m8_183200_474400 0.051429
R17735 n1_m8_183200_484000 n1_m8_183200_496800 0.068571
R17736 n1_m8_183200_496800 n1_m8_183200_519200 0.120000
R17737 n1_m8_183200_519200 n1_m8_183200_541600 0.120000
R17738 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R17739 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R17740 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R17741 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R17742 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R17743 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R17744 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R17745 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R17746 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R17747 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R17748 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R17749 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R17750 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R17751 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R17752 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R17753 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R17754 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R17755 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R17756 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R17757 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R17758 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R17759 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R17760 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R17761 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R17762 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R17763 n1_m8_205600_452000 n1_m8_205600_474400 0.120000
R17764 n1_m8_205600_484000 n1_m8_205600_474400 0.051429
R17765 n1_m8_205600_484000 n1_m8_205600_496800 0.068571
R17766 n1_m8_205600_496800 n1_m8_205600_519200 0.120000
R17767 n1_m8_205600_519200 n1_m8_205600_541600 0.120000
R17768 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R17769 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R17770 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R17771 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R17772 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R17773 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R17774 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R17775 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R17776 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R17777 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R17778 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R17779 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R17780 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R17781 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R17782 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R17783 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R17784 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R17785 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R17786 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R17787 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R17788 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R17789 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R17790 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R17791 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R17792 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R17793 n1_m8_228000_452000 n1_m8_228000_474400 0.120000
R17794 n1_m8_228000_484000 n1_m8_228000_474400 0.051429
R17795 n1_m8_228000_484000 n1_m8_228000_496800 0.068571
R17796 n1_m8_228000_496800 n1_m8_228000_519200 0.120000
R17797 n1_m8_228000_519200 n1_m8_228000_541600 0.120000
R17798 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R17799 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R17800 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R17801 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R17802 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R17803 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R17804 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R17805 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R17806 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R17807 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R17808 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R17809 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R17810 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R17811 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R17812 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R17813 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R17814 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R17815 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R17816 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R17817 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R17818 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R17819 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R17820 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R17821 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R17822 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R17823 n1_m8_250400_452000 n1_m8_250400_474400 0.120000
R17824 n1_m8_250400_484000 n1_m8_250400_474400 0.051429
R17825 n1_m8_250400_484000 n1_m8_250400_496800 0.068571
R17826 n1_m8_250400_496800 n1_m8_250400_519200 0.120000
R17827 n1_m8_250400_519200 n1_m8_250400_541600 0.120000
R17828 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R17829 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R17830 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R17831 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R17832 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R17833 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R17834 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R17835 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R17836 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R17837 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R17838 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R17839 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R17840 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R17841 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R17842 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R17843 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R17844 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R17845 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R17846 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R17847 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R17848 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R17849 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R17850 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R17851 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R17852 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R17853 n1_m8_272800_452000 n1_m8_272800_474400 0.120000
R17854 n1_m8_272800_484000 n1_m8_272800_474400 0.051429
R17855 n1_m8_272800_484000 n1_m8_272800_496800 0.068571
R17856 n1_m8_272800_496800 n1_m8_272800_519200 0.120000
R17857 n1_m8_272800_519200 n1_m8_272800_541600 0.120000
R17858 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R17859 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R17860 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R17861 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R17862 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R17863 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R17864 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R17865 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R17866 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R17867 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R17868 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R17869 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R17870 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R17871 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R17872 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R17873 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R17874 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R17875 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R17876 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R17877 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R17878 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R17879 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R17880 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R17881 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R17882 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R17883 n1_m8_295200_452000 n1_m8_295200_474400 0.120000
R17884 n1_m8_295200_484000 n1_m8_295200_474400 0.051429
R17885 n1_m8_295200_484000 n1_m8_295200_496800 0.068571
R17886 n1_m8_295200_496800 n1_m8_295200_519200 0.120000
R17887 n1_m8_295200_519200 n1_m8_295200_541600 0.120000
R17888 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R17889 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R17890 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R17891 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R17892 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R17893 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R17894 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R17895 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R17896 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R17897 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R17898 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R17899 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R17900 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R17901 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R17902 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R17903 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R17904 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R17905 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R17906 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R17907 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R17908 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R17909 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R17910 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R17911 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R17912 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R17913 n1_m8_317600_452000 n1_m8_317600_474400 0.120000
R17914 n1_m8_317600_484000 n1_m8_317600_474400 0.051429
R17915 n1_m8_317600_484000 n1_m8_317600_496800 0.068571
R17916 n1_m8_317600_496800 n1_m8_317600_519200 0.120000
R17917 n1_m8_317600_519200 n1_m8_317600_541600 0.120000
R17918 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R17919 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R17920 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R17921 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R17922 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R17923 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R17924 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R17925 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R17926 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R17927 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R17928 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R17929 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R17930 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R17931 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R17932 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R17933 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R17934 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R17935 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R17936 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R17937 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R17938 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R17939 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R17940 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R17941 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R17942 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R17943 n1_m8_340000_452000 n1_m8_340000_474400 0.120000
R17944 n1_m8_340000_484000 n1_m8_340000_474400 0.051429
R17945 n1_m8_340000_484000 n1_m8_340000_496800 0.068571
R17946 n1_m8_340000_496800 n1_m8_340000_519200 0.120000
R17947 n1_m8_340000_519200 n1_m8_340000_541600 0.120000
R17948 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R17949 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R17950 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R17951 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R17952 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R17953 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R17954 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R17955 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R17956 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R17957 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R17958 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R17959 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R17960 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R17961 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R17962 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R17963 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R17964 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R17965 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R17966 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R17967 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R17968 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R17969 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R17970 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R17971 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R17972 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R17973 n1_m8_362400_452000 n1_m8_362400_474400 0.120000
R17974 n1_m8_362400_484000 n1_m8_362400_474400 0.051429
R17975 n1_m8_362400_484000 n1_m8_362400_496800 0.068571
R17976 n1_m8_362400_496800 n1_m8_362400_519200 0.120000
R17977 n1_m8_362400_519200 n1_m8_362400_541600 0.120000
R17978 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R17979 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R17980 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R17981 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R17982 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R17983 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R17984 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R17985 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R17986 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R17987 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R17988 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R17989 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R17990 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R17991 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R17992 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R17993 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R17994 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R17995 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R17996 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R17997 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R17998 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R17999 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R18000 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R18001 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R18002 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R18003 n1_m8_384800_452000 n1_m8_384800_474400 0.120000
R18004 n1_m8_384800_484000 n1_m8_384800_474400 0.051429
R18005 n1_m8_384800_484000 n1_m8_384800_496800 0.068571
R18006 n1_m8_384800_496800 n1_m8_384800_519200 0.120000
R18007 n1_m8_384800_519200 n1_m8_384800_541600 0.120000
R18008 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R18009 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R18010 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R18011 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R18012 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R18013 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R18014 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R18015 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R18016 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R18017 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R18018 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R18019 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R18020 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R18021 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R18022 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R18023 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R18024 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R18025 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R18026 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R18027 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R18028 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R18029 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R18030 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R18031 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R18032 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R18033 n1_m8_407200_452000 n1_m8_407200_474400 0.120000
R18034 n1_m8_407200_484000 n1_m8_407200_474400 0.051429
R18035 n1_m8_407200_484000 n1_m8_407200_496800 0.068571
R18036 n1_m8_407200_496800 n1_m8_407200_519200 0.120000
R18037 n1_m8_407200_519200 n1_m8_407200_541600 0.120000
R18038 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R18039 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R18040 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R18041 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R18042 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R18043 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R18044 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R18045 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R18046 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R18047 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R18048 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R18049 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R18050 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R18051 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R18052 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R18053 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R18054 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R18055 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R18056 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R18057 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R18058 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R18059 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R18060 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R18061 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R18062 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R18063 n1_m8_429600_452000 n1_m8_429600_474400 0.120000
R18064 n1_m8_429600_484000 n1_m8_429600_474400 0.051429
R18065 n1_m8_429600_484000 n1_m8_429600_496800 0.068571
R18066 n1_m8_429600_496800 n1_m8_429600_519200 0.120000
R18067 n1_m8_429600_519200 n1_m8_429600_541600 0.120000
R18068 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R18069 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R18070 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R18071 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R18072 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R18073 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R18074 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R18075 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R18076 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R18077 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R18078 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R18079 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R18080 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R18081 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R18082 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R18083 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R18084 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R18085 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R18086 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R18087 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R18088 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R18089 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R18090 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R18091 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R18092 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R18093 n1_m8_452000_452000 n1_m8_452000_474400 0.120000
R18094 n1_m8_452000_484000 n1_m8_452000_474400 0.051429
R18095 n1_m8_452000_484000 n1_m8_452000_496800 0.068571
R18096 n1_m8_452000_496800 n1_m8_452000_519200 0.120000
R18097 n1_m8_452000_519200 n1_m8_452000_541600 0.120000
R18098 n1_m8_474400_4000 n1_m8_474400_26400 0.120000
R18099 n1_m8_474400_26400 n1_m8_474400_48800 0.120000
R18100 n1_m8_474400_48800 n1_m8_474400_71200 0.120000
R18101 n1_m8_474400_84000 n1_m8_474400_71200 0.068571
R18102 n1_m8_474400_84000 n1_m8_474400_93600 0.051429
R18103 n1_m8_474400_93600 n1_m8_474400_116000 0.120000
R18104 n1_m8_474400_116000 n1_m8_474400_138400 0.120000
R18105 n1_m8_474400_138400 n1_m8_474400_160800 0.120000
R18106 n1_m8_474400_164000 n1_m8_474400_160800 0.017143
R18107 n1_m8_474400_164000 n1_m8_474400_183200 0.102857
R18108 n1_m8_474400_183200 n1_m8_474400_205600 0.120000
R18109 n1_m8_474400_205600 n1_m8_474400_228000 0.120000
R18110 n1_m8_474400_244000 n1_m8_474400_228000 0.085714
R18111 n1_m8_474400_244000 n1_m8_474400_250400 0.034286
R18112 n1_m8_474400_250400 n1_m8_474400_272800 0.120000
R18113 n1_m8_474400_272800 n1_m8_474400_295200 0.120000
R18114 n1_m8_474400_295200 n1_m8_474400_317600 0.120000
R18115 n1_m8_474400_324000 n1_m8_474400_317600 0.034286
R18116 n1_m8_474400_324000 n1_m8_474400_340000 0.085714
R18117 n1_m8_474400_340000 n1_m8_474400_362400 0.120000
R18118 n1_m8_474400_362400 n1_m8_474400_384800 0.120000
R18119 n1_m8_474400_404000 n1_m8_474400_384800 0.102857
R18120 n1_m8_474400_404000 n1_m8_474400_407200 0.017143
R18121 n1_m8_474400_407200 n1_m8_474400_429600 0.120000
R18122 n1_m8_474400_429600 n1_m8_474400_452000 0.120000
R18123 n1_m8_474400_452000 n1_m8_474400_474400 0.120000
R18124 n1_m8_474400_484000 n1_m8_474400_474400 0.051429
R18125 n1_m8_474400_484000 n1_m8_474400_496800 0.068571
R18126 n1_m8_474400_496800 n1_m8_474400_519200 0.120000
R18127 n1_m8_474400_519200 n1_m8_474400_541600 0.120000
R18128 n1_m8_496800_4000 n1_m8_496800_26400 0.120000
R18129 n1_m8_496800_26400 n1_m8_496800_48800 0.120000
R18130 n1_m8_496800_48800 n1_m8_496800_71200 0.120000
R18131 n1_m8_496800_84000 n1_m8_496800_71200 0.068571
R18132 n1_m8_496800_84000 n1_m8_496800_93600 0.051429
R18133 n1_m8_496800_93600 n1_m8_496800_116000 0.120000
R18134 n1_m8_496800_116000 n1_m8_496800_138400 0.120000
R18135 n1_m8_496800_138400 n1_m8_496800_160800 0.120000
R18136 n1_m8_496800_164000 n1_m8_496800_160800 0.017143
R18137 n1_m8_496800_164000 n1_m8_496800_183200 0.102857
R18138 n1_m8_496800_183200 n1_m8_496800_205600 0.120000
R18139 n1_m8_496800_205600 n1_m8_496800_228000 0.120000
R18140 n1_m8_496800_244000 n1_m8_496800_228000 0.085714
R18141 n1_m8_496800_244000 n1_m8_496800_250400 0.034286
R18142 n1_m8_496800_250400 n1_m8_496800_272800 0.120000
R18143 n1_m8_496800_272800 n1_m8_496800_295200 0.120000
R18144 n1_m8_496800_295200 n1_m8_496800_317600 0.120000
R18145 n1_m8_496800_324000 n1_m8_496800_317600 0.034286
R18146 n1_m8_496800_324000 n1_m8_496800_340000 0.085714
R18147 n1_m8_496800_340000 n1_m8_496800_362400 0.120000
R18148 n1_m8_496800_362400 n1_m8_496800_384800 0.120000
R18149 n1_m8_496800_404000 n1_m8_496800_384800 0.102857
R18150 n1_m8_496800_404000 n1_m8_496800_407200 0.017143
R18151 n1_m8_496800_407200 n1_m8_496800_429600 0.120000
R18152 n1_m8_496800_429600 n1_m8_496800_452000 0.120000
R18153 n1_m8_496800_452000 n1_m8_496800_474400 0.120000
R18154 n1_m8_496800_484000 n1_m8_496800_474400 0.051429
R18155 n1_m8_496800_484000 n1_m8_496800_496800 0.068571
R18156 n1_m8_496800_496800 n1_m8_496800_519200 0.120000
R18157 n1_m8_496800_519200 n1_m8_496800_541600 0.120000
R18158 n1_m8_519200_4000 n1_m8_519200_26400 0.120000
R18159 n1_m8_519200_26400 n1_m8_519200_48800 0.120000
R18160 n1_m8_519200_48800 n1_m8_519200_71200 0.120000
R18161 n1_m8_519200_84000 n1_m8_519200_71200 0.068571
R18162 n1_m8_519200_84000 n1_m8_519200_93600 0.051429
R18163 n1_m8_519200_93600 n1_m8_519200_116000 0.120000
R18164 n1_m8_519200_116000 n1_m8_519200_138400 0.120000
R18165 n1_m8_519200_138400 n1_m8_519200_160800 0.120000
R18166 n1_m8_519200_164000 n1_m8_519200_160800 0.017143
R18167 n1_m8_519200_164000 n1_m8_519200_183200 0.102857
R18168 n1_m8_519200_183200 n1_m8_519200_205600 0.120000
R18169 n1_m8_519200_205600 n1_m8_519200_228000 0.120000
R18170 n1_m8_519200_244000 n1_m8_519200_228000 0.085714
R18171 n1_m8_519200_244000 n1_m8_519200_250400 0.034286
R18172 n1_m8_519200_250400 n1_m8_519200_272800 0.120000
R18173 n1_m8_519200_272800 n1_m8_519200_295200 0.120000
R18174 n1_m8_519200_295200 n1_m8_519200_317600 0.120000
R18175 n1_m8_519200_324000 n1_m8_519200_317600 0.034286
R18176 n1_m8_519200_324000 n1_m8_519200_340000 0.085714
R18177 n1_m8_519200_340000 n1_m8_519200_362400 0.120000
R18178 n1_m8_519200_362400 n1_m8_519200_384800 0.120000
R18179 n1_m8_519200_404000 n1_m8_519200_384800 0.102857
R18180 n1_m8_519200_404000 n1_m8_519200_407200 0.017143
R18181 n1_m8_519200_407200 n1_m8_519200_429600 0.120000
R18182 n1_m8_519200_429600 n1_m8_519200_452000 0.120000
R18183 n1_m8_519200_452000 n1_m8_519200_474400 0.120000
R18184 n1_m8_519200_484000 n1_m8_519200_474400 0.051429
R18185 n1_m8_519200_484000 n1_m8_519200_496800 0.068571
R18186 n1_m8_519200_496800 n1_m8_519200_519200 0.120000
R18187 n1_m8_519200_519200 n1_m8_519200_541600 0.120000
R18188 n1_m8_541600_4000 n1_m8_541600_26400 0.120000
R18189 n1_m8_541600_26400 n1_m8_541600_48800 0.120000
R18190 n1_m8_541600_48800 n1_m8_541600_71200 0.120000
R18191 n1_m8_541600_84000 n1_m8_541600_71200 0.068571
R18192 n1_m8_541600_84000 n1_m8_541600_93600 0.051429
R18193 n1_m8_541600_93600 n1_m8_541600_116000 0.120000
R18194 n1_m8_541600_116000 n1_m8_541600_138400 0.120000
R18195 n1_m8_541600_138400 n1_m8_541600_160800 0.120000
R18196 n1_m8_541600_164000 n1_m8_541600_160800 0.017143
R18197 n1_m8_541600_164000 n1_m8_541600_183200 0.102857
R18198 n1_m8_541600_183200 n1_m8_541600_205600 0.120000
R18199 n1_m8_541600_205600 n1_m8_541600_228000 0.120000
R18200 n1_m8_541600_244000 n1_m8_541600_228000 0.085714
R18201 n1_m8_541600_244000 n1_m8_541600_250400 0.034286
R18202 n1_m8_541600_250400 n1_m8_541600_272800 0.120000
R18203 n1_m8_541600_272800 n1_m8_541600_295200 0.120000
R18204 n1_m8_541600_295200 n1_m8_541600_317600 0.120000
R18205 n1_m8_541600_324000 n1_m8_541600_317600 0.034286
R18206 n1_m8_541600_324000 n1_m8_541600_340000 0.085714
R18207 n1_m8_541600_340000 n1_m8_541600_362400 0.120000
R18208 n1_m8_541600_362400 n1_m8_541600_384800 0.120000
R18209 n1_m8_541600_404000 n1_m8_541600_384800 0.102857
R18210 n1_m8_541600_404000 n1_m8_541600_407200 0.017143
R18211 n1_m8_541600_407200 n1_m8_541600_429600 0.120000
R18212 n1_m8_541600_429600 n1_m8_541600_452000 0.120000
R18213 n1_m8_541600_452000 n1_m8_541600_474400 0.120000
R18214 n1_m8_541600_484000 n1_m8_541600_474400 0.051429
R18215 n1_m8_541600_484000 n1_m8_541600_496800 0.068571
R18216 n1_m8_541600_496800 n1_m8_541600_519200 0.120000
R18217 n1_m8_541600_519200 n1_m8_541600_541600 0.120000
R18218 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R18219 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R18220 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R18221 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R18222 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R18223 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R18224 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R18225 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R18226 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R18227 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R18228 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R18229 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R18230 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R18231 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R18232 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R18233 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R18234 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R18235 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R18236 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R18237 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R18238 n1_m9_452000_4000 n1_m9_474400_4000 0.096000
R18239 n1_m9_474400_4000 n1_m9_496800_4000 0.096000
R18240 n1_m9_496800_4000 n1_m9_519200_4000 0.096000
R18241 n1_m9_519200_4000 n1_m9_541600_4000 0.096000
R18242 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R18243 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R18244 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R18245 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R18246 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R18247 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R18248 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R18249 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R18250 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R18251 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R18252 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R18253 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R18254 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R18255 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R18256 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R18257 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R18258 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R18259 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R18260 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R18261 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R18262 n1_m9_452000_26400 n1_m9_474400_26400 0.096000
R18263 n1_m9_474400_26400 n1_m9_496800_26400 0.096000
R18264 n1_m9_496800_26400 n1_m9_519200_26400 0.096000
R18265 n1_m9_519200_26400 n1_m9_541600_26400 0.096000
R18266 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R18267 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R18268 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R18269 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R18270 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R18271 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R18272 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R18273 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R18274 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R18275 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R18276 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R18277 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R18278 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R18279 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R18280 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R18281 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R18282 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R18283 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R18284 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R18285 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R18286 n1_m9_452000_48800 n1_m9_474400_48800 0.096000
R18287 n1_m9_474400_48800 n1_m9_496800_48800 0.096000
R18288 n1_m9_496800_48800 n1_m9_519200_48800 0.096000
R18289 n1_m9_519200_48800 n1_m9_541600_48800 0.096000
R18290 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R18291 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R18292 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R18293 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R18294 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R18295 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R18296 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R18297 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R18298 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R18299 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R18300 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R18301 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R18302 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R18303 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R18304 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R18305 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R18306 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R18307 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R18308 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R18309 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R18310 n1_m9_452000_71200 n1_m9_474400_71200 0.096000
R18311 n1_m9_474400_71200 n1_m9_496800_71200 0.096000
R18312 n1_m9_496800_71200 n1_m9_519200_71200 0.096000
R18313 n1_m9_519200_71200 n1_m9_541600_71200 0.096000
R18314 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R18315 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R18316 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R18317 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R18318 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R18319 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R18320 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R18321 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R18322 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R18323 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R18324 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R18325 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R18326 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R18327 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R18328 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R18329 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R18330 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R18331 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R18332 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R18333 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R18334 n1_m9_452000_93600 n1_m9_474400_93600 0.096000
R18335 n1_m9_474400_93600 n1_m9_496800_93600 0.096000
R18336 n1_m9_496800_93600 n1_m9_519200_93600 0.096000
R18337 n1_m9_519200_93600 n1_m9_541600_93600 0.096000
R18338 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R18339 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R18340 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R18341 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R18342 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R18343 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R18344 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R18345 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R18346 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R18347 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R18348 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R18349 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R18350 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R18351 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R18352 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R18353 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R18354 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R18355 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R18356 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R18357 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R18358 n1_m9_452000_116000 n1_m9_474400_116000 0.096000
R18359 n1_m9_474400_116000 n1_m9_496800_116000 0.096000
R18360 n1_m9_496800_116000 n1_m9_519200_116000 0.096000
R18361 n1_m9_519200_116000 n1_m9_541600_116000 0.096000
R18362 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R18363 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R18364 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R18365 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R18366 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R18367 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R18368 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R18369 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R18370 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R18371 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R18372 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R18373 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R18374 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R18375 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R18376 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R18377 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R18378 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R18379 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R18380 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R18381 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R18382 n1_m9_452000_138400 n1_m9_474400_138400 0.096000
R18383 n1_m9_474400_138400 n1_m9_496800_138400 0.096000
R18384 n1_m9_496800_138400 n1_m9_519200_138400 0.096000
R18385 n1_m9_519200_138400 n1_m9_541600_138400 0.096000
R18386 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R18387 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R18388 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R18389 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R18390 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R18391 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R18392 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R18393 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R18394 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R18395 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R18396 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R18397 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R18398 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R18399 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R18400 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R18401 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R18402 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R18403 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R18404 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R18405 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R18406 n1_m9_452000_160800 n1_m9_474400_160800 0.096000
R18407 n1_m9_474400_160800 n1_m9_496800_160800 0.096000
R18408 n1_m9_496800_160800 n1_m9_519200_160800 0.096000
R18409 n1_m9_519200_160800 n1_m9_541600_160800 0.096000
R18410 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R18411 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R18412 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R18413 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R18414 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R18415 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R18416 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R18417 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R18418 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R18419 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R18420 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R18421 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R18422 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R18423 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R18424 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R18425 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R18426 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R18427 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R18428 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R18429 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R18430 n1_m9_452000_183200 n1_m9_474400_183200 0.096000
R18431 n1_m9_474400_183200 n1_m9_496800_183200 0.096000
R18432 n1_m9_496800_183200 n1_m9_519200_183200 0.096000
R18433 n1_m9_519200_183200 n1_m9_541600_183200 0.096000
R18434 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R18435 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R18436 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R18437 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R18438 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R18439 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R18440 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R18441 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R18442 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R18443 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R18444 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R18445 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R18446 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R18447 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R18448 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R18449 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R18450 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R18451 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R18452 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R18453 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R18454 n1_m9_452000_205600 n1_m9_474400_205600 0.096000
R18455 n1_m9_474400_205600 n1_m9_496800_205600 0.096000
R18456 n1_m9_496800_205600 n1_m9_519200_205600 0.096000
R18457 n1_m9_519200_205600 n1_m9_541600_205600 0.096000
R18458 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R18459 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R18460 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R18461 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R18462 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R18463 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R18464 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R18465 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R18466 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R18467 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R18468 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R18469 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R18470 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R18471 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R18472 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R18473 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R18474 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R18475 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R18476 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R18477 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R18478 n1_m9_452000_228000 n1_m9_474400_228000 0.096000
R18479 n1_m9_474400_228000 n1_m9_496800_228000 0.096000
R18480 n1_m9_496800_228000 n1_m9_519200_228000 0.096000
R18481 n1_m9_519200_228000 n1_m9_541600_228000 0.096000
R18482 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R18483 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R18484 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R18485 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R18486 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R18487 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R18488 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R18489 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R18490 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R18491 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R18492 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R18493 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R18494 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R18495 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R18496 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R18497 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R18498 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R18499 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R18500 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R18501 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R18502 n1_m9_452000_250400 n1_m9_474400_250400 0.096000
R18503 n1_m9_474400_250400 n1_m9_496800_250400 0.096000
R18504 n1_m9_496800_250400 n1_m9_519200_250400 0.096000
R18505 n1_m9_519200_250400 n1_m9_541600_250400 0.096000
R18506 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R18507 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R18508 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R18509 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R18510 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R18511 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R18512 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R18513 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R18514 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R18515 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R18516 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R18517 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R18518 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R18519 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R18520 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R18521 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R18522 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R18523 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R18524 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R18525 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R18526 n1_m9_452000_272800 n1_m9_474400_272800 0.096000
R18527 n1_m9_474400_272800 n1_m9_496800_272800 0.096000
R18528 n1_m9_496800_272800 n1_m9_519200_272800 0.096000
R18529 n1_m9_519200_272800 n1_m9_541600_272800 0.096000
R18530 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R18531 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R18532 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R18533 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R18534 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R18535 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R18536 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R18537 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R18538 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R18539 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R18540 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R18541 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R18542 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R18543 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R18544 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R18545 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R18546 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R18547 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R18548 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R18549 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R18550 n1_m9_452000_295200 n1_m9_474400_295200 0.096000
R18551 n1_m9_474400_295200 n1_m9_496800_295200 0.096000
R18552 n1_m9_496800_295200 n1_m9_519200_295200 0.096000
R18553 n1_m9_519200_295200 n1_m9_541600_295200 0.096000
R18554 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R18555 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R18556 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R18557 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R18558 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R18559 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R18560 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R18561 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R18562 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R18563 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R18564 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R18565 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R18566 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R18567 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R18568 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R18569 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R18570 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R18571 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R18572 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R18573 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R18574 n1_m9_452000_317600 n1_m9_474400_317600 0.096000
R18575 n1_m9_474400_317600 n1_m9_496800_317600 0.096000
R18576 n1_m9_496800_317600 n1_m9_519200_317600 0.096000
R18577 n1_m9_519200_317600 n1_m9_541600_317600 0.096000
R18578 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R18579 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R18580 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R18581 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R18582 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R18583 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R18584 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R18585 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R18586 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R18587 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R18588 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R18589 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R18590 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R18591 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R18592 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R18593 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R18594 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R18595 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R18596 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R18597 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R18598 n1_m9_452000_340000 n1_m9_474400_340000 0.096000
R18599 n1_m9_474400_340000 n1_m9_496800_340000 0.096000
R18600 n1_m9_496800_340000 n1_m9_519200_340000 0.096000
R18601 n1_m9_519200_340000 n1_m9_541600_340000 0.096000
R18602 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R18603 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R18604 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R18605 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R18606 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R18607 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R18608 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R18609 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R18610 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R18611 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R18612 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R18613 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R18614 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R18615 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R18616 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R18617 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R18618 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R18619 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R18620 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R18621 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R18622 n1_m9_452000_362400 n1_m9_474400_362400 0.096000
R18623 n1_m9_474400_362400 n1_m9_496800_362400 0.096000
R18624 n1_m9_496800_362400 n1_m9_519200_362400 0.096000
R18625 n1_m9_519200_362400 n1_m9_541600_362400 0.096000
R18626 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R18627 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R18628 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R18629 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R18630 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R18631 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R18632 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R18633 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R18634 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R18635 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R18636 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R18637 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R18638 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R18639 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R18640 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R18641 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R18642 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R18643 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R18644 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R18645 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R18646 n1_m9_452000_384800 n1_m9_474400_384800 0.096000
R18647 n1_m9_474400_384800 n1_m9_496800_384800 0.096000
R18648 n1_m9_496800_384800 n1_m9_519200_384800 0.096000
R18649 n1_m9_519200_384800 n1_m9_541600_384800 0.096000
R18650 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R18651 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R18652 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R18653 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R18654 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R18655 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R18656 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R18657 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R18658 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R18659 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R18660 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R18661 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R18662 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R18663 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R18664 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R18665 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R18666 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R18667 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R18668 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R18669 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R18670 n1_m9_452000_407200 n1_m9_474400_407200 0.096000
R18671 n1_m9_474400_407200 n1_m9_496800_407200 0.096000
R18672 n1_m9_496800_407200 n1_m9_519200_407200 0.096000
R18673 n1_m9_519200_407200 n1_m9_541600_407200 0.096000
R18674 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R18675 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R18676 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R18677 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R18678 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R18679 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R18680 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R18681 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R18682 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R18683 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R18684 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R18685 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R18686 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R18687 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R18688 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R18689 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R18690 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R18691 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R18692 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R18693 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R18694 n1_m9_452000_429600 n1_m9_474400_429600 0.096000
R18695 n1_m9_474400_429600 n1_m9_496800_429600 0.096000
R18696 n1_m9_496800_429600 n1_m9_519200_429600 0.096000
R18697 n1_m9_519200_429600 n1_m9_541600_429600 0.096000
R18698 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R18699 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R18700 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R18701 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R18702 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R18703 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R18704 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R18705 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R18706 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R18707 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R18708 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R18709 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R18710 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R18711 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R18712 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R18713 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R18714 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R18715 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R18716 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R18717 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R18718 n1_m9_452000_452000 n1_m9_474400_452000 0.096000
R18719 n1_m9_474400_452000 n1_m9_496800_452000 0.096000
R18720 n1_m9_496800_452000 n1_m9_519200_452000 0.096000
R18721 n1_m9_519200_452000 n1_m9_541600_452000 0.096000
R18722 n1_m9_4000_474400 n1_m9_26400_474400 0.096000
R18723 n1_m9_26400_474400 n1_m9_48800_474400 0.096000
R18724 n1_m9_48800_474400 n1_m9_71200_474400 0.096000
R18725 n1_m9_71200_474400 n1_m9_93600_474400 0.096000
R18726 n1_m9_93600_474400 n1_m9_116000_474400 0.096000
R18727 n1_m9_116000_474400 n1_m9_138400_474400 0.096000
R18728 n1_m9_138400_474400 n1_m9_160800_474400 0.096000
R18729 n1_m9_160800_474400 n1_m9_183200_474400 0.096000
R18730 n1_m9_183200_474400 n1_m9_205600_474400 0.096000
R18731 n1_m9_205600_474400 n1_m9_228000_474400 0.096000
R18732 n1_m9_228000_474400 n1_m9_250400_474400 0.096000
R18733 n1_m9_250400_474400 n1_m9_272800_474400 0.096000
R18734 n1_m9_272800_474400 n1_m9_295200_474400 0.096000
R18735 n1_m9_295200_474400 n1_m9_317600_474400 0.096000
R18736 n1_m9_317600_474400 n1_m9_340000_474400 0.096000
R18737 n1_m9_340000_474400 n1_m9_362400_474400 0.096000
R18738 n1_m9_362400_474400 n1_m9_384800_474400 0.096000
R18739 n1_m9_384800_474400 n1_m9_407200_474400 0.096000
R18740 n1_m9_407200_474400 n1_m9_429600_474400 0.096000
R18741 n1_m9_429600_474400 n1_m9_452000_474400 0.096000
R18742 n1_m9_452000_474400 n1_m9_474400_474400 0.096000
R18743 n1_m9_474400_474400 n1_m9_496800_474400 0.096000
R18744 n1_m9_496800_474400 n1_m9_519200_474400 0.096000
R18745 n1_m9_519200_474400 n1_m9_541600_474400 0.096000
R18746 n1_m9_4000_496800 n1_m9_26400_496800 0.096000
R18747 n1_m9_26400_496800 n1_m9_48800_496800 0.096000
R18748 n1_m9_48800_496800 n1_m9_71200_496800 0.096000
R18749 n1_m9_71200_496800 n1_m9_93600_496800 0.096000
R18750 n1_m9_93600_496800 n1_m9_116000_496800 0.096000
R18751 n1_m9_116000_496800 n1_m9_138400_496800 0.096000
R18752 n1_m9_138400_496800 n1_m9_160800_496800 0.096000
R18753 n1_m9_160800_496800 n1_m9_183200_496800 0.096000
R18754 n1_m9_183200_496800 n1_m9_205600_496800 0.096000
R18755 n1_m9_205600_496800 n1_m9_228000_496800 0.096000
R18756 n1_m9_228000_496800 n1_m9_250400_496800 0.096000
R18757 n1_m9_250400_496800 n1_m9_272800_496800 0.096000
R18758 n1_m9_272800_496800 n1_m9_295200_496800 0.096000
R18759 n1_m9_295200_496800 n1_m9_317600_496800 0.096000
R18760 n1_m9_317600_496800 n1_m9_340000_496800 0.096000
R18761 n1_m9_340000_496800 n1_m9_362400_496800 0.096000
R18762 n1_m9_362400_496800 n1_m9_384800_496800 0.096000
R18763 n1_m9_384800_496800 n1_m9_407200_496800 0.096000
R18764 n1_m9_407200_496800 n1_m9_429600_496800 0.096000
R18765 n1_m9_429600_496800 n1_m9_452000_496800 0.096000
R18766 n1_m9_452000_496800 n1_m9_474400_496800 0.096000
R18767 n1_m9_474400_496800 n1_m9_496800_496800 0.096000
R18768 n1_m9_496800_496800 n1_m9_519200_496800 0.096000
R18769 n1_m9_519200_496800 n1_m9_541600_496800 0.096000
R18770 n1_m9_4000_519200 n1_m9_26400_519200 0.096000
R18771 n1_m9_26400_519200 n1_m9_48800_519200 0.096000
R18772 n1_m9_48800_519200 n1_m9_71200_519200 0.096000
R18773 n1_m9_71200_519200 n1_m9_93600_519200 0.096000
R18774 n1_m9_93600_519200 n1_m9_116000_519200 0.096000
R18775 n1_m9_116000_519200 n1_m9_138400_519200 0.096000
R18776 n1_m9_138400_519200 n1_m9_160800_519200 0.096000
R18777 n1_m9_160800_519200 n1_m9_183200_519200 0.096000
R18778 n1_m9_183200_519200 n1_m9_205600_519200 0.096000
R18779 n1_m9_205600_519200 n1_m9_228000_519200 0.096000
R18780 n1_m9_228000_519200 n1_m9_250400_519200 0.096000
R18781 n1_m9_250400_519200 n1_m9_272800_519200 0.096000
R18782 n1_m9_272800_519200 n1_m9_295200_519200 0.096000
R18783 n1_m9_295200_519200 n1_m9_317600_519200 0.096000
R18784 n1_m9_317600_519200 n1_m9_340000_519200 0.096000
R18785 n1_m9_340000_519200 n1_m9_362400_519200 0.096000
R18786 n1_m9_362400_519200 n1_m9_384800_519200 0.096000
R18787 n1_m9_384800_519200 n1_m9_407200_519200 0.096000
R18788 n1_m9_407200_519200 n1_m9_429600_519200 0.096000
R18789 n1_m9_429600_519200 n1_m9_452000_519200 0.096000
R18790 n1_m9_452000_519200 n1_m9_474400_519200 0.096000
R18791 n1_m9_474400_519200 n1_m9_496800_519200 0.096000
R18792 n1_m9_496800_519200 n1_m9_519200_519200 0.096000
R18793 n1_m9_519200_519200 n1_m9_541600_519200 0.096000
R18794 n1_m9_4000_541600 n1_m9_26400_541600 0.096000
R18795 n1_m9_26400_541600 n1_m9_48800_541600 0.096000
R18796 n1_m9_48800_541600 n1_m9_71200_541600 0.096000
R18797 n1_m9_71200_541600 n1_m9_93600_541600 0.096000
R18798 n1_m9_93600_541600 n1_m9_116000_541600 0.096000
R18799 n1_m9_116000_541600 n1_m9_138400_541600 0.096000
R18800 n1_m9_138400_541600 n1_m9_160800_541600 0.096000
R18801 n1_m9_160800_541600 n1_m9_183200_541600 0.096000
R18802 n1_m9_183200_541600 n1_m9_205600_541600 0.096000
R18803 n1_m9_205600_541600 n1_m9_228000_541600 0.096000
R18804 n1_m9_228000_541600 n1_m9_250400_541600 0.096000
R18805 n1_m9_250400_541600 n1_m9_272800_541600 0.096000
R18806 n1_m9_272800_541600 n1_m9_295200_541600 0.096000
R18807 n1_m9_295200_541600 n1_m9_317600_541600 0.096000
R18808 n1_m9_317600_541600 n1_m9_340000_541600 0.096000
R18809 n1_m9_340000_541600 n1_m9_362400_541600 0.096000
R18810 n1_m9_362400_541600 n1_m9_384800_541600 0.096000
R18811 n1_m9_384800_541600 n1_m9_407200_541600 0.096000
R18812 n1_m9_407200_541600 n1_m9_429600_541600 0.096000
R18813 n1_m9_429600_541600 n1_m9_452000_541600 0.096000
R18814 n1_m9_452000_541600 n1_m9_474400_541600 0.096000
R18815 n1_m9_474400_541600 n1_m9_496800_541600 0.096000
R18816 n1_m9_496800_541600 n1_m9_519200_541600 0.096000
R18817 n1_m9_519200_541600 n1_m9_541600_541600 0.096000
R18818 n1_m1_4000_0 n1_m4_4000_0 15.000000
R18819 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R18820 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R18821 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R18822 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R18823 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R18824 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R18825 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R18826 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R18827 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R18828 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R18829 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R18830 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R18831 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R18832 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R18833 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R18834 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R18835 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R18836 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R18837 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R18838 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R18839 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R18840 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R18841 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R18842 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R18843 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R18844 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R18845 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R18846 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R18847 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R18848 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R18849 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R18850 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R18851 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R18852 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R18853 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R18854 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R18855 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R18856 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R18857 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R18858 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R18859 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R18860 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R18861 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R18862 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R18863 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R18864 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R18865 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R18866 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R18867 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R18868 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R18869 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R18870 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R18871 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R18872 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R18873 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R18874 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R18875 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R18876 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R18877 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R18878 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R18879 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R18880 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R18881 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R18882 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R18883 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R18884 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R18885 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R18886 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R18887 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R18888 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R18889 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R18890 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R18891 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R18892 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R18893 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R18894 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R18895 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R18896 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R18897 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R18898 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R18899 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R18900 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R18901 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R18902 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R18903 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R18904 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R18905 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R18906 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R18907 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R18908 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R18909 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R18910 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R18911 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R18912 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R18913 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R18914 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R18915 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R18916 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R18917 n1_m1_4000_475200 n1_m4_4000_475200 15.000000
R18918 n1_m1_4000_480000 n1_m4_4000_480000 15.000000
R18919 n1_m1_4000_484800 n1_m4_4000_484800 15.000000
R18920 n1_m1_4000_489600 n1_m4_4000_489600 15.000000
R18921 n1_m1_4000_494400 n1_m4_4000_494400 15.000000
R18922 n1_m1_4000_499200 n1_m4_4000_499200 15.000000
R18923 n1_m1_4000_504000 n1_m4_4000_504000 15.000000
R18924 n1_m1_4000_508800 n1_m4_4000_508800 15.000000
R18925 n1_m1_4000_513600 n1_m4_4000_513600 15.000000
R18926 n1_m1_4000_518400 n1_m4_4000_518400 15.000000
R18927 n1_m1_4000_523200 n1_m4_4000_523200 15.000000
R18928 n1_m1_4000_528000 n1_m4_4000_528000 15.000000
R18929 n1_m1_4000_532800 n1_m4_4000_532800 15.000000
R18930 n1_m1_4000_537600 n1_m4_4000_537600 15.000000
R18931 n1_m1_4000_542400 n1_m4_4000_542400 15.000000
R18932 n1_m1_4000_547200 n1_m4_4000_547200 15.000000
R18933 n1_m1_4000_552000 n1_m4_4000_552000 15.000000
R18934 n1_m1_4000_556800 n1_m4_4000_556800 15.000000
R18935 n1_m1_32000_0 n1_m4_32000_0 15.000000
R18936 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R18937 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R18938 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R18939 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R18940 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R18941 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R18942 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R18943 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R18944 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R18945 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R18946 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R18947 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R18948 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R18949 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R18950 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R18951 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R18952 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R18953 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R18954 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R18955 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R18956 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R18957 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R18958 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R18959 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R18960 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R18961 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R18962 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R18963 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R18964 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R18965 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R18966 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R18967 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R18968 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R18969 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R18970 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R18971 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R18972 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R18973 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R18974 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R18975 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R18976 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R18977 n1_m1_32000_201600 n1_m4_32000_201600 15.000000
R18978 n1_m1_32000_206400 n1_m4_32000_206400 15.000000
R18979 n1_m1_32000_211200 n1_m4_32000_211200 15.000000
R18980 n1_m1_32000_216000 n1_m4_32000_216000 15.000000
R18981 n1_m1_32000_220800 n1_m4_32000_220800 15.000000
R18982 n1_m1_32000_225600 n1_m4_32000_225600 15.000000
R18983 n1_m1_32000_230400 n1_m4_32000_230400 15.000000
R18984 n1_m1_32000_235200 n1_m4_32000_235200 15.000000
R18985 n1_m1_32000_240000 n1_m4_32000_240000 15.000000
R18986 n1_m1_32000_244800 n1_m4_32000_244800 15.000000
R18987 n1_m1_32000_249600 n1_m4_32000_249600 15.000000
R18988 n1_m1_32000_254400 n1_m4_32000_254400 15.000000
R18989 n1_m1_32000_259200 n1_m4_32000_259200 15.000000
R18990 n1_m1_32000_264000 n1_m4_32000_264000 15.000000
R18991 n1_m1_32000_268800 n1_m4_32000_268800 15.000000
R18992 n1_m1_32000_273600 n1_m4_32000_273600 15.000000
R18993 n1_m1_32000_278400 n1_m4_32000_278400 15.000000
R18994 n1_m1_32000_283200 n1_m4_32000_283200 15.000000
R18995 n1_m1_32000_288000 n1_m4_32000_288000 15.000000
R18996 n1_m1_32000_292800 n1_m4_32000_292800 15.000000
R18997 n1_m1_32000_297600 n1_m4_32000_297600 15.000000
R18998 n1_m1_32000_302400 n1_m4_32000_302400 15.000000
R18999 n1_m1_32000_307200 n1_m4_32000_307200 15.000000
R19000 n1_m1_32000_312000 n1_m4_32000_312000 15.000000
R19001 n1_m1_32000_316800 n1_m4_32000_316800 15.000000
R19002 n1_m1_32000_321600 n1_m4_32000_321600 15.000000
R19003 n1_m1_32000_326400 n1_m4_32000_326400 15.000000
R19004 n1_m1_32000_331200 n1_m4_32000_331200 15.000000
R19005 n1_m1_32000_336000 n1_m4_32000_336000 15.000000
R19006 n1_m1_32000_340800 n1_m4_32000_340800 15.000000
R19007 n1_m1_32000_345600 n1_m4_32000_345600 15.000000
R19008 n1_m1_32000_350400 n1_m4_32000_350400 15.000000
R19009 n1_m1_32000_355200 n1_m4_32000_355200 15.000000
R19010 n1_m1_32000_360000 n1_m4_32000_360000 15.000000
R19011 n1_m1_32000_364800 n1_m4_32000_364800 15.000000
R19012 n1_m1_32000_369600 n1_m4_32000_369600 15.000000
R19013 n1_m1_32000_374400 n1_m4_32000_374400 15.000000
R19014 n1_m1_32000_379200 n1_m4_32000_379200 15.000000
R19015 n1_m1_32000_384000 n1_m4_32000_384000 15.000000
R19016 n1_m1_32000_388800 n1_m4_32000_388800 15.000000
R19017 n1_m1_32000_393600 n1_m4_32000_393600 15.000000
R19018 n1_m1_32000_398400 n1_m4_32000_398400 15.000000
R19019 n1_m1_60000_0 n1_m4_60000_0 15.000000
R19020 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R19021 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R19022 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R19023 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R19024 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R19025 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R19026 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R19027 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R19028 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R19029 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R19030 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R19031 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R19032 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R19033 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R19034 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R19035 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R19036 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R19037 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R19038 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R19039 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R19040 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R19041 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R19042 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R19043 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R19044 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R19045 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R19046 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R19047 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R19048 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R19049 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R19050 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R19051 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R19052 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R19053 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R19054 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R19055 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R19056 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R19057 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R19058 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R19059 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R19060 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R19061 n1_m1_60000_201600 n1_m4_60000_201600 15.000000
R19062 n1_m1_60000_206400 n1_m4_60000_206400 15.000000
R19063 n1_m1_60000_211200 n1_m4_60000_211200 15.000000
R19064 n1_m1_60000_216000 n1_m4_60000_216000 15.000000
R19065 n1_m1_60000_220800 n1_m4_60000_220800 15.000000
R19066 n1_m1_60000_225600 n1_m4_60000_225600 15.000000
R19067 n1_m1_60000_230400 n1_m4_60000_230400 15.000000
R19068 n1_m1_60000_235200 n1_m4_60000_235200 15.000000
R19069 n1_m1_60000_240000 n1_m4_60000_240000 15.000000
R19070 n1_m1_60000_244800 n1_m4_60000_244800 15.000000
R19071 n1_m1_60000_249600 n1_m4_60000_249600 15.000000
R19072 n1_m1_60000_254400 n1_m4_60000_254400 15.000000
R19073 n1_m1_60000_259200 n1_m4_60000_259200 15.000000
R19074 n1_m1_60000_264000 n1_m4_60000_264000 15.000000
R19075 n1_m1_60000_268800 n1_m4_60000_268800 15.000000
R19076 n1_m1_60000_273600 n1_m4_60000_273600 15.000000
R19077 n1_m1_60000_278400 n1_m4_60000_278400 15.000000
R19078 n1_m1_60000_283200 n1_m4_60000_283200 15.000000
R19079 n1_m1_60000_288000 n1_m4_60000_288000 15.000000
R19080 n1_m1_60000_292800 n1_m4_60000_292800 15.000000
R19081 n1_m1_60000_297600 n1_m4_60000_297600 15.000000
R19082 n1_m1_60000_302400 n1_m4_60000_302400 15.000000
R19083 n1_m1_60000_307200 n1_m4_60000_307200 15.000000
R19084 n1_m1_60000_312000 n1_m4_60000_312000 15.000000
R19085 n1_m1_60000_316800 n1_m4_60000_316800 15.000000
R19086 n1_m1_60000_321600 n1_m4_60000_321600 15.000000
R19087 n1_m1_60000_326400 n1_m4_60000_326400 15.000000
R19088 n1_m1_60000_331200 n1_m4_60000_331200 15.000000
R19089 n1_m1_60000_336000 n1_m4_60000_336000 15.000000
R19090 n1_m1_60000_340800 n1_m4_60000_340800 15.000000
R19091 n1_m1_60000_345600 n1_m4_60000_345600 15.000000
R19092 n1_m1_60000_350400 n1_m4_60000_350400 15.000000
R19093 n1_m1_60000_355200 n1_m4_60000_355200 15.000000
R19094 n1_m1_60000_360000 n1_m4_60000_360000 15.000000
R19095 n1_m1_60000_364800 n1_m4_60000_364800 15.000000
R19096 n1_m1_60000_369600 n1_m4_60000_369600 15.000000
R19097 n1_m1_60000_374400 n1_m4_60000_374400 15.000000
R19098 n1_m1_60000_379200 n1_m4_60000_379200 15.000000
R19099 n1_m1_60000_384000 n1_m4_60000_384000 15.000000
R19100 n1_m1_60000_388800 n1_m4_60000_388800 15.000000
R19101 n1_m1_60000_393600 n1_m4_60000_393600 15.000000
R19102 n1_m1_60000_398400 n1_m4_60000_398400 15.000000
R19103 n1_m1_88000_0 n1_m4_88000_0 15.000000
R19104 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R19105 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R19106 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R19107 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R19108 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R19109 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R19110 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R19111 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R19112 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R19113 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R19114 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R19115 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R19116 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R19117 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R19118 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R19119 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R19120 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R19121 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R19122 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R19123 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R19124 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R19125 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R19126 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R19127 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R19128 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R19129 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R19130 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R19131 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R19132 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R19133 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R19134 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R19135 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R19136 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R19137 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R19138 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R19139 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R19140 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R19141 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R19142 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R19143 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R19144 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R19145 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R19146 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R19147 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R19148 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R19149 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R19150 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R19151 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R19152 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R19153 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R19154 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R19155 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R19156 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R19157 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R19158 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R19159 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R19160 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R19161 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R19162 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R19163 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R19164 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R19165 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R19166 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R19167 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R19168 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R19169 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R19170 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R19171 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R19172 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R19173 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R19174 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R19175 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R19176 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R19177 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R19178 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R19179 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R19180 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R19181 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R19182 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R19183 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R19184 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R19185 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R19186 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R19187 n1_m1_116000_0 n1_m4_116000_0 15.000000
R19188 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R19189 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R19190 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R19191 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R19192 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R19193 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R19194 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R19195 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R19196 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R19197 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R19198 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R19199 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R19200 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R19201 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R19202 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R19203 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R19204 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R19205 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R19206 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R19207 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R19208 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R19209 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R19210 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R19211 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R19212 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R19213 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R19214 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R19215 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R19216 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R19217 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R19218 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R19219 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R19220 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R19221 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R19222 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R19223 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R19224 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R19225 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R19226 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R19227 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R19228 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R19229 n1_m1_116000_201600 n1_m4_116000_201600 15.000000
R19230 n1_m1_116000_206400 n1_m4_116000_206400 15.000000
R19231 n1_m1_116000_211200 n1_m4_116000_211200 15.000000
R19232 n1_m1_116000_216000 n1_m4_116000_216000 15.000000
R19233 n1_m1_116000_220800 n1_m4_116000_220800 15.000000
R19234 n1_m1_116000_225600 n1_m4_116000_225600 15.000000
R19235 n1_m1_116000_230400 n1_m4_116000_230400 15.000000
R19236 n1_m1_116000_235200 n1_m4_116000_235200 15.000000
R19237 n1_m1_116000_240000 n1_m4_116000_240000 15.000000
R19238 n1_m1_116000_244800 n1_m4_116000_244800 15.000000
R19239 n1_m1_116000_249600 n1_m4_116000_249600 15.000000
R19240 n1_m1_116000_254400 n1_m4_116000_254400 15.000000
R19241 n1_m1_116000_259200 n1_m4_116000_259200 15.000000
R19242 n1_m1_116000_264000 n1_m4_116000_264000 15.000000
R19243 n1_m1_116000_268800 n1_m4_116000_268800 15.000000
R19244 n1_m1_116000_273600 n1_m4_116000_273600 15.000000
R19245 n1_m1_116000_278400 n1_m4_116000_278400 15.000000
R19246 n1_m1_116000_283200 n1_m4_116000_283200 15.000000
R19247 n1_m1_116000_288000 n1_m4_116000_288000 15.000000
R19248 n1_m1_116000_292800 n1_m4_116000_292800 15.000000
R19249 n1_m1_116000_297600 n1_m4_116000_297600 15.000000
R19250 n1_m1_116000_302400 n1_m4_116000_302400 15.000000
R19251 n1_m1_116000_307200 n1_m4_116000_307200 15.000000
R19252 n1_m1_116000_312000 n1_m4_116000_312000 15.000000
R19253 n1_m1_116000_316800 n1_m4_116000_316800 15.000000
R19254 n1_m1_116000_321600 n1_m4_116000_321600 15.000000
R19255 n1_m1_116000_326400 n1_m4_116000_326400 15.000000
R19256 n1_m1_116000_331200 n1_m4_116000_331200 15.000000
R19257 n1_m1_116000_336000 n1_m4_116000_336000 15.000000
R19258 n1_m1_116000_340800 n1_m4_116000_340800 15.000000
R19259 n1_m1_116000_345600 n1_m4_116000_345600 15.000000
R19260 n1_m1_116000_350400 n1_m4_116000_350400 15.000000
R19261 n1_m1_116000_355200 n1_m4_116000_355200 15.000000
R19262 n1_m1_116000_360000 n1_m4_116000_360000 15.000000
R19263 n1_m1_116000_364800 n1_m4_116000_364800 15.000000
R19264 n1_m1_116000_369600 n1_m4_116000_369600 15.000000
R19265 n1_m1_116000_374400 n1_m4_116000_374400 15.000000
R19266 n1_m1_116000_379200 n1_m4_116000_379200 15.000000
R19267 n1_m1_116000_384000 n1_m4_116000_384000 15.000000
R19268 n1_m1_116000_388800 n1_m4_116000_388800 15.000000
R19269 n1_m1_116000_393600 n1_m4_116000_393600 15.000000
R19270 n1_m1_116000_398400 n1_m4_116000_398400 15.000000
R19271 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R19272 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R19273 n1_m1_116000_412800 n1_m4_116000_412800 15.000000
R19274 n1_m1_116000_417600 n1_m4_116000_417600 15.000000
R19275 n1_m1_116000_422400 n1_m4_116000_422400 15.000000
R19276 n1_m1_116000_427200 n1_m4_116000_427200 15.000000
R19277 n1_m1_116000_432000 n1_m4_116000_432000 15.000000
R19278 n1_m1_116000_436800 n1_m4_116000_436800 15.000000
R19279 n1_m1_116000_441600 n1_m4_116000_441600 15.000000
R19280 n1_m1_116000_446400 n1_m4_116000_446400 15.000000
R19281 n1_m1_116000_451200 n1_m4_116000_451200 15.000000
R19282 n1_m1_116000_456000 n1_m4_116000_456000 15.000000
R19283 n1_m1_116000_460800 n1_m4_116000_460800 15.000000
R19284 n1_m1_116000_465600 n1_m4_116000_465600 15.000000
R19285 n1_m1_116000_470400 n1_m4_116000_470400 15.000000
R19286 n1_m1_116000_475200 n1_m4_116000_475200 15.000000
R19287 n1_m1_116000_480000 n1_m4_116000_480000 15.000000
R19288 n1_m1_116000_484800 n1_m4_116000_484800 15.000000
R19289 n1_m1_116000_489600 n1_m4_116000_489600 15.000000
R19290 n1_m1_116000_494400 n1_m4_116000_494400 15.000000
R19291 n1_m1_116000_499200 n1_m4_116000_499200 15.000000
R19292 n1_m1_116000_504000 n1_m4_116000_504000 15.000000
R19293 n1_m1_116000_508800 n1_m4_116000_508800 15.000000
R19294 n1_m1_116000_513600 n1_m4_116000_513600 15.000000
R19295 n1_m1_116000_518400 n1_m4_116000_518400 15.000000
R19296 n1_m1_116000_523200 n1_m4_116000_523200 15.000000
R19297 n1_m1_116000_528000 n1_m4_116000_528000 15.000000
R19298 n1_m1_116000_532800 n1_m4_116000_532800 15.000000
R19299 n1_m1_116000_537600 n1_m4_116000_537600 15.000000
R19300 n1_m1_116000_542400 n1_m4_116000_542400 15.000000
R19301 n1_m1_116000_547200 n1_m4_116000_547200 15.000000
R19302 n1_m1_116000_552000 n1_m4_116000_552000 15.000000
R19303 n1_m1_116000_556800 n1_m4_116000_556800 15.000000
R19304 n1_m1_144000_0 n1_m4_144000_0 15.000000
R19305 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R19306 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R19307 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R19308 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R19309 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R19310 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R19311 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R19312 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R19313 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R19314 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R19315 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R19316 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R19317 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R19318 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R19319 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R19320 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R19321 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R19322 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R19323 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R19324 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R19325 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R19326 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R19327 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R19328 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R19329 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R19330 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R19331 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R19332 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R19333 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R19334 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R19335 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R19336 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R19337 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R19338 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R19339 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R19340 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R19341 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R19342 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R19343 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R19344 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R19345 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R19346 n1_m1_144000_201600 n1_m4_144000_201600 15.000000
R19347 n1_m1_144000_206400 n1_m4_144000_206400 15.000000
R19348 n1_m1_144000_211200 n1_m4_144000_211200 15.000000
R19349 n1_m1_144000_216000 n1_m4_144000_216000 15.000000
R19350 n1_m1_144000_220800 n1_m4_144000_220800 15.000000
R19351 n1_m1_144000_225600 n1_m4_144000_225600 15.000000
R19352 n1_m1_144000_230400 n1_m4_144000_230400 15.000000
R19353 n1_m1_144000_235200 n1_m4_144000_235200 15.000000
R19354 n1_m1_144000_240000 n1_m4_144000_240000 15.000000
R19355 n1_m1_144000_244800 n1_m4_144000_244800 15.000000
R19356 n1_m1_144000_249600 n1_m4_144000_249600 15.000000
R19357 n1_m1_144000_254400 n1_m4_144000_254400 15.000000
R19358 n1_m1_144000_259200 n1_m4_144000_259200 15.000000
R19359 n1_m1_144000_264000 n1_m4_144000_264000 15.000000
R19360 n1_m1_144000_268800 n1_m4_144000_268800 15.000000
R19361 n1_m1_144000_273600 n1_m4_144000_273600 15.000000
R19362 n1_m1_144000_278400 n1_m4_144000_278400 15.000000
R19363 n1_m1_144000_283200 n1_m4_144000_283200 15.000000
R19364 n1_m1_144000_288000 n1_m4_144000_288000 15.000000
R19365 n1_m1_144000_292800 n1_m4_144000_292800 15.000000
R19366 n1_m1_144000_297600 n1_m4_144000_297600 15.000000
R19367 n1_m1_144000_302400 n1_m4_144000_302400 15.000000
R19368 n1_m1_144000_307200 n1_m4_144000_307200 15.000000
R19369 n1_m1_144000_312000 n1_m4_144000_312000 15.000000
R19370 n1_m1_144000_316800 n1_m4_144000_316800 15.000000
R19371 n1_m1_144000_321600 n1_m4_144000_321600 15.000000
R19372 n1_m1_144000_326400 n1_m4_144000_326400 15.000000
R19373 n1_m1_144000_331200 n1_m4_144000_331200 15.000000
R19374 n1_m1_144000_336000 n1_m4_144000_336000 15.000000
R19375 n1_m1_144000_340800 n1_m4_144000_340800 15.000000
R19376 n1_m1_144000_345600 n1_m4_144000_345600 15.000000
R19377 n1_m1_144000_350400 n1_m4_144000_350400 15.000000
R19378 n1_m1_144000_355200 n1_m4_144000_355200 15.000000
R19379 n1_m1_144000_360000 n1_m4_144000_360000 15.000000
R19380 n1_m1_144000_364800 n1_m4_144000_364800 15.000000
R19381 n1_m1_144000_369600 n1_m4_144000_369600 15.000000
R19382 n1_m1_144000_374400 n1_m4_144000_374400 15.000000
R19383 n1_m1_144000_379200 n1_m4_144000_379200 15.000000
R19384 n1_m1_144000_384000 n1_m4_144000_384000 15.000000
R19385 n1_m1_144000_388800 n1_m4_144000_388800 15.000000
R19386 n1_m1_144000_393600 n1_m4_144000_393600 15.000000
R19387 n1_m1_144000_398400 n1_m4_144000_398400 15.000000
R19388 n1_m1_172000_0 n1_m4_172000_0 15.000000
R19389 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R19390 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R19391 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R19392 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R19393 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R19394 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R19395 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R19396 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R19397 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R19398 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R19399 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R19400 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R19401 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R19402 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R19403 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R19404 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R19405 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R19406 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R19407 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R19408 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R19409 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R19410 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R19411 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R19412 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R19413 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R19414 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R19415 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R19416 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R19417 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R19418 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R19419 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R19420 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R19421 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R19422 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R19423 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R19424 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R19425 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R19426 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R19427 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R19428 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R19429 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R19430 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R19431 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R19432 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R19433 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R19434 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R19435 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R19436 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R19437 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R19438 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R19439 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R19440 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R19441 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R19442 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R19443 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R19444 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R19445 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R19446 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R19447 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R19448 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R19449 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R19450 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R19451 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R19452 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R19453 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R19454 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R19455 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R19456 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R19457 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R19458 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R19459 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R19460 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R19461 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R19462 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R19463 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R19464 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R19465 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R19466 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R19467 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R19468 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R19469 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R19470 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R19471 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R19472 n1_m1_200000_0 n1_m4_200000_0 15.000000
R19473 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R19474 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R19475 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R19476 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R19477 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R19478 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R19479 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R19480 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R19481 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R19482 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R19483 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R19484 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R19485 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R19486 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R19487 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R19488 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R19489 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R19490 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R19491 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R19492 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R19493 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R19494 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R19495 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R19496 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R19497 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R19498 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R19499 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R19500 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R19501 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R19502 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R19503 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R19504 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R19505 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R19506 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R19507 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R19508 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R19509 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R19510 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R19511 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R19512 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R19513 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R19514 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R19515 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R19516 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R19517 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R19518 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R19519 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R19520 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R19521 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R19522 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R19523 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R19524 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R19525 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R19526 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R19527 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R19528 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R19529 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R19530 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R19531 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R19532 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R19533 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R19534 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R19535 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R19536 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R19537 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R19538 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R19539 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R19540 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R19541 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R19542 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R19543 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R19544 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R19545 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R19546 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R19547 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R19548 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R19549 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R19550 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R19551 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R19552 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R19553 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R19554 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R19555 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R19556 n1_m1_228000_0 n1_m4_228000_0 15.000000
R19557 n1_m1_228000_403200 n1_m4_228000_403200 15.000000
R19558 n1_m1_228000_408000 n1_m4_228000_408000 15.000000
R19559 n1_m1_228000_412800 n1_m4_228000_412800 15.000000
R19560 n1_m1_228000_417600 n1_m4_228000_417600 15.000000
R19561 n1_m1_228000_422400 n1_m4_228000_422400 15.000000
R19562 n1_m1_228000_427200 n1_m4_228000_427200 15.000000
R19563 n1_m1_228000_432000 n1_m4_228000_432000 15.000000
R19564 n1_m1_228000_436800 n1_m4_228000_436800 15.000000
R19565 n1_m1_228000_441600 n1_m4_228000_441600 15.000000
R19566 n1_m1_228000_446400 n1_m4_228000_446400 15.000000
R19567 n1_m1_228000_451200 n1_m4_228000_451200 15.000000
R19568 n1_m1_228000_456000 n1_m4_228000_456000 15.000000
R19569 n1_m1_228000_460800 n1_m4_228000_460800 15.000000
R19570 n1_m1_228000_465600 n1_m4_228000_465600 15.000000
R19571 n1_m1_228000_470400 n1_m4_228000_470400 15.000000
R19572 n1_m1_228000_475200 n1_m4_228000_475200 15.000000
R19573 n1_m1_228000_480000 n1_m4_228000_480000 15.000000
R19574 n1_m1_228000_484800 n1_m4_228000_484800 15.000000
R19575 n1_m1_228000_489600 n1_m4_228000_489600 15.000000
R19576 n1_m1_228000_494400 n1_m4_228000_494400 15.000000
R19577 n1_m1_228000_499200 n1_m4_228000_499200 15.000000
R19578 n1_m1_228000_504000 n1_m4_228000_504000 15.000000
R19579 n1_m1_228000_508800 n1_m4_228000_508800 15.000000
R19580 n1_m1_228000_513600 n1_m4_228000_513600 15.000000
R19581 n1_m1_228000_518400 n1_m4_228000_518400 15.000000
R19582 n1_m1_228000_523200 n1_m4_228000_523200 15.000000
R19583 n1_m1_228000_528000 n1_m4_228000_528000 15.000000
R19584 n1_m1_228000_532800 n1_m4_228000_532800 15.000000
R19585 n1_m1_228000_537600 n1_m4_228000_537600 15.000000
R19586 n1_m1_228000_542400 n1_m4_228000_542400 15.000000
R19587 n1_m1_228000_547200 n1_m4_228000_547200 15.000000
R19588 n1_m1_228000_552000 n1_m4_228000_552000 15.000000
R19589 n1_m1_228000_556800 n1_m4_228000_556800 15.000000
R19590 n1_m1_256000_0 n1_m4_256000_0 15.000000
R19591 n1_m1_256000_4800 n1_m4_256000_4800 15.000000
R19592 n1_m1_256000_9600 n1_m4_256000_9600 15.000000
R19593 n1_m1_256000_14400 n1_m4_256000_14400 15.000000
R19594 n1_m1_256000_19200 n1_m4_256000_19200 15.000000
R19595 n1_m1_256000_24000 n1_m4_256000_24000 15.000000
R19596 n1_m1_256000_28800 n1_m4_256000_28800 15.000000
R19597 n1_m1_256000_33600 n1_m4_256000_33600 15.000000
R19598 n1_m1_256000_38400 n1_m4_256000_38400 15.000000
R19599 n1_m1_256000_43200 n1_m4_256000_43200 15.000000
R19600 n1_m1_256000_48000 n1_m4_256000_48000 15.000000
R19601 n1_m1_256000_52800 n1_m4_256000_52800 15.000000
R19602 n1_m1_256000_57600 n1_m4_256000_57600 15.000000
R19603 n1_m1_256000_62400 n1_m4_256000_62400 15.000000
R19604 n1_m1_256000_67200 n1_m4_256000_67200 15.000000
R19605 n1_m1_256000_72000 n1_m4_256000_72000 15.000000
R19606 n1_m1_256000_76800 n1_m4_256000_76800 15.000000
R19607 n1_m1_256000_81600 n1_m4_256000_81600 15.000000
R19608 n1_m1_256000_86400 n1_m4_256000_86400 15.000000
R19609 n1_m1_256000_91200 n1_m4_256000_91200 15.000000
R19610 n1_m1_256000_96000 n1_m4_256000_96000 15.000000
R19611 n1_m1_256000_100800 n1_m4_256000_100800 15.000000
R19612 n1_m1_256000_105600 n1_m4_256000_105600 15.000000
R19613 n1_m1_256000_110400 n1_m4_256000_110400 15.000000
R19614 n1_m1_256000_115200 n1_m4_256000_115200 15.000000
R19615 n1_m1_256000_120000 n1_m4_256000_120000 15.000000
R19616 n1_m1_256000_124800 n1_m4_256000_124800 15.000000
R19617 n1_m1_256000_129600 n1_m4_256000_129600 15.000000
R19618 n1_m1_256000_134400 n1_m4_256000_134400 15.000000
R19619 n1_m1_256000_139200 n1_m4_256000_139200 15.000000
R19620 n1_m1_256000_144000 n1_m4_256000_144000 15.000000
R19621 n1_m1_256000_148800 n1_m4_256000_148800 15.000000
R19622 n1_m1_256000_153600 n1_m4_256000_153600 15.000000
R19623 n1_m1_256000_158400 n1_m4_256000_158400 15.000000
R19624 n1_m1_256000_163200 n1_m4_256000_163200 15.000000
R19625 n1_m1_256000_168000 n1_m4_256000_168000 15.000000
R19626 n1_m1_256000_172800 n1_m4_256000_172800 15.000000
R19627 n1_m1_256000_177600 n1_m4_256000_177600 15.000000
R19628 n1_m1_256000_182400 n1_m4_256000_182400 15.000000
R19629 n1_m1_256000_187200 n1_m4_256000_187200 15.000000
R19630 n1_m1_256000_192000 n1_m4_256000_192000 15.000000
R19631 n1_m1_256000_196800 n1_m4_256000_196800 15.000000
R19632 n1_m1_256000_201600 n1_m4_256000_201600 15.000000
R19633 n1_m1_256000_206400 n1_m4_256000_206400 15.000000
R19634 n1_m1_256000_211200 n1_m4_256000_211200 15.000000
R19635 n1_m1_256000_216000 n1_m4_256000_216000 15.000000
R19636 n1_m1_256000_220800 n1_m4_256000_220800 15.000000
R19637 n1_m1_256000_225600 n1_m4_256000_225600 15.000000
R19638 n1_m1_256000_230400 n1_m4_256000_230400 15.000000
R19639 n1_m1_256000_235200 n1_m4_256000_235200 15.000000
R19640 n1_m1_256000_240000 n1_m4_256000_240000 15.000000
R19641 n1_m1_256000_244800 n1_m4_256000_244800 15.000000
R19642 n1_m1_256000_249600 n1_m4_256000_249600 15.000000
R19643 n1_m1_256000_254400 n1_m4_256000_254400 15.000000
R19644 n1_m1_256000_259200 n1_m4_256000_259200 15.000000
R19645 n1_m1_256000_264000 n1_m4_256000_264000 15.000000
R19646 n1_m1_256000_268800 n1_m4_256000_268800 15.000000
R19647 n1_m1_256000_273600 n1_m4_256000_273600 15.000000
R19648 n1_m1_256000_278400 n1_m4_256000_278400 15.000000
R19649 n1_m1_256000_283200 n1_m4_256000_283200 15.000000
R19650 n1_m1_256000_288000 n1_m4_256000_288000 15.000000
R19651 n1_m1_256000_292800 n1_m4_256000_292800 15.000000
R19652 n1_m1_256000_297600 n1_m4_256000_297600 15.000000
R19653 n1_m1_256000_302400 n1_m4_256000_302400 15.000000
R19654 n1_m1_256000_307200 n1_m4_256000_307200 15.000000
R19655 n1_m1_256000_312000 n1_m4_256000_312000 15.000000
R19656 n1_m1_256000_316800 n1_m4_256000_316800 15.000000
R19657 n1_m1_256000_321600 n1_m4_256000_321600 15.000000
R19658 n1_m1_256000_326400 n1_m4_256000_326400 15.000000
R19659 n1_m1_256000_331200 n1_m4_256000_331200 15.000000
R19660 n1_m1_256000_336000 n1_m4_256000_336000 15.000000
R19661 n1_m1_256000_340800 n1_m4_256000_340800 15.000000
R19662 n1_m1_256000_345600 n1_m4_256000_345600 15.000000
R19663 n1_m1_256000_350400 n1_m4_256000_350400 15.000000
R19664 n1_m1_256000_355200 n1_m4_256000_355200 15.000000
R19665 n1_m1_256000_360000 n1_m4_256000_360000 15.000000
R19666 n1_m1_256000_364800 n1_m4_256000_364800 15.000000
R19667 n1_m1_256000_369600 n1_m4_256000_369600 15.000000
R19668 n1_m1_256000_374400 n1_m4_256000_374400 15.000000
R19669 n1_m1_256000_379200 n1_m4_256000_379200 15.000000
R19670 n1_m1_256000_384000 n1_m4_256000_384000 15.000000
R19671 n1_m1_256000_388800 n1_m4_256000_388800 15.000000
R19672 n1_m1_256000_393600 n1_m4_256000_393600 15.000000
R19673 n1_m1_256000_398400 n1_m4_256000_398400 15.000000
R19674 n1_m1_256000_403200 n1_m4_256000_403200 15.000000
R19675 n1_m1_256000_408000 n1_m4_256000_408000 15.000000
R19676 n1_m1_256000_412800 n1_m4_256000_412800 15.000000
R19677 n1_m1_256000_417600 n1_m4_256000_417600 15.000000
R19678 n1_m1_256000_422400 n1_m4_256000_422400 15.000000
R19679 n1_m1_256000_427200 n1_m4_256000_427200 15.000000
R19680 n1_m1_256000_432000 n1_m4_256000_432000 15.000000
R19681 n1_m1_256000_436800 n1_m4_256000_436800 15.000000
R19682 n1_m1_256000_441600 n1_m4_256000_441600 15.000000
R19683 n1_m1_256000_446400 n1_m4_256000_446400 15.000000
R19684 n1_m1_256000_451200 n1_m4_256000_451200 15.000000
R19685 n1_m1_256000_456000 n1_m4_256000_456000 15.000000
R19686 n1_m1_256000_460800 n1_m4_256000_460800 15.000000
R19687 n1_m1_256000_465600 n1_m4_256000_465600 15.000000
R19688 n1_m1_256000_470400 n1_m4_256000_470400 15.000000
R19689 n1_m1_256000_475200 n1_m4_256000_475200 15.000000
R19690 n1_m1_256000_480000 n1_m4_256000_480000 15.000000
R19691 n1_m1_256000_484800 n1_m4_256000_484800 15.000000
R19692 n1_m1_256000_489600 n1_m4_256000_489600 15.000000
R19693 n1_m1_256000_494400 n1_m4_256000_494400 15.000000
R19694 n1_m1_256000_499200 n1_m4_256000_499200 15.000000
R19695 n1_m1_256000_504000 n1_m4_256000_504000 15.000000
R19696 n1_m1_256000_508800 n1_m4_256000_508800 15.000000
R19697 n1_m1_256000_513600 n1_m4_256000_513600 15.000000
R19698 n1_m1_256000_518400 n1_m4_256000_518400 15.000000
R19699 n1_m1_256000_523200 n1_m4_256000_523200 15.000000
R19700 n1_m1_256000_528000 n1_m4_256000_528000 15.000000
R19701 n1_m1_256000_532800 n1_m4_256000_532800 15.000000
R19702 n1_m1_256000_537600 n1_m4_256000_537600 15.000000
R19703 n1_m1_256000_542400 n1_m4_256000_542400 15.000000
R19704 n1_m1_256000_547200 n1_m4_256000_547200 15.000000
R19705 n1_m1_256000_552000 n1_m4_256000_552000 15.000000
R19706 n1_m1_256000_556800 n1_m4_256000_556800 15.000000
R19707 n1_m1_284000_0 n1_m4_284000_0 15.000000
R19708 n1_m1_284000_403200 n1_m4_284000_403200 15.000000
R19709 n1_m1_284000_408000 n1_m4_284000_408000 15.000000
R19710 n1_m1_284000_412800 n1_m4_284000_412800 15.000000
R19711 n1_m1_284000_417600 n1_m4_284000_417600 15.000000
R19712 n1_m1_284000_422400 n1_m4_284000_422400 15.000000
R19713 n1_m1_284000_427200 n1_m4_284000_427200 15.000000
R19714 n1_m1_284000_432000 n1_m4_284000_432000 15.000000
R19715 n1_m1_284000_436800 n1_m4_284000_436800 15.000000
R19716 n1_m1_284000_441600 n1_m4_284000_441600 15.000000
R19717 n1_m1_284000_446400 n1_m4_284000_446400 15.000000
R19718 n1_m1_284000_451200 n1_m4_284000_451200 15.000000
R19719 n1_m1_284000_456000 n1_m4_284000_456000 15.000000
R19720 n1_m1_284000_460800 n1_m4_284000_460800 15.000000
R19721 n1_m1_284000_465600 n1_m4_284000_465600 15.000000
R19722 n1_m1_284000_470400 n1_m4_284000_470400 15.000000
R19723 n1_m1_284000_475200 n1_m4_284000_475200 15.000000
R19724 n1_m1_284000_480000 n1_m4_284000_480000 15.000000
R19725 n1_m1_284000_484800 n1_m4_284000_484800 15.000000
R19726 n1_m1_284000_489600 n1_m4_284000_489600 15.000000
R19727 n1_m1_284000_494400 n1_m4_284000_494400 15.000000
R19728 n1_m1_284000_499200 n1_m4_284000_499200 15.000000
R19729 n1_m1_284000_504000 n1_m4_284000_504000 15.000000
R19730 n1_m1_284000_508800 n1_m4_284000_508800 15.000000
R19731 n1_m1_284000_513600 n1_m4_284000_513600 15.000000
R19732 n1_m1_284000_518400 n1_m4_284000_518400 15.000000
R19733 n1_m1_284000_523200 n1_m4_284000_523200 15.000000
R19734 n1_m1_284000_528000 n1_m4_284000_528000 15.000000
R19735 n1_m1_284000_532800 n1_m4_284000_532800 15.000000
R19736 n1_m1_284000_537600 n1_m4_284000_537600 15.000000
R19737 n1_m1_284000_542400 n1_m4_284000_542400 15.000000
R19738 n1_m1_284000_547200 n1_m4_284000_547200 15.000000
R19739 n1_m1_284000_552000 n1_m4_284000_552000 15.000000
R19740 n1_m1_284000_556800 n1_m4_284000_556800 15.000000
R19741 n1_m1_312000_0 n1_m4_312000_0 15.000000
R19742 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R19743 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R19744 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R19745 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R19746 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R19747 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R19748 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R19749 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R19750 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R19751 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R19752 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R19753 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R19754 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R19755 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R19756 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R19757 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R19758 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R19759 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R19760 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R19761 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R19762 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R19763 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R19764 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R19765 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R19766 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R19767 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R19768 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R19769 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R19770 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R19771 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R19772 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R19773 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R19774 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R19775 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R19776 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R19777 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R19778 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R19779 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R19780 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R19781 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R19782 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R19783 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R19784 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R19785 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R19786 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R19787 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R19788 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R19789 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R19790 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R19791 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R19792 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R19793 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R19794 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R19795 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R19796 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R19797 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R19798 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R19799 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R19800 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R19801 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R19802 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R19803 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R19804 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R19805 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R19806 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R19807 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R19808 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R19809 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R19810 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R19811 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R19812 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R19813 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R19814 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R19815 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R19816 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R19817 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R19818 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R19819 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R19820 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R19821 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R19822 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R19823 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R19824 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R19825 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R19826 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R19827 n1_m1_312000_412800 n1_m4_312000_412800 15.000000
R19828 n1_m1_312000_417600 n1_m4_312000_417600 15.000000
R19829 n1_m1_312000_422400 n1_m4_312000_422400 15.000000
R19830 n1_m1_312000_427200 n1_m4_312000_427200 15.000000
R19831 n1_m1_312000_432000 n1_m4_312000_432000 15.000000
R19832 n1_m1_312000_436800 n1_m4_312000_436800 15.000000
R19833 n1_m1_312000_441600 n1_m4_312000_441600 15.000000
R19834 n1_m1_312000_446400 n1_m4_312000_446400 15.000000
R19835 n1_m1_312000_451200 n1_m4_312000_451200 15.000000
R19836 n1_m1_312000_456000 n1_m4_312000_456000 15.000000
R19837 n1_m1_312000_460800 n1_m4_312000_460800 15.000000
R19838 n1_m1_312000_465600 n1_m4_312000_465600 15.000000
R19839 n1_m1_312000_470400 n1_m4_312000_470400 15.000000
R19840 n1_m1_312000_475200 n1_m4_312000_475200 15.000000
R19841 n1_m1_312000_480000 n1_m4_312000_480000 15.000000
R19842 n1_m1_312000_484800 n1_m4_312000_484800 15.000000
R19843 n1_m1_312000_489600 n1_m4_312000_489600 15.000000
R19844 n1_m1_312000_494400 n1_m4_312000_494400 15.000000
R19845 n1_m1_312000_499200 n1_m4_312000_499200 15.000000
R19846 n1_m1_312000_504000 n1_m4_312000_504000 15.000000
R19847 n1_m1_312000_508800 n1_m4_312000_508800 15.000000
R19848 n1_m1_312000_513600 n1_m4_312000_513600 15.000000
R19849 n1_m1_312000_518400 n1_m4_312000_518400 15.000000
R19850 n1_m1_312000_523200 n1_m4_312000_523200 15.000000
R19851 n1_m1_312000_528000 n1_m4_312000_528000 15.000000
R19852 n1_m1_312000_532800 n1_m4_312000_532800 15.000000
R19853 n1_m1_312000_537600 n1_m4_312000_537600 15.000000
R19854 n1_m1_312000_542400 n1_m4_312000_542400 15.000000
R19855 n1_m1_312000_547200 n1_m4_312000_547200 15.000000
R19856 n1_m1_312000_552000 n1_m4_312000_552000 15.000000
R19857 n1_m1_312000_556800 n1_m4_312000_556800 15.000000
R19858 n1_m1_340000_0 n1_m4_340000_0 15.000000
R19859 n1_m1_340000_403200 n1_m4_340000_403200 15.000000
R19860 n1_m1_340000_408000 n1_m4_340000_408000 15.000000
R19861 n1_m1_340000_412800 n1_m4_340000_412800 15.000000
R19862 n1_m1_340000_417600 n1_m4_340000_417600 15.000000
R19863 n1_m1_340000_422400 n1_m4_340000_422400 15.000000
R19864 n1_m1_340000_427200 n1_m4_340000_427200 15.000000
R19865 n1_m1_340000_432000 n1_m4_340000_432000 15.000000
R19866 n1_m1_340000_436800 n1_m4_340000_436800 15.000000
R19867 n1_m1_340000_441600 n1_m4_340000_441600 15.000000
R19868 n1_m1_340000_446400 n1_m4_340000_446400 15.000000
R19869 n1_m1_340000_451200 n1_m4_340000_451200 15.000000
R19870 n1_m1_340000_456000 n1_m4_340000_456000 15.000000
R19871 n1_m1_340000_460800 n1_m4_340000_460800 15.000000
R19872 n1_m1_340000_465600 n1_m4_340000_465600 15.000000
R19873 n1_m1_340000_470400 n1_m4_340000_470400 15.000000
R19874 n1_m1_340000_475200 n1_m4_340000_475200 15.000000
R19875 n1_m1_340000_480000 n1_m4_340000_480000 15.000000
R19876 n1_m1_340000_484800 n1_m4_340000_484800 15.000000
R19877 n1_m1_340000_489600 n1_m4_340000_489600 15.000000
R19878 n1_m1_340000_494400 n1_m4_340000_494400 15.000000
R19879 n1_m1_340000_499200 n1_m4_340000_499200 15.000000
R19880 n1_m1_340000_504000 n1_m4_340000_504000 15.000000
R19881 n1_m1_340000_508800 n1_m4_340000_508800 15.000000
R19882 n1_m1_340000_513600 n1_m4_340000_513600 15.000000
R19883 n1_m1_340000_518400 n1_m4_340000_518400 15.000000
R19884 n1_m1_340000_523200 n1_m4_340000_523200 15.000000
R19885 n1_m1_340000_528000 n1_m4_340000_528000 15.000000
R19886 n1_m1_340000_532800 n1_m4_340000_532800 15.000000
R19887 n1_m1_340000_537600 n1_m4_340000_537600 15.000000
R19888 n1_m1_340000_542400 n1_m4_340000_542400 15.000000
R19889 n1_m1_340000_547200 n1_m4_340000_547200 15.000000
R19890 n1_m1_340000_552000 n1_m4_340000_552000 15.000000
R19891 n1_m1_340000_556800 n1_m4_340000_556800 15.000000
R19892 n1_m1_368000_0 n1_m4_368000_0 15.000000
R19893 n1_m1_368000_4800 n1_m4_368000_4800 15.000000
R19894 n1_m1_368000_9600 n1_m4_368000_9600 15.000000
R19895 n1_m1_368000_14400 n1_m4_368000_14400 15.000000
R19896 n1_m1_368000_19200 n1_m4_368000_19200 15.000000
R19897 n1_m1_368000_24000 n1_m4_368000_24000 15.000000
R19898 n1_m1_368000_28800 n1_m4_368000_28800 15.000000
R19899 n1_m1_368000_33600 n1_m4_368000_33600 15.000000
R19900 n1_m1_368000_38400 n1_m4_368000_38400 15.000000
R19901 n1_m1_368000_43200 n1_m4_368000_43200 15.000000
R19902 n1_m1_368000_48000 n1_m4_368000_48000 15.000000
R19903 n1_m1_368000_52800 n1_m4_368000_52800 15.000000
R19904 n1_m1_368000_57600 n1_m4_368000_57600 15.000000
R19905 n1_m1_368000_62400 n1_m4_368000_62400 15.000000
R19906 n1_m1_368000_67200 n1_m4_368000_67200 15.000000
R19907 n1_m1_368000_72000 n1_m4_368000_72000 15.000000
R19908 n1_m1_368000_76800 n1_m4_368000_76800 15.000000
R19909 n1_m1_368000_81600 n1_m4_368000_81600 15.000000
R19910 n1_m1_368000_86400 n1_m4_368000_86400 15.000000
R19911 n1_m1_368000_91200 n1_m4_368000_91200 15.000000
R19912 n1_m1_368000_96000 n1_m4_368000_96000 15.000000
R19913 n1_m1_368000_100800 n1_m4_368000_100800 15.000000
R19914 n1_m1_368000_105600 n1_m4_368000_105600 15.000000
R19915 n1_m1_368000_110400 n1_m4_368000_110400 15.000000
R19916 n1_m1_368000_115200 n1_m4_368000_115200 15.000000
R19917 n1_m1_368000_120000 n1_m4_368000_120000 15.000000
R19918 n1_m1_368000_124800 n1_m4_368000_124800 15.000000
R19919 n1_m1_368000_129600 n1_m4_368000_129600 15.000000
R19920 n1_m1_368000_134400 n1_m4_368000_134400 15.000000
R19921 n1_m1_368000_139200 n1_m4_368000_139200 15.000000
R19922 n1_m1_368000_144000 n1_m4_368000_144000 15.000000
R19923 n1_m1_368000_148800 n1_m4_368000_148800 15.000000
R19924 n1_m1_368000_153600 n1_m4_368000_153600 15.000000
R19925 n1_m1_368000_158400 n1_m4_368000_158400 15.000000
R19926 n1_m1_368000_163200 n1_m4_368000_163200 15.000000
R19927 n1_m1_368000_168000 n1_m4_368000_168000 15.000000
R19928 n1_m1_368000_172800 n1_m4_368000_172800 15.000000
R19929 n1_m1_368000_177600 n1_m4_368000_177600 15.000000
R19930 n1_m1_368000_182400 n1_m4_368000_182400 15.000000
R19931 n1_m1_368000_187200 n1_m4_368000_187200 15.000000
R19932 n1_m1_368000_192000 n1_m4_368000_192000 15.000000
R19933 n1_m1_368000_196800 n1_m4_368000_196800 15.000000
R19934 n1_m1_368000_201600 n1_m4_368000_201600 15.000000
R19935 n1_m1_368000_206400 n1_m4_368000_206400 15.000000
R19936 n1_m1_368000_211200 n1_m4_368000_211200 15.000000
R19937 n1_m1_368000_216000 n1_m4_368000_216000 15.000000
R19938 n1_m1_368000_220800 n1_m4_368000_220800 15.000000
R19939 n1_m1_368000_225600 n1_m4_368000_225600 15.000000
R19940 n1_m1_368000_230400 n1_m4_368000_230400 15.000000
R19941 n1_m1_368000_235200 n1_m4_368000_235200 15.000000
R19942 n1_m1_368000_240000 n1_m4_368000_240000 15.000000
R19943 n1_m1_368000_244800 n1_m4_368000_244800 15.000000
R19944 n1_m1_368000_249600 n1_m4_368000_249600 15.000000
R19945 n1_m1_368000_254400 n1_m4_368000_254400 15.000000
R19946 n1_m1_368000_259200 n1_m4_368000_259200 15.000000
R19947 n1_m1_368000_264000 n1_m4_368000_264000 15.000000
R19948 n1_m1_368000_268800 n1_m4_368000_268800 15.000000
R19949 n1_m1_368000_273600 n1_m4_368000_273600 15.000000
R19950 n1_m1_368000_278400 n1_m4_368000_278400 15.000000
R19951 n1_m1_368000_283200 n1_m4_368000_283200 15.000000
R19952 n1_m1_368000_288000 n1_m4_368000_288000 15.000000
R19953 n1_m1_368000_292800 n1_m4_368000_292800 15.000000
R19954 n1_m1_368000_297600 n1_m4_368000_297600 15.000000
R19955 n1_m1_368000_302400 n1_m4_368000_302400 15.000000
R19956 n1_m1_368000_307200 n1_m4_368000_307200 15.000000
R19957 n1_m1_368000_312000 n1_m4_368000_312000 15.000000
R19958 n1_m1_368000_316800 n1_m4_368000_316800 15.000000
R19959 n1_m1_368000_321600 n1_m4_368000_321600 15.000000
R19960 n1_m1_368000_326400 n1_m4_368000_326400 15.000000
R19961 n1_m1_368000_331200 n1_m4_368000_331200 15.000000
R19962 n1_m1_368000_336000 n1_m4_368000_336000 15.000000
R19963 n1_m1_368000_340800 n1_m4_368000_340800 15.000000
R19964 n1_m1_368000_345600 n1_m4_368000_345600 15.000000
R19965 n1_m1_368000_350400 n1_m4_368000_350400 15.000000
R19966 n1_m1_368000_355200 n1_m4_368000_355200 15.000000
R19967 n1_m1_368000_360000 n1_m4_368000_360000 15.000000
R19968 n1_m1_368000_364800 n1_m4_368000_364800 15.000000
R19969 n1_m1_368000_369600 n1_m4_368000_369600 15.000000
R19970 n1_m1_368000_374400 n1_m4_368000_374400 15.000000
R19971 n1_m1_368000_379200 n1_m4_368000_379200 15.000000
R19972 n1_m1_368000_384000 n1_m4_368000_384000 15.000000
R19973 n1_m1_368000_388800 n1_m4_368000_388800 15.000000
R19974 n1_m1_368000_393600 n1_m4_368000_393600 15.000000
R19975 n1_m1_368000_398400 n1_m4_368000_398400 15.000000
R19976 n1_m1_368000_403200 n1_m4_368000_403200 15.000000
R19977 n1_m1_368000_408000 n1_m4_368000_408000 15.000000
R19978 n1_m1_368000_412800 n1_m4_368000_412800 15.000000
R19979 n1_m1_368000_417600 n1_m4_368000_417600 15.000000
R19980 n1_m1_368000_422400 n1_m4_368000_422400 15.000000
R19981 n1_m1_368000_427200 n1_m4_368000_427200 15.000000
R19982 n1_m1_368000_432000 n1_m4_368000_432000 15.000000
R19983 n1_m1_368000_436800 n1_m4_368000_436800 15.000000
R19984 n1_m1_368000_441600 n1_m4_368000_441600 15.000000
R19985 n1_m1_368000_446400 n1_m4_368000_446400 15.000000
R19986 n1_m1_368000_451200 n1_m4_368000_451200 15.000000
R19987 n1_m1_368000_456000 n1_m4_368000_456000 15.000000
R19988 n1_m1_368000_460800 n1_m4_368000_460800 15.000000
R19989 n1_m1_368000_465600 n1_m4_368000_465600 15.000000
R19990 n1_m1_368000_470400 n1_m4_368000_470400 15.000000
R19991 n1_m1_368000_475200 n1_m4_368000_475200 15.000000
R19992 n1_m1_368000_480000 n1_m4_368000_480000 15.000000
R19993 n1_m1_368000_484800 n1_m4_368000_484800 15.000000
R19994 n1_m1_368000_489600 n1_m4_368000_489600 15.000000
R19995 n1_m1_368000_494400 n1_m4_368000_494400 15.000000
R19996 n1_m1_368000_499200 n1_m4_368000_499200 15.000000
R19997 n1_m1_368000_504000 n1_m4_368000_504000 15.000000
R19998 n1_m1_368000_508800 n1_m4_368000_508800 15.000000
R19999 n1_m1_368000_513600 n1_m4_368000_513600 15.000000
R20000 n1_m1_368000_518400 n1_m4_368000_518400 15.000000
R20001 n1_m1_368000_523200 n1_m4_368000_523200 15.000000
R20002 n1_m1_368000_528000 n1_m4_368000_528000 15.000000
R20003 n1_m1_368000_532800 n1_m4_368000_532800 15.000000
R20004 n1_m1_368000_537600 n1_m4_368000_537600 15.000000
R20005 n1_m1_368000_542400 n1_m4_368000_542400 15.000000
R20006 n1_m1_368000_547200 n1_m4_368000_547200 15.000000
R20007 n1_m1_368000_552000 n1_m4_368000_552000 15.000000
R20008 n1_m1_368000_556800 n1_m4_368000_556800 15.000000
R20009 n1_m1_396000_0 n1_m4_396000_0 15.000000
R20010 n1_m1_396000_403200 n1_m4_396000_403200 15.000000
R20011 n1_m1_396000_408000 n1_m4_396000_408000 15.000000
R20012 n1_m1_396000_412800 n1_m4_396000_412800 15.000000
R20013 n1_m1_396000_417600 n1_m4_396000_417600 15.000000
R20014 n1_m1_396000_422400 n1_m4_396000_422400 15.000000
R20015 n1_m1_396000_427200 n1_m4_396000_427200 15.000000
R20016 n1_m1_396000_432000 n1_m4_396000_432000 15.000000
R20017 n1_m1_396000_436800 n1_m4_396000_436800 15.000000
R20018 n1_m1_396000_441600 n1_m4_396000_441600 15.000000
R20019 n1_m1_396000_446400 n1_m4_396000_446400 15.000000
R20020 n1_m1_396000_451200 n1_m4_396000_451200 15.000000
R20021 n1_m1_396000_456000 n1_m4_396000_456000 15.000000
R20022 n1_m1_396000_460800 n1_m4_396000_460800 15.000000
R20023 n1_m1_396000_465600 n1_m4_396000_465600 15.000000
R20024 n1_m1_396000_470400 n1_m4_396000_470400 15.000000
R20025 n1_m1_396000_475200 n1_m4_396000_475200 15.000000
R20026 n1_m1_396000_480000 n1_m4_396000_480000 15.000000
R20027 n1_m1_396000_484800 n1_m4_396000_484800 15.000000
R20028 n1_m1_396000_489600 n1_m4_396000_489600 15.000000
R20029 n1_m1_396000_494400 n1_m4_396000_494400 15.000000
R20030 n1_m1_396000_499200 n1_m4_396000_499200 15.000000
R20031 n1_m1_396000_504000 n1_m4_396000_504000 15.000000
R20032 n1_m1_396000_508800 n1_m4_396000_508800 15.000000
R20033 n1_m1_396000_513600 n1_m4_396000_513600 15.000000
R20034 n1_m1_396000_518400 n1_m4_396000_518400 15.000000
R20035 n1_m1_396000_523200 n1_m4_396000_523200 15.000000
R20036 n1_m1_396000_528000 n1_m4_396000_528000 15.000000
R20037 n1_m1_396000_532800 n1_m4_396000_532800 15.000000
R20038 n1_m1_396000_537600 n1_m4_396000_537600 15.000000
R20039 n1_m1_396000_542400 n1_m4_396000_542400 15.000000
R20040 n1_m1_396000_547200 n1_m4_396000_547200 15.000000
R20041 n1_m1_396000_552000 n1_m4_396000_552000 15.000000
R20042 n1_m1_396000_556800 n1_m4_396000_556800 15.000000
R20043 n1_m1_424000_0 n1_m4_424000_0 15.000000
R20044 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R20045 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R20046 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R20047 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R20048 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R20049 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R20050 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R20051 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R20052 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R20053 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R20054 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R20055 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R20056 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R20057 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R20058 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R20059 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R20060 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R20061 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R20062 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R20063 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R20064 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R20065 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R20066 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R20067 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R20068 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R20069 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R20070 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R20071 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R20072 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R20073 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R20074 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R20075 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R20076 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R20077 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R20078 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R20079 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R20080 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R20081 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R20082 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R20083 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R20084 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R20085 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R20086 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R20087 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R20088 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R20089 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R20090 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R20091 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R20092 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R20093 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R20094 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R20095 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R20096 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R20097 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R20098 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R20099 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R20100 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R20101 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R20102 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R20103 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R20104 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R20105 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R20106 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R20107 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R20108 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R20109 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R20110 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R20111 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R20112 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R20113 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R20114 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R20115 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R20116 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R20117 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R20118 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R20119 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R20120 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R20121 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R20122 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R20123 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R20124 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R20125 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R20126 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R20127 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R20128 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R20129 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R20130 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R20131 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R20132 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R20133 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R20134 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R20135 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R20136 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R20137 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R20138 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R20139 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R20140 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R20141 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R20142 n1_m1_424000_475200 n1_m4_424000_475200 15.000000
R20143 n1_m1_424000_480000 n1_m4_424000_480000 15.000000
R20144 n1_m1_424000_484800 n1_m4_424000_484800 15.000000
R20145 n1_m1_424000_489600 n1_m4_424000_489600 15.000000
R20146 n1_m1_424000_494400 n1_m4_424000_494400 15.000000
R20147 n1_m1_424000_499200 n1_m4_424000_499200 15.000000
R20148 n1_m1_424000_504000 n1_m4_424000_504000 15.000000
R20149 n1_m1_424000_508800 n1_m4_424000_508800 15.000000
R20150 n1_m1_424000_513600 n1_m4_424000_513600 15.000000
R20151 n1_m1_424000_518400 n1_m4_424000_518400 15.000000
R20152 n1_m1_424000_523200 n1_m4_424000_523200 15.000000
R20153 n1_m1_424000_528000 n1_m4_424000_528000 15.000000
R20154 n1_m1_424000_532800 n1_m4_424000_532800 15.000000
R20155 n1_m1_424000_537600 n1_m4_424000_537600 15.000000
R20156 n1_m1_424000_542400 n1_m4_424000_542400 15.000000
R20157 n1_m1_424000_547200 n1_m4_424000_547200 15.000000
R20158 n1_m1_424000_552000 n1_m4_424000_552000 15.000000
R20159 n1_m1_424000_556800 n1_m4_424000_556800 15.000000
R20160 n1_m1_452000_0 n1_m4_452000_0 15.000000
R20161 n1_m1_452000_403200 n1_m4_452000_403200 15.000000
R20162 n1_m1_452000_408000 n1_m4_452000_408000 15.000000
R20163 n1_m1_452000_412800 n1_m4_452000_412800 15.000000
R20164 n1_m1_452000_417600 n1_m4_452000_417600 15.000000
R20165 n1_m1_452000_422400 n1_m4_452000_422400 15.000000
R20166 n1_m1_452000_427200 n1_m4_452000_427200 15.000000
R20167 n1_m1_452000_432000 n1_m4_452000_432000 15.000000
R20168 n1_m1_452000_436800 n1_m4_452000_436800 15.000000
R20169 n1_m1_452000_441600 n1_m4_452000_441600 15.000000
R20170 n1_m1_452000_446400 n1_m4_452000_446400 15.000000
R20171 n1_m1_452000_451200 n1_m4_452000_451200 15.000000
R20172 n1_m1_452000_456000 n1_m4_452000_456000 15.000000
R20173 n1_m1_452000_460800 n1_m4_452000_460800 15.000000
R20174 n1_m1_452000_465600 n1_m4_452000_465600 15.000000
R20175 n1_m1_452000_470400 n1_m4_452000_470400 15.000000
R20176 n1_m1_452000_475200 n1_m4_452000_475200 15.000000
R20177 n1_m1_452000_480000 n1_m4_452000_480000 15.000000
R20178 n1_m1_452000_484800 n1_m4_452000_484800 15.000000
R20179 n1_m1_452000_489600 n1_m4_452000_489600 15.000000
R20180 n1_m1_452000_494400 n1_m4_452000_494400 15.000000
R20181 n1_m1_452000_499200 n1_m4_452000_499200 15.000000
R20182 n1_m1_452000_504000 n1_m4_452000_504000 15.000000
R20183 n1_m1_452000_508800 n1_m4_452000_508800 15.000000
R20184 n1_m1_452000_513600 n1_m4_452000_513600 15.000000
R20185 n1_m1_452000_518400 n1_m4_452000_518400 15.000000
R20186 n1_m1_452000_523200 n1_m4_452000_523200 15.000000
R20187 n1_m1_452000_528000 n1_m4_452000_528000 15.000000
R20188 n1_m1_452000_532800 n1_m4_452000_532800 15.000000
R20189 n1_m1_452000_537600 n1_m4_452000_537600 15.000000
R20190 n1_m1_452000_542400 n1_m4_452000_542400 15.000000
R20191 n1_m1_452000_547200 n1_m4_452000_547200 15.000000
R20192 n1_m1_452000_552000 n1_m4_452000_552000 15.000000
R20193 n1_m1_452000_556800 n1_m4_452000_556800 15.000000
R20194 n1_m1_480000_0 n1_m4_480000_0 15.000000
R20195 n1_m1_480000_403200 n1_m4_480000_403200 15.000000
R20196 n1_m1_480000_408000 n1_m4_480000_408000 15.000000
R20197 n1_m1_480000_412800 n1_m4_480000_412800 15.000000
R20198 n1_m1_480000_417600 n1_m4_480000_417600 15.000000
R20199 n1_m1_480000_422400 n1_m4_480000_422400 15.000000
R20200 n1_m1_480000_427200 n1_m4_480000_427200 15.000000
R20201 n1_m1_480000_432000 n1_m4_480000_432000 15.000000
R20202 n1_m1_480000_436800 n1_m4_480000_436800 15.000000
R20203 n1_m1_480000_441600 n1_m4_480000_441600 15.000000
R20204 n1_m1_480000_446400 n1_m4_480000_446400 15.000000
R20205 n1_m1_480000_451200 n1_m4_480000_451200 15.000000
R20206 n1_m1_480000_456000 n1_m4_480000_456000 15.000000
R20207 n1_m1_480000_460800 n1_m4_480000_460800 15.000000
R20208 n1_m1_480000_465600 n1_m4_480000_465600 15.000000
R20209 n1_m1_480000_470400 n1_m4_480000_470400 15.000000
R20210 n1_m1_480000_475200 n1_m4_480000_475200 15.000000
R20211 n1_m1_480000_480000 n1_m4_480000_480000 15.000000
R20212 n1_m1_480000_484800 n1_m4_480000_484800 15.000000
R20213 n1_m1_480000_489600 n1_m4_480000_489600 15.000000
R20214 n1_m1_480000_494400 n1_m4_480000_494400 15.000000
R20215 n1_m1_480000_499200 n1_m4_480000_499200 15.000000
R20216 n1_m1_480000_504000 n1_m4_480000_504000 15.000000
R20217 n1_m1_480000_508800 n1_m4_480000_508800 15.000000
R20218 n1_m1_480000_513600 n1_m4_480000_513600 15.000000
R20219 n1_m1_480000_518400 n1_m4_480000_518400 15.000000
R20220 n1_m1_480000_523200 n1_m4_480000_523200 15.000000
R20221 n1_m1_480000_528000 n1_m4_480000_528000 15.000000
R20222 n1_m1_480000_532800 n1_m4_480000_532800 15.000000
R20223 n1_m1_480000_537600 n1_m4_480000_537600 15.000000
R20224 n1_m1_480000_542400 n1_m4_480000_542400 15.000000
R20225 n1_m1_480000_547200 n1_m4_480000_547200 15.000000
R20226 n1_m1_480000_552000 n1_m4_480000_552000 15.000000
R20227 n1_m1_480000_556800 n1_m4_480000_556800 15.000000
R20228 n1_m1_508000_0 n1_m4_508000_0 15.000000
R20229 n1_m1_508000_4800 n1_m4_508000_4800 15.000000
R20230 n1_m1_508000_9600 n1_m4_508000_9600 15.000000
R20231 n1_m1_508000_14400 n1_m4_508000_14400 15.000000
R20232 n1_m1_508000_19200 n1_m4_508000_19200 15.000000
R20233 n1_m1_508000_24000 n1_m4_508000_24000 15.000000
R20234 n1_m1_508000_28800 n1_m4_508000_28800 15.000000
R20235 n1_m1_508000_33600 n1_m4_508000_33600 15.000000
R20236 n1_m1_508000_38400 n1_m4_508000_38400 15.000000
R20237 n1_m1_508000_43200 n1_m4_508000_43200 15.000000
R20238 n1_m1_508000_48000 n1_m4_508000_48000 15.000000
R20239 n1_m1_508000_52800 n1_m4_508000_52800 15.000000
R20240 n1_m1_508000_57600 n1_m4_508000_57600 15.000000
R20241 n1_m1_508000_62400 n1_m4_508000_62400 15.000000
R20242 n1_m1_508000_67200 n1_m4_508000_67200 15.000000
R20243 n1_m1_508000_72000 n1_m4_508000_72000 15.000000
R20244 n1_m1_508000_76800 n1_m4_508000_76800 15.000000
R20245 n1_m1_508000_81600 n1_m4_508000_81600 15.000000
R20246 n1_m1_508000_86400 n1_m4_508000_86400 15.000000
R20247 n1_m1_508000_91200 n1_m4_508000_91200 15.000000
R20248 n1_m1_508000_96000 n1_m4_508000_96000 15.000000
R20249 n1_m1_508000_100800 n1_m4_508000_100800 15.000000
R20250 n1_m1_508000_105600 n1_m4_508000_105600 15.000000
R20251 n1_m1_508000_110400 n1_m4_508000_110400 15.000000
R20252 n1_m1_508000_115200 n1_m4_508000_115200 15.000000
R20253 n1_m1_508000_120000 n1_m4_508000_120000 15.000000
R20254 n1_m1_508000_124800 n1_m4_508000_124800 15.000000
R20255 n1_m1_508000_129600 n1_m4_508000_129600 15.000000
R20256 n1_m1_508000_134400 n1_m4_508000_134400 15.000000
R20257 n1_m1_508000_139200 n1_m4_508000_139200 15.000000
R20258 n1_m1_508000_144000 n1_m4_508000_144000 15.000000
R20259 n1_m1_508000_148800 n1_m4_508000_148800 15.000000
R20260 n1_m1_508000_153600 n1_m4_508000_153600 15.000000
R20261 n1_m1_508000_158400 n1_m4_508000_158400 15.000000
R20262 n1_m1_508000_163200 n1_m4_508000_163200 15.000000
R20263 n1_m1_508000_168000 n1_m4_508000_168000 15.000000
R20264 n1_m1_508000_172800 n1_m4_508000_172800 15.000000
R20265 n1_m1_508000_177600 n1_m4_508000_177600 15.000000
R20266 n1_m1_508000_182400 n1_m4_508000_182400 15.000000
R20267 n1_m1_508000_187200 n1_m4_508000_187200 15.000000
R20268 n1_m1_508000_192000 n1_m4_508000_192000 15.000000
R20269 n1_m1_508000_196800 n1_m4_508000_196800 15.000000
R20270 n1_m1_508000_201600 n1_m4_508000_201600 15.000000
R20271 n1_m1_508000_206400 n1_m4_508000_206400 15.000000
R20272 n1_m1_508000_211200 n1_m4_508000_211200 15.000000
R20273 n1_m1_508000_216000 n1_m4_508000_216000 15.000000
R20274 n1_m1_508000_220800 n1_m4_508000_220800 15.000000
R20275 n1_m1_508000_225600 n1_m4_508000_225600 15.000000
R20276 n1_m1_508000_230400 n1_m4_508000_230400 15.000000
R20277 n1_m1_508000_235200 n1_m4_508000_235200 15.000000
R20278 n1_m1_508000_240000 n1_m4_508000_240000 15.000000
R20279 n1_m1_508000_244800 n1_m4_508000_244800 15.000000
R20280 n1_m1_508000_249600 n1_m4_508000_249600 15.000000
R20281 n1_m1_508000_254400 n1_m4_508000_254400 15.000000
R20282 n1_m1_508000_259200 n1_m4_508000_259200 15.000000
R20283 n1_m1_508000_264000 n1_m4_508000_264000 15.000000
R20284 n1_m1_508000_268800 n1_m4_508000_268800 15.000000
R20285 n1_m1_508000_273600 n1_m4_508000_273600 15.000000
R20286 n1_m1_508000_278400 n1_m4_508000_278400 15.000000
R20287 n1_m1_508000_283200 n1_m4_508000_283200 15.000000
R20288 n1_m1_508000_288000 n1_m4_508000_288000 15.000000
R20289 n1_m1_508000_292800 n1_m4_508000_292800 15.000000
R20290 n1_m1_508000_297600 n1_m4_508000_297600 15.000000
R20291 n1_m1_508000_302400 n1_m4_508000_302400 15.000000
R20292 n1_m1_508000_307200 n1_m4_508000_307200 15.000000
R20293 n1_m1_508000_312000 n1_m4_508000_312000 15.000000
R20294 n1_m1_508000_316800 n1_m4_508000_316800 15.000000
R20295 n1_m1_508000_321600 n1_m4_508000_321600 15.000000
R20296 n1_m1_508000_326400 n1_m4_508000_326400 15.000000
R20297 n1_m1_508000_331200 n1_m4_508000_331200 15.000000
R20298 n1_m1_508000_336000 n1_m4_508000_336000 15.000000
R20299 n1_m1_508000_340800 n1_m4_508000_340800 15.000000
R20300 n1_m1_508000_345600 n1_m4_508000_345600 15.000000
R20301 n1_m1_508000_350400 n1_m4_508000_350400 15.000000
R20302 n1_m1_508000_355200 n1_m4_508000_355200 15.000000
R20303 n1_m1_508000_360000 n1_m4_508000_360000 15.000000
R20304 n1_m1_508000_364800 n1_m4_508000_364800 15.000000
R20305 n1_m1_508000_369600 n1_m4_508000_369600 15.000000
R20306 n1_m1_508000_374400 n1_m4_508000_374400 15.000000
R20307 n1_m1_508000_379200 n1_m4_508000_379200 15.000000
R20308 n1_m1_508000_384000 n1_m4_508000_384000 15.000000
R20309 n1_m1_508000_388800 n1_m4_508000_388800 15.000000
R20310 n1_m1_508000_393600 n1_m4_508000_393600 15.000000
R20311 n1_m1_508000_398400 n1_m4_508000_398400 15.000000
R20312 n1_m1_508000_403200 n1_m4_508000_403200 15.000000
R20313 n1_m1_508000_408000 n1_m4_508000_408000 15.000000
R20314 n1_m1_508000_412800 n1_m4_508000_412800 15.000000
R20315 n1_m1_508000_417600 n1_m4_508000_417600 15.000000
R20316 n1_m1_508000_422400 n1_m4_508000_422400 15.000000
R20317 n1_m1_508000_427200 n1_m4_508000_427200 15.000000
R20318 n1_m1_508000_432000 n1_m4_508000_432000 15.000000
R20319 n1_m1_508000_436800 n1_m4_508000_436800 15.000000
R20320 n1_m1_508000_441600 n1_m4_508000_441600 15.000000
R20321 n1_m1_508000_446400 n1_m4_508000_446400 15.000000
R20322 n1_m1_508000_451200 n1_m4_508000_451200 15.000000
R20323 n1_m1_508000_456000 n1_m4_508000_456000 15.000000
R20324 n1_m1_508000_460800 n1_m4_508000_460800 15.000000
R20325 n1_m1_508000_465600 n1_m4_508000_465600 15.000000
R20326 n1_m1_508000_470400 n1_m4_508000_470400 15.000000
R20327 n1_m1_508000_475200 n1_m4_508000_475200 15.000000
R20328 n1_m1_508000_480000 n1_m4_508000_480000 15.000000
R20329 n1_m1_508000_484800 n1_m4_508000_484800 15.000000
R20330 n1_m1_508000_489600 n1_m4_508000_489600 15.000000
R20331 n1_m1_508000_494400 n1_m4_508000_494400 15.000000
R20332 n1_m1_508000_499200 n1_m4_508000_499200 15.000000
R20333 n1_m1_508000_504000 n1_m4_508000_504000 15.000000
R20334 n1_m1_508000_508800 n1_m4_508000_508800 15.000000
R20335 n1_m1_508000_513600 n1_m4_508000_513600 15.000000
R20336 n1_m1_508000_518400 n1_m4_508000_518400 15.000000
R20337 n1_m1_508000_523200 n1_m4_508000_523200 15.000000
R20338 n1_m1_508000_528000 n1_m4_508000_528000 15.000000
R20339 n1_m1_508000_532800 n1_m4_508000_532800 15.000000
R20340 n1_m1_508000_537600 n1_m4_508000_537600 15.000000
R20341 n1_m1_508000_542400 n1_m4_508000_542400 15.000000
R20342 n1_m1_508000_547200 n1_m4_508000_547200 15.000000
R20343 n1_m1_508000_552000 n1_m4_508000_552000 15.000000
R20344 n1_m1_508000_556800 n1_m4_508000_556800 15.000000
R20345 n1_m1_536000_0 n1_m4_536000_0 15.000000
R20346 n1_m1_536000_403200 n1_m4_536000_403200 15.000000
R20347 n1_m1_536000_408000 n1_m4_536000_408000 15.000000
R20348 n1_m1_536000_412800 n1_m4_536000_412800 15.000000
R20349 n1_m1_536000_417600 n1_m4_536000_417600 15.000000
R20350 n1_m1_536000_422400 n1_m4_536000_422400 15.000000
R20351 n1_m1_536000_427200 n1_m4_536000_427200 15.000000
R20352 n1_m1_536000_432000 n1_m4_536000_432000 15.000000
R20353 n1_m1_536000_436800 n1_m4_536000_436800 15.000000
R20354 n1_m1_536000_441600 n1_m4_536000_441600 15.000000
R20355 n1_m1_536000_446400 n1_m4_536000_446400 15.000000
R20356 n1_m1_536000_451200 n1_m4_536000_451200 15.000000
R20357 n1_m1_536000_456000 n1_m4_536000_456000 15.000000
R20358 n1_m1_536000_460800 n1_m4_536000_460800 15.000000
R20359 n1_m1_536000_465600 n1_m4_536000_465600 15.000000
R20360 n1_m1_536000_470400 n1_m4_536000_470400 15.000000
R20361 n1_m1_536000_475200 n1_m4_536000_475200 15.000000
R20362 n1_m1_536000_480000 n1_m4_536000_480000 15.000000
R20363 n1_m1_536000_484800 n1_m4_536000_484800 15.000000
R20364 n1_m1_536000_489600 n1_m4_536000_489600 15.000000
R20365 n1_m1_536000_494400 n1_m4_536000_494400 15.000000
R20366 n1_m1_536000_499200 n1_m4_536000_499200 15.000000
R20367 n1_m1_536000_504000 n1_m4_536000_504000 15.000000
R20368 n1_m1_536000_508800 n1_m4_536000_508800 15.000000
R20369 n1_m1_536000_513600 n1_m4_536000_513600 15.000000
R20370 n1_m1_536000_518400 n1_m4_536000_518400 15.000000
R20371 n1_m1_536000_523200 n1_m4_536000_523200 15.000000
R20372 n1_m1_536000_528000 n1_m4_536000_528000 15.000000
R20373 n1_m1_536000_532800 n1_m4_536000_532800 15.000000
R20374 n1_m1_536000_537600 n1_m4_536000_537600 15.000000
R20375 n1_m1_536000_542400 n1_m4_536000_542400 15.000000
R20376 n1_m1_536000_547200 n1_m4_536000_547200 15.000000
R20377 n1_m1_536000_552000 n1_m4_536000_552000 15.000000
R20378 n1_m1_536000_556800 n1_m4_536000_556800 15.000000
R20379 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R20380 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R20381 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R20382 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R20383 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R20384 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R20385 n1_m4_4000_484000 n1_m7_4000_484000 9.000000
R20386 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R20387 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R20388 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R20389 n1_m4_32000_244000 n1_m7_32000_244000 9.000000
R20390 n1_m4_32000_324000 n1_m7_32000_324000 9.000000
R20391 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R20392 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R20393 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R20394 n1_m4_60000_244000 n1_m7_60000_244000 9.000000
R20395 n1_m4_60000_324000 n1_m7_60000_324000 9.000000
R20396 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R20397 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R20398 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R20399 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R20400 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R20401 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R20402 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R20403 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R20404 n1_m4_116000_244000 n1_m7_116000_244000 9.000000
R20405 n1_m4_116000_324000 n1_m7_116000_324000 9.000000
R20406 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R20407 n1_m4_116000_484000 n1_m7_116000_484000 9.000000
R20408 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R20409 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R20410 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R20411 n1_m4_144000_244000 n1_m7_144000_244000 9.000000
R20412 n1_m4_144000_324000 n1_m7_144000_324000 9.000000
R20413 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R20414 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R20415 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R20416 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R20417 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R20418 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R20419 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R20420 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R20421 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R20422 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R20423 n1_m4_228000_404000 n1_m7_228000_404000 9.000000
R20424 n1_m4_228000_484000 n1_m7_228000_484000 9.000000
R20425 n1_m4_256000_4000 n1_m7_256000_4000 9.000000
R20426 n1_m4_256000_84000 n1_m7_256000_84000 9.000000
R20427 n1_m4_256000_164000 n1_m7_256000_164000 9.000000
R20428 n1_m4_256000_244000 n1_m7_256000_244000 9.000000
R20429 n1_m4_256000_324000 n1_m7_256000_324000 9.000000
R20430 n1_m4_256000_404000 n1_m7_256000_404000 9.000000
R20431 n1_m4_256000_484000 n1_m7_256000_484000 9.000000
R20432 n1_m4_284000_404000 n1_m7_284000_404000 9.000000
R20433 n1_m4_284000_484000 n1_m7_284000_484000 9.000000
R20434 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R20435 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R20436 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R20437 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R20438 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R20439 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R20440 n1_m4_312000_484000 n1_m7_312000_484000 9.000000
R20441 n1_m4_340000_404000 n1_m7_340000_404000 9.000000
R20442 n1_m4_340000_484000 n1_m7_340000_484000 9.000000
R20443 n1_m4_368000_4000 n1_m7_368000_4000 9.000000
R20444 n1_m4_368000_84000 n1_m7_368000_84000 9.000000
R20445 n1_m4_368000_164000 n1_m7_368000_164000 9.000000
R20446 n1_m4_368000_244000 n1_m7_368000_244000 9.000000
R20447 n1_m4_368000_324000 n1_m7_368000_324000 9.000000
R20448 n1_m4_368000_404000 n1_m7_368000_404000 9.000000
R20449 n1_m4_368000_484000 n1_m7_368000_484000 9.000000
R20450 n1_m4_396000_404000 n1_m7_396000_404000 9.000000
R20451 n1_m4_396000_484000 n1_m7_396000_484000 9.000000
R20452 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R20453 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R20454 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R20455 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R20456 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R20457 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R20458 n1_m4_424000_484000 n1_m7_424000_484000 9.000000
R20459 n1_m4_452000_404000 n1_m7_452000_404000 9.000000
R20460 n1_m4_452000_484000 n1_m7_452000_484000 9.000000
R20461 n1_m4_480000_404000 n1_m7_480000_404000 9.000000
R20462 n1_m4_480000_484000 n1_m7_480000_484000 9.000000
R20463 n1_m4_508000_4000 n1_m7_508000_4000 9.000000
R20464 n1_m4_508000_84000 n1_m7_508000_84000 9.000000
R20465 n1_m4_508000_164000 n1_m7_508000_164000 9.000000
R20466 n1_m4_508000_244000 n1_m7_508000_244000 9.000000
R20467 n1_m4_508000_324000 n1_m7_508000_324000 9.000000
R20468 n1_m4_508000_404000 n1_m7_508000_404000 9.000000
R20469 n1_m4_508000_484000 n1_m7_508000_484000 9.000000
R20470 n1_m4_536000_404000 n1_m7_536000_404000 9.000000
R20471 n1_m4_536000_484000 n1_m7_536000_484000 9.000000
R20472 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R20473 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R20474 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R20475 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R20476 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R20477 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R20478 n1_m7_4000_484000 n1_m8_4000_484000 1.000000
R20479 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R20480 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R20481 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R20482 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R20483 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R20484 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R20485 n1_m7_26400_484000 n1_m8_26400_484000 1.000000
R20486 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R20487 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R20488 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R20489 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R20490 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R20491 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R20492 n1_m7_48800_484000 n1_m8_48800_484000 1.000000
R20493 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R20494 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R20495 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R20496 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R20497 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R20498 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R20499 n1_m7_71200_484000 n1_m8_71200_484000 1.000000
R20500 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R20501 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R20502 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R20503 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R20504 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R20505 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R20506 n1_m7_93600_484000 n1_m8_93600_484000 1.000000
R20507 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R20508 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R20509 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R20510 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R20511 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R20512 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R20513 n1_m7_116000_484000 n1_m8_116000_484000 1.000000
R20514 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R20515 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R20516 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R20517 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R20518 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R20519 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R20520 n1_m7_138400_484000 n1_m8_138400_484000 1.000000
R20521 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R20522 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R20523 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R20524 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R20525 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R20526 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R20527 n1_m7_160800_484000 n1_m8_160800_484000 1.000000
R20528 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R20529 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R20530 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R20531 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R20532 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R20533 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R20534 n1_m7_183200_484000 n1_m8_183200_484000 1.000000
R20535 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R20536 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R20537 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R20538 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R20539 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R20540 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R20541 n1_m7_205600_484000 n1_m8_205600_484000 1.000000
R20542 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R20543 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R20544 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R20545 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R20546 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R20547 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R20548 n1_m7_228000_484000 n1_m8_228000_484000 1.000000
R20549 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R20550 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R20551 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R20552 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R20553 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R20554 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R20555 n1_m7_250400_484000 n1_m8_250400_484000 1.000000
R20556 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R20557 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R20558 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R20559 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R20560 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R20561 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R20562 n1_m7_272800_484000 n1_m8_272800_484000 1.000000
R20563 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R20564 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R20565 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R20566 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R20567 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R20568 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R20569 n1_m7_295200_484000 n1_m8_295200_484000 1.000000
R20570 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R20571 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R20572 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R20573 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R20574 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R20575 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R20576 n1_m7_317600_484000 n1_m8_317600_484000 1.000000
R20577 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R20578 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R20579 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R20580 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R20581 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R20582 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R20583 n1_m7_340000_484000 n1_m8_340000_484000 1.000000
R20584 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R20585 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R20586 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R20587 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R20588 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R20589 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R20590 n1_m7_362400_484000 n1_m8_362400_484000 1.000000
R20591 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R20592 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R20593 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R20594 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R20595 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R20596 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R20597 n1_m7_384800_484000 n1_m8_384800_484000 1.000000
R20598 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R20599 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R20600 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R20601 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R20602 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R20603 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R20604 n1_m7_407200_484000 n1_m8_407200_484000 1.000000
R20605 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R20606 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R20607 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R20608 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R20609 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R20610 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R20611 n1_m7_429600_484000 n1_m8_429600_484000 1.000000
R20612 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R20613 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R20614 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R20615 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R20616 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R20617 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R20618 n1_m7_452000_484000 n1_m8_452000_484000 1.000000
R20619 n1_m7_474400_4000 n1_m8_474400_4000 1.000000
R20620 n1_m7_474400_84000 n1_m8_474400_84000 1.000000
R20621 n1_m7_474400_164000 n1_m8_474400_164000 1.000000
R20622 n1_m7_474400_244000 n1_m8_474400_244000 1.000000
R20623 n1_m7_474400_324000 n1_m8_474400_324000 1.000000
R20624 n1_m7_474400_404000 n1_m8_474400_404000 1.000000
R20625 n1_m7_474400_484000 n1_m8_474400_484000 1.000000
R20626 n1_m7_496800_4000 n1_m8_496800_4000 1.000000
R20627 n1_m7_496800_84000 n1_m8_496800_84000 1.000000
R20628 n1_m7_496800_164000 n1_m8_496800_164000 1.000000
R20629 n1_m7_496800_244000 n1_m8_496800_244000 1.000000
R20630 n1_m7_496800_324000 n1_m8_496800_324000 1.000000
R20631 n1_m7_496800_404000 n1_m8_496800_404000 1.000000
R20632 n1_m7_496800_484000 n1_m8_496800_484000 1.000000
R20633 n1_m7_519200_4000 n1_m8_519200_4000 1.000000
R20634 n1_m7_519200_84000 n1_m8_519200_84000 1.000000
R20635 n1_m7_519200_164000 n1_m8_519200_164000 1.000000
R20636 n1_m7_519200_244000 n1_m8_519200_244000 1.000000
R20637 n1_m7_519200_324000 n1_m8_519200_324000 1.000000
R20638 n1_m7_519200_404000 n1_m8_519200_404000 1.000000
R20639 n1_m7_519200_484000 n1_m8_519200_484000 1.000000
R20640 n1_m7_541600_4000 n1_m8_541600_4000 1.000000
R20641 n1_m7_541600_84000 n1_m8_541600_84000 1.000000
R20642 n1_m7_541600_164000 n1_m8_541600_164000 1.000000
R20643 n1_m7_541600_244000 n1_m8_541600_244000 1.000000
R20644 n1_m7_541600_324000 n1_m8_541600_324000 1.000000
R20645 n1_m7_541600_404000 n1_m8_541600_404000 1.000000
R20646 n1_m7_541600_484000 n1_m8_541600_484000 1.000000
R20647 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R20648 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R20649 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R20650 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R20651 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R20652 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R20653 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R20654 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R20655 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R20656 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R20657 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R20658 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R20659 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R20660 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R20661 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R20662 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R20663 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R20664 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R20665 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R20666 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R20667 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R20668 n1_m8_4000_474400 n1_m9_4000_474400 1.000000
R20669 n1_m8_4000_496800 n1_m9_4000_496800 1.000000
R20670 n1_m8_4000_519200 n1_m9_4000_519200 1.000000
R20671 n1_m8_4000_541600 n1_m9_4000_541600 1.000000
R20672 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R20673 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R20674 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R20675 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R20676 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R20677 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R20678 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R20679 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R20680 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R20681 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R20682 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R20683 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R20684 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R20685 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R20686 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R20687 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R20688 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R20689 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R20690 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R20691 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R20692 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R20693 n1_m8_26400_474400 n1_m9_26400_474400 1.000000
R20694 n1_m8_26400_496800 n1_m9_26400_496800 1.000000
R20695 n1_m8_26400_519200 n1_m9_26400_519200 1.000000
R20696 n1_m8_26400_541600 n1_m9_26400_541600 1.000000
R20697 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R20698 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R20699 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R20700 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R20701 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R20702 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R20703 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R20704 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R20705 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R20706 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R20707 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R20708 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R20709 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R20710 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R20711 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R20712 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R20713 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R20714 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R20715 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R20716 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R20717 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R20718 n1_m8_48800_474400 n1_m9_48800_474400 1.000000
R20719 n1_m8_48800_496800 n1_m9_48800_496800 1.000000
R20720 n1_m8_48800_519200 n1_m9_48800_519200 1.000000
R20721 n1_m8_48800_541600 n1_m9_48800_541600 1.000000
R20722 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R20723 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R20724 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R20725 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R20726 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R20727 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R20728 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R20729 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R20730 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R20731 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R20732 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R20733 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R20734 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R20735 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R20736 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R20737 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R20738 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R20739 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R20740 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R20741 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R20742 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R20743 n1_m8_71200_474400 n1_m9_71200_474400 1.000000
R20744 n1_m8_71200_496800 n1_m9_71200_496800 1.000000
R20745 n1_m8_71200_519200 n1_m9_71200_519200 1.000000
R20746 n1_m8_71200_541600 n1_m9_71200_541600 1.000000
R20747 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R20748 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R20749 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R20750 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R20751 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R20752 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R20753 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R20754 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R20755 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R20756 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R20757 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R20758 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R20759 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R20760 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R20761 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R20762 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R20763 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R20764 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R20765 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R20766 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R20767 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R20768 n1_m8_93600_474400 n1_m9_93600_474400 1.000000
R20769 n1_m8_93600_496800 n1_m9_93600_496800 1.000000
R20770 n1_m8_93600_519200 n1_m9_93600_519200 1.000000
R20771 n1_m8_93600_541600 n1_m9_93600_541600 1.000000
R20772 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R20773 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R20774 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R20775 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R20776 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R20777 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R20778 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R20779 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R20780 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R20781 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R20782 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R20783 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R20784 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R20785 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R20786 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R20787 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R20788 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R20789 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R20790 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R20791 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R20792 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R20793 n1_m8_116000_474400 n1_m9_116000_474400 1.000000
R20794 n1_m8_116000_496800 n1_m9_116000_496800 1.000000
R20795 n1_m8_116000_519200 n1_m9_116000_519200 1.000000
R20796 n1_m8_116000_541600 n1_m9_116000_541600 1.000000
R20797 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R20798 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R20799 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R20800 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R20801 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R20802 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R20803 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R20804 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R20805 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R20806 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R20807 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R20808 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R20809 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R20810 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R20811 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R20812 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R20813 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R20814 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R20815 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R20816 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R20817 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R20818 n1_m8_138400_474400 n1_m9_138400_474400 1.000000
R20819 n1_m8_138400_496800 n1_m9_138400_496800 1.000000
R20820 n1_m8_138400_519200 n1_m9_138400_519200 1.000000
R20821 n1_m8_138400_541600 n1_m9_138400_541600 1.000000
R20822 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R20823 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R20824 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R20825 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R20826 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R20827 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R20828 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R20829 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R20830 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R20831 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R20832 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R20833 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R20834 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R20835 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R20836 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R20837 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R20838 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R20839 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R20840 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R20841 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R20842 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R20843 n1_m8_160800_474400 n1_m9_160800_474400 1.000000
R20844 n1_m8_160800_496800 n1_m9_160800_496800 1.000000
R20845 n1_m8_160800_519200 n1_m9_160800_519200 1.000000
R20846 n1_m8_160800_541600 n1_m9_160800_541600 1.000000
R20847 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R20848 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R20849 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R20850 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R20851 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R20852 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R20853 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R20854 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R20855 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R20856 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R20857 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R20858 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R20859 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R20860 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R20861 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R20862 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R20863 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R20864 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R20865 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R20866 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R20867 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R20868 n1_m8_183200_474400 n1_m9_183200_474400 1.000000
R20869 n1_m8_183200_496800 n1_m9_183200_496800 1.000000
R20870 n1_m8_183200_519200 n1_m9_183200_519200 1.000000
R20871 n1_m8_183200_541600 n1_m9_183200_541600 1.000000
R20872 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R20873 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R20874 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R20875 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R20876 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R20877 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R20878 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R20879 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R20880 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R20881 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R20882 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R20883 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R20884 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R20885 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R20886 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R20887 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R20888 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R20889 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R20890 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R20891 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R20892 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R20893 n1_m8_205600_474400 n1_m9_205600_474400 1.000000
R20894 n1_m8_205600_496800 n1_m9_205600_496800 1.000000
R20895 n1_m8_205600_519200 n1_m9_205600_519200 1.000000
R20896 n1_m8_205600_541600 n1_m9_205600_541600 1.000000
R20897 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R20898 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R20899 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R20900 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R20901 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R20902 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R20903 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R20904 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R20905 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R20906 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R20907 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R20908 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R20909 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R20910 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R20911 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R20912 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R20913 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R20914 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R20915 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R20916 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R20917 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R20918 n1_m8_228000_474400 n1_m9_228000_474400 1.000000
R20919 n1_m8_228000_496800 n1_m9_228000_496800 1.000000
R20920 n1_m8_228000_519200 n1_m9_228000_519200 1.000000
R20921 n1_m8_228000_541600 n1_m9_228000_541600 1.000000
R20922 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R20923 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R20924 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R20925 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R20926 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R20927 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R20928 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R20929 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R20930 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R20931 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R20932 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R20933 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R20934 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R20935 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R20936 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R20937 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R20938 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R20939 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R20940 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R20941 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R20942 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R20943 n1_m8_250400_474400 n1_m9_250400_474400 1.000000
R20944 n1_m8_250400_496800 n1_m9_250400_496800 1.000000
R20945 n1_m8_250400_519200 n1_m9_250400_519200 1.000000
R20946 n1_m8_250400_541600 n1_m9_250400_541600 1.000000
R20947 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R20948 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R20949 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R20950 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R20951 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R20952 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R20953 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R20954 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R20955 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R20956 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R20957 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R20958 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R20959 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R20960 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R20961 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R20962 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R20963 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R20964 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R20965 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R20966 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R20967 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R20968 n1_m8_272800_474400 n1_m9_272800_474400 1.000000
R20969 n1_m8_272800_496800 n1_m9_272800_496800 1.000000
R20970 n1_m8_272800_519200 n1_m9_272800_519200 1.000000
R20971 n1_m8_272800_541600 n1_m9_272800_541600 1.000000
R20972 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R20973 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R20974 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R20975 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R20976 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R20977 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R20978 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R20979 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R20980 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R20981 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R20982 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R20983 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R20984 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R20985 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R20986 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R20987 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R20988 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R20989 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R20990 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R20991 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R20992 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R20993 n1_m8_295200_474400 n1_m9_295200_474400 1.000000
R20994 n1_m8_295200_496800 n1_m9_295200_496800 1.000000
R20995 n1_m8_295200_519200 n1_m9_295200_519200 1.000000
R20996 n1_m8_295200_541600 n1_m9_295200_541600 1.000000
R20997 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R20998 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R20999 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R21000 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R21001 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R21002 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R21003 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R21004 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R21005 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R21006 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R21007 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R21008 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R21009 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R21010 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R21011 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R21012 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R21013 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R21014 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R21015 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R21016 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R21017 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R21018 n1_m8_317600_474400 n1_m9_317600_474400 1.000000
R21019 n1_m8_317600_496800 n1_m9_317600_496800 1.000000
R21020 n1_m8_317600_519200 n1_m9_317600_519200 1.000000
R21021 n1_m8_317600_541600 n1_m9_317600_541600 1.000000
R21022 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R21023 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R21024 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R21025 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R21026 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R21027 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R21028 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R21029 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R21030 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R21031 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R21032 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R21033 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R21034 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R21035 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R21036 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R21037 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R21038 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R21039 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R21040 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R21041 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R21042 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R21043 n1_m8_340000_474400 n1_m9_340000_474400 1.000000
R21044 n1_m8_340000_496800 n1_m9_340000_496800 1.000000
R21045 n1_m8_340000_519200 n1_m9_340000_519200 1.000000
R21046 n1_m8_340000_541600 n1_m9_340000_541600 1.000000
R21047 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R21048 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R21049 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R21050 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R21051 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R21052 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R21053 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R21054 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R21055 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R21056 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R21057 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R21058 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R21059 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R21060 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R21061 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R21062 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R21063 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R21064 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R21065 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R21066 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R21067 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R21068 n1_m8_362400_474400 n1_m9_362400_474400 1.000000
R21069 n1_m8_362400_496800 n1_m9_362400_496800 1.000000
R21070 n1_m8_362400_519200 n1_m9_362400_519200 1.000000
R21071 n1_m8_362400_541600 n1_m9_362400_541600 1.000000
R21072 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R21073 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R21074 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R21075 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R21076 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R21077 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R21078 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R21079 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R21080 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R21081 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R21082 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R21083 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R21084 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R21085 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R21086 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R21087 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R21088 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R21089 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R21090 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R21091 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R21092 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R21093 n1_m8_384800_474400 n1_m9_384800_474400 1.000000
R21094 n1_m8_384800_496800 n1_m9_384800_496800 1.000000
R21095 n1_m8_384800_519200 n1_m9_384800_519200 1.000000
R21096 n1_m8_384800_541600 n1_m9_384800_541600 1.000000
R21097 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R21098 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R21099 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R21100 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R21101 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R21102 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R21103 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R21104 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R21105 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R21106 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R21107 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R21108 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R21109 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R21110 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R21111 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R21112 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R21113 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R21114 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R21115 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R21116 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R21117 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R21118 n1_m8_407200_474400 n1_m9_407200_474400 1.000000
R21119 n1_m8_407200_496800 n1_m9_407200_496800 1.000000
R21120 n1_m8_407200_519200 n1_m9_407200_519200 1.000000
R21121 n1_m8_407200_541600 n1_m9_407200_541600 1.000000
R21122 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R21123 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R21124 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R21125 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R21126 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R21127 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R21128 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R21129 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R21130 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R21131 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R21132 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R21133 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R21134 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R21135 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R21136 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R21137 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R21138 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R21139 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R21140 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R21141 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R21142 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R21143 n1_m8_429600_474400 n1_m9_429600_474400 1.000000
R21144 n1_m8_429600_496800 n1_m9_429600_496800 1.000000
R21145 n1_m8_429600_519200 n1_m9_429600_519200 1.000000
R21146 n1_m8_429600_541600 n1_m9_429600_541600 1.000000
R21147 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R21148 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R21149 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R21150 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R21151 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R21152 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R21153 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R21154 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R21155 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R21156 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R21157 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R21158 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R21159 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R21160 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R21161 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R21162 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R21163 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R21164 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R21165 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R21166 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R21167 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
R21168 n1_m8_452000_474400 n1_m9_452000_474400 1.000000
R21169 n1_m8_452000_496800 n1_m9_452000_496800 1.000000
R21170 n1_m8_452000_519200 n1_m9_452000_519200 1.000000
R21171 n1_m8_452000_541600 n1_m9_452000_541600 1.000000
R21172 n1_m8_474400_4000 n1_m9_474400_4000 1.000000
R21173 n1_m8_474400_26400 n1_m9_474400_26400 1.000000
R21174 n1_m8_474400_48800 n1_m9_474400_48800 1.000000
R21175 n1_m8_474400_71200 n1_m9_474400_71200 1.000000
R21176 n1_m8_474400_93600 n1_m9_474400_93600 1.000000
R21177 n1_m8_474400_116000 n1_m9_474400_116000 1.000000
R21178 n1_m8_474400_138400 n1_m9_474400_138400 1.000000
R21179 n1_m8_474400_160800 n1_m9_474400_160800 1.000000
R21180 n1_m8_474400_183200 n1_m9_474400_183200 1.000000
R21181 n1_m8_474400_205600 n1_m9_474400_205600 1.000000
R21182 n1_m8_474400_228000 n1_m9_474400_228000 1.000000
R21183 n1_m8_474400_250400 n1_m9_474400_250400 1.000000
R21184 n1_m8_474400_272800 n1_m9_474400_272800 1.000000
R21185 n1_m8_474400_295200 n1_m9_474400_295200 1.000000
R21186 n1_m8_474400_317600 n1_m9_474400_317600 1.000000
R21187 n1_m8_474400_340000 n1_m9_474400_340000 1.000000
R21188 n1_m8_474400_362400 n1_m9_474400_362400 1.000000
R21189 n1_m8_474400_384800 n1_m9_474400_384800 1.000000
R21190 n1_m8_474400_407200 n1_m9_474400_407200 1.000000
R21191 n1_m8_474400_429600 n1_m9_474400_429600 1.000000
R21192 n1_m8_474400_452000 n1_m9_474400_452000 1.000000
R21193 n1_m8_474400_474400 n1_m9_474400_474400 1.000000
R21194 n1_m8_474400_496800 n1_m9_474400_496800 1.000000
R21195 n1_m8_474400_519200 n1_m9_474400_519200 1.000000
R21196 n1_m8_474400_541600 n1_m9_474400_541600 1.000000
R21197 n1_m8_496800_4000 n1_m9_496800_4000 1.000000
R21198 n1_m8_496800_26400 n1_m9_496800_26400 1.000000
R21199 n1_m8_496800_48800 n1_m9_496800_48800 1.000000
R21200 n1_m8_496800_71200 n1_m9_496800_71200 1.000000
R21201 n1_m8_496800_93600 n1_m9_496800_93600 1.000000
R21202 n1_m8_496800_116000 n1_m9_496800_116000 1.000000
R21203 n1_m8_496800_138400 n1_m9_496800_138400 1.000000
R21204 n1_m8_496800_160800 n1_m9_496800_160800 1.000000
R21205 n1_m8_496800_183200 n1_m9_496800_183200 1.000000
R21206 n1_m8_496800_205600 n1_m9_496800_205600 1.000000
R21207 n1_m8_496800_228000 n1_m9_496800_228000 1.000000
R21208 n1_m8_496800_250400 n1_m9_496800_250400 1.000000
R21209 n1_m8_496800_272800 n1_m9_496800_272800 1.000000
R21210 n1_m8_496800_295200 n1_m9_496800_295200 1.000000
R21211 n1_m8_496800_317600 n1_m9_496800_317600 1.000000
R21212 n1_m8_496800_340000 n1_m9_496800_340000 1.000000
R21213 n1_m8_496800_362400 n1_m9_496800_362400 1.000000
R21214 n1_m8_496800_384800 n1_m9_496800_384800 1.000000
R21215 n1_m8_496800_407200 n1_m9_496800_407200 1.000000
R21216 n1_m8_496800_429600 n1_m9_496800_429600 1.000000
R21217 n1_m8_496800_452000 n1_m9_496800_452000 1.000000
R21218 n1_m8_496800_474400 n1_m9_496800_474400 1.000000
R21219 n1_m8_496800_496800 n1_m9_496800_496800 1.000000
R21220 n1_m8_496800_519200 n1_m9_496800_519200 1.000000
R21221 n1_m8_496800_541600 n1_m9_496800_541600 1.000000
R21222 n1_m8_519200_4000 n1_m9_519200_4000 1.000000
R21223 n1_m8_519200_26400 n1_m9_519200_26400 1.000000
R21224 n1_m8_519200_48800 n1_m9_519200_48800 1.000000
R21225 n1_m8_519200_71200 n1_m9_519200_71200 1.000000
R21226 n1_m8_519200_93600 n1_m9_519200_93600 1.000000
R21227 n1_m8_519200_116000 n1_m9_519200_116000 1.000000
R21228 n1_m8_519200_138400 n1_m9_519200_138400 1.000000
R21229 n1_m8_519200_160800 n1_m9_519200_160800 1.000000
R21230 n1_m8_519200_183200 n1_m9_519200_183200 1.000000
R21231 n1_m8_519200_205600 n1_m9_519200_205600 1.000000
R21232 n1_m8_519200_228000 n1_m9_519200_228000 1.000000
R21233 n1_m8_519200_250400 n1_m9_519200_250400 1.000000
R21234 n1_m8_519200_272800 n1_m9_519200_272800 1.000000
R21235 n1_m8_519200_295200 n1_m9_519200_295200 1.000000
R21236 n1_m8_519200_317600 n1_m9_519200_317600 1.000000
R21237 n1_m8_519200_340000 n1_m9_519200_340000 1.000000
R21238 n1_m8_519200_362400 n1_m9_519200_362400 1.000000
R21239 n1_m8_519200_384800 n1_m9_519200_384800 1.000000
R21240 n1_m8_519200_407200 n1_m9_519200_407200 1.000000
R21241 n1_m8_519200_429600 n1_m9_519200_429600 1.000000
R21242 n1_m8_519200_452000 n1_m9_519200_452000 1.000000
R21243 n1_m8_519200_474400 n1_m9_519200_474400 1.000000
R21244 n1_m8_519200_496800 n1_m9_519200_496800 1.000000
R21245 n1_m8_519200_519200 n1_m9_519200_519200 1.000000
R21246 n1_m8_519200_541600 n1_m9_519200_541600 1.000000
R21247 n1_m8_541600_4000 n1_m9_541600_4000 1.000000
R21248 n1_m8_541600_26400 n1_m9_541600_26400 1.000000
R21249 n1_m8_541600_48800 n1_m9_541600_48800 1.000000
R21250 n1_m8_541600_71200 n1_m9_541600_71200 1.000000
R21251 n1_m8_541600_93600 n1_m9_541600_93600 1.000000
R21252 n1_m8_541600_116000 n1_m9_541600_116000 1.000000
R21253 n1_m8_541600_138400 n1_m9_541600_138400 1.000000
R21254 n1_m8_541600_160800 n1_m9_541600_160800 1.000000
R21255 n1_m8_541600_183200 n1_m9_541600_183200 1.000000
R21256 n1_m8_541600_205600 n1_m9_541600_205600 1.000000
R21257 n1_m8_541600_228000 n1_m9_541600_228000 1.000000
R21258 n1_m8_541600_250400 n1_m9_541600_250400 1.000000
R21259 n1_m8_541600_272800 n1_m9_541600_272800 1.000000
R21260 n1_m8_541600_295200 n1_m9_541600_295200 1.000000
R21261 n1_m8_541600_317600 n1_m9_541600_317600 1.000000
R21262 n1_m8_541600_340000 n1_m9_541600_340000 1.000000
R21263 n1_m8_541600_362400 n1_m9_541600_362400 1.000000
R21264 n1_m8_541600_384800 n1_m9_541600_384800 1.000000
R21265 n1_m8_541600_407200 n1_m9_541600_407200 1.000000
R21266 n1_m8_541600_429600 n1_m9_541600_429600 1.000000
R21267 n1_m8_541600_452000 n1_m9_541600_452000 1.000000
R21268 n1_m8_541600_474400 n1_m9_541600_474400 1.000000
R21269 n1_m8_541600_496800 n1_m9_541600_496800 1.000000
R21270 n1_m8_541600_519200 n1_m9_541600_519200 1.000000
R21271 n1_m8_541600_541600 n1_m9_541600_541600 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_340000_250400 0 1.100000
V2 n1_m9_250400_340000 0 1.100000
V3 n1_m9_452000_340000 0 1.100000
R21272 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R21273 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R21274 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R21275 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R21276 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R21277 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R21278 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R21279 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R21280 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R21281 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R21282 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R21283 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R21284 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R21285 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R21286 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R21287 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R21288 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R21289 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R21290 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R21291 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R21292 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R21293 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R21294 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R21295 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R21296 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R21297 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R21298 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R21299 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R21300 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R21301 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R21302 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R21303 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
R21304 n1_m4_200000_470400 n1_m4_200000_475200 1.400000
R21305 n1_m1_200000_475200 n1_m4_200000_475200 15.000000
R21306 n1_m4_200000_475200 n1_m4_200000_480000 1.400000
R21307 n1_m1_200000_480000 n1_m4_200000_480000 15.000000
R21308 n1_m4_200000_480000 n1_m4_200000_484000 1.166667
R21309 n1_m4_200000_484000 n1_m7_200000_484000 9.000000
R21310 n1_m4_200000_484800 n1_m4_200000_484000 0.233333
R21311 n1_m1_200000_484800 n1_m4_200000_484800 15.000000
R21312 n1_m4_200000_484800 n1_m4_200000_489600 1.400000
R21313 n1_m1_200000_489600 n1_m4_200000_489600 15.000000
R21314 n1_m4_200000_489600 n1_m4_200000_494400 1.400000
R21315 n1_m1_200000_494400 n1_m4_200000_494400 15.000000
R21316 n1_m4_200000_494400 n1_m4_200000_499200 1.400000
R21317 n1_m1_200000_499200 n1_m4_200000_499200 15.000000
R21318 n1_m4_200000_499200 n1_m4_200000_504000 1.400000
R21319 n1_m1_200000_504000 n1_m4_200000_504000 15.000000
R21320 n1_m4_200000_504000 n1_m4_200000_508800 1.400000
R21321 n1_m1_200000_508800 n1_m4_200000_508800 15.000000
R21322 n1_m4_200000_508800 n1_m4_200000_513600 1.400000
R21323 n1_m1_200000_513600 n1_m4_200000_513600 15.000000
R21324 n1_m4_200000_513600 n1_m4_200000_518400 1.400000
R21325 n1_m1_200000_518400 n1_m4_200000_518400 15.000000
R21326 n1_m4_200000_518400 n1_m4_200000_523200 1.400000
R21327 n1_m1_200000_523200 n1_m4_200000_523200 15.000000
R21328 n1_m4_200000_523200 n1_m4_200000_528000 1.400000
R21329 n1_m1_200000_528000 n1_m4_200000_528000 15.000000
R21330 n1_m4_200000_528000 n1_m4_200000_532800 1.400000
R21331 n1_m1_200000_532800 n1_m4_200000_532800 15.000000
R21332 n1_m4_200000_532800 n1_m4_200000_537600 1.400000
R21333 n1_m1_200000_537600 n1_m4_200000_537600 15.000000
R21334 n1_m4_200000_537600 n1_m4_200000_542400 1.400000
R21335 n1_m1_200000_542400 n1_m4_200000_542400 15.000000
R21336 n1_m4_200000_542400 n1_m4_200000_547200 1.400000
R21337 n1_m1_200000_547200 n1_m4_200000_547200 15.000000
R21338 n1_m4_200000_547200 n1_m4_200000_552000 1.400000
R21339 n1_m1_200000_552000 n1_m4_200000_552000 15.000000
R21340 n1_m4_200000_552000 n1_m4_200000_556800 1.400000
R21341 n1_m1_200000_556800 n1_m4_200000_556800 15.000000
I0 n1_m1_0_0 0 1.650296e-07
I1 n1_m1_0_4800 0 1.646965e-07
I2 n1_m1_0_9600 0 2.374085e-07
I3 n1_m1_0_14400 0 1.509522e-07
I4 n1_m1_0_19200 0 1.467415e-07
I5 n1_m1_0_24000 0 2.177499e-07
I6 n1_m1_0_28800 0 1.432078e-07
I7 n1_m1_0_33600 0 2.109980e-07
I8 n1_m1_0_38400 0 1.414267e-07
I9 n1_m1_0_43200 0 1.442901e-07
I10 n1_m1_0_48000 0 2.198491e-07
I11 n1_m1_0_52800 0 1.465661e-07
I12 n1_m1_0_57600 0 2.198491e-07
I13 n1_m1_0_62400 0 1.465661e-07
I14 n1_m1_0_67200 0 1.465661e-07
I15 n1_m1_0_72000 0 2.198491e-07
I16 n1_m1_0_76800 0 1.465661e-07
I17 n1_m1_0_81600 0 2.198491e-07
I18 n1_m1_0_86400 0 1.465661e-07
I19 n1_m1_0_91200 0 1.465661e-07
I20 n1_m1_0_96000 0 2.198491e-07
I21 n1_m1_0_100800 0 1.464559e-07
I22 n1_m1_0_105600 0 2.135351e-07
I23 n1_m1_0_110400 0 1.422711e-07
I24 n1_m1_0_115200 0 1.460154e-07
I25 n1_m1_0_120000 0 2.198491e-07
I26 n1_m1_0_124800 0 1.450243e-07
I27 n1_m1_0_129600 0 2.121768e-07
I28 n1_m1_0_134400 0 1.444369e-07
I29 n1_m1_0_139200 0 1.432350e-07
I30 n1_m1_0_144000 0 2.142978e-07
I31 n1_m1_0_148800 0 1.410896e-07
I32 n1_m1_0_153600 0 2.178505e-07
I33 n1_m1_0_158400 0 1.463377e-07
I34 n1_m1_0_163200 0 1.452282e-07
I35 n1_m1_0_168000 0 2.157295e-07
I36 n1_m1_0_172800 0 1.412989e-07
I37 n1_m1_0_177600 0 2.174548e-07
I38 n1_m1_0_182400 0 1.421800e-07
I39 n1_m1_0_187200 0 1.423268e-07
I40 n1_m1_0_192000 0 2.131965e-07
I41 n1_m1_0_196800 0 1.437952e-07
I42 n1_m1_0_201600 0 2.178369e-07
I43 n1_m1_0_206400 0 1.464247e-07
I44 n1_m1_0_211200 0 1.465661e-07
I45 n1_m1_0_216000 0 2.198491e-07
I46 n1_m1_0_220800 0 1.465661e-07
I47 n1_m1_0_225600 0 2.198491e-07
I48 n1_m1_0_230400 0 1.465661e-07
I49 n1_m1_0_235200 0 1.465661e-07
I50 n1_m1_0_240000 0 2.197063e-07
I51 n1_m1_0_244800 0 1.417123e-07
I52 n1_m1_0_249600 0 2.101061e-07
I53 n1_m1_0_254400 0 1.418876e-07
I54 n1_m1_0_259200 0 1.457952e-07
I55 n1_m1_0_264000 0 2.198491e-07
I56 n1_m1_0_268800 0 1.465661e-07
I57 n1_m1_0_273600 0 2.198491e-07
I58 n1_m1_0_278400 0 1.473275e-07
I59 n1_m1_0_283200 0 1.480888e-07
I60 n1_m1_0_288000 0 2.221224e-07
I61 n1_m1_0_292800 0 1.470229e-07
I62 n1_m1_0_297600 0 2.198491e-07
I63 n1_m1_0_302400 0 1.465661e-07
I64 n1_m1_0_307200 0 1.465661e-07
I65 n1_m1_0_312000 0 2.202624e-07
I66 n1_m1_0_316800 0 1.480562e-07
I67 n1_m1_0_321600 0 2.221333e-07
I68 n1_m1_0_326400 0 1.505117e-07
I69 n1_m1_0_331200 0 1.538155e-07
I70 n1_m1_0_336000 0 2.321264e-07
I71 n1_m1_0_340800 0 1.547509e-07
I72 n1_m1_0_345600 0 2.255907e-07
I73 n1_m1_0_350400 0 1.520535e-07
I74 n1_m1_0_355200 0 1.489304e-07
I75 n1_m1_0_360000 0 2.201863e-07
I76 n1_m1_0_364800 0 1.465661e-07
I77 n1_m1_0_369600 0 2.198491e-07
I78 n1_m1_0_374400 0 1.465661e-07
I79 n1_m1_0_379200 0 1.465661e-07
I80 n1_m1_0_384000 0 2.209912e-07
I81 n1_m1_0_388800 0 1.480888e-07
I82 n1_m1_0_393600 0 2.221333e-07
I83 n1_m1_0_398400 0 1.480888e-07
I84 n1_m1_0_403200 0 1.480888e-07
I85 n1_m1_0_408000 0 2.221333e-07
I86 n1_m1_0_412800 0 1.480888e-07
I87 n1_m1_0_417600 0 2.213719e-07
I88 n1_m1_0_422400 0 1.444369e-07
I89 n1_m1_0_427200 0 1.431154e-07
I90 n1_m1_0_432000 0 2.198491e-07
I91 n1_m1_0_436800 0 1.465661e-07
I92 n1_m1_0_441600 0 2.247478e-07
I93 n1_m1_0_446400 0 1.486830e-07
I94 n1_m1_0_451200 0 1.480888e-07
I95 n1_m1_0_456000 0 2.221333e-07
I96 n1_m1_0_460800 0 1.478387e-07
I97 n1_m1_0_465600 0 2.200123e-07
I98 n1_m1_0_470400 0 1.465661e-07
I99 n1_m1_0_475200 0 1.450243e-07
I100 n1_m1_0_480000 0 2.111544e-07
I101 n1_m1_0_484800 0 1.399040e-07
I102 n1_m1_0_489600 0 2.098560e-07
I103 n1_m1_0_494400 0 1.399040e-07
I104 n1_m1_0_499200 0 1.399040e-07
I105 n1_m1_0_504000 0 2.098560e-07
I106 n1_m1_0_508800 0 1.399040e-07
I107 n1_m1_0_513600 0 2.098560e-07
I108 n1_m1_0_518400 0 1.422833e-07
I109 n1_m1_0_523200 0 1.447578e-07
I110 n1_m1_0_528000 0 2.099987e-07
I111 n1_m1_0_532800 0 1.399040e-07
I112 n1_m1_0_537600 0 2.097363e-07
I113 n1_m1_0_542400 0 1.390964e-07
I114 n1_m1_0_547200 0 1.473166e-07
I115 n1_m1_0_552000 0 2.492820e-07
I116 n1_m1_0_556800 0 1.789248e-07
I117 n1_m1_4800_0 0 7.953589e-08
I118 n1_m1_4800_4800 0 7.918851e-08
I119 n1_m1_4800_9600 0 1.143572e-07
I120 n1_m1_4800_14400 0 7.332586e-08
I121 n1_m1_4800_19200 0 7.252641e-08
I122 n1_m1_4800_24000 0 1.052920e-07
I123 n1_m1_4800_28800 0 7.007095e-08
I124 n1_m1_4800_33600 0 1.076761e-07
I125 n1_m1_4800_38400 0 7.328303e-08
I126 n1_m1_4800_43200 0 7.328303e-08
I127 n1_m1_4800_48000 0 1.099507e-07
I128 n1_m1_4800_52800 0 7.355190e-08
I129 n1_m1_4800_57600 0 1.104242e-07
I130 n1_m1_4800_62400 0 7.361614e-08
I131 n1_m1_4800_67200 0 7.357093e-08
I132 n1_m1_4800_72000 0 1.099698e-07
I133 n1_m1_4800_76800 0 7.328303e-08
I134 n1_m1_4800_81600 0 1.099246e-07
I135 n1_m1_4800_86400 0 7.328303e-08
I136 n1_m1_4800_91200 0 7.328303e-08
I137 n1_m1_4800_96000 0 1.099246e-07
I138 n1_m1_4800_100800 0 7.328303e-08
I139 n1_m1_4800_105600 0 1.099246e-07
I140 n1_m1_4800_110400 0 7.328303e-08
I141 n1_m1_4800_115200 0 7.328303e-08
I142 n1_m1_4800_120000 0 1.099246e-07
I143 n1_m1_4800_124800 0 7.328303e-08
I144 n1_m1_4800_129600 0 1.099246e-07
I145 n1_m1_4800_134400 0 7.328303e-08
I146 n1_m1_4800_139200 0 7.161751e-08
I147 n1_m1_4800_144000 0 1.049446e-07
I148 n1_m1_4800_148800 0 7.023275e-08
I149 n1_m1_4800_153600 0 1.090252e-07
I150 n1_m1_4800_158400 0 7.283334e-08
I151 n1_m1_4800_163200 0 7.061344e-08
I152 n1_m1_4800_168000 0 1.049827e-07
I153 n1_m1_4800_172800 0 7.004240e-08
I154 n1_m1_4800_177600 0 1.054205e-07
I155 n1_m1_4800_182400 0 7.028509e-08
I156 n1_m1_4800_187200 0 7.028509e-08
I157 n1_m1_4800_192000 0 1.054276e-07
I158 n1_m1_4800_196800 0 7.028509e-08
I159 n1_m1_4800_201600 0 1.059630e-07
I160 n1_m1_4800_206400 0 7.300465e-08
I161 n1_m1_4800_211200 0 7.328303e-08
I162 n1_m1_4800_216000 0 1.099246e-07
I163 n1_m1_4800_220800 0 7.328303e-08
I164 n1_m1_4800_225600 0 1.099246e-07
I165 n1_m1_4800_230400 0 7.328303e-08
I166 n1_m1_4800_235200 0 7.328303e-08
I167 n1_m1_4800_240000 0 1.098603e-07
I168 n1_m1_4800_244800 0 7.109882e-08
I169 n1_m1_4800_249600 0 1.059202e-07
I170 n1_m1_4800_254400 0 7.296183e-08
I171 n1_m1_4800_259200 0 7.330921e-08
I172 n1_m1_4800_264000 0 1.103600e-07
I173 n1_m1_4800_268800 0 7.361614e-08
I174 n1_m1_4800_273600 0 1.104242e-07
I175 n1_m1_4800_278400 0 7.528166e-08
I176 n1_m1_4800_283200 0 7.694719e-08
I177 n1_m1_4800_288000 0 1.153970e-07
I178 n1_m1_4800_292800 0 7.461545e-08
I179 n1_m1_4800_297600 0 1.104242e-07
I180 n1_m1_4800_302400 0 7.361614e-08
I181 n1_m1_4800_307200 0 7.361614e-08
I182 n1_m1_4800_312000 0 1.113284e-07
I183 n1_m1_4800_316800 0 7.680681e-08
I184 n1_m1_4800_321600 0 1.149425e-07
I185 n1_m1_4800_326400 0 7.661408e-08
I186 n1_m1_4800_331200 0 7.789891e-08
I187 n1_m1_4800_336000 0 1.199177e-07
I188 n1_m1_4800_340800 0 7.994513e-08
I189 n1_m1_4800_345600 0 1.163011e-07
I190 n1_m1_4800_350400 0 7.661408e-08
I191 n1_m1_4800_355200 0 7.646418e-08
I192 n1_m1_4800_360000 0 1.110880e-07
I193 n1_m1_4800_364800 0 7.361614e-08
I194 n1_m1_4800_369600 0 1.102481e-07
I195 n1_m1_4800_374400 0 7.328303e-08
I196 n1_m1_4800_379200 0 7.328303e-08
I197 n1_m1_4800_384000 0 1.124228e-07
I198 n1_m1_4800_388800 0 7.661408e-08
I199 n1_m1_4800_393600 0 1.149211e-07
I200 n1_m1_4800_398400 0 7.661408e-08
I201 n1_m1_4800_403200 0 7.661408e-08
I202 n1_m1_4800_408000 0 1.149211e-07
I203 n1_m1_4800_412800 0 7.661408e-08
I204 n1_m1_4800_417600 0 1.134222e-07
I205 n1_m1_4800_422400 0 7.347814e-08
I206 n1_m1_4800_427200 0 7.328303e-08
I207 n1_m1_4800_432000 0 1.099246e-07
I208 n1_m1_4800_436800 0 7.328303e-08
I209 n1_m1_4800_441600 0 1.105884e-07
I210 n1_m1_4800_446400 0 7.614298e-08
I211 n1_m1_4800_451200 0 7.687105e-08
I212 n1_m1_4800_456000 0 1.150115e-07
I213 n1_m1_4800_460800 0 7.606684e-08
I214 n1_m1_4800_465600 0 1.102815e-07
I215 n1_m1_4800_470400 0 7.328303e-08
I216 n1_m1_4800_475200 0 7.328303e-08
I217 n1_m1_4800_480000 0 1.079116e-07
I218 n1_m1_4800_484800 0 7.008999e-08
I219 n1_m1_4800_489600 0 1.052611e-07
I220 n1_m1_4800_494400 0 7.028509e-08
I221 n1_m1_4800_499200 0 7.028509e-08
I222 n1_m1_4800_504000 0 1.053634e-07
I223 n1_m1_4800_508800 0 6.997816e-08
I224 n1_m1_4800_513600 0 1.049280e-07
I225 n1_m1_4800_518400 0 7.102268e-08
I226 n1_m1_4800_523200 0 7.213620e-08
I227 n1_m1_4800_528000 0 1.049922e-07
I228 n1_m1_4800_532800 0 6.995199e-08
I229 n1_m1_4800_537600 0 1.046663e-07
I230 n1_m1_4800_542400 0 6.737043e-08
I231 n1_m1_4800_547200 0 6.889081e-08
I232 n1_m1_4800_552000 0 1.125823e-07
I233 n1_m1_4800_556800 0 8.049713e-08
I234 n1_m1_9600_0 0 2.277525e-07
I235 n1_m1_9600_4800 0 2.226288e-07
I236 n1_m1_9600_9600 0 3.295279e-07
I237 n1_m1_9600_14400 0 2.169531e-07
I238 n1_m1_9600_19200 0 2.116520e-07
I239 n1_m1_9600_24000 0 3.156796e-07
I240 n1_m1_9600_28800 0 2.139382e-07
I241 n1_m1_9600_33600 0 3.286673e-07
I242 n1_m1_9600_38400 0 2.198491e-07
I243 n1_m1_9600_43200 0 2.198491e-07
I244 n1_m1_9600_48000 0 3.304429e-07
I245 n1_m1_9600_52800 0 2.267243e-07
I246 n1_m1_9600_57600 0 3.425506e-07
I247 n1_m1_9600_62400 0 2.283671e-07
I248 n1_m1_9600_67200 0 2.272111e-07
I249 n1_m1_9600_72000 0 3.309297e-07
I250 n1_m1_9600_76800 0 2.198491e-07
I251 n1_m1_9600_81600 0 3.297737e-07
I252 n1_m1_9600_86400 0 2.198491e-07
I253 n1_m1_9600_91200 0 2.198491e-07
I254 n1_m1_9600_96000 0 3.297737e-07
I255 n1_m1_9600_100800 0 2.198491e-07
I256 n1_m1_9600_105600 0 3.297737e-07
I257 n1_m1_9600_110400 0 2.198491e-07
I258 n1_m1_9600_115200 0 2.198491e-07
I259 n1_m1_9600_120000 0 3.297737e-07
I260 n1_m1_9600_124800 0 2.198491e-07
I261 n1_m1_9600_129600 0 3.297737e-07
I262 n1_m1_9600_134400 0 2.198491e-07
I263 n1_m1_9600_139200 0 2.148525e-07
I264 n1_m1_9600_144000 0 3.152098e-07
I265 n1_m1_9600_148800 0 2.164983e-07
I266 n1_m1_9600_153600 0 3.293311e-07
I267 n1_m1_9600_158400 0 2.196278e-07
I268 n1_m1_9600_163200 0 2.178138e-07
I269 n1_m1_9600_168000 0 3.183444e-07
I270 n1_m1_9600_172800 0 2.133468e-07
I271 n1_m1_9600_177600 0 3.274130e-07
I272 n1_m1_9600_182400 0 2.183739e-07
I273 n1_m1_9600_187200 0 2.183739e-07
I274 n1_m1_9600_192000 0 3.275609e-07
I275 n1_m1_9600_196800 0 2.183739e-07
I276 n1_m1_9600_201600 0 3.278243e-07
I277 n1_m1_9600_206400 0 2.199317e-07
I278 n1_m1_9600_211200 0 2.212475e-07
I279 n1_m1_9600_216000 0 3.322006e-07
I280 n1_m1_9600_220800 0 2.214670e-07
I281 n1_m1_9600_225600 0 3.322006e-07
I282 n1_m1_9600_230400 0 2.214670e-07
I283 n1_m1_9600_235200 0 2.214670e-07
I284 n1_m1_9600_240000 0 3.321343e-07
I285 n1_m1_9600_244800 0 2.192135e-07
I286 n1_m1_9600_249600 0 3.278032e-07
I287 n1_m1_9600_254400 0 2.196910e-07
I288 n1_m1_9600_259200 0 2.205184e-07
I289 n1_m1_9600_264000 0 3.409079e-07
I290 n1_m1_9600_268800 0 2.283671e-07
I291 n1_m1_9600_273600 0 3.425506e-07
I292 n1_m1_9600_278400 0 2.333636e-07
I293 n1_m1_9600_283200 0 2.376899e-07
I294 n1_m1_9600_288000 0 3.550536e-07
I295 n1_m1_9600_292800 0 2.308796e-07
I296 n1_m1_9600_297600 0 3.425506e-07
I297 n1_m1_9600_302400 0 2.285404e-07
I298 n1_m1_9600_307200 0 2.297192e-07
I299 n1_m1_9600_312000 0 3.472508e-07
I300 n1_m1_9600_316800 0 2.364163e-07
I301 n1_m1_9600_321600 0 3.453110e-07
I302 n1_m1_9600_326400 0 2.298422e-07
I303 n1_m1_9600_331200 0 2.330727e-07
I304 n1_m1_9600_336000 0 3.586090e-07
I305 n1_m1_9600_340800 0 2.398354e-07
I306 n1_m1_9600_345600 0 3.491230e-07
I307 n1_m1_9600_350400 0 2.312406e-07
I308 n1_m1_9600_355200 0 2.313864e-07
I309 n1_m1_9600_360000 0 3.449112e-07
I310 n1_m1_9600_364800 0 2.284249e-07
I311 n1_m1_9600_369600 0 3.389034e-07
I312 n1_m1_9600_374400 0 2.214670e-07
I313 n1_m1_9600_379200 0 2.214670e-07
I314 n1_m1_9600_384000 0 3.384820e-07
I315 n1_m1_9600_388800 0 2.298422e-07
I316 n1_m1_9600_393600 0 3.447634e-07
I317 n1_m1_9600_398400 0 2.298422e-07
I318 n1_m1_9600_403200 0 2.298422e-07
I319 n1_m1_9600_408000 0 3.447634e-07
I320 n1_m1_9600_412800 0 2.298422e-07
I321 n1_m1_9600_417600 0 3.432168e-07
I322 n1_m1_9600_422400 0 2.245608e-07
I323 n1_m1_9600_427200 0 2.214670e-07
I324 n1_m1_9600_432000 0 3.333447e-07
I325 n1_m1_9600_436800 0 2.230850e-07
I326 n1_m1_9600_441600 0 3.417093e-07
I327 n1_m1_9600_446400 0 2.303093e-07
I328 n1_m1_9600_451200 0 2.351651e-07
I329 n1_m1_9600_456000 0 3.466362e-07
I330 n1_m1_9600_460800 0 2.282005e-07
I331 n1_m1_9600_465600 0 3.308444e-07
I332 n1_m1_9600_470400 0 2.198491e-07
I333 n1_m1_9600_475200 0 2.198491e-07
I334 n1_m1_9600_480000 0 3.287832e-07
I335 n1_m1_9600_484800 0 2.143325e-07
I336 n1_m1_9600_489600 0 3.226432e-07
I337 n1_m1_9600_494400 0 2.180850e-07
I338 n1_m1_9600_499200 0 2.183739e-07
I339 n1_m1_9600_504000 0 3.259181e-07
I340 n1_m1_9600_508800 0 2.107679e-07
I341 n1_m1_9600_513600 0 3.162979e-07
I342 n1_m1_9600_518400 0 2.103828e-07
I343 n1_m1_9600_523200 0 2.104916e-07
I344 n1_m1_9600_528000 0 3.134634e-07
I345 n1_m1_9600_532800 0 2.107574e-07
I346 n1_m1_9600_537600 0 3.148540e-07
I347 n1_m1_9600_542400 0 2.018428e-07
I348 n1_m1_9600_547200 0 2.009797e-07
I349 n1_m1_9600_552000 0 3.072221e-07
I350 n1_m1_9600_556800 0 2.118872e-07
I351 n1_m1_14400_0 0 1.442901e-07
I352 n1_m1_14400_4800 0 1.411021e-07
I353 n1_m1_14400_9600 0 2.102129e-07
I354 n1_m1_14400_14400 0 1.400960e-07
I355 n1_m1_14400_19200 0 1.399227e-07
I356 n1_m1_14400_24000 0 2.127009e-07
I357 n1_m1_14400_28800 0 1.464131e-07
I358 n1_m1_14400_33600 0 2.198491e-07
I359 n1_m1_14400_38400 0 1.465661e-07
I360 n1_m1_14400_43200 0 1.465661e-07
I361 n1_m1_14400_48000 0 2.202716e-07
I362 n1_m1_14400_52800 0 1.509063e-07
I363 n1_m1_14400_57600 0 2.279150e-07
I364 n1_m1_14400_62400 0 1.519433e-07
I365 n1_m1_14400_67200 0 1.512136e-07
I366 n1_m1_14400_72000 0 2.205789e-07
I367 n1_m1_14400_76800 0 1.465661e-07
I368 n1_m1_14400_81600 0 2.198491e-07
I369 n1_m1_14400_86400 0 1.465661e-07
I370 n1_m1_14400_91200 0 1.465661e-07
I371 n1_m1_14400_96000 0 2.198491e-07
I372 n1_m1_14400_100800 0 1.465661e-07
I373 n1_m1_14400_105600 0 2.198491e-07
I374 n1_m1_14400_110400 0 1.465661e-07
I375 n1_m1_14400_115200 0 1.465661e-07
I376 n1_m1_14400_120000 0 2.198491e-07
I377 n1_m1_14400_124800 0 1.465661e-07
I378 n1_m1_14400_129600 0 2.198491e-07
I379 n1_m1_14400_134400 0 1.465661e-07
I380 n1_m1_14400_139200 0 1.438774e-07
I381 n1_m1_14400_144000 0 2.120521e-07
I382 n1_m1_14400_148800 0 1.453754e-07
I383 n1_m1_14400_153600 0 2.198491e-07
I384 n1_m1_14400_158400 0 1.465661e-07
I385 n1_m1_14400_163200 0 1.465406e-07
I386 n1_m1_14400_168000 0 2.195313e-07
I387 n1_m1_14400_172800 0 1.463927e-07
I388 n1_m1_14400_177600 0 2.198440e-07
I389 n1_m1_14400_182400 0 1.465661e-07
I390 n1_m1_14400_187200 0 1.465661e-07
I391 n1_m1_14400_192000 0 2.198491e-07
I392 n1_m1_14400_196800 0 1.465661e-07
I393 n1_m1_14400_201600 0 2.198491e-07
I394 n1_m1_14400_206400 0 1.474379e-07
I395 n1_m1_14400_211200 0 1.521184e-07
I396 n1_m1_14400_216000 0 2.294853e-07
I397 n1_m1_14400_220800 0 1.529902e-07
I398 n1_m1_14400_225600 0 2.294853e-07
I399 n1_m1_14400_230400 0 1.529902e-07
I400 n1_m1_14400_235200 0 1.529902e-07
I401 n1_m1_14400_240000 0 2.293477e-07
I402 n1_m1_14400_244800 0 1.483098e-07
I403 n1_m1_14400_249600 0 2.198491e-07
I404 n1_m1_14400_254400 0 1.465661e-07
I405 n1_m1_14400_259200 0 1.469886e-07
I406 n1_m1_14400_264000 0 2.268780e-07
I407 n1_m1_14400_268800 0 1.519433e-07
I408 n1_m1_14400_273600 0 2.286675e-07
I409 n1_m1_14400_278400 0 1.559168e-07
I410 n1_m1_14400_283200 0 1.564763e-07
I411 n1_m1_14400_288000 0 2.301974e-07
I412 n1_m1_14400_292800 0 1.532995e-07
I413 n1_m1_14400_297600 0 2.300350e-07
I414 n1_m1_14400_302400 0 1.549076e-07
I415 n1_m1_14400_307200 0 1.588906e-07
I416 n1_m1_14400_312000 0 2.412042e-07
I417 n1_m1_14400_316800 0 1.597900e-07
I418 n1_m1_14400_321600 0 2.314819e-07
I419 n1_m1_14400_326400 0 1.532282e-07
I420 n1_m1_14400_331200 0 1.538155e-07
I421 n1_m1_14400_336000 0 2.372198e-07
I422 n1_m1_14400_340800 0 1.611751e-07
I423 n1_m1_14400_345600 0 2.352270e-07
I424 n1_m1_14400_350400 0 1.589548e-07
I425 n1_m1_14400_355200 0 1.596523e-07
I426 n1_m1_14400_360000 0 2.382304e-07
I427 n1_m1_14400_364800 0 1.544488e-07
I428 n1_m1_14400_369600 0 2.298174e-07
I429 n1_m1_14400_374400 0 1.529902e-07
I430 n1_m1_14400_379200 0 1.529902e-07
I431 n1_m1_14400_384000 0 2.296638e-07
I432 n1_m1_14400_388800 0 1.532282e-07
I433 n1_m1_14400_393600 0 2.298422e-07
I434 n1_m1_14400_398400 0 1.532282e-07
I435 n1_m1_14400_403200 0 1.532282e-07
I436 n1_m1_14400_408000 0 2.298422e-07
I437 n1_m1_14400_412800 0 1.532282e-07
I438 n1_m1_14400_417600 0 2.266302e-07
I439 n1_m1_14400_422400 0 1.493669e-07
I440 n1_m1_14400_427200 0 1.534124e-07
I441 n1_m1_14400_432000 0 2.359554e-07
I442 n1_m1_14400_436800 0 1.606992e-07
I443 n1_m1_14400_441600 0 2.404676e-07
I444 n1_m1_14400_446400 0 1.544273e-07
I445 n1_m1_14400_451200 0 1.524206e-07
I446 n1_m1_14400_456000 0 2.295581e-07
I447 n1_m1_14400_460800 0 1.523448e-07
I448 n1_m1_14400_465600 0 2.217468e-07
I449 n1_m1_14400_470400 0 1.465661e-07
I450 n1_m1_14400_475200 0 1.465661e-07
I451 n1_m1_14400_480000 0 2.198491e-07
I452 n1_m1_14400_484800 0 1.464267e-07
I453 n1_m1_14400_489600 0 2.150680e-07
I454 n1_m1_14400_494400 0 1.456483e-07
I455 n1_m1_14400_499200 0 1.465661e-07
I456 n1_m1_14400_504000 0 2.185643e-07
I457 n1_m1_14400_508800 0 1.411983e-07
I458 n1_m1_14400_513600 0 2.146649e-07
I459 n1_m1_14400_518400 0 1.394451e-07
I460 n1_m1_14400_523200 0 1.372242e-07
I461 n1_m1_14400_528000 0 2.044597e-07
I462 n1_m1_14400_532800 0 1.434832e-07
I463 n1_m1_14400_537600 0 2.139763e-07
I464 n1_m1_14400_542400 0 1.358115e-07
I465 n1_m1_14400_547200 0 1.345267e-07
I466 n1_m1_14400_552000 0 2.018326e-07
I467 n1_m1_14400_556800 0 1.347103e-07
I468 n1_m1_19200_0 0 1.403078e-07
I469 n1_m1_19200_4800 0 1.399974e-07
I470 n1_m1_19200_9600 0 2.098560e-07
I471 n1_m1_19200_14400 0 1.399040e-07
I472 n1_m1_19200_19200 0 1.399040e-07
I473 n1_m1_19200_24000 0 2.128063e-07
I474 n1_m1_19200_28800 0 1.465661e-07
I475 n1_m1_19200_33600 0 2.198491e-07
I476 n1_m1_19200_38400 0 1.465661e-07
I477 n1_m1_19200_43200 0 1.465661e-07
I478 n1_m1_19200_48000 0 2.198902e-07
I479 n1_m1_19200_52800 0 1.469886e-07
I480 n1_m1_19200_57600 0 2.206343e-07
I481 n1_m1_19200_62400 0 1.470895e-07
I482 n1_m1_19200_67200 0 1.470185e-07
I483 n1_m1_19200_72000 0 2.199201e-07
I484 n1_m1_19200_76800 0 1.465661e-07
I485 n1_m1_19200_81600 0 2.198491e-07
I486 n1_m1_19200_86400 0 1.465661e-07
I487 n1_m1_19200_91200 0 1.465661e-07
I488 n1_m1_19200_96000 0 2.198491e-07
I489 n1_m1_19200_100800 0 1.465661e-07
I490 n1_m1_19200_105600 0 2.198491e-07
I491 n1_m1_19200_110400 0 1.465661e-07
I492 n1_m1_19200_115200 0 1.465661e-07
I493 n1_m1_19200_120000 0 2.198491e-07
I494 n1_m1_19200_124800 0 1.465661e-07
I495 n1_m1_19200_129600 0 2.198491e-07
I496 n1_m1_19200_134400 0 1.465661e-07
I497 n1_m1_19200_139200 0 1.463043e-07
I498 n1_m1_19200_144000 0 2.190901e-07
I499 n1_m1_19200_148800 0 1.464502e-07
I500 n1_m1_19200_153600 0 2.198491e-07
I501 n1_m1_19200_158400 0 1.467160e-07
I502 n1_m1_19200_163200 0 1.474440e-07
I503 n1_m1_19200_168000 0 2.213481e-07
I504 n1_m1_19200_172800 0 1.475654e-07
I505 n1_m1_19200_177600 0 2.213481e-07
I506 n1_m1_19200_182400 0 1.475654e-07
I507 n1_m1_19200_187200 0 1.475654e-07
I508 n1_m1_19200_192000 0 2.204630e-07
I509 n1_m1_19200_196800 0 1.465661e-07
I510 n1_m1_19200_201600 0 2.198491e-07
I511 n1_m1_19200_206400 0 1.473346e-07
I512 n1_m1_19200_211200 0 1.515531e-07
I513 n1_m1_19200_216000 0 2.293355e-07
I514 n1_m1_19200_220800 0 1.522288e-07
I515 n1_m1_19200_225600 0 2.283433e-07
I516 n1_m1_19200_230400 0 1.522288e-07
I517 n1_m1_19200_235200 0 1.522288e-07
I518 n1_m1_19200_240000 0 2.282219e-07
I519 n1_m1_19200_244800 0 1.481031e-07
I520 n1_m1_19200_249600 0 2.198491e-07
I521 n1_m1_19200_254400 0 1.465661e-07
I522 n1_m1_19200_259200 0 1.466072e-07
I523 n1_m1_19200_264000 0 2.208331e-07
I524 n1_m1_19200_268800 0 1.480817e-07
I525 n1_m1_19200_273600 0 2.251434e-07
I526 n1_m1_19200_278400 0 1.534899e-07
I527 n1_m1_19200_283200 0 1.535348e-07
I528 n1_m1_19200_288000 0 2.298422e-07
I529 n1_m1_19200_292800 0 1.532282e-07
I530 n1_m1_19200_297600 0 2.307630e-07
I531 n1_m1_19200_302400 0 1.587846e-07
I532 n1_m1_19200_307200 0 1.609698e-07
I533 n1_m1_19200_312000 0 2.485213e-07
I534 n1_m1_19200_316800 0 1.666047e-07
I535 n1_m1_19200_321600 0 2.390563e-07
I536 n1_m1_19200_326400 0 1.547557e-07
I537 n1_m1_19200_331200 0 1.565952e-07
I538 n1_m1_19200_336000 0 2.458313e-07
I539 n1_m1_19200_340800 0 1.670282e-07
I540 n1_m1_19200_345600 0 2.441940e-07
I541 n1_m1_19200_350400 0 1.600905e-07
I542 n1_m1_19200_355200 0 1.598903e-07
I543 n1_m1_19200_360000 0 2.394656e-07
I544 n1_m1_19200_364800 0 1.574307e-07
I545 n1_m1_19200_369600 0 2.302461e-07
I546 n1_m1_19200_374400 0 1.532282e-07
I547 n1_m1_19200_379200 0 1.532282e-07
I548 n1_m1_19200_384000 0 2.298422e-07
I549 n1_m1_19200_388800 0 1.532282e-07
I550 n1_m1_19200_393600 0 2.298422e-07
I551 n1_m1_19200_398400 0 1.532282e-07
I552 n1_m1_19200_403200 0 1.532282e-07
I553 n1_m1_19200_408000 0 2.298422e-07
I554 n1_m1_19200_412800 0 1.532282e-07
I555 n1_m1_19200_417600 0 2.265112e-07
I556 n1_m1_19200_422400 0 1.493261e-07
I557 n1_m1_19200_427200 0 1.552451e-07
I558 n1_m1_19200_432000 0 2.437613e-07
I559 n1_m1_19200_436800 0 1.660289e-07
I560 n1_m1_19200_441600 0 2.467510e-07
I561 n1_m1_19200_446400 0 1.547723e-07
I562 n1_m1_19200_451200 0 1.485141e-07
I563 n1_m1_19200_456000 0 2.291968e-07
I564 n1_m1_19200_460800 0 1.532064e-07
I565 n1_m1_19200_465600 0 2.266903e-07
I566 n1_m1_19200_470400 0 1.471799e-07
I567 n1_m1_19200_475200 0 1.465661e-07
I568 n1_m1_19200_480000 0 2.198491e-07
I569 n1_m1_19200_484800 0 1.465661e-07
I570 n1_m1_19200_489600 0 2.193743e-07
I571 n1_m1_19200_494400 0 1.464726e-07
I572 n1_m1_19200_499200 0 1.465732e-07
I573 n1_m1_19200_504000 0 2.197634e-07
I574 n1_m1_19200_508800 0 1.413554e-07
I575 n1_m1_19200_513600 0 2.104671e-07
I576 n1_m1_19200_518400 0 1.377116e-07
I577 n1_m1_19200_523200 0 1.336233e-07
I578 n1_m1_19200_528000 0 2.041568e-07
I579 n1_m1_19200_532800 0 1.436157e-07
I580 n1_m1_19200_537600 0 2.188172e-07
I581 n1_m1_19200_542400 0 1.406654e-07
I582 n1_m1_19200_547200 0 1.393805e-07
I583 n1_m1_19200_552000 0 2.102414e-07
I584 n1_m1_19200_556800 0 1.403798e-07
I585 n1_m1_24000_0 0 2.128063e-07
I586 n1_m1_24000_4800 0 2.128063e-07
I587 n1_m1_24000_9600 0 3.184930e-07
I588 n1_m1_24000_14400 0 2.099613e-07
I589 n1_m1_24000_19200 0 2.098560e-07
I590 n1_m1_24000_24000 0 3.192095e-07
I591 n1_m1_24000_28800 0 2.198491e-07
I592 n1_m1_24000_33600 0 3.297737e-07
I593 n1_m1_24000_38400 0 2.198491e-07
I594 n1_m1_24000_43200 0 2.198491e-07
I595 n1_m1_24000_48000 0 3.297737e-07
I596 n1_m1_24000_52800 0 2.198491e-07
I597 n1_m1_24000_57600 0 3.297737e-07
I598 n1_m1_24000_62400 0 2.198491e-07
I599 n1_m1_24000_67200 0 2.198491e-07
I600 n1_m1_24000_72000 0 3.297737e-07
I601 n1_m1_24000_76800 0 2.198491e-07
I602 n1_m1_24000_81600 0 3.297737e-07
I603 n1_m1_24000_86400 0 2.198491e-07
I604 n1_m1_24000_91200 0 2.198491e-07
I605 n1_m1_24000_96000 0 3.297737e-07
I606 n1_m1_24000_100800 0 2.198491e-07
I607 n1_m1_24000_105600 0 3.297737e-07
I608 n1_m1_24000_110400 0 2.198491e-07
I609 n1_m1_24000_115200 0 2.198491e-07
I610 n1_m1_24000_120000 0 3.297737e-07
I611 n1_m1_24000_124800 0 2.198491e-07
I612 n1_m1_24000_129600 0 3.297737e-07
I613 n1_m1_24000_134400 0 2.198491e-07
I614 n1_m1_24000_139200 0 2.198491e-07
I615 n1_m1_24000_144000 0 3.297737e-07
I616 n1_m1_24000_148800 0 2.198702e-07
I617 n1_m1_24000_153600 0 3.333141e-07
I618 n1_m1_24000_158400 0 2.237345e-07
I619 n1_m1_24000_163200 0 2.282763e-07
I620 n1_m1_24000_168000 0 3.435499e-07
I621 n1_m1_24000_172800 0 2.298341e-07
I622 n1_m1_24000_177600 0 3.479122e-07
I623 n1_m1_24000_182400 0 2.303399e-07
I624 n1_m1_24000_187200 0 2.290333e-07
I625 n1_m1_24000_192000 0 3.380285e-07
I626 n1_m1_24000_196800 0 2.227995e-07
I627 n1_m1_24000_201600 0 3.341992e-07
I628 n1_m1_24000_206400 0 2.225088e-07
I629 n1_m1_24000_211200 0 2.215275e-07
I630 n1_m1_24000_216000 0 3.371764e-07
I631 n1_m1_24000_220800 0 2.206581e-07
I632 n1_m1_24000_225600 0 3.309871e-07
I633 n1_m1_24000_230400 0 2.206581e-07
I634 n1_m1_24000_235200 0 2.206581e-07
I635 n1_m1_24000_240000 0 3.309698e-07
I636 n1_m1_24000_244800 0 2.200687e-07
I637 n1_m1_24000_249600 0 3.297737e-07
I638 n1_m1_24000_254400 0 2.202074e-07
I639 n1_m1_24000_259200 0 2.223569e-07
I640 n1_m1_24000_264000 0 3.360693e-07
I641 n1_m1_24000_268800 0 2.289887e-07
I642 n1_m1_24000_273600 0 3.440237e-07
I643 n1_m1_24000_278400 0 2.327926e-07
I644 n1_m1_24000_283200 0 2.345207e-07
I645 n1_m1_24000_288000 0 3.491889e-07
I646 n1_m1_24000_292800 0 2.327926e-07
I647 n1_m1_24000_297600 0 3.502453e-07
I648 n1_m1_24000_302400 0 2.396481e-07
I649 n1_m1_24000_307200 0 2.450971e-07
I650 n1_m1_24000_312000 0 3.751354e-07
I651 n1_m1_24000_316800 0 2.627829e-07
I652 n1_m1_24000_321600 0 3.779549e-07
I653 n1_m1_24000_326400 0 2.423214e-07
I654 n1_m1_24000_331200 0 2.417429e-07
I655 n1_m1_24000_336000 0 3.770269e-07
I656 n1_m1_24000_340800 0 2.580433e-07
I657 n1_m1_24000_345600 0 3.847475e-07
I658 n1_m1_24000_350400 0 2.397783e-07
I659 n1_m1_24000_355200 0 2.368850e-07
I660 n1_m1_24000_360000 0 3.538136e-07
I661 n1_m1_24000_364800 0 2.307178e-07
I662 n1_m1_24000_369600 0 3.448269e-07
I663 n1_m1_24000_374400 0 2.298422e-07
I664 n1_m1_24000_379200 0 2.298422e-07
I665 n1_m1_24000_384000 0 3.447634e-07
I666 n1_m1_24000_388800 0 2.298422e-07
I667 n1_m1_24000_393600 0 3.447634e-07
I668 n1_m1_24000_398400 0 2.298422e-07
I669 n1_m1_24000_403200 0 2.298422e-07
I670 n1_m1_24000_408000 0 3.447634e-07
I671 n1_m1_24000_412800 0 2.298422e-07
I672 n1_m1_24000_417600 0 3.412420e-07
I673 n1_m1_24000_422400 0 2.257172e-07
I674 n1_m1_24000_427200 0 2.321563e-07
I675 n1_m1_24000_432000 0 3.603078e-07
I676 n1_m1_24000_436800 0 2.439278e-07
I677 n1_m1_24000_441600 0 3.586385e-07
I678 n1_m1_24000_446400 0 2.306794e-07
I679 n1_m1_24000_451200 0 2.245428e-07
I680 n1_m1_24000_456000 0 3.498303e-07
I681 n1_m1_24000_460800 0 2.325190e-07
I682 n1_m1_24000_465600 0 3.446981e-07
I683 n1_m1_24000_470400 0 2.266288e-07
I684 n1_m1_24000_475200 0 2.219144e-07
I685 n1_m1_24000_480000 0 3.297947e-07
I686 n1_m1_24000_484800 0 2.198491e-07
I687 n1_m1_24000_489600 0 3.327240e-07
I688 n1_m1_24000_494400 0 2.229470e-07
I689 n1_m1_24000_499200 0 2.251411e-07
I690 n1_m1_24000_504000 0 3.447471e-07
I691 n1_m1_24000_508800 0 2.241166e-07
I692 n1_m1_24000_513600 0 3.234436e-07
I693 n1_m1_24000_518400 0 2.092373e-07
I694 n1_m1_24000_523200 0 2.028132e-07
I695 n1_m1_24000_528000 0 3.087473e-07
I696 n1_m1_24000_532800 0 2.154236e-07
I697 n1_m1_24000_537600 0 3.263542e-07
I698 n1_m1_24000_542400 0 2.112142e-07
I699 n1_m1_24000_547200 0 2.098560e-07
I700 n1_m1_24000_552000 0 3.226133e-07
I701 n1_m1_24000_556800 0 2.183658e-07
I702 n1_m1_28800_0 0 1.484015e-07
I703 n1_m1_28800_4800 0 1.469909e-07
I704 n1_m1_28800_9600 0 2.188090e-07
I705 n1_m1_28800_14400 0 1.419774e-07
I706 n1_m1_28800_19200 0 1.400909e-07
I707 n1_m1_28800_24000 0 2.117526e-07
I708 n1_m1_28800_28800 0 1.450365e-07
I709 n1_m1_28800_33600 0 2.198491e-07
I710 n1_m1_28800_38400 0 1.465661e-07
I711 n1_m1_28800_43200 0 1.465661e-07
I712 n1_m1_28800_48000 0 2.200361e-07
I713 n1_m1_28800_52800 0 1.484865e-07
I714 n1_m1_28800_57600 0 2.228912e-07
I715 n1_m1_28800_62400 0 1.466850e-07
I716 n1_m1_28800_67200 0 1.465661e-07
I717 n1_m1_28800_72000 0 2.198491e-07
I718 n1_m1_28800_76800 0 1.465661e-07
I719 n1_m1_28800_81600 0 2.198491e-07
I720 n1_m1_28800_86400 0 1.465661e-07
I721 n1_m1_28800_91200 0 1.465661e-07
I722 n1_m1_28800_96000 0 2.198491e-07
I723 n1_m1_28800_100800 0 1.465661e-07
I724 n1_m1_28800_105600 0 2.198491e-07
I725 n1_m1_28800_110400 0 1.465661e-07
I726 n1_m1_28800_115200 0 1.465661e-07
I727 n1_m1_28800_120000 0 2.198491e-07
I728 n1_m1_28800_124800 0 1.465661e-07
I729 n1_m1_28800_129600 0 2.198491e-07
I730 n1_m1_28800_134400 0 1.465661e-07
I731 n1_m1_28800_139200 0 1.465661e-07
I732 n1_m1_28800_144000 0 2.198491e-07
I733 n1_m1_28800_148800 0 1.466137e-07
I734 n1_m1_28800_153600 0 2.278436e-07
I735 n1_m1_28800_158400 0 1.532282e-07
I736 n1_m1_28800_163200 0 1.532282e-07
I737 n1_m1_28800_168000 0 2.298422e-07
I738 n1_m1_28800_172800 0 1.550364e-07
I739 n1_m1_28800_177600 0 2.396926e-07
I740 n1_m1_28800_182400 0 1.575041e-07
I741 n1_m1_28800_187200 0 1.556075e-07
I742 n1_m1_28800_192000 0 2.334112e-07
I743 n1_m1_28800_196800 0 1.556075e-07
I744 n1_m1_28800_201600 0 2.334112e-07
I745 n1_m1_28800_206400 0 1.543804e-07
I746 n1_m1_28800_211200 0 1.477931e-07
I747 n1_m1_28800_216000 0 2.198491e-07
I748 n1_m1_28800_220800 0 1.465661e-07
I749 n1_m1_28800_225600 0 2.198491e-07
I750 n1_m1_28800_230400 0 1.465661e-07
I751 n1_m1_28800_235200 0 1.465661e-07
I752 n1_m1_28800_240000 0 2.199001e-07
I753 n1_m1_28800_244800 0 1.482996e-07
I754 n1_m1_28800_249600 0 2.234181e-07
I755 n1_m1_28800_254400 0 1.494654e-07
I756 n1_m1_28800_259200 0 1.525857e-07
I757 n1_m1_28800_264000 0 2.305560e-07
I758 n1_m1_28800_268800 0 1.555905e-07
I759 n1_m1_28800_273600 0 2.334112e-07
I760 n1_m1_28800_278400 0 1.622696e-07
I761 n1_m1_28800_283200 0 1.671574e-07
I762 n1_m1_28800_288000 0 2.469563e-07
I763 n1_m1_28800_292800 0 1.629834e-07
I764 n1_m1_28800_297600 0 2.407531e-07
I765 n1_m1_28800_302400 0 1.598903e-07
I766 n1_m1_28800_307200 0 1.598903e-07
I767 n1_m1_28800_312000 0 2.428061e-07
I768 n1_m1_28800_316800 0 1.692206e-07
I769 n1_m1_28800_321600 0 2.429761e-07
I770 n1_m1_28800_326400 0 1.575109e-07
I771 n1_m1_28800_331200 0 1.575109e-07
I772 n1_m1_28800_336000 0 2.396620e-07
I773 n1_m1_28800_340800 0 1.662668e-07
I774 n1_m1_28800_345600 0 2.506171e-07
I775 n1_m1_28800_350400 0 1.552948e-07
I776 n1_m1_28800_355200 0 1.532282e-07
I777 n1_m1_28800_360000 0 2.298422e-07
I778 n1_m1_28800_364800 0 1.532282e-07
I779 n1_m1_28800_369600 0 2.298422e-07
I780 n1_m1_28800_374400 0 1.532282e-07
I781 n1_m1_28800_379200 0 1.532282e-07
I782 n1_m1_28800_384000 0 2.298422e-07
I783 n1_m1_28800_388800 0 1.532282e-07
I784 n1_m1_28800_393600 0 2.298422e-07
I785 n1_m1_28800_398400 0 1.530412e-07
I786 n1_m1_28800_403200 0 1.513077e-07
I787 n1_m1_28800_408000 0 2.262733e-07
I788 n1_m1_28800_412800 0 1.508488e-07
I789 n1_m1_28800_417600 0 2.286526e-07
I790 n1_m1_28800_422400 0 1.546218e-07
I791 n1_m1_28800_427200 0 1.524464e-07
I792 n1_m1_28800_432000 0 2.262733e-07
I793 n1_m1_28800_436800 0 1.508488e-07
I794 n1_m1_28800_441600 0 2.289755e-07
I795 n1_m1_28800_446400 0 1.553696e-07
I796 n1_m1_28800_451200 0 1.573920e-07
I797 n1_m1_28800_456000 0 2.325139e-07
I798 n1_m1_28800_460800 0 1.583675e-07
I799 n1_m1_28800_465600 0 2.305560e-07
I800 n1_m1_28800_470400 0 1.532282e-07
I801 n1_m1_28800_475200 0 1.512295e-07
I802 n1_m1_28800_480000 0 2.198967e-07
I803 n1_m1_28800_484800 0 1.465661e-07
I804 n1_m1_28800_489600 0 2.288905e-07
I805 n1_m1_28800_494400 0 1.559406e-07
I806 n1_m1_28800_499200 0 1.607944e-07
I807 n1_m1_28800_504000 0 2.434044e-07
I808 n1_m1_28800_508800 0 1.612703e-07
I809 n1_m1_28800_513600 0 2.302161e-07
I810 n1_m1_28800_518400 0 1.441868e-07
I811 n1_m1_28800_523200 0 1.399040e-07
I812 n1_m1_28800_528000 0 2.098560e-07
I813 n1_m1_28800_532800 0 1.422901e-07
I814 n1_m1_28800_537600 0 2.121197e-07
I815 n1_m1_28800_542400 0 1.399040e-07
I816 n1_m1_28800_547200 0 1.399040e-07
I817 n1_m1_28800_552000 0 2.110456e-07
I818 n1_m1_28800_556800 0 1.450433e-07
I819 n1_m1_33600_0 0 1.479610e-07
I820 n1_m1_33600_4800 0 1.466463e-07
I821 n1_m1_33600_9600 0 2.136432e-07
I822 n1_m1_33600_14400 0 1.413635e-07
I823 n1_m1_33600_19200 0 1.400461e-07
I824 n1_m1_33600_24000 0 2.098560e-07
I825 n1_m1_33600_28800 0 1.422833e-07
I826 n1_m1_33600_33600 0 2.234895e-07
I827 n1_m1_33600_38400 0 1.514199e-07
I828 n1_m1_33600_43200 0 1.541241e-07
I829 n1_m1_33600_48000 0 2.392677e-07
I830 n1_m1_33600_52800 0 1.624137e-07
I831 n1_m1_33600_57600 0 2.368266e-07
I832 n1_m1_33600_62400 0 1.517530e-07
I833 n1_m1_33600_67200 0 1.514199e-07
I834 n1_m1_33600_72000 0 2.271298e-07
I835 n1_m1_33600_76800 0 1.514199e-07
I836 n1_m1_33600_81600 0 2.236975e-07
I837 n1_m1_33600_86400 0 1.465661e-07
I838 n1_m1_33600_91200 0 1.465661e-07
I839 n1_m1_33600_96000 0 2.198491e-07
I840 n1_m1_33600_100800 0 1.465661e-07
I841 n1_m1_33600_105600 0 2.198491e-07
I842 n1_m1_33600_110400 0 1.465661e-07
I843 n1_m1_33600_115200 0 1.465661e-07
I844 n1_m1_33600_120000 0 2.198491e-07
I845 n1_m1_33600_124800 0 1.480222e-07
I846 n1_m1_33600_129600 0 2.238362e-07
I847 n1_m1_33600_134400 0 1.465661e-07
I848 n1_m1_33600_139200 0 1.465661e-07
I849 n1_m1_33600_144000 0 2.200918e-07
I850 n1_m1_33600_148800 0 1.503580e-07
I851 n1_m1_33600_153600 0 2.283637e-07
I852 n1_m1_33600_158400 0 1.494838e-07
I853 n1_m1_33600_163200 0 1.526388e-07
I854 n1_m1_33600_168000 0 2.298422e-07
I855 n1_m1_33600_172800 0 1.537190e-07
I856 n1_m1_33600_177600 0 2.325159e-07
I857 n1_m1_33600_182400 0 1.550364e-07
I858 n1_m1_33600_187200 0 1.550364e-07
I859 n1_m1_33600_192000 0 2.282556e-07
I860 n1_m1_33600_196800 0 1.501826e-07
I861 n1_m1_33600_201600 0 2.252740e-07
I862 n1_m1_33600_206400 0 1.503505e-07
I863 n1_m1_33600_211200 0 1.512520e-07
I864 n1_m1_33600_216000 0 2.271298e-07
I865 n1_m1_33600_220800 0 1.502411e-07
I866 n1_m1_33600_225600 0 2.200225e-07
I867 n1_m1_33600_230400 0 1.465661e-07
I868 n1_m1_33600_235200 0 1.465661e-07
I869 n1_m1_33600_240000 0 2.239443e-07
I870 n1_m1_33600_244800 0 1.492010e-07
I871 n1_m1_33600_249600 0 2.352508e-07
I872 n1_m1_33600_254400 0 1.667495e-07
I873 n1_m1_33600_259200 0 1.666455e-07
I874 n1_m1_33600_264000 0 2.317369e-07
I875 n1_m1_33600_268800 0 1.512792e-07
I876 n1_m1_33600_273600 0 2.351549e-07
I877 n1_m1_33600_278400 0 1.665524e-07
I878 n1_m1_33600_283200 0 1.712036e-07
I879 n1_m1_33600_288000 0 2.525280e-07
I880 n1_m1_33600_292800 0 1.670948e-07
I881 n1_m1_33600_297600 0 2.416770e-07
I882 n1_m1_33600_302400 0 1.556258e-07
I883 n1_m1_33600_307200 0 1.550364e-07
I884 n1_m1_33600_312000 0 2.330455e-07
I885 n1_m1_33600_316800 0 1.564314e-07
I886 n1_m1_33600_321600 0 2.316634e-07
I887 n1_m1_33600_326400 0 1.532282e-07
I888 n1_m1_33600_331200 0 1.532282e-07
I889 n1_m1_33600_336000 0 2.336906e-07
I890 n1_m1_33600_340800 0 1.592961e-07
I891 n1_m1_33600_345600 0 2.395900e-07
I892 n1_m1_33600_350400 0 1.583274e-07
I893 n1_m1_33600_355200 0 1.578393e-07
I894 n1_m1_33600_360000 0 2.320958e-07
I895 n1_m1_33600_364800 0 1.579086e-07
I896 n1_m1_33600_369600 0 2.371230e-07
I897 n1_m1_33600_374400 0 1.559324e-07
I898 n1_m1_33600_379200 0 1.532282e-07
I899 n1_m1_33600_384000 0 2.298422e-07
I900 n1_m1_33600_388800 0 1.563485e-07
I901 n1_m1_33600_393600 0 2.314024e-07
I902 n1_m1_33600_398400 0 1.489603e-07
I903 n1_m1_33600_403200 0 1.469148e-07
I904 n1_m1_33600_408000 0 2.198491e-07
I905 n1_m1_33600_412800 0 1.465661e-07
I906 n1_m1_33600_417600 0 2.240843e-07
I907 n1_m1_33600_422400 0 1.542873e-07
I908 n1_m1_33600_427200 0 1.526340e-07
I909 n1_m1_33600_432000 0 2.271298e-07
I910 n1_m1_33600_436800 0 1.514199e-07
I911 n1_m1_33600_441600 0 2.247111e-07
I912 n1_m1_33600_446400 0 1.543702e-07
I913 n1_m1_33600_451200 0 1.600330e-07
I914 n1_m1_33600_456000 0 2.265527e-07
I915 n1_m1_33600_460800 0 1.497693e-07
I916 n1_m1_33600_465600 0 2.227553e-07
I917 n1_m1_33600_470400 0 1.483744e-07
I918 n1_m1_33600_475200 0 1.478319e-07
I919 n1_m1_33600_480000 0 2.231210e-07
I920 n1_m1_33600_484800 0 1.514199e-07
I921 n1_m1_33600_489600 0 2.351495e-07
I922 n1_m1_33600_494400 0 1.559936e-07
I923 n1_m1_33600_499200 0 1.564443e-07
I924 n1_m1_33600_504000 0 2.343310e-07
I925 n1_m1_33600_508800 0 1.521010e-07
I926 n1_m1_33600_513600 0 2.238919e-07
I927 n1_m1_33600_518400 0 1.459203e-07
I928 n1_m1_33600_523200 0 1.447578e-07
I929 n1_m1_33600_528000 0 2.171367e-07
I930 n1_m1_33600_532800 0 1.420535e-07
I931 n1_m1_33600_537600 0 2.098560e-07
I932 n1_m1_33600_542400 0 1.400773e-07
I933 n1_m1_33600_547200 0 1.435790e-07
I934 n1_m1_33600_552000 0 2.240122e-07
I935 n1_m1_33600_556800 0 1.547509e-07
I936 n1_m1_38400_0 0 1.455871e-07
I937 n1_m1_38400_4800 0 1.429291e-07
I938 n1_m1_38400_9600 0 2.103828e-07
I939 n1_m1_38400_14400 0 1.399040e-07
I940 n1_m1_38400_19200 0 1.399040e-07
I941 n1_m1_38400_24000 0 2.117526e-07
I942 n1_m1_38400_28800 0 1.450365e-07
I943 n1_m1_38400_33600 0 2.248457e-07
I944 n1_m1_38400_38400 0 1.532282e-07
I945 n1_m1_38400_43200 0 1.569399e-07
I946 n1_m1_38400_48000 0 2.463071e-07
I947 n1_m1_38400_52800 0 1.663144e-07
I948 n1_m1_38400_57600 0 2.399781e-07
I949 n1_m1_38400_62400 0 1.535613e-07
I950 n1_m1_38400_67200 0 1.532282e-07
I951 n1_m1_38400_72000 0 2.298422e-07
I952 n1_m1_38400_76800 0 1.532282e-07
I953 n1_m1_38400_81600 0 2.251312e-07
I954 n1_m1_38400_86400 0 1.465661e-07
I955 n1_m1_38400_91200 0 1.465661e-07
I956 n1_m1_38400_96000 0 2.198491e-07
I957 n1_m1_38400_100800 0 1.465661e-07
I958 n1_m1_38400_105600 0 2.207363e-07
I959 n1_m1_38400_110400 0 1.519807e-07
I960 n1_m1_38400_115200 0 1.584967e-07
I961 n1_m1_38400_120000 0 2.391216e-07
I962 n1_m1_38400_124800 0 1.601282e-07
I963 n1_m1_38400_129600 0 2.353249e-07
I964 n1_m1_38400_134400 0 1.483404e-07
I965 n1_m1_38400_139200 0 1.444247e-07
I966 n1_m1_38400_144000 0 2.176737e-07
I967 n1_m1_38400_148800 0 1.517530e-07
I968 n1_m1_38400_153600 0 2.285574e-07
I969 n1_m1_38400_158400 0 1.480888e-07
I970 n1_m1_38400_163200 0 1.528781e-07
I971 n1_m1_38400_168000 0 2.370924e-07
I972 n1_m1_38400_172800 0 1.594688e-07
I973 n1_m1_38400_177600 0 2.300258e-07
I974 n1_m1_38400_182400 0 1.532282e-07
I975 n1_m1_38400_187200 0 1.532282e-07
I976 n1_m1_38400_192000 0 2.239415e-07
I977 n1_m1_38400_196800 0 1.465661e-07
I978 n1_m1_38400_201600 0 2.248661e-07
I979 n1_m1_38400_206400 0 1.505905e-07
I980 n1_m1_38400_211200 0 1.492037e-07
I981 n1_m1_38400_216000 0 2.234181e-07
I982 n1_m1_38400_220800 0 1.483676e-07
I983 n1_m1_38400_225600 0 2.199341e-07
I984 n1_m1_38400_230400 0 1.465661e-07
I985 n1_m1_38400_235200 0 1.465661e-07
I986 n1_m1_38400_240000 0 2.218375e-07
I987 n1_m1_38400_244800 0 1.472119e-07
I988 n1_m1_38400_249600 0 2.372657e-07
I989 n1_m1_38400_254400 0 1.712668e-07
I990 n1_m1_38400_259200 0 1.683402e-07
I991 n1_m1_38400_264000 0 2.321570e-07
I992 n1_m1_38400_268800 0 1.513927e-07
I993 n1_m1_38400_273600 0 2.336254e-07
I994 n1_m1_38400_278400 0 1.644110e-07
I995 n1_m1_38400_283200 0 1.661717e-07
I996 n1_m1_38400_288000 0 2.434044e-07
I997 n1_m1_38400_292800 0 1.622696e-07
I998 n1_m1_38400_297600 0 2.356240e-07
I999 n1_m1_38400_302400 0 1.535171e-07
I1000 n1_m1_38400_307200 0 1.532282e-07
I1001 n1_m1_38400_312000 0 2.298422e-07
I1002 n1_m1_38400_316800 0 1.532282e-07
I1003 n1_m1_38400_321600 0 2.298422e-07
I1004 n1_m1_38400_326400 0 1.532282e-07
I1005 n1_m1_38400_331200 0 1.532282e-07
I1006 n1_m1_38400_336000 0 2.351243e-07
I1007 n1_m1_38400_340800 0 1.598903e-07
I1008 n1_m1_38400_345600 0 2.392542e-07
I1009 n1_m1_38400_350400 0 1.561887e-07
I1010 n1_m1_38400_355200 0 1.554885e-07
I1011 n1_m1_38400_360000 0 2.309469e-07
I1012 n1_m1_38400_364800 0 1.555225e-07
I1013 n1_m1_38400_369600 0 2.334112e-07
I1014 n1_m1_38400_374400 0 1.545538e-07
I1015 n1_m1_38400_379200 0 1.532282e-07
I1016 n1_m1_38400_384000 0 2.426906e-07
I1017 n1_m1_38400_388800 0 1.718888e-07
I1018 n1_m1_38400_393600 0 2.456885e-07
I1019 n1_m1_38400_398400 0 1.488502e-07
I1020 n1_m1_38400_403200 0 1.467190e-07
I1021 n1_m1_38400_408000 0 2.242848e-07
I1022 n1_m1_38400_412800 0 1.467802e-07
I1023 n1_m1_38400_417600 0 2.210388e-07
I1024 n1_m1_38400_422400 0 1.489454e-07
I1025 n1_m1_38400_427200 0 1.489454e-07
I1026 n1_m1_38400_432000 0 2.234181e-07
I1027 n1_m1_38400_436800 0 1.489454e-07
I1028 n1_m1_38400_441600 0 2.212257e-07
I1029 n1_m1_38400_446400 0 1.489828e-07
I1030 n1_m1_38400_451200 0 1.541255e-07
I1031 n1_m1_38400_456000 0 2.275649e-07
I1032 n1_m1_38400_460800 0 1.501452e-07
I1033 n1_m1_38400_465600 0 2.203080e-07
I1034 n1_m1_38400_470400 0 1.465661e-07
I1035 n1_m1_38400_475200 0 1.478509e-07
I1036 n1_m1_38400_480000 0 2.307158e-07
I1037 n1_m1_38400_484800 0 1.575109e-07
I1038 n1_m1_38400_489600 0 2.384248e-07
I1039 n1_m1_38400_494400 0 1.577217e-07
I1040 n1_m1_38400_499200 0 1.541765e-07
I1041 n1_m1_38400_504000 0 2.293834e-07
I1042 n1_m1_38400_508800 0 1.503934e-07
I1043 n1_m1_38400_513600 0 2.203692e-07
I1044 n1_m1_38400_518400 0 1.465661e-07
I1045 n1_m1_38400_523200 0 1.477285e-07
I1046 n1_m1_38400_528000 0 2.234283e-07
I1047 n1_m1_38400_532800 0 1.452404e-07
I1048 n1_m1_38400_537600 0 2.121197e-07
I1049 n1_m1_38400_542400 0 1.401419e-07
I1050 n1_m1_38400_547200 0 1.449481e-07
I1051 n1_m1_38400_552000 0 2.238260e-07
I1052 n1_m1_38400_556800 0 1.540847e-07
I1053 n1_m1_43200_0 0 1.450433e-07
I1054 n1_m1_43200_4800 0 1.410936e-07
I1055 n1_m1_43200_9600 0 2.098560e-07
I1056 n1_m1_43200_14400 0 1.399040e-07
I1057 n1_m1_43200_19200 0 1.404607e-07
I1058 n1_m1_43200_24000 0 2.162794e-07
I1059 n1_m1_43200_28800 0 1.465661e-07
I1060 n1_m1_43200_33600 0 2.220619e-07
I1061 n1_m1_43200_38400 0 1.519025e-07
I1062 n1_m1_43200_43200 0 1.569399e-07
I1063 n1_m1_43200_48000 0 2.427014e-07
I1064 n1_m1_43200_52800 0 1.627352e-07
I1065 n1_m1_43200_57600 0 2.390767e-07
I1066 n1_m1_43200_62400 0 1.528985e-07
I1067 n1_m1_43200_67200 0 1.503648e-07
I1068 n1_m1_43200_72000 0 2.293385e-07
I1069 n1_m1_43200_76800 0 1.520086e-07
I1070 n1_m1_43200_81600 0 2.221883e-07
I1071 n1_m1_43200_86400 0 1.488461e-07
I1072 n1_m1_43200_91200 0 1.502778e-07
I1073 n1_m1_43200_96000 0 2.219171e-07
I1074 n1_m1_43200_100800 0 1.465661e-07
I1075 n1_m1_43200_105600 0 2.235357e-07
I1076 n1_m1_43200_110400 0 1.727257e-07
I1077 n1_m1_43200_115200 0 2.160286e-07
I1078 n1_m1_43200_120000 0 3.161626e-07
I1079 n1_m1_43200_124800 0 1.754605e-07
I1080 n1_m1_43200_129600 0 2.465029e-07
I1081 n1_m1_43200_134400 0 1.530378e-07
I1082 n1_m1_43200_139200 0 1.469468e-07
I1083 n1_m1_43200_144000 0 2.184541e-07
I1084 n1_m1_43200_148800 0 1.517530e-07
I1085 n1_m1_43200_153600 0 2.292732e-07
I1086 n1_m1_43200_158400 0 1.520657e-07
I1087 n1_m1_43200_163200 0 1.601058e-07
I1088 n1_m1_43200_168000 0 2.535811e-07
I1089 n1_m1_43200_172800 0 1.730635e-07
I1090 n1_m1_43200_177600 0 2.389564e-07
I1091 n1_m1_43200_182400 0 1.548719e-07
I1092 n1_m1_43200_187200 0 1.532282e-07
I1093 n1_m1_43200_192000 0 2.239415e-07
I1094 n1_m1_43200_196800 0 1.465661e-07
I1095 n1_m1_43200_201600 0 2.276533e-07
I1096 n1_m1_43200_206400 0 1.523240e-07
I1097 n1_m1_43200_211200 0 1.474702e-07
I1098 n1_m1_43200_216000 0 2.198491e-07
I1099 n1_m1_43200_220800 0 1.474675e-07
I1100 n1_m1_43200_225600 0 2.252841e-07
I1101 n1_m1_43200_230400 0 1.483159e-07
I1102 n1_m1_43200_235200 0 1.465661e-07
I1103 n1_m1_43200_240000 0 2.199286e-07
I1104 n1_m1_43200_244800 0 1.492703e-07
I1105 n1_m1_43200_249600 0 2.385913e-07
I1106 n1_m1_43200_254400 0 1.709779e-07
I1107 n1_m1_43200_259200 0 1.665048e-07
I1108 n1_m1_43200_264000 0 2.324119e-07
I1109 n1_m1_43200_268800 0 1.532282e-07
I1110 n1_m1_43200_273600 0 2.337443e-07
I1111 n1_m1_43200_278400 0 1.613654e-07
I1112 n1_m1_43200_283200 0 1.631560e-07
I1113 n1_m1_43200_288000 0 2.423276e-07
I1114 n1_m1_43200_292800 0 1.598903e-07
I1115 n1_m1_43200_297600 0 2.365478e-07
I1116 n1_m1_43200_302400 0 1.565422e-07
I1117 n1_m1_43200_307200 0 1.538379e-07
I1118 n1_m1_43200_312000 0 2.298422e-07
I1119 n1_m1_43200_316800 0 1.532282e-07
I1120 n1_m1_43200_321600 0 2.298422e-07
I1121 n1_m1_43200_326400 0 1.532282e-07
I1122 n1_m1_43200_331200 0 1.532282e-07
I1123 n1_m1_43200_336000 0 2.321815e-07
I1124 n1_m1_43200_340800 0 1.586707e-07
I1125 n1_m1_43200_345600 0 2.389312e-07
I1126 n1_m1_43200_350400 0 1.541323e-07
I1127 n1_m1_43200_355200 0 1.532282e-07
I1128 n1_m1_43200_360000 0 2.298422e-07
I1129 n1_m1_43200_364800 0 1.532282e-07
I1130 n1_m1_43200_369600 0 2.318042e-07
I1131 n1_m1_43200_374400 0 1.602274e-07
I1132 n1_m1_43200_379200 0 1.656890e-07
I1133 n1_m1_43200_384000 0 3.639645e-07
I1134 n1_m1_43200_388800 0 2.766469e-07
I1135 n1_m1_43200_393600 0 2.940254e-07
I1136 n1_m1_43200_398400 0 1.566959e-07
I1137 n1_m1_43200_403200 0 1.512316e-07
I1138 n1_m1_43200_408000 0 2.323167e-07
I1139 n1_m1_43200_412800 0 1.499481e-07
I1140 n1_m1_43200_417600 0 2.201938e-07
I1141 n1_m1_43200_422400 0 1.465661e-07
I1142 n1_m1_43200_427200 0 1.465661e-07
I1143 n1_m1_43200_432000 0 2.198491e-07
I1144 n1_m1_43200_436800 0 1.465661e-07
I1145 n1_m1_43200_441600 0 2.198491e-07
I1146 n1_m1_43200_446400 0 1.467557e-07
I1147 n1_m1_43200_451200 0 1.489848e-07
I1148 n1_m1_43200_456000 0 2.288348e-07
I1149 n1_m1_43200_460800 0 1.527435e-07
I1150 n1_m1_43200_465600 0 2.257328e-07
I1151 n1_m1_43200_470400 0 1.488461e-07
I1152 n1_m1_43200_475200 0 1.485647e-07
I1153 n1_m1_43200_480000 0 2.342678e-07
I1154 n1_m1_43200_484800 0 1.620643e-07
I1155 n1_m1_43200_489600 0 2.450583e-07
I1156 n1_m1_43200_494400 0 1.604056e-07
I1157 n1_m1_43200_499200 0 1.575667e-07
I1158 n1_m1_43200_504000 0 2.309558e-07
I1159 n1_m1_43200_508800 0 1.527856e-07
I1160 n1_m1_43200_513600 0 2.257750e-07
I1161 n1_m1_43200_518400 0 1.502778e-07
I1162 n1_m1_43200_523200 0 1.500711e-07
I1163 n1_m1_43200_528000 0 2.223943e-07
I1164 n1_m1_43200_532800 0 1.465661e-07
I1165 n1_m1_43200_537600 0 2.169830e-07
I1166 n1_m1_43200_542400 0 1.437211e-07
I1167 n1_m1_43200_547200 0 1.458496e-07
I1168 n1_m1_43200_552000 0 2.203760e-07
I1169 n1_m1_43200_556800 0 1.488421e-07
I1170 n1_m1_48000_0 0 2.125725e-07
I1171 n1_m1_48000_4800 0 2.104848e-07
I1172 n1_m1_48000_9600 0 3.147839e-07
I1173 n1_m1_48000_14400 0 2.098560e-07
I1174 n1_m1_48000_19200 0 2.113549e-07
I1175 n1_m1_48000_24000 0 3.285602e-07
I1176 n1_m1_48000_28800 0 2.198491e-07
I1177 n1_m1_48000_33600 0 3.297737e-07
I1178 n1_m1_48000_38400 0 2.259368e-07
I1179 n1_m1_48000_43200 0 2.315724e-07
I1180 n1_m1_48000_48000 0 3.558238e-07
I1181 n1_m1_48000_52800 0 2.390995e-07
I1182 n1_m1_48000_57600 0 3.505944e-07
I1183 n1_m1_48000_62400 0 2.288922e-07
I1184 n1_m1_48000_67200 0 2.258661e-07
I1185 n1_m1_48000_72000 0 3.360992e-07
I1186 n1_m1_48000_76800 0 2.227369e-07
I1187 n1_m1_48000_81600 0 3.305588e-07
I1188 n1_m1_48000_86400 0 2.261897e-07
I1189 n1_m1_48000_91200 0 2.298422e-07
I1190 n1_m1_48000_96000 0 3.414432e-07
I1191 n1_m1_48000_100800 0 2.263209e-07
I1192 n1_m1_48000_105600 0 3.590675e-07
I1193 n1_m1_48000_110400 0 3.488742e-07
I1194 n1_m1_48000_115200 0 4.986890e-07
I1195 n1_m1_48000_120000 0 6.371107e-07
I1196 n1_m1_48000_124800 0 2.681493e-07
I1197 n1_m1_48000_129600 0 3.602521e-07
I1198 n1_m1_48000_134400 0 2.310843e-07
I1199 n1_m1_48000_139200 0 2.251074e-07
I1200 n1_m1_48000_144000 0 3.310323e-07
I1201 n1_m1_48000_148800 0 2.277454e-07
I1202 n1_m1_48000_153600 0 3.447634e-07
I1203 n1_m1_48000_158400 0 2.326832e-07
I1204 n1_m1_48000_163200 0 2.482459e-07
I1205 n1_m1_48000_168000 0 3.999914e-07
I1206 n1_m1_48000_172800 0 2.707659e-07
I1207 n1_m1_48000_177600 0 3.681647e-07
I1208 n1_m1_48000_182400 0 2.340360e-07
I1209 n1_m1_48000_187200 0 2.298422e-07
I1210 n1_m1_48000_192000 0 3.363759e-07
I1211 n1_m1_48000_196800 0 2.203726e-07
I1212 n1_m1_48000_201600 0 3.357461e-07
I1213 n1_m1_48000_206400 0 2.288830e-07
I1214 n1_m1_48000_211200 0 2.278035e-07
I1215 n1_m1_48000_216000 0 3.481267e-07
I1216 n1_m1_48000_220800 0 2.336478e-07
I1217 n1_m1_48000_225600 0 3.540237e-07
I1218 n1_m1_48000_230400 0 2.307851e-07
I1219 n1_m1_48000_235200 0 2.263209e-07
I1220 n1_m1_48000_240000 0 3.395680e-07
I1221 n1_m1_48000_244800 0 2.292678e-07
I1222 n1_m1_48000_249600 0 3.585053e-07
I1223 n1_m1_48000_254400 0 2.510070e-07
I1224 n1_m1_48000_259200 0 2.483041e-07
I1225 n1_m1_48000_264000 0 3.485169e-07
I1226 n1_m1_48000_268800 0 2.298422e-07
I1227 n1_m1_48000_273600 0 3.506165e-07
I1228 n1_m1_48000_278400 0 2.398354e-07
I1229 n1_m1_48000_283200 0 2.412942e-07
I1230 n1_m1_48000_288000 0 3.621174e-07
I1231 n1_m1_48000_292800 0 2.398354e-07
I1232 n1_m1_48000_297600 0 3.597531e-07
I1233 n1_m1_48000_302400 0 2.394581e-07
I1234 n1_m1_48000_307200 0 2.368925e-07
I1235 n1_m1_48000_312000 0 3.527144e-07
I1236 n1_m1_48000_316800 0 2.299809e-07
I1237 n1_m1_48000_321600 0 3.447634e-07
I1238 n1_m1_48000_326400 0 2.298422e-07
I1239 n1_m1_48000_331200 0 2.298422e-07
I1240 n1_m1_48000_336000 0 3.447634e-07
I1241 n1_m1_48000_340800 0 2.322066e-07
I1242 n1_m1_48000_345600 0 3.496386e-07
I1243 n1_m1_48000_350400 0 2.307726e-07
I1244 n1_m1_48000_355200 0 2.306369e-07
I1245 n1_m1_48000_360000 0 3.510400e-07
I1246 n1_m1_48000_364800 0 2.300547e-07
I1247 n1_m1_48000_369600 0 3.568870e-07
I1248 n1_m1_48000_374400 0 2.882675e-07
I1249 n1_m1_48000_379200 0 3.888284e-07
I1250 n1_m1_48000_384000 0 9.682640e-07
I1251 n1_m1_48000_388800 0 6.417364e-07
I1252 n1_m1_48000_393600 0 5.378363e-07
I1253 n1_m1_48000_398400 0 2.508176e-07
I1254 n1_m1_48000_403200 0 2.432983e-07
I1255 n1_m1_48000_408000 0 3.737435e-07
I1256 n1_m1_48000_412800 0 2.388531e-07
I1257 n1_m1_48000_417600 0 3.323297e-07
I1258 n1_m1_48000_422400 0 2.227471e-07
I1259 n1_m1_48000_427200 0 2.266723e-07
I1260 n1_m1_48000_432000 0 3.391111e-07
I1261 n1_m1_48000_436800 0 2.261190e-07
I1262 n1_m1_48000_441600 0 3.459829e-07
I1263 n1_m1_48000_446400 0 2.274915e-07
I1264 n1_m1_48000_451200 0 2.219273e-07
I1265 n1_m1_48000_456000 0 3.427277e-07
I1266 n1_m1_48000_460800 0 2.298759e-07
I1267 n1_m1_48000_465600 0 3.419592e-07
I1268 n1_m1_48000_470400 0 2.246281e-07
I1269 n1_m1_48000_475200 0 2.268538e-07
I1270 n1_m1_48000_480000 0 3.506627e-07
I1271 n1_m1_48000_484800 0 2.451651e-07
I1272 n1_m1_48000_489600 0 3.671589e-07
I1273 n1_m1_48000_494400 0 2.396433e-07
I1274 n1_m1_48000_499200 0 2.346556e-07
I1275 n1_m1_48000_504000 0 3.457188e-07
I1276 n1_m1_48000_508800 0 2.294384e-07
I1277 n1_m1_48000_513600 0 3.444680e-07
I1278 n1_m1_48000_518400 0 2.295057e-07
I1279 n1_m1_48000_523200 0 2.271298e-07
I1280 n1_m1_48000_528000 0 3.299878e-07
I1281 n1_m1_48000_532800 0 2.198491e-07
I1282 n1_m1_48000_537600 0 3.360605e-07
I1283 n1_m1_48000_542400 0 2.263209e-07
I1284 n1_m1_48000_547200 0 2.263209e-07
I1285 n1_m1_48000_552000 0 3.325133e-07
I1286 n1_m1_48000_556800 0 2.203726e-07
I1287 n1_m1_52800_0 0 1.399040e-07
I1288 n1_m1_52800_4800 0 1.399040e-07
I1289 n1_m1_52800_9600 0 2.098560e-07
I1290 n1_m1_52800_14400 0 1.399040e-07
I1291 n1_m1_52800_19200 0 1.409033e-07
I1292 n1_m1_52800_24000 0 2.190401e-07
I1293 n1_m1_52800_28800 0 1.466510e-07
I1294 n1_m1_52800_33600 0 2.200276e-07
I1295 n1_m1_52800_38400 0 1.473920e-07
I1296 n1_m1_52800_43200 0 1.507142e-07
I1297 n1_m1_52800_48000 0 2.307335e-07
I1298 n1_m1_52800_52800 0 1.542292e-07
I1299 n1_m1_52800_57600 0 2.286594e-07
I1300 n1_m1_52800_62400 0 1.481079e-07
I1301 n1_m1_52800_67200 0 1.483740e-07
I1302 n1_m1_52800_72000 0 2.270350e-07
I1303 n1_m1_52800_76800 0 1.517836e-07
I1304 n1_m1_52800_81600 0 2.279150e-07
I1305 n1_m1_52800_86400 0 1.527326e-07
I1306 n1_m1_52800_91200 0 1.532282e-07
I1307 n1_m1_52800_96000 0 2.298422e-07
I1308 n1_m1_52800_100800 0 1.532231e-07
I1309 n1_m1_52800_105600 0 2.394958e-07
I1310 n1_m1_52800_110400 0 2.184711e-07
I1311 n1_m1_52800_115200 0 3.024778e-07
I1312 n1_m1_52800_120000 0 3.456301e-07
I1313 n1_m1_52800_124800 0 1.599283e-07
I1314 n1_m1_52800_129600 0 2.229511e-07
I1315 n1_m1_52800_134400 0 1.510004e-07
I1316 n1_m1_52800_139200 0 1.527047e-07
I1317 n1_m1_52800_144000 0 2.283361e-07
I1318 n1_m1_52800_148800 0 1.531799e-07
I1319 n1_m1_52800_153600 0 2.299136e-07
I1320 n1_m1_52800_158400 0 1.536136e-07
I1321 n1_m1_52800_163200 0 1.568624e-07
I1322 n1_m1_52800_168000 0 2.532378e-07
I1323 n1_m1_52800_172800 0 1.714075e-07
I1324 n1_m1_52800_177600 0 2.375839e-07
I1325 n1_m1_52800_182400 0 1.537972e-07
I1326 n1_m1_52800_187200 0 1.532282e-07
I1327 n1_m1_52800_192000 0 2.287043e-07
I1328 n1_m1_52800_196800 0 1.519433e-07
I1329 n1_m1_52800_201600 0 2.281444e-07
I1330 n1_m1_52800_206400 0 1.538386e-07
I1331 n1_m1_52800_211200 0 1.579729e-07
I1332 n1_m1_52800_216000 0 2.392915e-07
I1333 n1_m1_52800_220800 0 1.596523e-07
I1334 n1_m1_52800_225600 0 2.363215e-07
I1335 n1_m1_52800_230400 0 1.538339e-07
I1336 n1_m1_52800_235200 0 1.532282e-07
I1337 n1_m1_52800_240000 0 2.301614e-07
I1338 n1_m1_52800_244800 0 1.573838e-07
I1339 n1_m1_52800_249600 0 2.396726e-07
I1340 n1_m1_52800_254400 0 1.610374e-07
I1341 n1_m1_52800_259200 0 1.605694e-07
I1342 n1_m1_52800_264000 0 2.316145e-07
I1343 n1_m1_52800_268800 0 1.532299e-07
I1344 n1_m1_52800_273600 0 2.337443e-07
I1345 n1_m1_52800_278400 0 1.598903e-07
I1346 n1_m1_52800_283200 0 1.599888e-07
I1347 n1_m1_52800_288000 0 2.399951e-07
I1348 n1_m1_52800_292800 0 1.598903e-07
I1349 n1_m1_52800_297600 0 2.396060e-07
I1350 n1_m1_52800_302400 0 1.598614e-07
I1351 n1_m1_52800_307200 0 1.599056e-07
I1352 n1_m1_52800_312000 0 2.383347e-07
I1353 n1_m1_52800_316800 0 1.536089e-07
I1354 n1_m1_52800_321600 0 2.300666e-07
I1355 n1_m1_52800_326400 0 1.532282e-07
I1356 n1_m1_52800_331200 0 1.532282e-07
I1357 n1_m1_52800_336000 0 2.298422e-07
I1358 n1_m1_52800_340800 0 1.532282e-07
I1359 n1_m1_52800_345600 0 2.305720e-07
I1360 n1_m1_52800_350400 0 1.578536e-07
I1361 n1_m1_52800_355200 0 1.582173e-07
I1362 n1_m1_52800_360000 0 2.323110e-07
I1363 n1_m1_52800_364800 0 1.532741e-07
I1364 n1_m1_52800_369600 0 2.404064e-07
I1365 n1_m1_52800_374400 0 2.400822e-07
I1366 n1_m1_52800_379200 0 3.934442e-07
I1367 n1_m1_52800_384000 0 7.839619e-07
I1368 n1_m1_52800_388800 0 3.980839e-07
I1369 n1_m1_52800_393600 0 3.293083e-07
I1370 n1_m1_52800_398400 0 1.632855e-07
I1371 n1_m1_52800_403200 0 1.611666e-07
I1372 n1_m1_52800_408000 0 2.480066e-07
I1373 n1_m1_52800_412800 0 1.594263e-07
I1374 n1_m1_52800_417600 0 2.258236e-07
I1375 n1_m1_52800_422400 0 1.514552e-07
I1376 n1_m1_52800_427200 0 1.566007e-07
I1377 n1_m1_52800_432000 0 2.258511e-07
I1378 n1_m1_52800_436800 0 1.511541e-07
I1379 n1_m1_52800_441600 0 2.420012e-07
I1380 n1_m1_52800_446400 0 1.597322e-07
I1381 n1_m1_52800_451200 0 1.537482e-07
I1382 n1_m1_52800_456000 0 2.350999e-07
I1383 n1_m1_52800_460800 0 1.537574e-07
I1384 n1_m1_52800_465600 0 2.292620e-07
I1385 n1_m1_52800_470400 0 1.504566e-07
I1386 n1_m1_52800_475200 0 1.480888e-07
I1387 n1_m1_52800_480000 0 2.264466e-07
I1388 n1_m1_52800_484800 0 1.582757e-07
I1389 n1_m1_52800_489600 0 2.349816e-07
I1390 n1_m1_52800_494400 0 1.544488e-07
I1391 n1_m1_52800_499200 0 1.535110e-07
I1392 n1_m1_52800_504000 0 2.285656e-07
I1393 n1_m1_52800_508800 0 1.490256e-07
I1394 n1_m1_52800_513600 0 2.266907e-07
I1395 n1_m1_52800_518400 0 1.498393e-07
I1396 n1_m1_52800_523200 0 1.512465e-07
I1397 n1_m1_52800_528000 0 2.199868e-07
I1398 n1_m1_52800_532800 0 1.465661e-07
I1399 n1_m1_52800_537600 0 2.261084e-07
I1400 n1_m1_52800_542400 0 1.531823e-07
I1401 n1_m1_52800_547200 0 1.532282e-07
I1402 n1_m1_52800_552000 0 2.283796e-07
I1403 n1_m1_52800_556800 0 1.521269e-07
I1404 n1_m1_57600_0 0 1.399040e-07
I1405 n1_m1_57600_4800 0 1.399040e-07
I1406 n1_m1_57600_9600 0 2.098560e-07
I1407 n1_m1_57600_14400 0 1.399040e-07
I1408 n1_m1_57600_19200 0 1.409033e-07
I1409 n1_m1_57600_24000 0 2.190401e-07
I1410 n1_m1_57600_28800 0 1.483676e-07
I1411 n1_m1_57600_33600 0 2.236322e-07
I1412 n1_m1_57600_38400 0 1.465661e-07
I1413 n1_m1_57600_43200 0 1.474675e-07
I1414 n1_m1_57600_48000 0 2.222760e-07
I1415 n1_m1_57600_52800 0 1.481840e-07
I1416 n1_m1_57600_57600 0 2.219178e-07
I1417 n1_m1_57600_62400 0 1.466470e-07
I1418 n1_m1_57600_67200 0 1.467856e-07
I1419 n1_m1_57600_72000 0 2.220564e-07
I1420 n1_m1_57600_76800 0 1.498414e-07
I1421 n1_m1_57600_81600 0 2.298422e-07
I1422 n1_m1_57600_86400 0 1.532282e-07
I1423 n1_m1_57600_91200 0 1.532282e-07
I1424 n1_m1_57600_96000 0 2.298422e-07
I1425 n1_m1_57600_100800 0 1.531201e-07
I1426 n1_m1_57600_105600 0 2.277457e-07
I1427 n1_m1_57600_110400 0 1.731492e-07
I1428 n1_m1_57600_115200 0 1.984019e-07
I1429 n1_m1_57600_120000 0 2.522167e-07
I1430 n1_m1_57600_124800 0 1.488312e-07
I1431 n1_m1_57600_129600 0 2.198722e-07
I1432 n1_m1_57600_134400 0 1.504682e-07
I1433 n1_m1_57600_139200 0 1.557502e-07
I1434 n1_m1_57600_144000 0 2.374085e-07
I1435 n1_m1_57600_148800 0 1.582363e-07
I1436 n1_m1_57600_153600 0 2.313555e-07
I1437 n1_m1_57600_158400 0 1.532282e-07
I1438 n1_m1_57600_163200 0 1.535749e-07
I1439 n1_m1_57600_168000 0 2.365438e-07
I1440 n1_m1_57600_172800 0 1.608787e-07
I1441 n1_m1_57600_177600 0 2.314065e-07
I1442 n1_m1_57600_182400 0 1.532282e-07
I1443 n1_m1_57600_187200 0 1.532282e-07
I1444 n1_m1_57600_192000 0 2.298422e-07
I1445 n1_m1_57600_196800 0 1.532282e-07
I1446 n1_m1_57600_201600 0 2.298422e-07
I1447 n1_m1_57600_206400 0 1.541323e-07
I1448 n1_m1_57600_211200 0 1.585177e-07
I1449 n1_m1_57600_216000 0 2.331699e-07
I1450 n1_m1_57600_220800 0 1.548461e-07
I1451 n1_m1_57600_225600 0 2.312753e-07
I1452 n1_m1_57600_230400 0 1.532282e-07
I1453 n1_m1_57600_235200 0 1.532282e-07
I1454 n1_m1_57600_240000 0 2.343086e-07
I1455 n1_m1_57600_244800 0 1.631261e-07
I1456 n1_m1_57600_249600 0 2.416369e-07
I1457 n1_m1_57600_254400 0 1.598903e-07
I1458 n1_m1_57600_259200 0 1.597631e-07
I1459 n1_m1_57600_264000 0 2.362073e-07
I1460 n1_m1_57600_268800 0 1.532642e-07
I1461 n1_m1_57600_273600 0 2.337443e-07
I1462 n1_m1_57600_278400 0 1.598903e-07
I1463 n1_m1_57600_283200 0 1.619800e-07
I1464 n1_m1_57600_288000 0 2.432222e-07
I1465 n1_m1_57600_292800 0 1.598903e-07
I1466 n1_m1_57600_297600 0 2.349714e-07
I1467 n1_m1_57600_302400 0 1.592778e-07
I1468 n1_m1_57600_307200 0 1.602145e-07
I1469 n1_m1_57600_312000 0 2.445485e-07
I1470 n1_m1_57600_316800 0 1.584151e-07
I1471 n1_m1_57600_321600 0 2.345982e-07
I1472 n1_m1_57600_326400 0 1.532282e-07
I1473 n1_m1_57600_331200 0 1.532282e-07
I1474 n1_m1_57600_336000 0 2.298422e-07
I1475 n1_m1_57600_340800 0 1.532282e-07
I1476 n1_m1_57600_345600 0 2.307464e-07
I1477 n1_m1_57600_350400 0 1.585177e-07
I1478 n1_m1_57600_355200 0 1.556659e-07
I1479 n1_m1_57600_360000 0 2.302005e-07
I1480 n1_m1_57600_364800 0 1.532282e-07
I1481 n1_m1_57600_369600 0 2.404064e-07
I1482 n1_m1_57600_374400 0 2.342868e-07
I1483 n1_m1_57600_379200 0 3.668638e-07
I1484 n1_m1_57600_384000 0 6.152920e-07
I1485 n1_m1_57600_388800 0 2.625749e-07
I1486 n1_m1_57600_393600 0 2.654321e-07
I1487 n1_m1_57600_398400 0 1.560881e-07
I1488 n1_m1_57600_403200 0 1.549039e-07
I1489 n1_m1_57600_408000 0 2.328280e-07
I1490 n1_m1_57600_412800 0 1.498461e-07
I1491 n1_m1_57600_417600 0 2.216173e-07
I1492 n1_m1_57600_422400 0 1.499964e-07
I1493 n1_m1_57600_427200 0 1.526571e-07
I1494 n1_m1_57600_432000 0 2.211319e-07
I1495 n1_m1_57600_436800 0 1.506585e-07
I1496 n1_m1_57600_441600 0 2.532099e-07
I1497 n1_m1_57600_446400 0 1.703205e-07
I1498 n1_m1_57600_451200 0 1.607319e-07
I1499 n1_m1_57600_456000 0 2.390611e-07
I1500 n1_m1_57600_460800 0 1.575476e-07
I1501 n1_m1_57600_465600 0 2.303827e-07
I1502 n1_m1_57600_470400 0 1.526041e-07
I1503 n1_m1_57600_475200 0 1.516102e-07
I1504 n1_m1_57600_480000 0 2.285017e-07
I1505 n1_m1_57600_484800 0 1.541758e-07
I1506 n1_m1_57600_489600 0 2.306512e-07
I1507 n1_m1_57600_494400 0 1.532282e-07
I1508 n1_m1_57600_499200 0 1.531921e-07
I1509 n1_m1_57600_504000 0 2.234772e-07
I1510 n1_m1_57600_508800 0 1.469359e-07
I1511 n1_m1_57600_513600 0 2.235969e-07
I1512 n1_m1_57600_518400 0 1.503866e-07
I1513 n1_m1_57600_523200 0 1.477449e-07
I1514 n1_m1_57600_528000 0 2.198838e-07
I1515 n1_m1_57600_532800 0 1.465661e-07
I1516 n1_m1_57600_537600 0 2.218171e-07
I1517 n1_m1_57600_542400 0 1.522554e-07
I1518 n1_m1_57600_547200 0 1.532282e-07
I1519 n1_m1_57600_552000 0 2.307430e-07
I1520 n1_m1_57600_556800 0 1.571194e-07
I1521 n1_m1_62400_0 0 1.378115e-07
I1522 n1_m1_62400_4800 0 1.357269e-07
I1523 n1_m1_62400_9600 0 2.087180e-07
I1524 n1_m1_62400_14400 0 1.401334e-07
I1525 n1_m1_62400_19200 0 1.418210e-07
I1526 n1_m1_62400_24000 0 2.191846e-07
I1527 n1_m1_62400_28800 0 1.489454e-07
I1528 n1_m1_62400_33600 0 2.248457e-07
I1529 n1_m1_62400_38400 0 1.465661e-07
I1530 n1_m1_62400_43200 0 1.465661e-07
I1531 n1_m1_62400_48000 0 2.198491e-07
I1532 n1_m1_62400_52800 0 1.465661e-07
I1533 n1_m1_62400_57600 0 2.198491e-07
I1534 n1_m1_62400_62400 0 1.476962e-07
I1535 n1_m1_62400_67200 0 1.514484e-07
I1536 n1_m1_62400_72000 0 2.207080e-07
I1537 n1_m1_62400_76800 0 1.466755e-07
I1538 n1_m1_62400_81600 0 2.248243e-07
I1539 n1_m1_62400_86400 0 1.532282e-07
I1540 n1_m1_62400_91200 0 1.532282e-07
I1541 n1_m1_62400_96000 0 2.298422e-07
I1542 n1_m1_62400_100800 0 1.531364e-07
I1543 n1_m1_62400_105600 0 2.257831e-07
I1544 n1_m1_62400_110400 0 1.534474e-07
I1545 n1_m1_62400_115200 0 1.494291e-07
I1546 n1_m1_62400_120000 0 2.210075e-07
I1547 n1_m1_62400_124800 0 1.484695e-07
I1548 n1_m1_62400_129600 0 2.278375e-07
I1549 n1_m1_62400_134400 0 1.535830e-07
I1550 n1_m1_62400_139200 0 1.565592e-07
I1551 n1_m1_62400_144000 0 2.456219e-07
I1552 n1_m1_62400_148800 0 1.661802e-07
I1553 n1_m1_62400_153600 0 2.413119e-07
I1554 n1_m1_62400_158400 0 1.538189e-07
I1555 n1_m1_62400_163200 0 1.532282e-07
I1556 n1_m1_62400_168000 0 2.299612e-07
I1557 n1_m1_62400_172800 0 1.534709e-07
I1558 n1_m1_62400_177600 0 2.306142e-07
I1559 n1_m1_62400_182400 0 1.579440e-07
I1560 n1_m1_62400_187200 0 1.637305e-07
I1561 n1_m1_62400_192000 0 2.516249e-07
I1562 n1_m1_62400_196800 0 1.673647e-07
I1563 n1_m1_62400_201600 0 2.494835e-07
I1564 n1_m1_62400_206400 0 1.605208e-07
I1565 n1_m1_62400_211200 0 1.555337e-07
I1566 n1_m1_62400_216000 0 2.316862e-07
I1567 n1_m1_62400_220800 0 1.544178e-07
I1568 n1_m1_62400_225600 0 2.323575e-07
I1569 n1_m1_62400_230400 0 1.629269e-07
I1570 n1_m1_62400_235200 0 1.769996e-07
I1571 n1_m1_62400_240000 0 2.908422e-07
I1572 n1_m1_62400_244800 0 1.757100e-07
I1573 n1_m1_62400_249600 0 2.422147e-07
I1574 n1_m1_62400_254400 0 1.598903e-07
I1575 n1_m1_62400_259200 0 1.598903e-07
I1576 n1_m1_62400_264000 0 2.397355e-07
I1577 n1_m1_62400_268800 0 1.595595e-07
I1578 n1_m1_62400_273600 0 2.395308e-07
I1579 n1_m1_62400_278400 0 1.771165e-07
I1580 n1_m1_62400_283200 0 1.934951e-07
I1581 n1_m1_62400_288000 0 2.769936e-07
I1582 n1_m1_62400_292800 0 1.768310e-07
I1583 n1_m1_62400_297600 0 2.577517e-07
I1584 n1_m1_62400_302400 0 1.758181e-07
I1585 n1_m1_62400_307200 0 1.806753e-07
I1586 n1_m1_62400_312000 0 2.748528e-07
I1587 n1_m1_62400_316800 0 1.605337e-07
I1588 n1_m1_62400_321600 0 2.396498e-07
I1589 n1_m1_62400_326400 0 1.565735e-07
I1590 n1_m1_62400_331200 0 1.536870e-07
I1591 n1_m1_62400_336000 0 2.306835e-07
I1592 n1_m1_62400_340800 0 1.532282e-07
I1593 n1_m1_62400_345600 0 2.309078e-07
I1594 n1_m1_62400_350400 0 1.595062e-07
I1595 n1_m1_62400_355200 0 1.565847e-07
I1596 n1_m1_62400_360000 0 2.349483e-07
I1597 n1_m1_62400_364800 0 1.627016e-07
I1598 n1_m1_62400_369600 0 2.534546e-07
I1599 n1_m1_62400_374400 0 1.805693e-07
I1600 n1_m1_62400_379200 0 1.937310e-07
I1601 n1_m1_62400_384000 0 2.890873e-07
I1602 n1_m1_62400_388800 0 1.734558e-07
I1603 n1_m1_62400_393600 0 2.383758e-07
I1604 n1_m1_62400_398400 0 1.593502e-07
I1605 n1_m1_62400_403200 0 1.553699e-07
I1606 n1_m1_62400_408000 0 2.221010e-07
I1607 n1_m1_62400_412800 0 1.479253e-07
I1608 n1_m1_62400_417600 0 2.266696e-07
I1609 n1_m1_62400_422400 0 1.498189e-07
I1610 n1_m1_62400_427200 0 1.522288e-07
I1611 n1_m1_62400_432000 0 2.216336e-07
I1612 n1_m1_62400_436800 0 1.610854e-07
I1613 n1_m1_62400_441600 0 4.025513e-07
I1614 n1_m1_62400_446400 0 3.434898e-07
I1615 n1_m1_62400_451200 0 2.735667e-07
I1616 n1_m1_62400_456000 0 2.745435e-07
I1617 n1_m1_62400_460800 0 1.663144e-07
I1618 n1_m1_62400_465600 0 2.382895e-07
I1619 n1_m1_62400_470400 0 1.532282e-07
I1620 n1_m1_62400_475200 0 1.532282e-07
I1621 n1_m1_62400_480000 0 2.298422e-07
I1622 n1_m1_62400_484800 0 1.532282e-07
I1623 n1_m1_62400_489600 0 2.298422e-07
I1624 n1_m1_62400_494400 0 1.532282e-07
I1625 n1_m1_62400_499200 0 1.532258e-07
I1626 n1_m1_62400_504000 0 2.294425e-07
I1627 n1_m1_62400_508800 0 1.528951e-07
I1628 n1_m1_62400_513600 0 2.300170e-07
I1629 n1_m1_62400_518400 0 1.542989e-07
I1630 n1_m1_62400_523200 0 1.561255e-07
I1631 n1_m1_62400_528000 0 2.414792e-07
I1632 n1_m1_62400_532800 0 1.568876e-07
I1633 n1_m1_62400_537600 0 2.238494e-07
I1634 n1_m1_62400_542400 0 1.468349e-07
I1635 n1_m1_62400_547200 0 1.468992e-07
I1636 n1_m1_62400_552000 0 2.213260e-07
I1637 n1_m1_62400_556800 0 1.511208e-07
I1638 n1_m1_67200_0 0 1.357980e-07
I1639 n1_m1_67200_4800 0 1.385090e-07
I1640 n1_m1_67200_9600 0 2.097190e-07
I1641 n1_m1_67200_14400 0 1.410695e-07
I1642 n1_m1_67200_19200 0 1.455654e-07
I1643 n1_m1_67200_24000 0 2.201744e-07
I1644 n1_m1_67200_28800 0 1.495266e-07
I1645 n1_m1_67200_33600 0 2.255238e-07
I1646 n1_m1_67200_38400 0 1.474702e-07
I1647 n1_m1_67200_43200 0 1.469665e-07
I1648 n1_m1_67200_48000 0 2.198491e-07
I1649 n1_m1_67200_52800 0 1.465661e-07
I1650 n1_m1_67200_57600 0 2.198491e-07
I1651 n1_m1_67200_62400 0 1.475943e-07
I1652 n1_m1_67200_67200 0 1.510079e-07
I1653 n1_m1_67200_72000 0 2.206305e-07
I1654 n1_m1_67200_76800 0 1.465661e-07
I1655 n1_m1_67200_81600 0 2.239208e-07
I1656 n1_m1_67200_86400 0 1.523240e-07
I1657 n1_m1_67200_91200 0 1.532798e-07
I1658 n1_m1_67200_96000 0 2.321091e-07
I1659 n1_m1_67200_100800 0 1.558114e-07
I1660 n1_m1_67200_105600 0 2.371841e-07
I1661 n1_m1_67200_110400 0 1.574399e-07
I1662 n1_m1_67200_115200 0 1.526024e-07
I1663 n1_m1_67200_120000 0 2.243073e-07
I1664 n1_m1_67200_124800 0 1.565973e-07
I1665 n1_m1_67200_129600 0 2.431868e-07
I1666 n1_m1_67200_134400 0 1.571656e-07
I1667 n1_m1_67200_139200 0 1.574634e-07
I1668 n1_m1_67200_144000 0 2.450546e-07
I1669 n1_m1_67200_148800 0 1.649399e-07
I1670 n1_m1_67200_153600 0 2.442721e-07
I1671 n1_m1_67200_158400 0 1.542200e-07
I1672 n1_m1_67200_163200 0 1.540225e-07
I1673 n1_m1_67200_168000 0 2.311985e-07
I1674 n1_m1_67200_172800 0 1.538869e-07
I1675 n1_m1_67200_177600 0 2.360716e-07
I1676 n1_m1_67200_182400 0 1.817120e-07
I1677 n1_m1_67200_187200 0 1.972578e-07
I1678 n1_m1_67200_192000 0 2.794850e-07
I1679 n1_m1_67200_196800 0 1.720098e-07
I1680 n1_m1_67200_201600 0 2.542813e-07
I1681 n1_m1_67200_206400 0 1.659711e-07
I1682 n1_m1_67200_211200 0 1.595170e-07
I1683 n1_m1_67200_216000 0 2.378483e-07
I1684 n1_m1_67200_220800 0 1.592716e-07
I1685 n1_m1_67200_225600 0 2.420645e-07
I1686 n1_m1_67200_230400 0 1.751261e-07
I1687 n1_m1_67200_235200 0 2.201292e-07
I1688 n1_m1_67200_240000 0 4.452281e-07
I1689 n1_m1_67200_244800 0 2.101707e-07
I1690 n1_m1_67200_249600 0 2.444557e-07
I1691 n1_m1_67200_254400 0 1.607815e-07
I1692 n1_m1_67200_259200 0 1.600259e-07
I1693 n1_m1_67200_264000 0 2.398354e-07
I1694 n1_m1_67200_268800 0 1.598903e-07
I1695 n1_m1_67200_273600 0 2.403650e-07
I1696 n1_m1_67200_278400 0 2.046453e-07
I1697 n1_m1_67200_283200 0 2.618427e-07
I1698 n1_m1_67200_288000 0 4.115403e-07
I1699 n1_m1_67200_292800 0 2.514798e-07
I1700 n1_m1_67200_297600 0 3.382903e-07
I1701 n1_m1_67200_302400 0 2.209735e-07
I1702 n1_m1_67200_307200 0 2.268637e-07
I1703 n1_m1_67200_312000 0 3.237326e-07
I1704 n1_m1_67200_316800 0 1.620459e-07
I1705 n1_m1_67200_321600 0 2.398935e-07
I1706 n1_m1_67200_326400 0 1.571758e-07
I1707 n1_m1_67200_331200 0 1.561146e-07
I1708 n1_m1_67200_336000 0 2.348327e-07
I1709 n1_m1_67200_340800 0 1.541323e-07
I1710 n1_m1_67200_345600 0 2.331682e-07
I1711 n1_m1_67200_350400 0 1.668708e-07
I1712 n1_m1_67200_355200 0 1.705921e-07
I1713 n1_m1_67200_360000 0 2.621905e-07
I1714 n1_m1_67200_364800 0 1.758755e-07
I1715 n1_m1_67200_369600 0 2.598567e-07
I1716 n1_m1_67200_374400 0 1.724578e-07
I1717 n1_m1_67200_379200 0 1.710289e-07
I1718 n1_m1_67200_384000 0 2.544325e-07
I1719 n1_m1_67200_388800 0 1.670214e-07
I1720 n1_m1_67200_393600 0 2.410743e-07
I1721 n1_m1_67200_398400 0 1.628093e-07
I1722 n1_m1_67200_403200 0 1.590565e-07
I1723 n1_m1_67200_408000 0 2.227152e-07
I1724 n1_m1_67200_412800 0 1.485120e-07
I1725 n1_m1_67200_417600 0 2.306386e-07
I1726 n1_m1_67200_422400 0 1.528889e-07
I1727 n1_m1_67200_427200 0 1.570827e-07
I1728 n1_m1_67200_432000 0 2.295537e-07
I1729 n1_m1_67200_436800 0 1.715496e-07
I1730 n1_m1_67200_441600 0 4.975667e-07
I1731 n1_m1_67200_446400 0 4.507671e-07
I1732 n1_m1_67200_451200 0 4.049537e-07
I1733 n1_m1_67200_456000 0 3.169138e-07
I1734 n1_m1_67200_460800 0 1.696931e-07
I1735 n1_m1_67200_465600 0 2.417647e-07
I1736 n1_m1_67200_470400 0 1.532282e-07
I1737 n1_m1_67200_475200 0 1.532282e-07
I1738 n1_m1_67200_480000 0 2.298422e-07
I1739 n1_m1_67200_484800 0 1.532282e-07
I1740 n1_m1_67200_489600 0 2.307464e-07
I1741 n1_m1_67200_494400 0 1.540871e-07
I1742 n1_m1_67200_499200 0 1.534284e-07
I1743 n1_m1_67200_504000 0 2.298422e-07
I1744 n1_m1_67200_508800 0 1.533638e-07
I1745 n1_m1_67200_513600 0 2.337651e-07
I1746 n1_m1_67200_518400 0 1.601758e-07
I1747 n1_m1_67200_523200 0 1.697597e-07
I1748 n1_m1_67200_528000 0 2.752172e-07
I1749 n1_m1_67200_532800 0 1.634232e-07
I1750 n1_m1_67200_537600 0 2.282505e-07
I1751 n1_m1_67200_542400 0 1.476123e-07
I1752 n1_m1_67200_547200 0 1.467856e-07
I1753 n1_m1_67200_552000 0 2.201210e-07
I1754 n1_m1_67200_556800 0 1.477408e-07
I1755 n1_m1_72000_0 0 2.119185e-07
I1756 n1_m1_72000_4800 0 2.123165e-07
I1757 n1_m1_72000_9600 0 3.160654e-07
I1758 n1_m1_72000_14400 0 2.139124e-07
I1759 n1_m1_72000_19200 0 2.196948e-07
I1760 n1_m1_72000_24000 0 3.363814e-07
I1761 n1_m1_72000_28800 0 2.302467e-07
I1762 n1_m1_72000_33600 0 3.461553e-07
I1763 n1_m1_72000_38400 0 2.289381e-07
I1764 n1_m1_72000_43200 0 2.238742e-07
I1765 n1_m1_72000_48000 0 3.297737e-07
I1766 n1_m1_72000_52800 0 2.198491e-07
I1767 n1_m1_72000_57600 0 3.297737e-07
I1768 n1_m1_72000_62400 0 2.200106e-07
I1769 n1_m1_72000_67200 0 2.205466e-07
I1770 n1_m1_72000_72000 0 3.298964e-07
I1771 n1_m1_72000_76800 0 2.198491e-07
I1772 n1_m1_72000_81600 0 3.304130e-07
I1773 n1_m1_72000_86400 0 2.224487e-07
I1774 n1_m1_72000_91200 0 2.316628e-07
I1775 n1_m1_72000_96000 0 3.649485e-07
I1776 n1_m1_72000_100800 0 2.520964e-07
I1777 n1_m1_72000_105600 0 3.589907e-07
I1778 n1_m1_72000_110400 0 2.310047e-07
I1779 n1_m1_72000_115200 0 2.298293e-07
I1780 n1_m1_72000_120000 0 3.463327e-07
I1781 n1_m1_72000_124800 0 2.375417e-07
I1782 n1_m1_72000_129600 0 3.647191e-07
I1783 n1_m1_72000_134400 0 2.456348e-07
I1784 n1_m1_72000_139200 0 2.411678e-07
I1785 n1_m1_72000_144000 0 3.561233e-07
I1786 n1_m1_72000_148800 0 2.330322e-07
I1787 n1_m1_72000_153600 0 3.438150e-07
I1788 n1_m1_72000_158400 0 2.285877e-07
I1789 n1_m1_72000_163200 0 2.350676e-07
I1790 n1_m1_72000_168000 0 3.542569e-07
I1791 n1_m1_72000_172800 0 2.344534e-07
I1792 n1_m1_72000_177600 0 3.711463e-07
I1793 n1_m1_72000_182400 0 3.958630e-07
I1794 n1_m1_72000_187200 0 4.808822e-07
I1795 n1_m1_72000_192000 0 5.231644e-07
I1796 n1_m1_72000_196800 0 2.436933e-07
I1797 n1_m1_72000_201600 0 3.534608e-07
I1798 n1_m1_72000_206400 0 2.483880e-07
I1799 n1_m1_72000_211200 0 2.338205e-07
I1800 n1_m1_72000_216000 0 3.491060e-07
I1801 n1_m1_72000_220800 0 2.398354e-07
I1802 n1_m1_72000_225600 0 3.586130e-07
I1803 n1_m1_72000_230400 0 2.557122e-07
I1804 n1_m1_72000_235200 0 3.660868e-07
I1805 n1_m1_72000_240000 0 9.001342e-07
I1806 n1_m1_72000_244800 0 3.779154e-07
I1807 n1_m1_72000_249600 0 3.831489e-07
I1808 n1_m1_72000_254400 0 2.484988e-07
I1809 n1_m1_72000_259200 0 2.411987e-07
I1810 n1_m1_72000_264000 0 3.597531e-07
I1811 n1_m1_72000_268800 0 2.398354e-07
I1812 n1_m1_72000_273600 0 3.650766e-07
I1813 n1_m1_72000_278400 0 2.674355e-07
I1814 n1_m1_72000_283200 0 4.084319e-07
I1815 n1_m1_72000_288000 0 1.074185e-06
I1816 n1_m1_72000_292800 0 8.964276e-07
I1817 n1_m1_72000_297600 0 1.207106e-06
I1818 n1_m1_72000_302400 0 5.724370e-07
I1819 n1_m1_72000_307200 0 4.208754e-07
I1820 n1_m1_72000_312000 0 4.483858e-07
I1821 n1_m1_72000_316800 0 2.500641e-07
I1822 n1_m1_72000_321600 0 3.605148e-07
I1823 n1_m1_72000_326400 0 2.394091e-07
I1824 n1_m1_72000_331200 0 2.392800e-07
I1825 n1_m1_72000_336000 0 3.590362e-07
I1826 n1_m1_72000_340800 0 2.389312e-07
I1827 n1_m1_72000_345600 0 3.632017e-07
I1828 n1_m1_72000_350400 0 2.715500e-07
I1829 n1_m1_72000_355200 0 2.939194e-07
I1830 n1_m1_72000_360000 0 4.799770e-07
I1831 n1_m1_72000_364800 0 2.922362e-07
I1832 n1_m1_72000_369600 0 3.934993e-07
I1833 n1_m1_72000_374400 0 2.467075e-07
I1834 n1_m1_72000_379200 0 2.413208e-07
I1835 n1_m1_72000_384000 0 3.549706e-07
I1836 n1_m1_72000_388800 0 2.319734e-07
I1837 n1_m1_72000_393600 0 3.466298e-07
I1838 n1_m1_72000_398400 0 2.314439e-07
I1839 n1_m1_72000_403200 0 2.306301e-07
I1840 n1_m1_72000_408000 0 3.358899e-07
I1841 n1_m1_72000_412800 0 2.234249e-07
I1842 n1_m1_72000_417600 0 3.485268e-07
I1843 n1_m1_72000_422400 0 2.431528e-07
I1844 n1_m1_72000_427200 0 2.393119e-07
I1845 n1_m1_72000_432000 0 3.533789e-07
I1846 n1_m1_72000_436800 0 2.494839e-07
I1847 n1_m1_72000_441600 0 4.507896e-07
I1848 n1_m1_72000_446400 0 3.852019e-07
I1849 n1_m1_72000_451200 0 4.333352e-07
I1850 n1_m1_72000_456000 0 4.181314e-07
I1851 n1_m1_72000_460800 0 2.378728e-07
I1852 n1_m1_72000_465600 0 3.473983e-07
I1853 n1_m1_72000_470400 0 2.298422e-07
I1854 n1_m1_72000_475200 0 2.298422e-07
I1855 n1_m1_72000_480000 0 3.447634e-07
I1856 n1_m1_72000_484800 0 2.298422e-07
I1857 n1_m1_72000_489600 0 3.510924e-07
I1858 n1_m1_72000_494400 0 2.358548e-07
I1859 n1_m1_72000_499200 0 2.312437e-07
I1860 n1_m1_72000_504000 0 3.447634e-07
I1861 n1_m1_72000_508800 0 2.312056e-07
I1862 n1_m1_72000_513600 0 3.604964e-07
I1863 n1_m1_72000_518400 0 2.461644e-07
I1864 n1_m1_72000_523200 0 2.982817e-07
I1865 n1_m1_72000_528000 0 5.460487e-07
I1866 n1_m1_72000_532800 0 2.523540e-07
I1867 n1_m1_72000_537600 0 3.560403e-07
I1868 n1_m1_72000_542400 0 2.325941e-07
I1869 n1_m1_72000_547200 0 2.248164e-07
I1870 n1_m1_72000_552000 0 3.323036e-07
I1871 n1_m1_72000_556800 0 2.268606e-07
I1872 n1_m1_76800_0 0 1.465661e-07
I1873 n1_m1_76800_4800 0 1.463424e-07
I1874 n1_m1_76800_9600 0 2.152162e-07
I1875 n1_m1_76800_14400 0 1.468285e-07
I1876 n1_m1_76800_19200 0 1.492540e-07
I1877 n1_m1_76800_24000 0 2.302685e-07
I1878 n1_m1_76800_28800 0 1.570147e-07
I1879 n1_m1_76800_33600 0 2.348388e-07
I1880 n1_m1_76800_38400 0 1.532282e-07
I1881 n1_m1_76800_43200 0 1.495164e-07
I1882 n1_m1_76800_48000 0 2.198491e-07
I1883 n1_m1_76800_52800 0 1.465661e-07
I1884 n1_m1_76800_57600 0 2.198491e-07
I1885 n1_m1_76800_62400 0 1.465661e-07
I1886 n1_m1_76800_67200 0 1.465661e-07
I1887 n1_m1_76800_72000 0 2.198491e-07
I1888 n1_m1_76800_76800 0 1.472853e-07
I1889 n1_m1_76800_81600 0 2.231326e-07
I1890 n1_m1_76800_86400 0 1.515028e-07
I1891 n1_m1_76800_91200 0 1.555925e-07
I1892 n1_m1_76800_96000 0 2.368395e-07
I1893 n1_m1_76800_100800 0 1.610561e-07
I1894 n1_m1_76800_105600 0 2.322705e-07
I1895 n1_m1_76800_110400 0 1.532282e-07
I1896 n1_m1_76800_115200 0 1.532282e-07
I1897 n1_m1_76800_120000 0 2.298422e-07
I1898 n1_m1_76800_124800 0 1.545701e-07
I1899 n1_m1_76800_129600 0 2.365200e-07
I1900 n1_m1_76800_134400 0 1.577013e-07
I1901 n1_m1_76800_139200 0 1.554647e-07
I1902 n1_m1_76800_144000 0 2.298422e-07
I1903 n1_m1_76800_148800 0 1.531806e-07
I1904 n1_m1_76800_153600 0 2.222699e-07
I1905 n1_m1_76800_158400 0 1.492540e-07
I1906 n1_m1_76800_163200 0 1.526850e-07
I1907 n1_m1_76800_168000 0 2.298422e-07
I1908 n1_m1_76800_172800 0 1.538223e-07
I1909 n1_m1_76800_177600 0 2.417055e-07
I1910 n1_m1_76800_182400 0 1.949777e-07
I1911 n1_m1_76800_187200 0 2.167886e-07
I1912 n1_m1_76800_192000 0 2.907039e-07
I1913 n1_m1_76800_196800 0 1.658698e-07
I1914 n1_m1_76800_201600 0 2.335492e-07
I1915 n1_m1_76800_206400 0 1.566789e-07
I1916 n1_m1_76800_211200 0 1.538352e-07
I1917 n1_m1_76800_216000 0 2.320312e-07
I1918 n1_m1_76800_220800 0 1.598903e-07
I1919 n1_m1_76800_225600 0 2.357430e-07
I1920 n1_m1_76800_230400 0 1.579569e-07
I1921 n1_m1_76800_235200 0 1.690867e-07
I1922 n1_m1_76800_240000 0 3.244324e-07
I1923 n1_m1_76800_244800 0 1.916657e-07
I1924 n1_m1_76800_249600 0 2.510665e-07
I1925 n1_m1_76800_254400 0 1.640547e-07
I1926 n1_m1_76800_259200 0 1.605612e-07
I1927 n1_m1_76800_264000 0 2.398354e-07
I1928 n1_m1_76800_268800 0 1.598903e-07
I1929 n1_m1_76800_273600 0 2.424554e-07
I1930 n1_m1_76800_278400 0 1.643158e-07
I1931 n1_m1_76800_283200 0 1.615476e-07
I1932 n1_m1_76800_288000 0 3.380652e-07
I1933 n1_m1_76800_292800 0 6.031003e-07
I1934 n1_m1_76800_297600 0 1.086277e-06
I1935 n1_m1_76800_302400 0 3.556307e-07
I1936 n1_m1_76800_307200 0 1.984985e-07
I1937 n1_m1_76800_312000 0 2.670997e-07
I1938 n1_m1_76800_316800 0 1.710506e-07
I1939 n1_m1_76800_321600 0 2.413955e-07
I1940 n1_m1_76800_326400 0 1.577013e-07
I1941 n1_m1_76800_331200 0 1.577013e-07
I1942 n1_m1_76800_336000 0 2.382875e-07
I1943 n1_m1_76800_340800 0 1.613600e-07
I1944 n1_m1_76800_345600 0 2.449400e-07
I1945 n1_m1_76800_350400 0 1.742960e-07
I1946 n1_m1_76800_355200 0 1.813041e-07
I1947 n1_m1_76800_360000 0 2.801411e-07
I1948 n1_m1_76800_364800 0 1.802511e-07
I1949 n1_m1_76800_369600 0 2.538917e-07
I1950 n1_m1_76800_374400 0 1.614130e-07
I1951 n1_m1_76800_379200 0 1.577013e-07
I1952 n1_m1_76800_384000 0 2.331971e-07
I1953 n1_m1_76800_388800 0 1.532282e-07
I1954 n1_m1_76800_393600 0 2.321563e-07
I1955 n1_m1_76800_398400 0 1.554171e-07
I1956 n1_m1_76800_403200 0 1.554953e-07
I1957 n1_m1_76800_408000 0 2.358776e-07
I1958 n1_m1_76800_412800 0 1.584049e-07
I1959 n1_m1_76800_417600 0 2.537435e-07
I1960 n1_m1_76800_422400 0 1.795856e-07
I1961 n1_m1_76800_427200 0 1.702111e-07
I1962 n1_m1_76800_432000 0 2.433065e-07
I1963 n1_m1_76800_436800 0 1.585456e-07
I1964 n1_m1_76800_441600 0 2.416321e-07
I1965 n1_m1_76800_446400 0 1.662002e-07
I1966 n1_m1_76800_451200 0 1.699065e-07
I1967 n1_m1_76800_456000 0 2.392677e-07
I1968 n1_m1_76800_460800 0 1.535157e-07
I1969 n1_m1_76800_465600 0 2.298422e-07
I1970 n1_m1_76800_470400 0 1.532282e-07
I1971 n1_m1_76800_475200 0 1.532282e-07
I1972 n1_m1_76800_480000 0 2.313120e-07
I1973 n1_m1_76800_484800 0 1.554171e-07
I1974 n1_m1_76800_489600 0 2.309367e-07
I1975 n1_m1_76800_494400 0 1.532282e-07
I1976 n1_m1_76800_499200 0 1.532282e-07
I1977 n1_m1_76800_504000 0 2.302644e-07
I1978 n1_m1_76800_508800 0 1.559161e-07
I1979 n1_m1_76800_513600 0 2.392922e-07
I1980 n1_m1_76800_518400 0 1.598903e-07
I1981 n1_m1_76800_523200 0 1.701716e-07
I1982 n1_m1_76800_528000 0 2.786496e-07
I1983 n1_m1_76800_532800 0 1.623294e-07
I1984 n1_m1_76800_537600 0 2.395975e-07
I1985 n1_m1_76800_542400 0 1.617631e-07
I1986 n1_m1_76800_547200 0 1.553777e-07
I1987 n1_m1_76800_552000 0 2.232277e-07
I1988 n1_m1_76800_556800 0 1.517054e-07
I1989 n1_m1_81600_0 0 2.198491e-07
I1990 n1_m1_81600_4800 0 2.200847e-07
I1991 n1_m1_81600_9600 0 3.357971e-07
I1992 n1_m1_81600_14400 0 2.255788e-07
I1993 n1_m1_81600_19200 0 2.301339e-07
I1994 n1_m1_81600_24000 0 3.535971e-07
I1995 n1_m1_81600_28800 0 2.398354e-07
I1996 n1_m1_81600_33600 0 3.522582e-07
I1997 n1_m1_81600_38400 0 2.298422e-07
I1998 n1_m1_81600_43200 0 2.242746e-07
I1999 n1_m1_81600_48000 0 3.297737e-07
I2000 n1_m1_81600_52800 0 2.198491e-07
I2001 n1_m1_81600_57600 0 3.297737e-07
I2002 n1_m1_81600_62400 0 2.198491e-07
I2003 n1_m1_81600_67200 0 2.204885e-07
I2004 n1_m1_81600_72000 0 3.362009e-07
I2005 n1_m1_81600_76800 0 2.278436e-07
I2006 n1_m1_81600_81600 0 3.518299e-07
I2007 n1_m1_81600_86400 0 2.345533e-07
I2008 n1_m1_81600_91200 0 2.320632e-07
I2009 n1_m1_81600_96000 0 3.447634e-07
I2010 n1_m1_81600_100800 0 2.298422e-07
I2011 n1_m1_81600_105600 0 3.447634e-07
I2012 n1_m1_81600_110400 0 2.298422e-07
I2013 n1_m1_81600_115200 0 2.298422e-07
I2014 n1_m1_81600_120000 0 3.447634e-07
I2015 n1_m1_81600_124800 0 2.298422e-07
I2016 n1_m1_81600_129600 0 3.447634e-07
I2017 n1_m1_81600_134400 0 2.298422e-07
I2018 n1_m1_81600_139200 0 2.298422e-07
I2019 n1_m1_81600_144000 0 3.449989e-07
I2020 n1_m1_81600_148800 0 2.334724e-07
I2021 n1_m1_81600_153600 0 3.465101e-07
I2022 n1_m1_81600_158400 0 2.334316e-07
I2023 n1_m1_81600_163200 0 2.304143e-07
I2024 n1_m1_81600_168000 0 3.447634e-07
I2025 n1_m1_81600_172800 0 2.325547e-07
I2026 n1_m1_81600_177600 0 3.565104e-07
I2027 n1_m1_81600_182400 0 2.380672e-07
I2028 n1_m1_81600_187200 0 2.428966e-07
I2029 n1_m1_81600_192000 0 3.725168e-07
I2030 n1_m1_81600_196800 0 2.464003e-07
I2031 n1_m1_81600_201600 0 3.497824e-07
I2032 n1_m1_81600_206400 0 2.298422e-07
I2033 n1_m1_81600_211200 0 2.298422e-07
I2034 n1_m1_81600_216000 0 3.480468e-07
I2035 n1_m1_81600_220800 0 2.398354e-07
I2036 n1_m1_81600_225600 0 3.565084e-07
I2037 n1_m1_81600_230400 0 2.345533e-07
I2038 n1_m1_81600_235200 0 2.368925e-07
I2039 n1_m1_81600_240000 0 3.683186e-07
I2040 n1_m1_81600_244800 0 2.498285e-07
I2041 n1_m1_81600_249600 0 3.684910e-07
I2042 n1_m1_81600_254400 0 2.404013e-07
I2043 n1_m1_81600_259200 0 2.394652e-07
I2044 n1_m1_81600_264000 0 3.535951e-07
I2045 n1_m1_81600_268800 0 2.351243e-07
I2046 n1_m1_81600_273600 0 3.554458e-07
I2047 n1_m1_81600_278400 0 2.521841e-07
I2048 n1_m1_81600_283200 0 2.560161e-07
I2049 n1_m1_81600_288000 0 3.646456e-07
I2050 n1_m1_81600_292800 0 4.468933e-07
I2051 n1_m1_81600_297600 0 8.640039e-07
I2052 n1_m1_81600_302400 0 3.369524e-07
I2053 n1_m1_81600_307200 0 2.626320e-07
I2054 n1_m1_81600_312000 0 3.892216e-07
I2055 n1_m1_81600_316800 0 2.577639e-07
I2056 n1_m1_81600_321600 0 3.668747e-07
I2057 n1_m1_81600_326400 0 2.323324e-07
I2058 n1_m1_81600_331200 0 2.298422e-07
I2059 n1_m1_81600_336000 0 3.526865e-07
I2060 n1_m1_81600_340800 0 2.465451e-07
I2061 n1_m1_81600_345600 0 3.785789e-07
I2062 n1_m1_81600_350400 0 2.473241e-07
I2063 n1_m1_81600_355200 0 2.535902e-07
I2064 n1_m1_81600_360000 0 3.881367e-07
I2065 n1_m1_81600_364800 0 2.533720e-07
I2066 n1_m1_81600_369600 0 3.656694e-07
I2067 n1_m1_81600_374400 0 2.354099e-07
I2068 n1_m1_81600_379200 0 2.298422e-07
I2069 n1_m1_81600_384000 0 3.447634e-07
I2070 n1_m1_81600_388800 0 2.298422e-07
I2071 n1_m1_81600_393600 0 3.509193e-07
I2072 n1_m1_81600_398400 0 2.391287e-07
I2073 n1_m1_81600_403200 0 2.401923e-07
I2074 n1_m1_81600_408000 0 3.723159e-07
I2075 n1_m1_81600_412800 0 2.498285e-07
I2076 n1_m1_81600_417600 0 4.164998e-07
I2077 n1_m1_81600_422400 0 3.170191e-07
I2078 n1_m1_81600_427200 0 2.842784e-07
I2079 n1_m1_81600_432000 0 3.826659e-07
I2080 n1_m1_81600_436800 0 2.384078e-07
I2081 n1_m1_81600_441600 0 3.469843e-07
I2082 n1_m1_81600_446400 0 2.298422e-07
I2083 n1_m1_81600_451200 0 2.298422e-07
I2084 n1_m1_81600_456000 0 3.447634e-07
I2085 n1_m1_81600_460800 0 2.298422e-07
I2086 n1_m1_81600_465600 0 3.447634e-07
I2087 n1_m1_81600_470400 0 2.298422e-07
I2088 n1_m1_81600_475200 0 2.312556e-07
I2089 n1_m1_81600_480000 0 3.553428e-07
I2090 n1_m1_81600_484800 0 2.425947e-07
I2091 n1_m1_81600_489600 0 3.568265e-07
I2092 n1_m1_81600_494400 0 2.345533e-07
I2093 n1_m1_81600_499200 0 2.345533e-07
I2094 n1_m1_81600_504000 0 3.528486e-07
I2095 n1_m1_81600_508800 0 2.394204e-07
I2096 n1_m1_81600_513600 0 3.618394e-07
I2097 n1_m1_81600_518400 0 2.445464e-07
I2098 n1_m1_81600_523200 0 2.565199e-07
I2099 n1_m1_81600_528000 0 4.161664e-07
I2100 n1_m1_81600_532800 0 2.557693e-07
I2101 n1_m1_81600_537600 0 3.740708e-07
I2102 n1_m1_81600_542400 0 2.454805e-07
I2103 n1_m1_81600_547200 0 2.335519e-07
I2104 n1_m1_81600_552000 0 3.348416e-07
I2105 n1_m1_81600_556800 0 2.275581e-07
I2106 n1_m1_86400_0 0 7.328303e-08
I2107 n1_m1_86400_4800 0 7.344959e-08
I2108 n1_m1_86400_9600 0 1.141835e-07
I2109 n1_m1_86400_14400 0 7.686187e-08
I2110 n1_m1_86400_19200 0 7.810490e-08
I2111 n1_m1_86400_24000 0 1.196692e-07
I2112 n1_m1_86400_28800 0 7.994513e-08
I2113 n1_m1_86400_33600 0 1.174194e-07
I2114 n1_m1_86400_38400 0 7.661408e-08
I2115 n1_m1_86400_43200 0 7.475821e-08
I2116 n1_m1_86400_48000 0 1.099246e-07
I2117 n1_m1_86400_52800 0 7.328303e-08
I2118 n1_m1_86400_57600 0 1.099246e-07
I2119 n1_m1_86400_62400 0 7.328303e-08
I2120 n1_m1_86400_67200 0 7.390948e-08
I2121 n1_m1_86400_72000 0 1.162219e-07
I2122 n1_m1_86400_76800 0 7.857124e-08
I2123 n1_m1_86400_81600 0 1.199177e-07
I2124 n1_m1_86400_86400 0 7.994513e-08
I2125 n1_m1_86400_91200 0 7.818443e-08
I2126 n1_m1_86400_96000 0 1.149211e-07
I2127 n1_m1_86400_100800 0 7.661408e-08
I2128 n1_m1_86400_105600 0 1.149211e-07
I2129 n1_m1_86400_110400 0 7.661408e-08
I2130 n1_m1_86400_115200 0 7.661408e-08
I2131 n1_m1_86400_120000 0 1.149211e-07
I2132 n1_m1_86400_124800 0 7.661408e-08
I2133 n1_m1_86400_129600 0 1.149211e-07
I2134 n1_m1_86400_134400 0 7.661408e-08
I2135 n1_m1_86400_139200 0 7.661408e-08
I2136 n1_m1_86400_144000 0 1.150877e-07
I2137 n1_m1_86400_148800 0 7.920754e-08
I2138 n1_m1_86400_153600 0 1.199177e-07
I2139 n1_m1_86400_158400 0 7.963820e-08
I2140 n1_m1_86400_163200 0 7.814738e-08
I2141 n1_m1_86400_168000 0 1.163895e-07
I2142 n1_m1_86400_172800 0 7.716948e-08
I2143 n1_m1_86400_177600 0 1.166312e-07
I2144 n1_m1_86400_182400 0 7.661408e-08
I2145 n1_m1_86400_187200 0 7.661408e-08
I2146 n1_m1_86400_192000 0 1.167335e-07
I2147 n1_m1_86400_196800 0 7.866030e-08
I2148 n1_m1_86400_201600 0 1.155935e-07
I2149 n1_m1_86400_206400 0 7.661408e-08
I2150 n1_m1_86400_211200 0 7.673339e-08
I2151 n1_m1_86400_216000 0 1.172913e-07
I2152 n1_m1_86400_220800 0 7.994513e-08
I2153 n1_m1_86400_225600 0 1.191284e-07
I2154 n1_m1_86400_230400 0 7.933942e-08
I2155 n1_m1_86400_235200 0 8.051413e-08
I2156 n1_m1_86400_240000 0 1.246451e-07
I2157 n1_m1_86400_244800 0 8.268882e-08
I2158 n1_m1_86400_249600 0 1.206485e-07
I2159 n1_m1_86400_254400 0 7.978911e-08
I2160 n1_m1_86400_259200 0 7.869225e-08
I2161 n1_m1_86400_264000 0 1.153157e-07
I2162 n1_m1_86400_268800 0 7.661408e-08
I2163 n1_m1_86400_273600 0 1.168722e-07
I2164 n1_m1_86400_278400 0 8.237203e-08
I2165 n1_m1_86400_283200 0 8.608037e-08
I2166 n1_m1_86400_288000 0 1.273551e-07
I2167 n1_m1_86400_292800 0 7.981665e-08
I2168 n1_m1_86400_297600 0 1.246746e-07
I2169 n1_m1_86400_302400 0 8.773604e-08
I2170 n1_m1_86400_307200 0 8.557290e-08
I2171 n1_m1_86400_312000 0 1.232688e-07
I2172 n1_m1_86400_316800 0 8.479962e-08
I2173 n1_m1_86400_321600 0 1.231899e-07
I2174 n1_m1_86400_326400 0 7.898048e-08
I2175 n1_m1_86400_331200 0 7.740334e-08
I2176 n1_m1_86400_336000 0 1.175622e-07
I2177 n1_m1_86400_340800 0 8.218169e-08
I2178 n1_m1_86400_345600 0 1.274523e-07
I2179 n1_m1_86400_350400 0 8.004812e-08
I2180 n1_m1_86400_355200 0 8.139651e-08
I2181 n1_m1_86400_360000 0 1.226750e-07
I2182 n1_m1_86400_364800 0 8.060556e-08
I2183 n1_m1_86400_369600 0 1.199775e-07
I2184 n1_m1_86400_374400 0 7.846995e-08
I2185 n1_m1_86400_379200 0 7.661408e-08
I2186 n1_m1_86400_384000 0 1.149211e-07
I2187 n1_m1_86400_388800 0 7.661408e-08
I2188 n1_m1_86400_393600 0 1.151696e-07
I2189 n1_m1_86400_398400 0 7.845432e-08
I2190 n1_m1_86400_403200 0 7.977042e-08
I2191 n1_m1_86400_408000 0 1.227746e-07
I2192 n1_m1_86400_412800 0 8.321193e-08
I2193 n1_m1_86400_417600 0 1.374533e-07
I2194 n1_m1_86400_422400 0 1.035833e-07
I2195 n1_m1_86400_427200 0 9.414899e-08
I2196 n1_m1_86400_432000 0 1.282691e-07
I2197 n1_m1_86400_436800 0 7.994513e-08
I2198 n1_m1_86400_441600 0 1.158858e-07
I2199 n1_m1_86400_446400 0 7.661408e-08
I2200 n1_m1_86400_451200 0 7.661408e-08
I2201 n1_m1_86400_456000 0 1.149211e-07
I2202 n1_m1_86400_460800 0 7.661408e-08
I2203 n1_m1_86400_465600 0 1.149211e-07
I2204 n1_m1_86400_470400 0 7.710966e-08
I2205 n1_m1_86400_475200 0 7.851278e-08
I2206 n1_m1_86400_480000 0 1.207658e-07
I2207 n1_m1_86400_484800 0 8.242846e-08
I2208 n1_m1_86400_489600 0 1.215832e-07
I2209 n1_m1_86400_494400 0 7.994513e-08
I2210 n1_m1_86400_499200 0 7.994513e-08
I2211 n1_m1_86400_504000 0 1.199177e-07
I2212 n1_m1_86400_508800 0 8.013785e-08
I2213 n1_m1_86400_513600 0 1.225951e-07
I2214 n1_m1_86400_518400 0 8.327618e-08
I2215 n1_m1_86400_523200 0 8.939850e-08
I2216 n1_m1_86400_528000 0 1.510147e-07
I2217 n1_m1_86400_532800 0 9.012658e-08
I2218 n1_m1_86400_537600 0 1.251651e-07
I2219 n1_m1_86400_542400 0 7.918375e-08
I2220 n1_m1_86400_547200 0 7.613822e-08
I2221 n1_m1_86400_552000 0 1.111917e-07
I2222 n1_m1_86400_556800 0 7.585270e-08
I2223 n1_m1_91200_0 0 1.465661e-07
I2224 n1_m1_91200_4800 0 1.468992e-07
I2225 n1_m1_91200_9600 0 2.292223e-07
I2226 n1_m1_91200_14400 0 1.572295e-07
I2227 n1_m1_91200_19200 0 1.596435e-07
I2228 n1_m1_91200_24000 0 2.398354e-07
I2229 n1_m1_91200_28800 0 1.598903e-07
I2230 n1_m1_91200_33600 0 2.348388e-07
I2231 n1_m1_91200_38400 0 1.532282e-07
I2232 n1_m1_91200_43200 0 1.495164e-07
I2233 n1_m1_91200_48000 0 2.198491e-07
I2234 n1_m1_91200_52800 0 1.465661e-07
I2235 n1_m1_91200_57600 0 2.198491e-07
I2236 n1_m1_91200_62400 0 1.465661e-07
I2237 n1_m1_91200_67200 0 1.483744e-07
I2238 n1_m1_91200_72000 0 2.380271e-07
I2239 n1_m1_91200_76800 0 1.598903e-07
I2240 n1_m1_91200_81600 0 2.398354e-07
I2241 n1_m1_91200_86400 0 1.598903e-07
I2242 n1_m1_91200_91200 0 1.563689e-07
I2243 n1_m1_91200_96000 0 2.298422e-07
I2244 n1_m1_91200_100800 0 1.532282e-07
I2245 n1_m1_91200_105600 0 2.298422e-07
I2246 n1_m1_91200_110400 0 1.538067e-07
I2247 n1_m1_91200_115200 0 1.563723e-07
I2248 n1_m1_91200_120000 0 2.351243e-07
I2249 n1_m1_91200_124800 0 1.556931e-07
I2250 n1_m1_91200_129600 0 2.298674e-07
I2251 n1_m1_91200_134400 0 1.511656e-07
I2252 n1_m1_91200_139200 0 1.514675e-07
I2253 n1_m1_91200_144000 0 2.299993e-07
I2254 n1_m1_91200_148800 0 1.556734e-07
I2255 n1_m1_91200_153600 0 2.345533e-07
I2256 n1_m1_91200_158400 0 1.563689e-07
I2257 n1_m1_91200_163200 0 1.567462e-07
I2258 n1_m1_91200_168000 0 2.393928e-07
I2259 n1_m1_91200_172800 0 1.583593e-07
I2260 n1_m1_91200_177600 0 2.299932e-07
I2261 n1_m1_91200_182400 0 1.532282e-07
I2262 n1_m1_91200_187200 0 1.532282e-07
I2263 n1_m1_91200_192000 0 2.298422e-07
I2264 n1_m1_91200_196800 0 1.532282e-07
I2265 n1_m1_91200_201600 0 2.304711e-07
I2266 n1_m1_91200_206400 0 1.569005e-07
I2267 n1_m1_91200_211200 0 1.600847e-07
I2268 n1_m1_91200_216000 0 2.433996e-07
I2269 n1_m1_91200_220800 0 1.598903e-07
I2270 n1_m1_91200_225600 0 2.357430e-07
I2271 n1_m1_91200_230400 0 1.548882e-07
I2272 n1_m1_91200_235200 0 1.577597e-07
I2273 n1_m1_91200_240000 0 2.418972e-07
I2274 n1_m1_91200_244800 0 1.606394e-07
I2275 n1_m1_91200_249600 0 2.398354e-07
I2276 n1_m1_91200_254400 0 1.595089e-07
I2277 n1_m1_91200_259200 0 1.569440e-07
I2278 n1_m1_91200_264000 0 2.315778e-07
I2279 n1_m1_91200_268800 0 1.559447e-07
I2280 n1_m1_91200_273600 0 2.339204e-07
I2281 n1_m1_91200_278400 0 1.565592e-07
I2282 n1_m1_91200_283200 0 1.598916e-07
I2283 n1_m1_91200_288000 0 2.542167e-07
I2284 n1_m1_91200_292800 0 1.630976e-07
I2285 n1_m1_91200_297600 0 2.448483e-07
I2286 n1_m1_91200_302400 0 1.685938e-07
I2287 n1_m1_91200_307200 0 1.666645e-07
I2288 n1_m1_91200_312000 0 2.424567e-07
I2289 n1_m1_91200_316800 0 1.629718e-07
I2290 n1_m1_91200_321600 0 2.447585e-07
I2291 n1_m1_91200_326400 0 1.634117e-07
I2292 n1_m1_91200_331200 0 1.622002e-07
I2293 n1_m1_91200_336000 0 2.428966e-07
I2294 n1_m1_91200_340800 0 1.655204e-07
I2295 n1_m1_91200_345600 0 2.548271e-07
I2296 n1_m1_91200_350400 0 1.589487e-07
I2297 n1_m1_91200_355200 0 1.564368e-07
I2298 n1_m1_91200_360000 0 2.337906e-07
I2299 n1_m1_91200_364800 0 1.546252e-07
I2300 n1_m1_91200_369600 0 2.393119e-07
I2301 n1_m1_91200_374400 0 1.584994e-07
I2302 n1_m1_91200_379200 0 1.554919e-07
I2303 n1_m1_91200_384000 0 2.298422e-07
I2304 n1_m1_91200_388800 0 1.532282e-07
I2305 n1_m1_91200_393600 0 2.298422e-07
I2306 n1_m1_91200_398400 0 1.534749e-07
I2307 n1_m1_91200_403200 0 1.557632e-07
I2308 n1_m1_91200_408000 0 2.360285e-07
I2309 n1_m1_91200_412800 0 1.626979e-07
I2310 n1_m1_91200_417600 0 2.459264e-07
I2311 n1_m1_91200_422400 0 1.644898e-07
I2312 n1_m1_91200_427200 0 1.626503e-07
I2313 n1_m1_91200_432000 0 2.395336e-07
I2314 n1_m1_91200_436800 0 1.544396e-07
I2315 n1_m1_91200_441600 0 2.298422e-07
I2316 n1_m1_91200_446400 0 1.532282e-07
I2317 n1_m1_91200_451200 0 1.532282e-07
I2318 n1_m1_91200_456000 0 2.298422e-07
I2319 n1_m1_91200_460800 0 1.532282e-07
I2320 n1_m1_91200_465600 0 2.298422e-07
I2321 n1_m1_91200_470400 0 1.557978e-07
I2322 n1_m1_91200_475200 0 1.598903e-07
I2323 n1_m1_91200_480000 0 2.443085e-07
I2324 n1_m1_91200_484800 0 1.665524e-07
I2325 n1_m1_91200_489600 0 2.396450e-07
I2326 n1_m1_91200_494400 0 1.565449e-07
I2327 n1_m1_91200_499200 0 1.591105e-07
I2328 n1_m1_91200_504000 0 2.398354e-07
I2329 n1_m1_91200_508800 0 1.603614e-07
I2330 n1_m1_91200_513600 0 2.457245e-07
I2331 n1_m1_91200_518400 0 1.665524e-07
I2332 n1_m1_91200_523200 0 1.762396e-07
I2333 n1_m1_91200_528000 0 2.922586e-07
I2334 n1_m1_91200_532800 0 1.769846e-07
I2335 n1_m1_91200_537600 0 2.410726e-07
I2336 n1_m1_91200_542400 0 1.508794e-07
I2337 n1_m1_91200_547200 0 1.473288e-07
I2338 n1_m1_91200_552000 0 2.251638e-07
I2339 n1_m1_91200_556800 0 1.552268e-07
I2340 n1_m1_96000_0 0 2.149056e-07
I2341 n1_m1_96000_4800 0 2.188753e-07
I2342 n1_m1_96000_9600 0 3.429136e-07
I2343 n1_m1_96000_14400 0 2.346175e-07
I2344 n1_m1_96000_19200 0 2.393418e-07
I2345 n1_m1_96000_24000 0 3.595634e-07
I2346 n1_m1_96000_28800 0 2.373167e-07
I2347 n1_m1_96000_33600 0 3.475472e-07
I2348 n1_m1_96000_38400 0 2.298422e-07
I2349 n1_m1_96000_43200 0 2.242746e-07
I2350 n1_m1_96000_48000 0 3.297737e-07
I2351 n1_m1_96000_52800 0 2.198491e-07
I2352 n1_m1_96000_57600 0 3.297737e-07
I2353 n1_m1_96000_62400 0 2.209708e-07
I2354 n1_m1_96000_67200 0 2.282597e-07
I2355 n1_m1_96000_72000 0 3.664628e-07
I2356 n1_m1_96000_76800 0 2.440529e-07
I2357 n1_m1_96000_81600 0 3.594502e-07
I2358 n1_m1_96000_86400 0 2.358116e-07
I2359 n1_m1_96000_91200 0 2.315921e-07
I2360 n1_m1_96000_96000 0 3.451672e-07
I2361 n1_m1_96000_100800 0 2.302613e-07
I2362 n1_m1_96000_105600 0 3.461808e-07
I2363 n1_m1_96000_110400 0 2.364000e-07
I2364 n1_m1_96000_115200 0 2.405308e-07
I2365 n1_m1_96000_120000 0 3.660396e-07
I2366 n1_m1_96000_124800 0 2.390217e-07
I2367 n1_m1_96000_129600 0 3.499975e-07
I2368 n1_m1_96000_134400 0 2.239891e-07
I2369 n1_m1_96000_139200 0 2.252740e-07
I2370 n1_m1_96000_144000 0 3.456352e-07
I2371 n1_m1_96000_148800 0 2.299371e-07
I2372 n1_m1_96000_153600 0 3.448460e-07
I2373 n1_m1_96000_158400 0 2.312433e-07
I2374 n1_m1_96000_163200 0 2.379092e-07
I2375 n1_m1_96000_168000 0 3.813893e-07
I2376 n1_m1_96000_172800 0 2.589549e-07
I2377 n1_m1_96000_177600 0 3.604108e-07
I2378 n1_m1_96000_182400 0 2.326240e-07
I2379 n1_m1_96000_187200 0 2.298422e-07
I2380 n1_m1_96000_192000 0 3.451580e-07
I2381 n1_m1_96000_196800 0 2.305948e-07
I2382 n1_m1_96000_201600 0 3.461328e-07
I2383 n1_m1_96000_206400 0 2.353997e-07
I2384 n1_m1_96000_211200 0 2.472497e-07
I2385 n1_m1_96000_216000 0 3.709576e-07
I2386 n1_m1_96000_220800 0 2.399394e-07
I2387 n1_m1_96000_225600 0 3.583632e-07
I2388 n1_m1_96000_230400 0 2.367538e-07
I2389 n1_m1_96000_235200 0 2.337702e-07
I2390 n1_m1_96000_240000 0 3.456107e-07
I2391 n1_m1_96000_244800 0 2.372392e-07
I2392 n1_m1_96000_249600 0 3.602425e-07
I2393 n1_m1_96000_254400 0 2.402637e-07
I2394 n1_m1_96000_259200 0 2.399720e-07
I2395 n1_m1_96000_264000 0 3.565288e-07
I2396 n1_m1_96000_268800 0 2.376940e-07
I2397 n1_m1_96000_273600 0 3.514863e-07
I2398 n1_m1_96000_278400 0 2.438326e-07
I2399 n1_m1_96000_283200 0 2.448727e-07
I2400 n1_m1_96000_288000 0 3.589506e-07
I2401 n1_m1_96000_292800 0 2.422195e-07
I2402 n1_m1_96000_297600 0 3.729624e-07
I2403 n1_m1_96000_302400 0 2.502109e-07
I2404 n1_m1_96000_307200 0 2.510002e-07
I2405 n1_m1_96000_312000 0 3.895286e-07
I2406 n1_m1_96000_316800 0 2.404166e-07
I2407 n1_m1_96000_321600 0 3.655593e-07
I2408 n1_m1_96000_326400 0 2.530161e-07
I2409 n1_m1_96000_331200 0 2.561099e-07
I2410 n1_m1_96000_336000 0 3.841649e-07
I2411 n1_m1_96000_340800 0 2.518924e-07
I2412 n1_m1_96000_345600 0 3.778233e-07
I2413 n1_m1_96000_350400 0 2.465665e-07
I2414 n1_m1_96000_355200 0 2.380009e-07
I2415 n1_m1_96000_360000 0 3.462491e-07
I2416 n1_m1_96000_364800 0 2.318521e-07
I2417 n1_m1_96000_369600 0 3.626705e-07
I2418 n1_m1_96000_374400 0 2.433350e-07
I2419 n1_m1_96000_379200 0 2.385098e-07
I2420 n1_m1_96000_384000 0 3.494744e-07
I2421 n1_m1_96000_388800 0 2.298422e-07
I2422 n1_m1_96000_393600 0 3.447634e-07
I2423 n1_m1_96000_398400 0 2.298422e-07
I2424 n1_m1_96000_403200 0 2.298422e-07
I2425 n1_m1_96000_408000 0 3.468813e-07
I2426 n1_m1_96000_412800 0 2.389289e-07
I2427 n1_m1_96000_417600 0 3.543282e-07
I2428 n1_m1_96000_422400 0 2.298422e-07
I2429 n1_m1_96000_427200 0 2.298422e-07
I2430 n1_m1_96000_432000 0 3.447634e-07
I2431 n1_m1_96000_436800 0 2.298422e-07
I2432 n1_m1_96000_441600 0 3.447634e-07
I2433 n1_m1_96000_446400 0 2.298422e-07
I2434 n1_m1_96000_451200 0 2.298514e-07
I2435 n1_m1_96000_456000 0 3.452895e-07
I2436 n1_m1_96000_460800 0 2.302002e-07
I2437 n1_m1_96000_465600 0 3.448093e-07
I2438 n1_m1_96000_470400 0 2.314391e-07
I2439 n1_m1_96000_475200 0 2.357382e-07
I2440 n1_m1_96000_480000 0 3.661334e-07
I2441 n1_m1_96000_484800 0 2.496511e-07
I2442 n1_m1_96000_489600 0 3.614662e-07
I2443 n1_m1_96000_494400 0 2.367161e-07
I2444 n1_m1_96000_499200 0 2.391083e-07
I2445 n1_m1_96000_504000 0 3.598357e-07
I2446 n1_m1_96000_508800 0 2.402300e-07
I2447 n1_m1_96000_513600 0 3.646314e-07
I2448 n1_m1_96000_518400 0 2.499815e-07
I2449 n1_m1_96000_523200 0 2.594403e-07
I2450 n1_m1_96000_528000 0 4.376170e-07
I2451 n1_m1_96000_532800 0 2.842274e-07
I2452 n1_m1_96000_537600 0 3.715939e-07
I2453 n1_m1_96000_542400 0 2.235965e-07
I2454 n1_m1_96000_547200 0 2.206016e-07
I2455 n1_m1_96000_552000 0 3.423477e-07
I2456 n1_m1_96000_556800 0 2.323752e-07
I2457 n1_m1_100800_0 0 1.402520e-07
I2458 n1_m1_100800_4800 0 1.414808e-07
I2459 n1_m1_100800_9600 0 2.217237e-07
I2460 n1_m1_100800_14400 0 1.541867e-07
I2461 n1_m1_100800_19200 0 1.592240e-07
I2462 n1_m1_100800_24000 0 2.373453e-07
I2463 n1_m1_100800_28800 0 1.541153e-07
I2464 n1_m1_100800_33600 0 2.298422e-07
I2465 n1_m1_100800_38400 0 1.531364e-07
I2466 n1_m1_100800_43200 0 1.494532e-07
I2467 n1_m1_100800_48000 0 2.198491e-07
I2468 n1_m1_100800_52800 0 1.465661e-07
I2469 n1_m1_100800_57600 0 2.198491e-07
I2470 n1_m1_100800_62400 0 1.477557e-07
I2471 n1_m1_100800_67200 0 1.543597e-07
I2472 n1_m1_100800_72000 0 2.474951e-07
I2473 n1_m1_100800_76800 0 1.641248e-07
I2474 n1_m1_100800_81600 0 2.359870e-07
I2475 n1_m1_100800_86400 0 1.537605e-07
I2476 n1_m1_100800_91200 0 1.532282e-07
I2477 n1_m1_100800_96000 0 2.346879e-07
I2478 n1_m1_100800_100800 0 1.582574e-07
I2479 n1_m1_100800_105600 0 2.325876e-07
I2480 n1_m1_100800_110400 0 1.601727e-07
I2481 n1_m1_100800_115200 0 1.645038e-07
I2482 n1_m1_100800_120000 0 2.486610e-07
I2483 n1_m1_100800_124800 0 1.633450e-07
I2484 n1_m1_100800_129600 0 2.352807e-07
I2485 n1_m1_100800_134400 0 1.494097e-07
I2486 n1_m1_100800_139200 0 1.551792e-07
I2487 n1_m1_100800_144000 0 2.406491e-07
I2488 n1_m1_100800_148800 0 1.546496e-07
I2489 n1_m1_100800_153600 0 2.309191e-07
I2490 n1_m1_100800_158400 0 1.597125e-07
I2491 n1_m1_100800_163200 0 1.700228e-07
I2492 n1_m1_100800_168000 0 2.823161e-07
I2493 n1_m1_100800_172800 0 1.998091e-07
I2494 n1_m1_100800_177600 0 2.507779e-07
I2495 n1_m1_100800_182400 0 1.561785e-07
I2496 n1_m1_100800_187200 0 1.532955e-07
I2497 n1_m1_100800_192000 0 2.350499e-07
I2498 n1_m1_100800_196800 0 1.627951e-07
I2499 n1_m1_100800_201600 0 2.390115e-07
I2500 n1_m1_100800_206400 0 1.551670e-07
I2501 n1_m1_100800_211200 0 1.602635e-07
I2502 n1_m1_100800_216000 0 2.417354e-07
I2503 n1_m1_100800_220800 0 1.611037e-07
I2504 n1_m1_100800_225600 0 2.503088e-07
I2505 n1_m1_100800_230400 0 1.674606e-07
I2506 n1_m1_100800_235200 0 1.622852e-07
I2507 n1_m1_100800_240000 0 2.378898e-07
I2508 n1_m1_100800_244800 0 1.596197e-07
I2509 n1_m1_100800_249600 0 2.459465e-07
I2510 n1_m1_100800_254400 0 1.652998e-07
I2511 n1_m1_100800_259200 0 1.653151e-07
I2512 n1_m1_100800_264000 0 2.463880e-07
I2513 n1_m1_100800_268800 0 1.597652e-07
I2514 n1_m1_100800_273600 0 2.387732e-07
I2515 n1_m1_100800_278400 0 1.612703e-07
I2516 n1_m1_100800_283200 0 1.658834e-07
I2517 n1_m1_100800_288000 0 2.500552e-07
I2518 n1_m1_100800_292800 0 1.648154e-07
I2519 n1_m1_100800_297600 0 2.552156e-07
I2520 n1_m1_100800_302400 0 1.711737e-07
I2521 n1_m1_100800_307200 0 1.674334e-07
I2522 n1_m1_100800_312000 0 2.468833e-07
I2523 n1_m1_100800_316800 0 1.600381e-07
I2524 n1_m1_100800_321600 0 2.467745e-07
I2525 n1_m1_100800_326400 0 1.739146e-07
I2526 n1_m1_100800_331200 0 1.758167e-07
I2527 n1_m1_100800_336000 0 2.616510e-07
I2528 n1_m1_100800_340800 0 1.686924e-07
I2529 n1_m1_100800_345600 0 2.503312e-07
I2530 n1_m1_100800_350400 0 1.703695e-07
I2531 n1_m1_100800_355200 0 1.657536e-07
I2532 n1_m1_100800_360000 0 2.328521e-07
I2533 n1_m1_100800_364800 0 1.557621e-07
I2534 n1_m1_100800_369600 0 2.475719e-07
I2535 n1_m1_100800_374400 0 1.636652e-07
I2536 n1_m1_100800_379200 0 1.599820e-07
I2537 n1_m1_100800_384000 0 2.350530e-07
I2538 n1_m1_100800_388800 0 1.535137e-07
I2539 n1_m1_100800_393600 0 2.301196e-07
I2540 n1_m1_100800_398400 0 1.533597e-07
I2541 n1_m1_100800_403200 0 1.532557e-07
I2542 n1_m1_100800_408000 0 2.301478e-07
I2543 n1_m1_100800_412800 0 1.545392e-07
I2544 n1_m1_100800_417600 0 2.312223e-07
I2545 n1_m1_100800_422400 0 1.532282e-07
I2546 n1_m1_100800_427200 0 1.532282e-07
I2547 n1_m1_100800_432000 0 2.298422e-07
I2548 n1_m1_100800_436800 0 1.532282e-07
I2549 n1_m1_100800_441600 0 2.298422e-07
I2550 n1_m1_100800_446400 0 1.532282e-07
I2551 n1_m1_100800_451200 0 1.533414e-07
I2552 n1_m1_100800_456000 0 2.363317e-07
I2553 n1_m1_100800_460800 0 1.576659e-07
I2554 n1_m1_100800_465600 0 2.306070e-07
I2555 n1_m1_100800_470400 0 1.553532e-07
I2556 n1_m1_100800_475200 0 1.589243e-07
I2557 n1_m1_100800_480000 0 2.407521e-07
I2558 n1_m1_100800_484800 0 1.642804e-07
I2559 n1_m1_100800_489600 0 2.484934e-07
I2560 n1_m1_100800_494400 0 1.648236e-07
I2561 n1_m1_100800_499200 0 1.610293e-07
I2562 n1_m1_100800_504000 0 2.409979e-07
I2563 n1_m1_100800_508800 0 1.647471e-07
I2564 n1_m1_100800_513600 0 2.482361e-07
I2565 n1_m1_100800_518400 0 1.684388e-07
I2566 n1_m1_100800_523200 0 1.896977e-07
I2567 n1_m1_100800_528000 0 3.973671e-07
I2568 n1_m1_100800_532800 0 2.803396e-07
I2569 n1_m1_100800_537600 0 3.070498e-07
I2570 n1_m1_100800_542400 0 1.565786e-07
I2571 n1_m1_100800_547200 0 1.556313e-07
I2572 n1_m1_100800_552000 0 2.299966e-07
I2573 n1_m1_100800_556800 0 1.493410e-07
I2574 n1_m1_105600_0 0 2.117268e-07
I2575 n1_m1_105600_4800 0 2.166697e-07
I2576 n1_m1_105600_9600 0 3.298124e-07
I2577 n1_m1_105600_14400 0 2.235201e-07
I2578 n1_m1_105600_19200 0 2.308654e-07
I2579 n1_m1_105600_24000 0 3.466750e-07
I2580 n1_m1_105600_28800 0 2.293494e-07
I2581 n1_m1_105600_33600 0 3.437284e-07
I2582 n1_m1_105600_38400 0 2.245806e-07
I2583 n1_m1_105600_43200 0 2.206499e-07
I2584 n1_m1_105600_48000 0 3.297737e-07
I2585 n1_m1_105600_52800 0 2.198491e-07
I2586 n1_m1_105600_57600 0 3.297737e-07
I2587 n1_m1_105600_62400 0 2.216336e-07
I2588 n1_m1_105600_67200 0 2.284816e-07
I2589 n1_m1_105600_72000 0 3.432328e-07
I2590 n1_m1_105600_76800 0 2.328647e-07
I2591 n1_m1_105600_81600 0 3.452212e-07
I2592 n1_m1_105600_86400 0 2.293100e-07
I2593 n1_m1_105600_91200 0 2.298422e-07
I2594 n1_m1_105600_96000 0 3.464683e-07
I2595 n1_m1_105600_100800 0 2.316118e-07
I2596 n1_m1_105600_105600 0 3.456288e-07
I2597 n1_m1_105600_110400 0 2.318314e-07
I2598 n1_m1_105600_115200 0 2.332651e-07
I2599 n1_m1_105600_120000 0 3.501882e-07
I2600 n1_m1_105600_124800 0 2.329163e-07
I2601 n1_m1_105600_129600 0 3.462746e-07
I2602 n1_m1_105600_134400 0 2.287831e-07
I2603 n1_m1_105600_139200 0 2.341488e-07
I2604 n1_m1_105600_144000 0 3.673968e-07
I2605 n1_m1_105600_148800 0 2.464954e-07
I2606 n1_m1_105600_153600 0 3.500230e-07
I2607 n1_m1_105600_158400 0 2.320509e-07
I2608 n1_m1_105600_163200 0 2.360924e-07
I2609 n1_m1_105600_168000 0 3.714002e-07
I2610 n1_m1_105600_172800 0 2.531412e-07
I2611 n1_m1_105600_177600 0 3.667411e-07
I2612 n1_m1_105600_182400 0 2.336566e-07
I2613 n1_m1_105600_187200 0 2.337008e-07
I2614 n1_m1_105600_192000 0 3.722758e-07
I2615 n1_m1_105600_196800 0 2.623913e-07
I2616 n1_m1_105600_201600 0 3.851982e-07
I2617 n1_m1_105600_206400 0 2.512085e-07
I2618 n1_m1_105600_211200 0 2.418235e-07
I2619 n1_m1_105600_216000 0 3.734726e-07
I2620 n1_m1_105600_220800 0 2.403371e-07
I2621 n1_m1_105600_225600 0 3.576382e-07
I2622 n1_m1_105600_230400 0 2.449156e-07
I2623 n1_m1_105600_235200 0 2.484166e-07
I2624 n1_m1_105600_240000 0 3.654563e-07
I2625 n1_m1_105600_244800 0 2.461732e-07
I2626 n1_m1_105600_249600 0 3.752149e-07
I2627 n1_m1_105600_254400 0 2.557367e-07
I2628 n1_m1_105600_259200 0 2.554604e-07
I2629 n1_m1_105600_264000 0 3.802961e-07
I2630 n1_m1_105600_268800 0 2.470073e-07
I2631 n1_m1_105600_273600 0 3.671674e-07
I2632 n1_m1_105600_278400 0 2.405254e-07
I2633 n1_m1_105600_283200 0 2.489237e-07
I2634 n1_m1_105600_288000 0 3.747679e-07
I2635 n1_m1_105600_292800 0 2.511705e-07
I2636 n1_m1_105600_297600 0 3.838743e-07
I2637 n1_m1_105600_302400 0 2.523577e-07
I2638 n1_m1_105600_307200 0 2.590304e-07
I2639 n1_m1_105600_312000 0 3.689794e-07
I2640 n1_m1_105600_316800 0 2.429700e-07
I2641 n1_m1_105600_321600 0 3.892696e-07
I2642 n1_m1_105600_326400 0 3.425166e-07
I2643 n1_m1_105600_331200 0 4.100845e-07
I2644 n1_m1_105600_336000 0 4.976615e-07
I2645 n1_m1_105600_340800 0 2.516858e-07
I2646 n1_m1_105600_345600 0 3.640189e-07
I2647 n1_m1_105600_350400 0 2.477272e-07
I2648 n1_m1_105600_355200 0 2.472106e-07
I2649 n1_m1_105600_360000 0 3.659787e-07
I2650 n1_m1_105600_364800 0 2.441494e-07
I2651 n1_m1_105600_369600 0 3.710480e-07
I2652 n1_m1_105600_374400 0 2.482589e-07
I2653 n1_m1_105600_379200 0 2.460828e-07
I2654 n1_m1_105600_384000 0 3.666055e-07
I2655 n1_m1_105600_388800 0 2.462120e-07
I2656 n1_m1_105600_393600 0 3.606654e-07
I2657 n1_m1_105600_398400 0 2.373840e-07
I2658 n1_m1_105600_403200 0 2.314208e-07
I2659 n1_m1_105600_408000 0 3.447634e-07
I2660 n1_m1_105600_412800 0 2.298422e-07
I2661 n1_m1_105600_417600 0 3.447634e-07
I2662 n1_m1_105600_422400 0 2.298422e-07
I2663 n1_m1_105600_427200 0 2.298422e-07
I2664 n1_m1_105600_432000 0 3.447634e-07
I2665 n1_m1_105600_436800 0 2.298422e-07
I2666 n1_m1_105600_441600 0 3.447634e-07
I2667 n1_m1_105600_446400 0 2.298422e-07
I2668 n1_m1_105600_451200 0 2.300564e-07
I2669 n1_m1_105600_456000 0 3.570407e-07
I2670 n1_m1_105600_460800 0 2.395383e-07
I2671 n1_m1_105600_465600 0 3.572344e-07
I2672 n1_m1_105600_470400 0 2.387246e-07
I2673 n1_m1_105600_475200 0 2.398354e-07
I2674 n1_m1_105600_480000 0 3.597531e-07
I2675 n1_m1_105600_484800 0 2.408945e-07
I2676 n1_m1_105600_489600 0 3.760633e-07
I2677 n1_m1_105600_494400 0 2.442300e-07
I2678 n1_m1_105600_499200 0 2.402943e-07
I2679 n1_m1_105600_504000 0 3.699237e-07
I2680 n1_m1_105600_508800 0 2.484587e-07
I2681 n1_m1_105600_513600 0 3.670841e-07
I2682 n1_m1_105600_518400 0 2.533975e-07
I2683 n1_m1_105600_523200 0 2.657115e-07
I2684 n1_m1_105600_528000 0 4.357662e-07
I2685 n1_m1_105600_532800 0 2.961682e-07
I2686 n1_m1_105600_537600 0 3.979323e-07
I2687 n1_m1_105600_542400 0 2.341665e-07
I2688 n1_m1_105600_547200 0 2.250143e-07
I2689 n1_m1_105600_552000 0 3.356805e-07
I2690 n1_m1_105600_556800 0 2.328905e-07
I2691 n1_m1_110400_0 0 1.414267e-07
I2692 n1_m1_110400_4800 0 1.453764e-07
I2693 n1_m1_110400_9600 0 2.198491e-07
I2694 n1_m1_110400_14400 0 1.478509e-07
I2695 n1_m1_110400_19200 0 1.525405e-07
I2696 n1_m1_110400_24000 0 2.283334e-07
I2697 n1_m1_110400_28800 0 1.502982e-07
I2698 n1_m1_110400_33600 0 2.243460e-07
I2699 n1_m1_110400_38400 0 1.485545e-07
I2700 n1_m1_110400_43200 0 1.465661e-07
I2701 n1_m1_110400_48000 0 2.198491e-07
I2702 n1_m1_110400_52800 0 1.465661e-07
I2703 n1_m1_110400_57600 0 2.198491e-07
I2704 n1_m1_110400_62400 0 1.477557e-07
I2705 n1_m1_110400_67200 0 1.525514e-07
I2706 n1_m1_110400_72000 0 2.294354e-07
I2707 n1_m1_110400_76800 0 1.532282e-07
I2708 n1_m1_110400_81600 0 2.254340e-07
I2709 n1_m1_110400_86400 0 1.501514e-07
I2710 n1_m1_110400_91200 0 1.521337e-07
I2711 n1_m1_110400_96000 0 2.282005e-07
I2712 n1_m1_110400_100800 0 1.521571e-07
I2713 n1_m1_110400_105600 0 2.295452e-07
I2714 n1_m1_110400_110400 0 1.532282e-07
I2715 n1_m1_110400_115200 0 1.532282e-07
I2716 n1_m1_110400_120000 0 2.298422e-07
I2717 n1_m1_110400_124800 0 1.532282e-07
I2718 n1_m1_110400_129600 0 2.298422e-07
I2719 n1_m1_110400_134400 0 1.532282e-07
I2720 n1_m1_110400_139200 0 1.534423e-07
I2721 n1_m1_110400_144000 0 2.412745e-07
I2722 n1_m1_110400_148800 0 1.653705e-07
I2723 n1_m1_110400_153600 0 2.335112e-07
I2724 n1_m1_110400_158400 0 1.533923e-07
I2725 n1_m1_110400_163200 0 1.546690e-07
I2726 n1_m1_110400_168000 0 2.356233e-07
I2727 n1_m1_110400_172800 0 1.540698e-07
I2728 n1_m1_110400_177600 0 2.324609e-07
I2729 n1_m1_110400_182400 0 1.551221e-07
I2730 n1_m1_110400_187200 0 1.580419e-07
I2731 n1_m1_110400_192000 0 2.460563e-07
I2732 n1_m1_110400_196800 0 1.709303e-07
I2733 n1_m1_110400_201600 0 2.524957e-07
I2734 n1_m1_110400_206400 0 1.664623e-07
I2735 n1_m1_110400_211200 0 1.589062e-07
I2736 n1_m1_110400_216000 0 2.436535e-07
I2737 n1_m1_110400_220800 0 1.696917e-07
I2738 n1_m1_110400_225600 0 2.691010e-07
I2739 n1_m1_110400_230400 0 1.754041e-07
I2740 n1_m1_110400_235200 0 1.659806e-07
I2741 n1_m1_110400_240000 0 2.486997e-07
I2742 n1_m1_110400_244800 0 1.670303e-07
I2743 n1_m1_110400_249600 0 2.497191e-07
I2744 n1_m1_110400_254400 0 1.653335e-07
I2745 n1_m1_110400_259200 0 1.615177e-07
I2746 n1_m1_110400_264000 0 2.409917e-07
I2747 n1_m1_110400_268800 0 1.617019e-07
I2748 n1_m1_110400_273600 0 2.456148e-07
I2749 n1_m1_110400_278400 0 1.624599e-07
I2750 n1_m1_110400_283200 0 1.684205e-07
I2751 n1_m1_110400_288000 0 2.507109e-07
I2752 n1_m1_110400_292800 0 1.734048e-07
I2753 n1_m1_110400_297600 0 2.727414e-07
I2754 n1_m1_110400_302400 0 1.699555e-07
I2755 n1_m1_110400_307200 0 1.846879e-07
I2756 n1_m1_110400_312000 0 2.640504e-07
I2757 n1_m1_110400_316800 0 1.693895e-07
I2758 n1_m1_110400_321600 0 2.694171e-07
I2759 n1_m1_110400_326400 0 2.380033e-07
I2760 n1_m1_110400_331200 0 2.883470e-07
I2761 n1_m1_110400_336000 0 3.479275e-07
I2762 n1_m1_110400_340800 0 1.712369e-07
I2763 n1_m1_110400_345600 0 2.414737e-07
I2764 n1_m1_110400_350400 0 1.567645e-07
I2765 n1_m1_110400_355200 0 1.562190e-07
I2766 n1_m1_110400_360000 0 2.327454e-07
I2767 n1_m1_110400_364800 0 1.541238e-07
I2768 n1_m1_110400_369600 0 2.338436e-07
I2769 n1_m1_110400_374400 0 1.619847e-07
I2770 n1_m1_110400_379200 0 1.671404e-07
I2771 n1_m1_110400_384000 0 2.525410e-07
I2772 n1_m1_110400_388800 0 1.665524e-07
I2773 n1_m1_110400_393600 0 2.426528e-07
I2774 n1_m1_110400_398400 0 1.585225e-07
I2775 n1_m1_110400_403200 0 1.543019e-07
I2776 n1_m1_110400_408000 0 2.298422e-07
I2777 n1_m1_110400_412800 0 1.532282e-07
I2778 n1_m1_110400_417600 0 2.298422e-07
I2779 n1_m1_110400_422400 0 1.532282e-07
I2780 n1_m1_110400_427200 0 1.532282e-07
I2781 n1_m1_110400_432000 0 2.298422e-07
I2782 n1_m1_110400_436800 0 1.532282e-07
I2783 n1_m1_110400_441600 0 2.298422e-07
I2784 n1_m1_110400_446400 0 1.532282e-07
I2785 n1_m1_110400_451200 0 1.533709e-07
I2786 n1_m1_110400_456000 0 2.380271e-07
I2787 n1_m1_110400_460800 0 1.598903e-07
I2788 n1_m1_110400_465600 0 2.398354e-07
I2789 n1_m1_110400_470400 0 1.598903e-07
I2790 n1_m1_110400_475200 0 1.598903e-07
I2791 n1_m1_110400_480000 0 2.398354e-07
I2792 n1_m1_110400_484800 0 1.598903e-07
I2793 n1_m1_110400_489600 0 2.441800e-07
I2794 n1_m1_110400_494400 0 1.599212e-07
I2795 n1_m1_110400_499200 0 1.596955e-07
I2796 n1_m1_110400_504000 0 2.478299e-07
I2797 n1_m1_110400_508800 0 1.657172e-07
I2798 n1_m1_110400_513600 0 2.446188e-07
I2799 n1_m1_110400_518400 0 1.689317e-07
I2800 n1_m1_110400_523200 0 1.732144e-07
I2801 n1_m1_110400_528000 0 2.598217e-07
I2802 n1_m1_110400_532800 0 1.726047e-07
I2803 n1_m1_110400_537600 0 2.517245e-07
I2804 n1_m1_110400_542400 0 1.555599e-07
I2805 n1_m1_110400_547200 0 1.481840e-07
I2806 n1_m1_110400_552000 0 2.231196e-07
I2807 n1_m1_110400_556800 0 1.562506e-07
I2808 n1_m1_115200_0 0 7.071337e-08
I2809 n1_m1_115200_4800 0 7.268821e-08
I2810 n1_m1_115200_9600 0 1.099246e-07
I2811 n1_m1_115200_14400 0 7.392545e-08
I2812 n1_m1_115200_19200 0 7.595977e-08
I2813 n1_m1_115200_24000 0 1.113131e-07
I2814 n1_m1_115200_28800 0 7.374190e-08
I2815 n1_m1_115200_33600 0 1.104599e-07
I2816 n1_m1_115200_38400 0 7.353796e-08
I2817 n1_m1_115200_43200 0 7.328303e-08
I2818 n1_m1_115200_48000 0 1.099246e-07
I2819 n1_m1_115200_52800 0 7.328303e-08
I2820 n1_m1_115200_57600 0 1.099246e-07
I2821 n1_m1_115200_62400 0 7.387786e-08
I2822 n1_m1_115200_67200 0 7.630477e-08
I2823 n1_m1_115200_72000 0 1.149211e-07
I2824 n1_m1_115200_76800 0 7.661408e-08
I2825 n1_m1_115200_81600 0 1.125656e-07
I2826 n1_m1_115200_86400 0 7.372151e-08
I2827 n1_m1_115200_91200 0 7.399683e-08
I2828 n1_m1_115200_96000 0 1.109952e-07
I2829 n1_m1_115200_100800 0 7.405291e-08
I2830 n1_m1_115200_105600 0 1.142107e-07
I2831 n1_m1_115200_110400 0 7.661408e-08
I2832 n1_m1_115200_115200 0 7.661408e-08
I2833 n1_m1_115200_120000 0 1.149211e-07
I2834 n1_m1_115200_124800 0 7.661408e-08
I2835 n1_m1_115200_129600 0 1.149211e-07
I2836 n1_m1_115200_134400 0 7.661408e-08
I2837 n1_m1_115200_139200 0 7.661408e-08
I2838 n1_m1_115200_144000 0 1.186193e-07
I2839 n1_m1_115200_148800 0 8.063003e-08
I2840 n1_m1_115200_153600 0 1.161346e-07
I2841 n1_m1_115200_158400 0 7.700667e-08
I2842 n1_m1_115200_163200 0 7.870958e-08
I2843 n1_m1_115200_168000 0 1.160496e-07
I2844 n1_m1_115200_172800 0 7.732448e-08
I2845 n1_m1_115200_177600 0 1.187909e-07
I2846 n1_m1_115200_182400 0 8.068952e-08
I2847 n1_m1_115200_187200 0 8.218509e-08
I2848 n1_m1_115200_192000 0 1.222766e-07
I2849 n1_m1_115200_196800 0 8.318100e-08
I2850 n1_m1_115200_201600 0 1.256162e-07
I2851 n1_m1_115200_206400 0 8.545665e-08
I2852 n1_m1_115200_211200 0 8.448283e-08
I2853 n1_m1_115200_216000 0 1.252780e-07
I2854 n1_m1_115200_220800 0 8.924487e-08
I2855 n1_m1_115200_225600 0 1.570861e-07
I2856 n1_m1_115200_230400 0 9.995181e-08
I2857 n1_m1_115200_235200 0 8.703550e-08
I2858 n1_m1_115200_240000 0 1.305125e-07
I2859 n1_m1_115200_244800 0 8.469697e-08
I2860 n1_m1_115200_249600 0 1.244843e-07
I2861 n1_m1_115200_254400 0 8.085267e-08
I2862 n1_m1_115200_259200 0 8.005220e-08
I2863 n1_m1_115200_264000 0 1.199177e-07
I2864 n1_m1_115200_268800 0 8.068272e-08
I2865 n1_m1_115200_273600 0 1.227967e-07
I2866 n1_m1_115200_278400 0 8.030203e-08
I2867 n1_m1_115200_283200 0 8.312322e-08
I2868 n1_m1_115200_288000 0 1.289897e-07
I2869 n1_m1_115200_292800 0 1.108287e-07
I2870 n1_m1_115200_297600 0 1.956871e-07
I2871 n1_m1_115200_302400 0 9.655448e-08
I2872 n1_m1_115200_307200 0 9.061298e-08
I2873 n1_m1_115200_312000 0 1.267956e-07
I2874 n1_m1_115200_316800 0 8.797873e-08
I2875 n1_m1_115200_321600 0 1.341426e-07
I2876 n1_m1_115200_326400 0 1.092379e-07
I2877 n1_m1_115200_331200 0 1.233133e-07
I2878 n1_m1_115200_336000 0 1.535885e-07
I2879 n1_m1_115200_340800 0 8.308243e-08
I2880 n1_m1_115200_345600 0 1.204717e-07
I2881 n1_m1_115200_350400 0 8.159026e-08
I2882 n1_m1_115200_355200 0 8.171772e-08
I2883 n1_m1_115200_360000 0 1.187909e-07
I2884 n1_m1_115200_364800 0 7.670756e-08
I2885 n1_m1_115200_369600 0 1.152984e-07
I2886 n1_m1_115200_374400 0 7.880306e-08
I2887 n1_m1_115200_379200 0 8.091385e-08
I2888 n1_m1_115200_384000 0 1.234867e-07
I2889 n1_m1_115200_388800 0 8.327618e-08
I2890 n1_m1_115200_393600 0 1.210751e-07
I2891 n1_m1_115200_398400 0 7.766438e-08
I2892 n1_m1_115200_403200 0 7.675174e-08
I2893 n1_m1_115200_408000 0 1.149211e-07
I2894 n1_m1_115200_412800 0 7.661408e-08
I2895 n1_m1_115200_417600 0 1.149211e-07
I2896 n1_m1_115200_422400 0 7.661408e-08
I2897 n1_m1_115200_427200 0 7.661408e-08
I2898 n1_m1_115200_432000 0 1.149211e-07
I2899 n1_m1_115200_436800 0 7.661408e-08
I2900 n1_m1_115200_441600 0 1.149211e-07
I2901 n1_m1_115200_446400 0 7.661408e-08
I2902 n1_m1_115200_451200 0 7.668546e-08
I2903 n1_m1_115200_456000 0 1.190136e-07
I2904 n1_m1_115200_460800 0 7.994513e-08
I2905 n1_m1_115200_465600 0 1.199177e-07
I2906 n1_m1_115200_470400 0 7.994513e-08
I2907 n1_m1_115200_475200 0 7.994513e-08
I2908 n1_m1_115200_480000 0 1.199177e-07
I2909 n1_m1_115200_484800 0 7.994513e-08
I2910 n1_m1_115200_489600 0 1.179480e-07
I2911 n1_m1_115200_494400 0 7.758620e-08
I2912 n1_m1_115200_499200 0 7.938939e-08
I2913 n1_m1_115200_504000 0 1.239149e-07
I2914 n1_m1_115200_508800 0 8.316911e-08
I2915 n1_m1_115200_513600 0 1.242464e-07
I2916 n1_m1_115200_518400 0 8.446584e-08
I2917 n1_m1_115200_523200 0 8.660722e-08
I2918 n1_m1_115200_528000 0 1.299108e-07
I2919 n1_m1_115200_532800 0 8.514904e-08
I2920 n1_m1_115200_537600 0 1.247681e-07
I2921 n1_m1_115200_542400 0 7.777995e-08
I2922 n1_m1_115200_547200 0 7.409200e-08
I2923 n1_m1_115200_552000 0 1.132454e-07
I2924 n1_m1_115200_556800 0 7.700157e-08
I2925 n1_m1_120000_0 0 1.414267e-07
I2926 n1_m1_120000_4800 0 1.453764e-07
I2927 n1_m1_120000_9600 0 2.198491e-07
I2928 n1_m1_120000_14400 0 1.465661e-07
I2929 n1_m1_120000_19200 0 1.465661e-07
I2930 n1_m1_120000_24000 0 2.198491e-07
I2931 n1_m1_120000_28800 0 1.465661e-07
I2932 n1_m1_120000_33600 0 2.198491e-07
I2933 n1_m1_120000_38400 0 1.465661e-07
I2934 n1_m1_120000_43200 0 1.465661e-07
I2935 n1_m1_120000_48000 0 2.198491e-07
I2936 n1_m1_120000_52800 0 1.465661e-07
I2937 n1_m1_120000_57600 0 2.198491e-07
I2938 n1_m1_120000_62400 0 1.465661e-07
I2939 n1_m1_120000_67200 0 1.474702e-07
I2940 n1_m1_120000_72000 0 2.289381e-07
I2941 n1_m1_120000_76800 0 1.532282e-07
I2942 n1_m1_120000_81600 0 2.251312e-07
I2943 n1_m1_120000_86400 0 1.465661e-07
I2944 n1_m1_120000_91200 0 1.465661e-07
I2945 n1_m1_120000_96000 0 2.198491e-07
I2946 n1_m1_120000_100800 0 1.467088e-07
I2947 n1_m1_120000_105600 0 2.280340e-07
I2948 n1_m1_120000_110400 0 1.532282e-07
I2949 n1_m1_120000_115200 0 1.532282e-07
I2950 n1_m1_120000_120000 0 2.298422e-07
I2951 n1_m1_120000_124800 0 1.532282e-07
I2952 n1_m1_120000_129600 0 2.298422e-07
I2953 n1_m1_120000_134400 0 1.532282e-07
I2954 n1_m1_120000_139200 0 1.519433e-07
I2955 n1_m1_120000_144000 0 2.285418e-07
I2956 n1_m1_120000_148800 0 1.563852e-07
I2957 n1_m1_120000_153600 0 2.315656e-07
I2958 n1_m1_120000_158400 0 1.569807e-07
I2959 n1_m1_120000_163200 0 1.631948e-07
I2960 n1_m1_120000_168000 0 2.368103e-07
I2961 n1_m1_120000_172800 0 1.554498e-07
I2962 n1_m1_120000_177600 0 2.452480e-07
I2963 n1_m1_120000_182400 0 1.716958e-07
I2964 n1_m1_120000_187200 0 1.750662e-07
I2965 n1_m1_120000_192000 0 2.576755e-07
I2966 n1_m1_120000_196800 0 1.682233e-07
I2967 n1_m1_120000_201600 0 2.598971e-07
I2968 n1_m1_120000_206400 0 1.861090e-07
I2969 n1_m1_120000_211200 0 2.091626e-07
I2970 n1_m1_120000_216000 0 4.007610e-07
I2971 n1_m1_120000_220800 0 3.200660e-07
I2972 n1_m1_120000_225600 0 5.787116e-07
I2973 n1_m1_120000_230400 0 4.830943e-07
I2974 n1_m1_120000_235200 0 5.306100e-07
I2975 n1_m1_120000_240000 0 8.299222e-07
I2976 n1_m1_120000_244800 0 3.088370e-07
I2977 n1_m1_120000_249600 0 2.864544e-07
I2978 n1_m1_120000_254400 0 1.721104e-07
I2979 n1_m1_120000_259200 0 1.636428e-07
I2980 n1_m1_120000_264000 0 2.403310e-07
I2981 n1_m1_120000_268800 0 1.613654e-07
I2982 n1_m1_120000_273600 0 2.494954e-07
I2983 n1_m1_120000_278400 0 1.691220e-07
I2984 n1_m1_120000_283200 0 1.733871e-07
I2985 n1_m1_120000_288000 0 2.576354e-07
I2986 n1_m1_120000_292800 0 2.402161e-07
I2987 n1_m1_120000_297600 0 6.956919e-07
I2988 n1_m1_120000_302400 0 6.604589e-07
I2989 n1_m1_120000_307200 0 8.404952e-07
I2990 n1_m1_120000_312000 0 1.078268e-06
I2991 n1_m1_120000_316800 0 2.866495e-07
I2992 n1_m1_120000_321600 0 2.973408e-07
I2993 n1_m1_120000_326400 0 1.739323e-07
I2994 n1_m1_120000_331200 0 1.721675e-07
I2995 n1_m1_120000_336000 0 2.456233e-07
I2996 n1_m1_120000_340800 0 1.598903e-07
I2997 n1_m1_120000_345600 0 2.498584e-07
I2998 n1_m1_120000_350400 0 1.695020e-07
I2999 n1_m1_120000_355200 0 1.726121e-07
I3000 n1_m1_120000_360000 0 2.624831e-07
I3001 n1_m1_120000_364800 0 1.728106e-07
I3002 n1_m1_120000_369600 0 2.504845e-07
I3003 n1_m1_120000_374400 0 1.580779e-07
I3004 n1_m1_120000_379200 0 1.557978e-07
I3005 n1_m1_120000_384000 0 2.367661e-07
I3006 n1_m1_120000_388800 0 1.598903e-07
I3007 n1_m1_120000_393600 0 2.366219e-07
I3008 n1_m1_120000_398400 0 1.538420e-07
I3009 n1_m1_120000_403200 0 1.532282e-07
I3010 n1_m1_120000_408000 0 2.298422e-07
I3011 n1_m1_120000_412800 0 1.532282e-07
I3012 n1_m1_120000_417600 0 2.298422e-07
I3013 n1_m1_120000_422400 0 1.532282e-07
I3014 n1_m1_120000_427200 0 1.532282e-07
I3015 n1_m1_120000_432000 0 2.298422e-07
I3016 n1_m1_120000_436800 0 1.532282e-07
I3017 n1_m1_120000_441600 0 2.298422e-07
I3018 n1_m1_120000_446400 0 1.532282e-07
I3019 n1_m1_120000_451200 0 1.533709e-07
I3020 n1_m1_120000_456000 0 2.380271e-07
I3021 n1_m1_120000_460800 0 1.598903e-07
I3022 n1_m1_120000_465600 0 2.398354e-07
I3023 n1_m1_120000_470400 0 1.598903e-07
I3024 n1_m1_120000_475200 0 1.598903e-07
I3025 n1_m1_120000_480000 0 2.398354e-07
I3026 n1_m1_120000_484800 0 1.598903e-07
I3027 n1_m1_120000_489600 0 2.355043e-07
I3028 n1_m1_120000_494400 0 1.538155e-07
I3029 n1_m1_120000_499200 0 1.553056e-07
I3030 n1_m1_120000_504000 0 2.466022e-07
I3031 n1_m1_120000_508800 0 1.655530e-07
I3032 n1_m1_120000_513600 0 2.406444e-07
I3033 n1_m1_120000_518400 0 1.598903e-07
I3034 n1_m1_120000_523200 0 1.635068e-07
I3035 n1_m1_120000_528000 0 2.595362e-07
I3036 n1_m1_120000_532800 0 1.680710e-07
I3037 n1_m1_120000_537600 0 2.391807e-07
I3038 n1_m1_120000_542400 0 1.540174e-07
I3039 n1_m1_120000_547200 0 1.532282e-07
I3040 n1_m1_120000_552000 0 2.298422e-07
I3041 n1_m1_120000_556800 0 1.532282e-07
I3042 n1_m1_124800_0 0 1.414267e-07
I3043 n1_m1_124800_4800 0 1.453764e-07
I3044 n1_m1_124800_9600 0 2.198491e-07
I3045 n1_m1_124800_14400 0 1.465661e-07
I3046 n1_m1_124800_19200 0 1.465661e-07
I3047 n1_m1_124800_24000 0 2.198491e-07
I3048 n1_m1_124800_28800 0 1.465661e-07
I3049 n1_m1_124800_33600 0 2.198491e-07
I3050 n1_m1_124800_38400 0 1.465661e-07
I3051 n1_m1_124800_43200 0 1.465661e-07
I3052 n1_m1_124800_48000 0 2.198491e-07
I3053 n1_m1_124800_52800 0 1.465661e-07
I3054 n1_m1_124800_57600 0 2.198491e-07
I3055 n1_m1_124800_62400 0 1.465661e-07
I3056 n1_m1_124800_67200 0 1.474702e-07
I3057 n1_m1_124800_72000 0 2.289381e-07
I3058 n1_m1_124800_76800 0 1.525715e-07
I3059 n1_m1_124800_81600 0 2.235466e-07
I3060 n1_m1_124800_86400 0 1.465661e-07
I3061 n1_m1_124800_91200 0 1.465661e-07
I3062 n1_m1_124800_96000 0 2.198491e-07
I3063 n1_m1_124800_100800 0 1.467088e-07
I3064 n1_m1_124800_105600 0 2.280340e-07
I3065 n1_m1_124800_110400 0 1.532282e-07
I3066 n1_m1_124800_115200 0 1.532282e-07
I3067 n1_m1_124800_120000 0 2.298422e-07
I3068 n1_m1_124800_124800 0 1.532282e-07
I3069 n1_m1_124800_129600 0 2.298422e-07
I3070 n1_m1_124800_134400 0 1.532282e-07
I3071 n1_m1_124800_139200 0 1.498971e-07
I3072 n1_m1_124800_144000 0 2.259402e-07
I3073 n1_m1_124800_148800 0 1.532282e-07
I3074 n1_m1_124800_153600 0 2.318980e-07
I3075 n1_m1_124800_158400 0 1.650486e-07
I3076 n1_m1_124800_163200 0 1.748800e-07
I3077 n1_m1_124800_168000 0 2.528741e-07
I3078 n1_m1_124800_172800 0 1.575966e-07
I3079 n1_m1_124800_177600 0 2.385363e-07
I3080 n1_m1_124800_182400 0 1.862246e-07
I3081 n1_m1_124800_187200 0 2.257308e-07
I3082 n1_m1_124800_192000 0 3.867821e-07
I3083 n1_m1_124800_196800 0 2.453364e-07
I3084 n1_m1_124800_201600 0 3.252434e-07
I3085 n1_m1_124800_206400 0 2.313079e-07
I3086 n1_m1_124800_211200 0 3.882240e-07
I3087 n1_m1_124800_216000 0 9.559011e-07
I3088 n1_m1_124800_220800 0 7.590790e-07
I3089 n1_m1_124800_225600 0 1.146423e-06
I3090 n1_m1_124800_230400 0 8.191901e-07
I3091 n1_m1_124800_235200 0 9.172752e-07
I3092 n1_m1_124800_240000 0 1.458342e-06
I3093 n1_m1_124800_244800 0 4.692398e-07
I3094 n1_m1_124800_249600 0 3.404996e-07
I3095 n1_m1_124800_254400 0 1.839690e-07
I3096 n1_m1_124800_259200 0 1.698691e-07
I3097 n1_m1_124800_264000 0 2.415057e-07
I3098 n1_m1_124800_268800 0 1.609229e-07
I3099 n1_m1_124800_273600 0 2.477680e-07
I3100 n1_m1_124800_278400 0 1.702165e-07
I3101 n1_m1_124800_283200 0 1.763647e-07
I3102 n1_m1_124800_288000 0 3.136181e-07
I3103 n1_m1_124800_292800 0 4.653473e-07
I3104 n1_m1_124800_297600 0 1.239435e-06
I3105 n1_m1_124800_302400 0 1.027642e-06
I3106 n1_m1_124800_307200 0 1.127583e-06
I3107 n1_m1_124800_312000 0 1.336692e-06
I3108 n1_m1_124800_316800 0 3.801248e-07
I3109 n1_m1_124800_321600 0 3.461910e-07
I3110 n1_m1_124800_326400 0 1.720724e-07
I3111 n1_m1_124800_331200 0 1.659813e-07
I3112 n1_m1_124800_336000 0 2.412487e-07
I3113 n1_m1_124800_340800 0 1.625741e-07
I3114 n1_m1_124800_345600 0 2.692485e-07
I3115 n1_m1_124800_350400 0 2.334731e-07
I3116 n1_m1_124800_355200 0 2.356335e-07
I3117 n1_m1_124800_360000 0 3.191571e-07
I3118 n1_m1_124800_364800 0 1.784632e-07
I3119 n1_m1_124800_369600 0 2.490862e-07
I3120 n1_m1_124800_374400 0 1.598903e-07
I3121 n1_m1_124800_379200 0 1.598903e-07
I3122 n1_m1_124800_384000 0 2.398354e-07
I3123 n1_m1_124800_388800 0 1.586054e-07
I3124 n1_m1_124800_393600 0 2.319075e-07
I3125 n1_m1_124800_398400 0 1.532282e-07
I3126 n1_m1_124800_403200 0 1.532282e-07
I3127 n1_m1_124800_408000 0 2.298422e-07
I3128 n1_m1_124800_412800 0 1.532282e-07
I3129 n1_m1_124800_417600 0 2.298422e-07
I3130 n1_m1_124800_422400 0 1.532282e-07
I3131 n1_m1_124800_427200 0 1.532282e-07
I3132 n1_m1_124800_432000 0 2.298422e-07
I3133 n1_m1_124800_436800 0 1.532282e-07
I3134 n1_m1_124800_441600 0 2.298422e-07
I3135 n1_m1_124800_446400 0 1.532282e-07
I3136 n1_m1_124800_451200 0 1.533709e-07
I3137 n1_m1_124800_456000 0 2.380271e-07
I3138 n1_m1_124800_460800 0 1.598903e-07
I3139 n1_m1_124800_465600 0 2.398354e-07
I3140 n1_m1_124800_470400 0 1.598903e-07
I3141 n1_m1_124800_475200 0 1.598903e-07
I3142 n1_m1_124800_480000 0 2.398354e-07
I3143 n1_m1_124800_484800 0 1.598903e-07
I3144 n1_m1_124800_489600 0 2.412154e-07
I3145 n1_m1_124800_494400 0 1.566496e-07
I3146 n1_m1_124800_499200 0 1.589052e-07
I3147 n1_m1_124800_504000 0 2.478299e-07
I3148 n1_m1_124800_508800 0 1.655530e-07
I3149 n1_m1_124800_513600 0 2.406444e-07
I3150 n1_m1_124800_518400 0 1.598903e-07
I3151 n1_m1_124800_523200 0 1.635068e-07
I3152 n1_m1_124800_528000 0 2.582513e-07
I3153 n1_m1_124800_532800 0 1.649059e-07
I3154 n1_m1_124800_537600 0 2.333636e-07
I3155 n1_m1_124800_542400 0 1.532282e-07
I3156 n1_m1_124800_547200 0 1.532282e-07
I3157 n1_m1_124800_552000 0 2.298422e-07
I3158 n1_m1_124800_556800 0 1.532282e-07
I3159 n1_m1_129600_0 0 2.155908e-07
I3160 n1_m1_129600_4800 0 2.188634e-07
I3161 n1_m1_129600_9600 0 3.297737e-07
I3162 n1_m1_129600_14400 0 2.198491e-07
I3163 n1_m1_129600_19200 0 2.198491e-07
I3164 n1_m1_129600_24000 0 3.297737e-07
I3165 n1_m1_129600_28800 0 2.198491e-07
I3166 n1_m1_129600_33600 0 3.297737e-07
I3167 n1_m1_129600_38400 0 2.198491e-07
I3168 n1_m1_129600_43200 0 2.198491e-07
I3169 n1_m1_129600_48000 0 3.297737e-07
I3170 n1_m1_129600_52800 0 2.198491e-07
I3171 n1_m1_129600_57600 0 3.297737e-07
I3172 n1_m1_129600_62400 0 2.198491e-07
I3173 n1_m1_129600_67200 0 2.205983e-07
I3174 n1_m1_129600_72000 0 3.373045e-07
I3175 n1_m1_129600_76800 0 2.235710e-07
I3176 n1_m1_129600_81600 0 3.298114e-07
I3177 n1_m1_129600_86400 0 2.198491e-07
I3178 n1_m1_129600_91200 0 2.198491e-07
I3179 n1_m1_129600_96000 0 3.339912e-07
I3180 n1_m1_129600_100800 0 2.244405e-07
I3181 n1_m1_129600_105600 0 3.432651e-07
I3182 n1_m1_129600_110400 0 2.298422e-07
I3183 n1_m1_129600_115200 0 2.298422e-07
I3184 n1_m1_129600_120000 0 3.447634e-07
I3185 n1_m1_129600_124800 0 2.298422e-07
I3186 n1_m1_129600_129600 0 3.447634e-07
I3187 n1_m1_129600_134400 0 2.298422e-07
I3188 n1_m1_129600_139200 0 2.270822e-07
I3189 n1_m1_129600_144000 0 3.415302e-07
I3190 n1_m1_129600_148800 0 2.298742e-07
I3191 n1_m1_129600_153600 0 3.550318e-07
I3192 n1_m1_129600_158400 0 2.660956e-07
I3193 n1_m1_129600_163200 0 3.081341e-07
I3194 n1_m1_129600_168000 0 4.511047e-07
I3195 n1_m1_129600_172800 0 2.605266e-07
I3196 n1_m1_129600_177600 0 3.687948e-07
I3197 n1_m1_129600_182400 0 3.014672e-07
I3198 n1_m1_129600_187200 0 4.320572e-07
I3199 n1_m1_129600_192000 0 9.212956e-07
I3200 n1_m1_129600_196800 0 6.937075e-07
I3201 n1_m1_129600_201600 0 1.025699e-06
I3202 n1_m1_129600_206400 0 7.575821e-07
I3203 n1_m1_129600_211200 0 1.295674e-06
I3204 n1_m1_129600_216000 0 2.636793e-06
I3205 n1_m1_129600_220800 0 1.857460e-06
I3206 n1_m1_129600_225600 0 2.521883e-06
I3207 n1_m1_129600_230400 0 1.462667e-06
I3208 n1_m1_129600_235200 0 1.461054e-06
I3209 n1_m1_129600_240000 0 2.309609e-06
I3210 n1_m1_129600_244800 0 7.354952e-07
I3211 n1_m1_129600_249600 0 5.244870e-07
I3212 n1_m1_129600_254400 0 2.800316e-07
I3213 n1_m1_129600_259200 0 2.605344e-07
I3214 n1_m1_129600_264000 0 3.635984e-07
I3215 n1_m1_129600_268800 0 2.398459e-07
I3216 n1_m1_129600_273600 0 3.656473e-07
I3217 n1_m1_129600_278400 0 2.449033e-07
I3218 n1_m1_129600_283200 0 2.486328e-07
I3219 n1_m1_129600_288000 0 5.401976e-07
I3220 n1_m1_129600_292800 0 1.010368e-06
I3221 n1_m1_129600_297600 0 2.536647e-06
I3222 n1_m1_129600_302400 0 1.858748e-06
I3223 n1_m1_129600_307200 0 1.814004e-06
I3224 n1_m1_129600_312000 0 2.019121e-06
I3225 n1_m1_129600_316800 0 5.879471e-07
I3226 n1_m1_129600_321600 0 5.255250e-07
I3227 n1_m1_129600_326400 0 2.626918e-07
I3228 n1_m1_129600_331200 0 2.559196e-07
I3229 n1_m1_129600_336000 0 3.667860e-07
I3230 n1_m1_129600_340800 0 2.531908e-07
I3231 n1_m1_129600_345600 0 4.758642e-07
I3232 n1_m1_129600_350400 0 6.637121e-07
I3233 n1_m1_129600_355200 0 7.124127e-07
I3234 n1_m1_129600_360000 0 9.045088e-07
I3235 n1_m1_129600_364800 0 4.103860e-07
I3236 n1_m1_129600_369600 0 4.174149e-07
I3237 n1_m1_129600_374400 0 2.448197e-07
I3238 n1_m1_129600_379200 0 2.398354e-07
I3239 n1_m1_129600_384000 0 3.597531e-07
I3240 n1_m1_129600_388800 0 2.334418e-07
I3241 n1_m1_129600_393600 0 3.447844e-07
I3242 n1_m1_129600_398400 0 2.298422e-07
I3243 n1_m1_129600_403200 0 2.298422e-07
I3244 n1_m1_129600_408000 0 3.447634e-07
I3245 n1_m1_129600_412800 0 2.298422e-07
I3246 n1_m1_129600_417600 0 3.447634e-07
I3247 n1_m1_129600_422400 0 2.298422e-07
I3248 n1_m1_129600_427200 0 2.298422e-07
I3249 n1_m1_129600_432000 0 3.447634e-07
I3250 n1_m1_129600_436800 0 2.298422e-07
I3251 n1_m1_129600_441600 0 3.447634e-07
I3252 n1_m1_129600_446400 0 2.298422e-07
I3253 n1_m1_129600_451200 0 2.300564e-07
I3254 n1_m1_129600_456000 0 3.570407e-07
I3255 n1_m1_129600_460800 0 2.398354e-07
I3256 n1_m1_129600_465600 0 3.597531e-07
I3257 n1_m1_129600_470400 0 2.398354e-07
I3258 n1_m1_129600_475200 0 2.398354e-07
I3259 n1_m1_129600_480000 0 3.597531e-07
I3260 n1_m1_129600_484800 0 2.398354e-07
I3261 n1_m1_129600_489600 0 3.683553e-07
I3262 n1_m1_129600_494400 0 2.379003e-07
I3263 n1_m1_129600_499200 0 2.354551e-07
I3264 n1_m1_129600_504000 0 3.704029e-07
I3265 n1_m1_129600_508800 0 2.483296e-07
I3266 n1_m1_129600_513600 0 3.629475e-07
I3267 n1_m1_129600_518400 0 2.459061e-07
I3268 n1_m1_129600_523200 0 2.517782e-07
I3269 n1_m1_129600_528000 0 3.831024e-07
I3270 n1_m1_129600_532800 0 2.417898e-07
I3271 n1_m1_129600_537600 0 3.476811e-07
I3272 n1_m1_129600_542400 0 2.298422e-07
I3273 n1_m1_129600_547200 0 2.298422e-07
I3274 n1_m1_129600_552000 0 3.447634e-07
I3275 n1_m1_129600_556800 0 2.298422e-07
I3276 n1_m1_134400_0 0 1.465661e-07
I3277 n1_m1_134400_4800 0 1.465661e-07
I3278 n1_m1_134400_9600 0 2.198491e-07
I3279 n1_m1_134400_14400 0 1.465661e-07
I3280 n1_m1_134400_19200 0 1.465661e-07
I3281 n1_m1_134400_24000 0 2.198491e-07
I3282 n1_m1_134400_28800 0 1.465661e-07
I3283 n1_m1_134400_33600 0 2.198491e-07
I3284 n1_m1_134400_38400 0 1.465661e-07
I3285 n1_m1_134400_43200 0 1.465661e-07
I3286 n1_m1_134400_48000 0 2.198491e-07
I3287 n1_m1_134400_52800 0 1.465661e-07
I3288 n1_m1_134400_57600 0 2.198491e-07
I3289 n1_m1_134400_62400 0 1.465661e-07
I3290 n1_m1_134400_67200 0 1.465661e-07
I3291 n1_m1_134400_72000 0 2.198491e-07
I3292 n1_m1_134400_76800 0 1.465661e-07
I3293 n1_m1_134400_81600 0 2.198491e-07
I3294 n1_m1_134400_86400 0 1.465661e-07
I3295 n1_m1_134400_91200 0 1.486286e-07
I3296 n1_m1_134400_96000 0 2.283045e-07
I3297 n1_m1_134400_100800 0 1.532282e-07
I3298 n1_m1_134400_105600 0 2.298422e-07
I3299 n1_m1_134400_110400 0 1.532282e-07
I3300 n1_m1_134400_115200 0 1.532282e-07
I3301 n1_m1_134400_120000 0 2.298422e-07
I3302 n1_m1_134400_124800 0 1.532282e-07
I3303 n1_m1_134400_129600 0 2.298422e-07
I3304 n1_m1_134400_134400 0 1.532282e-07
I3305 n1_m1_134400_139200 0 1.532282e-07
I3306 n1_m1_134400_144000 0 2.332148e-07
I3307 n1_m1_134400_148800 0 1.541398e-07
I3308 n1_m1_134400_153600 0 2.411590e-07
I3309 n1_m1_134400_158400 0 1.892681e-07
I3310 n1_m1_134400_163200 0 2.570535e-07
I3311 n1_m1_134400_168000 0 3.907209e-07
I3312 n1_m1_134400_172800 0 2.059756e-07
I3313 n1_m1_134400_177600 0 2.592221e-07
I3314 n1_m1_134400_182400 0 1.695775e-07
I3315 n1_m1_134400_187200 0 1.924461e-07
I3316 n1_m1_134400_192000 0 4.158955e-07
I3317 n1_m1_134400_196800 0 4.931173e-07
I3318 n1_m1_134400_201600 0 1.085561e-06
I3319 n1_m1_134400_206400 0 8.581797e-07
I3320 n1_m1_134400_211200 0 8.855548e-07
I3321 n1_m1_134400_216000 0 1.136476e-06
I3322 n1_m1_134400_220800 0 6.541565e-07
I3323 n1_m1_134400_225600 0 9.345688e-07
I3324 n1_m1_134400_230400 0 5.485188e-07
I3325 n1_m1_134400_235200 0 5.101315e-07
I3326 n1_m1_134400_240000 0 7.638268e-07
I3327 n1_m1_134400_244800 0 2.972681e-07
I3328 n1_m1_134400_249600 0 2.922137e-07
I3329 n1_m1_134400_254400 0 1.767664e-07
I3330 n1_m1_134400_259200 0 1.695714e-07
I3331 n1_m1_134400_264000 0 2.416525e-07
I3332 n1_m1_134400_268800 0 1.598903e-07
I3333 n1_m1_134400_273600 0 2.414520e-07
I3334 n1_m1_134400_278400 0 1.690744e-07
I3335 n1_m1_134400_283200 0 2.008907e-07
I3336 n1_m1_134400_288000 0 4.285841e-07
I3337 n1_m1_134400_292800 0 6.519430e-07
I3338 n1_m1_134400_297600 0 1.624224e-06
I3339 n1_m1_134400_302400 0 1.132899e-06
I3340 n1_m1_134400_307200 0 9.999137e-07
I3341 n1_m1_134400_312000 0 9.952122e-07
I3342 n1_m1_134400_316800 0 2.844694e-07
I3343 n1_m1_134400_321600 0 2.826305e-07
I3344 n1_m1_134400_326400 0 1.711519e-07
I3345 n1_m1_134400_331200 0 1.706448e-07
I3346 n1_m1_134400_336000 0 2.445464e-07
I3347 n1_m1_134400_340800 0 1.662165e-07
I3348 n1_m1_134400_345600 0 3.000410e-07
I3349 n1_m1_134400_350400 0 3.759726e-07
I3350 n1_m1_134400_355200 0 4.736429e-07
I3351 n1_m1_134400_360000 0 7.999537e-07
I3352 n1_m1_134400_364800 0 4.618775e-07
I3353 n1_m1_134400_369600 0 4.335868e-07
I3354 n1_m1_134400_374400 0 1.859880e-07
I3355 n1_m1_134400_379200 0 1.649072e-07
I3356 n1_m1_134400_384000 0 2.369088e-07
I3357 n1_m1_134400_388800 0 1.542139e-07
I3358 n1_m1_134400_393600 0 2.298422e-07
I3359 n1_m1_134400_398400 0 1.532282e-07
I3360 n1_m1_134400_403200 0 1.532282e-07
I3361 n1_m1_134400_408000 0 2.298422e-07
I3362 n1_m1_134400_412800 0 1.532282e-07
I3363 n1_m1_134400_417600 0 2.298422e-07
I3364 n1_m1_134400_422400 0 1.532282e-07
I3365 n1_m1_134400_427200 0 1.532282e-07
I3366 n1_m1_134400_432000 0 2.298422e-07
I3367 n1_m1_134400_436800 0 1.532282e-07
I3368 n1_m1_134400_441600 0 2.302603e-07
I3369 n1_m1_134400_446400 0 1.564892e-07
I3370 n1_m1_134400_451200 0 1.571894e-07
I3371 n1_m1_134400_456000 0 2.390862e-07
I3372 n1_m1_134400_460800 0 1.598903e-07
I3373 n1_m1_134400_465600 0 2.416749e-07
I3374 n1_m1_134400_470400 0 1.622873e-07
I3375 n1_m1_134400_475200 0 1.598903e-07
I3376 n1_m1_134400_480000 0 2.398354e-07
I3377 n1_m1_134400_484800 0 1.598903e-07
I3378 n1_m1_134400_489600 0 2.417205e-07
I3379 n1_m1_134400_494400 0 1.549107e-07
I3380 n1_m1_134400_499200 0 1.532955e-07
I3381 n1_m1_134400_504000 0 2.419013e-07
I3382 n1_m1_134400_508800 0 1.658318e-07
I3383 n1_m1_134400_513600 0 2.489740e-07
I3384 n1_m1_134400_518400 0 1.742274e-07
I3385 n1_m1_134400_523200 0 1.789003e-07
I3386 n1_m1_134400_528000 0 2.531976e-07
I3387 n1_m1_134400_532800 0 1.574008e-07
I3388 n1_m1_134400_537600 0 2.298422e-07
I3389 n1_m1_134400_542400 0 1.533675e-07
I3390 n1_m1_134400_547200 0 1.561826e-07
I3391 n1_m1_134400_552000 0 2.304276e-07
I3392 n1_m1_134400_556800 0 1.502180e-07
I3393 n1_m1_139200_0 0 1.439964e-07
I3394 n1_m1_139200_4800 0 1.461378e-07
I3395 n1_m1_139200_9600 0 2.241081e-07
I3396 n1_m1_139200_14400 0 1.492547e-07
I3397 n1_m1_139200_19200 0 1.468278e-07
I3398 n1_m1_139200_24000 0 2.213243e-07
I3399 n1_m1_139200_28800 0 1.510868e-07
I3400 n1_m1_139200_33600 0 2.373371e-07
I3401 n1_m1_139200_38400 0 1.610799e-07
I3402 n1_m1_139200_43200 0 1.580344e-07
I3403 n1_m1_139200_48000 0 2.281053e-07
I3404 n1_m1_139200_52800 0 1.472085e-07
I3405 n1_m1_139200_57600 0 2.198491e-07
I3406 n1_m1_139200_62400 0 1.465661e-07
I3407 n1_m1_139200_67200 0 1.465661e-07
I3408 n1_m1_139200_72000 0 2.198491e-07
I3409 n1_m1_139200_76800 0 1.465661e-07
I3410 n1_m1_139200_81600 0 2.198491e-07
I3411 n1_m1_139200_86400 0 1.486123e-07
I3412 n1_m1_139200_91200 0 1.498971e-07
I3413 n1_m1_139200_96000 0 2.248457e-07
I3414 n1_m1_139200_100800 0 1.498971e-07
I3415 n1_m1_139200_105600 0 2.255357e-07
I3416 n1_m1_139200_110400 0 1.530140e-07
I3417 n1_m1_139200_115200 0 1.532282e-07
I3418 n1_m1_139200_120000 0 2.298422e-07
I3419 n1_m1_139200_124800 0 1.532282e-07
I3420 n1_m1_139200_129600 0 2.320788e-07
I3421 n1_m1_139200_134400 0 1.604613e-07
I3422 n1_m1_139200_139200 0 1.598903e-07
I3423 n1_m1_139200_144000 0 2.378843e-07
I3424 n1_m1_139200_148800 0 1.599378e-07
I3425 n1_m1_139200_153600 0 2.503996e-07
I3426 n1_m1_139200_158400 0 1.868242e-07
I3427 n1_m1_139200_163200 0 2.270584e-07
I3428 n1_m1_139200_168000 0 3.435023e-07
I3429 n1_m1_139200_172800 0 1.974835e-07
I3430 n1_m1_139200_177600 0 2.562527e-07
I3431 n1_m1_139200_182400 0 1.628406e-07
I3432 n1_m1_139200_187200 0 1.614606e-07
I3433 n1_m1_139200_192000 0 2.714327e-07
I3434 n1_m1_139200_196800 0 3.126426e-07
I3435 n1_m1_139200_201600 0 7.206958e-07
I3436 n1_m1_139200_206400 0 5.657308e-07
I3437 n1_m1_139200_211200 0 4.742935e-07
I3438 n1_m1_139200_216000 0 4.708911e-07
I3439 n1_m1_139200_220800 0 2.238939e-07
I3440 n1_m1_139200_225600 0 3.705314e-07
I3441 n1_m1_139200_230400 0 2.525885e-07
I3442 n1_m1_139200_235200 0 2.372657e-07
I3443 n1_m1_139200_240000 0 3.353413e-07
I3444 n1_m1_139200_244800 0 1.907262e-07
I3445 n1_m1_139200_249600 0 2.643662e-07
I3446 n1_m1_139200_254400 0 1.672186e-07
I3447 n1_m1_139200_259200 0 1.639827e-07
I3448 n1_m1_139200_264000 0 2.481868e-07
I3449 n1_m1_139200_268800 0 1.632451e-07
I3450 n1_m1_139200_273600 0 2.565382e-07
I3451 n1_m1_139200_278400 0 1.898697e-07
I3452 n1_m1_139200_283200 0 2.724321e-07
I3453 n1_m1_139200_288000 0 8.287883e-07
I3454 n1_m1_139200_292800 0 9.343587e-07
I3455 n1_m1_139200_297600 0 1.651010e-06
I3456 n1_m1_139200_302400 0 8.480132e-07
I3457 n1_m1_139200_307200 0 5.809584e-07
I3458 n1_m1_139200_312000 0 4.736273e-07
I3459 n1_m1_139200_316800 0 2.041218e-07
I3460 n1_m1_139200_321600 0 2.566096e-07
I3461 n1_m1_139200_326400 0 1.647917e-07
I3462 n1_m1_139200_331200 0 1.652675e-07
I3463 n1_m1_139200_336000 0 2.421909e-07
I3464 n1_m1_139200_340800 0 1.665999e-07
I3465 n1_m1_139200_345600 0 2.688393e-07
I3466 n1_m1_139200_350400 0 2.259164e-07
I3467 n1_m1_139200_355200 0 2.847331e-07
I3468 n1_m1_139200_360000 0 5.291368e-07
I3469 n1_m1_139200_364800 0 3.502358e-07
I3470 n1_m1_139200_369600 0 4.006298e-07
I3471 n1_m1_139200_374400 0 1.899173e-07
I3472 n1_m1_139200_379200 0 1.684558e-07
I3473 n1_m1_139200_384000 0 2.348388e-07
I3474 n1_m1_139200_388800 0 1.532282e-07
I3475 n1_m1_139200_393600 0 2.298422e-07
I3476 n1_m1_139200_398400 0 1.534899e-07
I3477 n1_m1_139200_403200 0 1.559168e-07
I3478 n1_m1_139200_408000 0 2.348388e-07
I3479 n1_m1_139200_412800 0 1.565592e-07
I3480 n1_m1_139200_417600 0 2.381699e-07
I3481 n1_m1_139200_422400 0 1.632213e-07
I3482 n1_m1_139200_427200 0 1.632213e-07
I3483 n1_m1_139200_432000 0 2.448320e-07
I3484 n1_m1_139200_436800 0 1.611751e-07
I3485 n1_m1_139200_441600 0 2.367661e-07
I3486 n1_m1_139200_446400 0 1.593430e-07
I3487 n1_m1_139200_451200 0 1.600330e-07
I3488 n1_m1_139200_456000 0 2.480202e-07
I3489 n1_m1_139200_460800 0 1.665524e-07
I3490 n1_m1_139200_465600 0 2.529692e-07
I3491 n1_m1_139200_470400 0 1.706448e-07
I3492 n1_m1_139200_475200 0 1.655530e-07
I3493 n1_m1_139200_480000 0 2.426192e-07
I3494 n1_m1_139200_484800 0 1.579392e-07
I3495 n1_m1_139200_489600 0 2.378606e-07
I3496 n1_m1_139200_494400 0 1.571540e-07
I3497 n1_m1_139200_499200 0 1.565592e-07
I3498 n1_m1_139200_504000 0 2.361236e-07
I3499 n1_m1_139200_508800 0 1.626979e-07
I3500 n1_m1_139200_513600 0 2.477823e-07
I3501 n1_m1_139200_518400 0 1.734524e-07
I3502 n1_m1_139200_523200 0 1.789724e-07
I3503 n1_m1_139200_528000 0 2.584655e-07
I3504 n1_m1_139200_532800 0 1.628406e-07
I3505 n1_m1_139200_537600 0 2.363378e-07
I3506 n1_m1_139200_542400 0 1.539895e-07
I3507 n1_m1_139200_547200 0 1.557502e-07
I3508 n1_m1_139200_552000 0 2.303419e-07
I3509 n1_m1_139200_556800 0 1.506585e-07
I3510 n1_m1_144000_0 0 2.168389e-07
I3511 n1_m1_144000_4800 0 2.196520e-07
I3512 n1_m1_144000_9600 0 3.425506e-07
I3513 n1_m1_144000_14400 0 2.279150e-07
I3514 n1_m1_144000_19200 0 2.206343e-07
I3515 n1_m1_144000_24000 0 3.340517e-07
I3516 n1_m1_144000_28800 0 2.310217e-07
I3517 n1_m1_144000_33600 0 3.685328e-07
I3518 n1_m1_144000_38400 0 2.512085e-07
I3519 n1_m1_144000_43200 0 2.420719e-07
I3520 n1_m1_144000_48000 0 3.481294e-07
I3521 n1_m1_144000_52800 0 2.220452e-07
I3522 n1_m1_144000_57600 0 3.315483e-07
I3523 n1_m1_144000_62400 0 2.257117e-07
I3524 n1_m1_144000_67200 0 2.253705e-07
I3525 n1_m1_144000_72000 0 3.306455e-07
I3526 n1_m1_144000_76800 0 2.198491e-07
I3527 n1_m1_144000_81600 0 3.297737e-07
I3528 n1_m1_144000_86400 0 2.222461e-07
I3529 n1_m1_144000_91200 0 2.216887e-07
I3530 n1_m1_144000_96000 0 3.297737e-07
I3531 n1_m1_144000_100800 0 2.199796e-07
I3532 n1_m1_144000_105600 0 3.381342e-07
I3533 n1_m1_144000_110400 0 2.309038e-07
I3534 n1_m1_144000_115200 0 2.356138e-07
I3535 n1_m1_144000_120000 0 3.542711e-07
I3536 n1_m1_144000_124800 0 2.342059e-07
I3537 n1_m1_144000_129600 0 3.517902e-07
I3538 n1_m1_144000_134400 0 2.477789e-07
I3539 n1_m1_144000_139200 0 2.437375e-07
I3540 n1_m1_144000_144000 0 3.510067e-07
I3541 n1_m1_144000_148800 0 2.368514e-07
I3542 n1_m1_144000_153600 0 3.699247e-07
I3543 n1_m1_144000_158400 0 2.562075e-07
I3544 n1_m1_144000_163200 0 2.565484e-07
I3545 n1_m1_144000_168000 0 3.781812e-07
I3546 n1_m1_144000_172800 0 2.447749e-07
I3547 n1_m1_144000_177600 0 3.571691e-07
I3548 n1_m1_144000_182400 0 2.410019e-07
I3549 n1_m1_144000_187200 0 2.434044e-07
I3550 n1_m1_144000_192000 0 3.655409e-07
I3551 n1_m1_144000_196800 0 2.466919e-07
I3552 n1_m1_144000_201600 0 3.724875e-07
I3553 n1_m1_144000_206400 0 2.534376e-07
I3554 n1_m1_144000_211200 0 2.575926e-07
I3555 n1_m1_144000_216000 0 3.954493e-07
I3556 n1_m1_144000_220800 0 2.676258e-07
I3557 n1_m1_144000_225600 0 3.990418e-07
I3558 n1_m1_144000_230400 0 2.616612e-07
I3559 n1_m1_144000_235200 0 2.598217e-07
I3560 n1_m1_144000_240000 0 3.894857e-07
I3561 n1_m1_144000_244800 0 2.514315e-07
I3562 n1_m1_144000_249600 0 3.714705e-07
I3563 n1_m1_144000_254400 0 2.464074e-07
I3564 n1_m1_144000_259200 0 2.463680e-07
I3565 n1_m1_144000_264000 0 3.721497e-07
I3566 n1_m1_144000_268800 0 2.543666e-07
I3567 n1_m1_144000_273600 0 4.129424e-07
I3568 n1_m1_144000_278400 0 4.348206e-07
I3569 n1_m1_144000_283200 0 7.893922e-07
I3570 n1_m1_144000_288000 0 2.097477e-06
I3571 n1_m1_144000_292800 0 1.671905e-06
I3572 n1_m1_144000_297600 0 1.909335e-06
I3573 n1_m1_144000_302400 0 6.264126e-07
I3574 n1_m1_144000_307200 0 3.632656e-07
I3575 n1_m1_144000_312000 0 4.107602e-07
I3576 n1_m1_144000_316800 0 2.567816e-07
I3577 n1_m1_144000_321600 0 3.734549e-07
I3578 n1_m1_144000_326400 0 2.405016e-07
I3579 n1_m1_144000_331200 0 2.402446e-07
I3580 n1_m1_144000_336000 0 3.597531e-07
I3581 n1_m1_144000_340800 0 2.489414e-07
I3582 n1_m1_144000_345600 0 3.877685e-07
I3583 n1_m1_144000_350400 0 2.653057e-07
I3584 n1_m1_144000_355200 0 2.586011e-07
I3585 n1_m1_144000_360000 0 3.735174e-07
I3586 n1_m1_144000_364800 0 2.511086e-07
I3587 n1_m1_144000_369600 0 3.988953e-07
I3588 n1_m1_144000_374400 0 2.582561e-07
I3589 n1_m1_144000_379200 0 2.424628e-07
I3590 n1_m1_144000_384000 0 3.476899e-07
I3591 n1_m1_144000_388800 0 2.298422e-07
I3592 n1_m1_144000_393600 0 3.447634e-07
I3593 n1_m1_144000_398400 0 2.306274e-07
I3594 n1_m1_144000_403200 0 2.379081e-07
I3595 n1_m1_144000_408000 0 3.597531e-07
I3596 n1_m1_144000_412800 0 2.398354e-07
I3597 n1_m1_144000_417600 0 3.694131e-07
I3598 n1_m1_144000_422400 0 2.592935e-07
I3599 n1_m1_144000_427200 0 2.595980e-07
I3600 n1_m1_144000_432000 0 3.811180e-07
I3601 n1_m1_144000_436800 0 2.454472e-07
I3602 n1_m1_144000_441600 0 3.690100e-07
I3603 n1_m1_144000_446400 0 2.513071e-07
I3604 n1_m1_144000_451200 0 2.518662e-07
I3605 n1_m1_144000_456000 0 3.813022e-07
I3606 n1_m1_144000_460800 0 2.594301e-07
I3607 n1_m1_144000_465600 0 3.914150e-07
I3608 n1_m1_144000_470400 0 2.618856e-07
I3609 n1_m1_144000_475200 0 2.565906e-07
I3610 n1_m1_144000_480000 0 3.683258e-07
I3611 n1_m1_144000_484800 0 2.376879e-07
I3612 n1_m1_144000_489600 0 3.578020e-07
I3613 n1_m1_144000_494400 0 2.398354e-07
I3614 n1_m1_144000_499200 0 2.397664e-07
I3615 n1_m1_144000_504000 0 3.488493e-07
I3616 n1_m1_144000_508800 0 2.334639e-07
I3617 n1_m1_144000_513600 0 3.548945e-07
I3618 n1_m1_144000_518400 0 2.447980e-07
I3619 n1_m1_144000_523200 0 2.516722e-07
I3620 n1_m1_144000_528000 0 3.922328e-07
I3621 n1_m1_144000_532800 0 2.541065e-07
I3622 n1_m1_144000_537600 0 3.645736e-07
I3623 n1_m1_144000_542400 0 2.321026e-07
I3624 n1_m1_144000_547200 0 2.301754e-07
I3625 n1_m1_144000_552000 0 3.448728e-07
I3626 n1_m1_144000_556800 0 2.298422e-07
I3627 n1_m1_148800_0 0 1.465661e-07
I3628 n1_m1_148800_4800 0 1.468992e-07
I3629 n1_m1_148800_9600 0 2.283671e-07
I3630 n1_m1_148800_14400 0 1.519433e-07
I3631 n1_m1_148800_19200 0 1.470895e-07
I3632 n1_m1_148800_24000 0 2.205024e-07
I3633 n1_m1_148800_28800 0 1.498937e-07
I3634 n1_m1_148800_33600 0 2.399068e-07
I3635 n1_m1_148800_38400 0 1.623648e-07
I3636 n1_m1_148800_43200 0 1.562737e-07
I3637 n1_m1_148800_48000 0 2.298191e-07
I3638 n1_m1_148800_52800 0 1.520467e-07
I3639 n1_m1_148800_57600 0 2.279561e-07
I3640 n1_m1_148800_62400 0 1.540721e-07
I3641 n1_m1_148800_67200 0 1.562951e-07
I3642 n1_m1_148800_72000 0 2.215156e-07
I3643 n1_m1_148800_76800 0 1.466137e-07
I3644 n1_m1_148800_81600 0 2.199205e-07
I3645 n1_m1_148800_86400 0 1.466137e-07
I3646 n1_m1_148800_91200 0 1.466137e-07
I3647 n1_m1_148800_96000 0 2.199205e-07
I3648 n1_m1_148800_100800 0 1.467554e-07
I3649 n1_m1_148800_105600 0 2.291213e-07
I3650 n1_m1_148800_110400 0 1.591839e-07
I3651 n1_m1_148800_115200 0 1.644059e-07
I3652 n1_m1_148800_120000 0 2.456865e-07
I3653 n1_m1_148800_124800 0 1.594810e-07
I3654 n1_m1_148800_129600 0 2.386240e-07
I3655 n1_m1_148800_134400 0 1.607543e-07
I3656 n1_m1_148800_139200 0 1.599378e-07
I3657 n1_m1_148800_144000 0 2.330183e-07
I3658 n1_m1_148800_148800 0 1.532598e-07
I3659 n1_m1_148800_153600 0 2.318970e-07
I3660 n1_m1_148800_158400 0 1.560698e-07
I3661 n1_m1_148800_163200 0 1.562203e-07
I3662 n1_m1_148800_168000 0 2.338123e-07
I3663 n1_m1_148800_172800 0 1.557455e-07
I3664 n1_m1_148800_177600 0 2.375441e-07
I3665 n1_m1_148800_182400 0 1.563736e-07
I3666 n1_m1_148800_187200 0 1.547509e-07
I3667 n1_m1_148800_192000 0 2.366801e-07
I3668 n1_m1_148800_196800 0 1.599263e-07
I3669 n1_m1_148800_201600 0 2.401702e-07
I3670 n1_m1_148800_206400 0 1.619735e-07
I3671 n1_m1_148800_211200 0 1.659919e-07
I3672 n1_m1_148800_216000 0 2.534821e-07
I3673 n1_m1_148800_220800 0 1.732144e-07
I3674 n1_m1_148800_225600 0 2.598217e-07
I3675 n1_m1_148800_230400 0 1.732144e-07
I3676 n1_m1_148800_235200 0 1.731934e-07
I3677 n1_m1_148800_240000 0 2.596932e-07
I3678 n1_m1_148800_244800 0 1.712253e-07
I3679 n1_m1_148800_249600 0 2.456263e-07
I3680 n1_m1_148800_254400 0 1.705115e-07
I3681 n1_m1_148800_259200 0 1.708154e-07
I3682 n1_m1_148800_264000 0 2.492014e-07
I3683 n1_m1_148800_268800 0 2.197193e-07
I3684 n1_m1_148800_273600 0 4.564568e-07
I3685 n1_m1_148800_278400 0 3.464765e-07
I3686 n1_m1_148800_283200 0 5.782555e-07
I3687 n1_m1_148800_288000 0 1.288805e-06
I3688 n1_m1_148800_292800 0 7.290187e-07
I3689 n1_m1_148800_297600 0 5.514144e-07
I3690 n1_m1_148800_302400 0 1.984944e-07
I3691 n1_m1_148800_307200 0 1.757474e-07
I3692 n1_m1_148800_312000 0 2.565766e-07
I3693 n1_m1_148800_316800 0 1.627026e-07
I3694 n1_m1_148800_321600 0 2.516579e-07
I3695 n1_m1_148800_326400 0 1.703368e-07
I3696 n1_m1_148800_331200 0 1.663287e-07
I3697 n1_m1_148800_336000 0 2.399027e-07
I3698 n1_m1_148800_340800 0 1.608807e-07
I3699 n1_m1_148800_345600 0 2.492877e-07
I3700 n1_m1_148800_350400 0 1.674500e-07
I3701 n1_m1_148800_355200 0 1.625265e-07
I3702 n1_m1_148800_360000 0 2.389129e-07
I3703 n1_m1_148800_364800 0 1.564579e-07
I3704 n1_m1_148800_369600 0 2.436216e-07
I3705 n1_m1_148800_374400 0 1.592580e-07
I3706 n1_m1_148800_379200 0 1.542241e-07
I3707 n1_m1_148800_384000 0 2.299136e-07
I3708 n1_m1_148800_388800 0 1.532452e-07
I3709 n1_m1_148800_393600 0 2.298926e-07
I3710 n1_m1_148800_398400 0 1.537955e-07
I3711 n1_m1_148800_403200 0 1.586146e-07
I3712 n1_m1_148800_408000 0 2.398354e-07
I3713 n1_m1_148800_412800 0 1.598988e-07
I3714 n1_m1_148800_417600 0 2.413537e-07
I3715 n1_m1_148800_422400 0 1.649895e-07
I3716 n1_m1_148800_427200 0 1.697318e-07
I3717 n1_m1_148800_432000 0 2.504669e-07
I3718 n1_m1_148800_436800 0 1.631424e-07
I3719 n1_m1_148800_441600 0 2.551993e-07
I3720 n1_m1_148800_446400 0 1.766033e-07
I3721 n1_m1_148800_451200 0 1.701370e-07
I3722 n1_m1_148800_456000 0 2.517062e-07
I3723 n1_m1_148800_460800 0 1.727923e-07
I3724 n1_m1_148800_465600 0 2.573764e-07
I3725 n1_m1_148800_470400 0 1.680275e-07
I3726 n1_m1_148800_475200 0 1.675707e-07
I3727 n1_m1_148800_480000 0 2.488095e-07
I3728 n1_m1_148800_484800 0 1.620670e-07
I3729 n1_m1_148800_489600 0 2.398636e-07
I3730 n1_m1_148800_494400 0 1.599293e-07
I3731 n1_m1_148800_499200 0 1.599273e-07
I3732 n1_m1_148800_504000 0 2.371454e-07
I3733 n1_m1_148800_508800 0 1.537200e-07
I3734 n1_m1_148800_513600 0 2.305516e-07
I3735 n1_m1_148800_518400 0 1.547033e-07
I3736 n1_m1_148800_523200 0 1.583070e-07
I3737 n1_m1_148800_528000 0 2.516854e-07
I3738 n1_m1_148800_532800 0 1.671581e-07
I3739 n1_m1_148800_537600 0 2.478506e-07
I3740 n1_m1_148800_542400 0 1.597366e-07
I3741 n1_m1_148800_547200 0 1.584266e-07
I3742 n1_m1_148800_552000 0 2.315465e-07
I3743 n1_m1_148800_556800 0 1.532282e-07
I3744 n1_m1_153600_0 0 2.201428e-07
I3745 n1_m1_153600_4800 0 2.213399e-07
I3746 n1_m1_153600_9600 0 3.428351e-07
I3747 n1_m1_153600_14400 0 2.279150e-07
I3748 n1_m1_153600_19200 0 2.206343e-07
I3749 n1_m1_153600_24000 0 3.297737e-07
I3750 n1_m1_153600_28800 0 2.234181e-07
I3751 n1_m1_153600_33600 0 3.707812e-07
I3752 n1_m1_153600_38400 0 2.589345e-07
I3753 n1_m1_153600_43200 0 2.502568e-07
I3754 n1_m1_153600_48000 0 3.604536e-07
I3755 n1_m1_153600_52800 0 2.323752e-07
I3756 n1_m1_153600_57600 0 3.450754e-07
I3757 n1_m1_153600_62400 0 2.301991e-07
I3758 n1_m1_153600_67200 0 2.311128e-07
I3759 n1_m1_153600_72000 0 3.423079e-07
I3760 n1_m1_153600_76800 0 2.278436e-07
I3761 n1_m1_153600_81600 0 3.417654e-07
I3762 n1_m1_153600_86400 0 2.278436e-07
I3763 n1_m1_153600_91200 0 2.278436e-07
I3764 n1_m1_153600_96000 0 3.417654e-07
I3765 n1_m1_153600_100800 0 2.278864e-07
I3766 n1_m1_153600_105600 0 3.462909e-07
I3767 n1_m1_153600_110400 0 2.421481e-07
I3768 n1_m1_153600_115200 0 2.558958e-07
I3769 n1_m1_153600_120000 0 3.828801e-07
I3770 n1_m1_153600_124800 0 2.454315e-07
I3771 n1_m1_153600_129600 0 3.598102e-07
I3772 n1_m1_153600_134400 0 2.398354e-07
I3773 n1_m1_153600_139200 0 2.478299e-07
I3774 n1_m1_153600_144000 0 3.749753e-07
I3775 n1_m1_153600_148800 0 2.346675e-07
I3776 n1_m1_153600_153600 0 3.466906e-07
I3777 n1_m1_153600_158400 0 2.321335e-07
I3778 n1_m1_153600_163200 0 2.370220e-07
I3779 n1_m1_153600_168000 0 3.567551e-07
I3780 n1_m1_153600_172800 0 2.383792e-07
I3781 n1_m1_153600_177600 0 3.597103e-07
I3782 n1_m1_153600_182400 0 2.387219e-07
I3783 n1_m1_153600_187200 0 2.378368e-07
I3784 n1_m1_153600_192000 0 3.587650e-07
I3785 n1_m1_153600_196800 0 2.449156e-07
I3786 n1_m1_153600_201600 0 3.700470e-07
I3787 n1_m1_153600_206400 0 2.479818e-07
I3788 n1_m1_153600_211200 0 2.495573e-07
I3789 n1_m1_153600_216000 0 3.776041e-07
I3790 n1_m1_153600_220800 0 2.585368e-07
I3791 n1_m1_153600_225600 0 3.878053e-07
I3792 n1_m1_153600_230400 0 2.578577e-07
I3793 n1_m1_153600_235200 0 2.542806e-07
I3794 n1_m1_153600_240000 0 3.767863e-07
I3795 n1_m1_153600_244800 0 2.836176e-07
I3796 n1_m1_153600_249600 0 3.909531e-07
I3797 n1_m1_153600_254400 0 2.644104e-07
I3798 n1_m1_153600_259200 0 2.584593e-07
I3799 n1_m1_153600_264000 0 4.437475e-07
I3800 n1_m1_153600_268800 0 6.512275e-07
I3801 n1_m1_153600_273600 0 1.560129e-06
I3802 n1_m1_153600_278400 0 6.515528e-07
I3803 n1_m1_153600_283200 0 4.521794e-07
I3804 n1_m1_153600_288000 0 8.054655e-07
I3805 n1_m1_153600_292800 0 4.302761e-07
I3806 n1_m1_153600_297600 0 4.755715e-07
I3807 n1_m1_153600_302400 0 2.963252e-07
I3808 n1_m1_153600_307200 0 2.762267e-07
I3809 n1_m1_153600_312000 0 3.789216e-07
I3810 n1_m1_153600_316800 0 2.435522e-07
I3811 n1_m1_153600_321600 0 3.937553e-07
I3812 n1_m1_153600_326400 0 2.713627e-07
I3813 n1_m1_153600_331200 0 2.631908e-07
I3814 n1_m1_153600_336000 0 3.710596e-07
I3815 n1_m1_153600_340800 0 2.398354e-07
I3816 n1_m1_153600_345600 0 3.704672e-07
I3817 n1_m1_153600_350400 0 2.556358e-07
I3818 n1_m1_153600_355200 0 2.492147e-07
I3819 n1_m1_153600_360000 0 3.594084e-07
I3820 n1_m1_153600_364800 0 2.331175e-07
I3821 n1_m1_153600_369600 0 3.590689e-07
I3822 n1_m1_153600_374400 0 2.389503e-07
I3823 n1_m1_153600_379200 0 2.378368e-07
I3824 n1_m1_153600_384000 0 3.567551e-07
I3825 n1_m1_153600_388800 0 2.335234e-07
I3826 n1_m1_153600_393600 0 3.524255e-07
I3827 n1_m1_153600_398400 0 2.368099e-07
I3828 n1_m1_153600_403200 0 2.392021e-07
I3829 n1_m1_153600_408000 0 3.597531e-07
I3830 n1_m1_153600_412800 0 2.412630e-07
I3831 n1_m1_153600_417600 0 3.689325e-07
I3832 n1_m1_153600_422400 0 2.457007e-07
I3833 n1_m1_153600_427200 0 2.514050e-07
I3834 n1_m1_153600_432000 0 3.866856e-07
I3835 n1_m1_153600_436800 0 2.619896e-07
I3836 n1_m1_153600_441600 0 3.907114e-07
I3837 n1_m1_153600_446400 0 2.596014e-07
I3838 n1_m1_153600_451200 0 2.535454e-07
I3839 n1_m1_153600_456000 0 4.018997e-07
I3840 n1_m1_153600_460800 0 2.626850e-07
I3841 n1_m1_153600_465600 0 3.852968e-07
I3842 n1_m1_153600_470400 0 2.493329e-07
I3843 n1_m1_153600_475200 0 2.465308e-07
I3844 n1_m1_153600_480000 0 3.673040e-07
I3845 n1_m1_153600_484800 0 2.473731e-07
I3846 n1_m1_153600_489600 0 3.638503e-07
I3847 n1_m1_153600_494400 0 2.464023e-07
I3848 n1_m1_153600_499200 0 2.478299e-07
I3849 n1_m1_153600_504000 0 3.713594e-07
I3850 n1_m1_153600_508800 0 2.447891e-07
I3851 n1_m1_153600_513600 0 3.541855e-07
I3852 n1_m1_153600_518400 0 2.298422e-07
I3853 n1_m1_153600_523200 0 2.327484e-07
I3854 n1_m1_153600_528000 0 3.614203e-07
I3855 n1_m1_153600_532800 0 2.418340e-07
I3856 n1_m1_153600_537600 0 3.702591e-07
I3857 n1_m1_153600_542400 0 2.469387e-07
I3858 n1_m1_153600_547200 0 2.414649e-07
I3859 n1_m1_153600_552000 0 3.480468e-07
I3860 n1_m1_153600_556800 0 2.298422e-07
I3861 n1_m1_158400_0 0 1.479692e-07
I3862 n1_m1_158400_4800 0 1.516347e-07
I3863 n1_m1_158400_9600 0 2.297263e-07
I3864 n1_m1_158400_14400 0 1.519433e-07
I3865 n1_m1_158400_19200 0 1.470895e-07
I3866 n1_m1_158400_24000 0 2.198491e-07
I3867 n1_m1_158400_28800 0 1.485885e-07
I3868 n1_m1_158400_33600 0 2.422266e-07
I3869 n1_m1_158400_38400 0 1.704035e-07
I3870 n1_m1_158400_43200 0 1.670615e-07
I3871 n1_m1_158400_48000 0 2.412885e-07
I3872 n1_m1_158400_52800 0 1.582849e-07
I3873 n1_m1_158400_57600 0 2.310904e-07
I3874 n1_m1_158400_62400 0 1.532282e-07
I3875 n1_m1_158400_67200 0 1.532282e-07
I3876 n1_m1_158400_72000 0 2.298422e-07
I3877 n1_m1_158400_76800 0 1.532282e-07
I3878 n1_m1_158400_81600 0 2.298422e-07
I3879 n1_m1_158400_86400 0 1.532282e-07
I3880 n1_m1_158400_91200 0 1.532282e-07
I3881 n1_m1_158400_96000 0 2.298422e-07
I3882 n1_m1_158400_100800 0 1.532282e-07
I3883 n1_m1_158400_105600 0 2.312223e-07
I3884 n1_m1_158400_110400 0 1.614868e-07
I3885 n1_m1_158400_115200 0 1.708946e-07
I3886 n1_m1_158400_120000 0 2.557530e-07
I3887 n1_m1_158400_124800 0 1.638542e-07
I3888 n1_m1_158400_129600 0 2.398758e-07
I3889 n1_m1_158400_134400 0 1.598903e-07
I3890 n1_m1_158400_139200 0 1.665524e-07
I3891 n1_m1_158400_144000 0 2.578132e-07
I3892 n1_m1_158400_148800 0 1.620887e-07
I3893 n1_m1_158400_153600 0 2.380438e-07
I3894 n1_m1_158400_158400 0 1.593668e-07
I3895 n1_m1_158400_163200 0 1.598267e-07
I3896 n1_m1_158400_168000 0 2.398354e-07
I3897 n1_m1_158400_172800 0 1.598903e-07
I3898 n1_m1_158400_177600 0 2.398354e-07
I3899 n1_m1_158400_182400 0 1.593335e-07
I3900 n1_m1_158400_187200 0 1.588909e-07
I3901 n1_m1_158400_192000 0 2.383551e-07
I3902 n1_m1_158400_196800 0 1.592873e-07
I3903 n1_m1_158400_201600 0 2.400393e-07
I3904 n1_m1_158400_206400 0 1.642121e-07
I3905 n1_m1_158400_211200 0 1.655102e-07
I3906 n1_m1_158400_216000 0 2.498221e-07
I3907 n1_m1_158400_220800 0 1.670758e-07
I3908 n1_m1_158400_225600 0 2.506137e-07
I3909 n1_m1_158400_230400 0 1.638311e-07
I3910 n1_m1_158400_235200 0 1.607053e-07
I3911 n1_m1_158400_240000 0 2.411284e-07
I3912 n1_m1_158400_244800 0 1.776794e-07
I3913 n1_m1_158400_249600 0 2.521174e-07
I3914 n1_m1_158400_254400 0 1.754660e-07
I3915 n1_m1_158400_259200 0 1.682814e-07
I3916 n1_m1_158400_264000 0 2.932569e-07
I3917 n1_m1_158400_268800 0 4.262411e-07
I3918 n1_m1_158400_273600 0 1.012472e-06
I3919 n1_m1_158400_278400 0 4.208778e-07
I3920 n1_m1_158400_283200 0 2.305200e-07
I3921 n1_m1_158400_288000 0 2.764885e-07
I3922 n1_m1_158400_292800 0 1.906215e-07
I3923 n1_m1_158400_297600 0 3.355116e-07
I3924 n1_m1_158400_302400 0 2.022707e-07
I3925 n1_m1_158400_307200 0 1.776957e-07
I3926 n1_m1_158400_312000 0 2.555345e-07
I3927 n1_m1_158400_316800 0 1.616499e-07
I3928 n1_m1_158400_321600 0 2.564617e-07
I3929 n1_m1_158400_326400 0 1.776835e-07
I3930 n1_m1_158400_331200 0 1.746944e-07
I3931 n1_m1_158400_336000 0 2.478442e-07
I3932 n1_m1_158400_340800 0 1.598903e-07
I3933 n1_m1_158400_345600 0 2.418697e-07
I3934 n1_m1_158400_350400 0 1.692240e-07
I3935 n1_m1_158400_355200 0 1.662811e-07
I3936 n1_m1_158400_360000 0 2.409622e-07
I3937 n1_m1_158400_364800 0 1.594865e-07
I3938 n1_m1_158400_369600 0 2.397943e-07
I3939 n1_m1_158400_374400 0 1.594477e-07
I3940 n1_m1_158400_379200 0 1.588909e-07
I3941 n1_m1_158400_384000 0 2.390859e-07
I3942 n1_m1_158400_388800 0 1.595538e-07
I3943 n1_m1_158400_393600 0 2.341706e-07
I3944 n1_m1_158400_398400 0 1.551547e-07
I3945 n1_m1_158400_403200 0 1.588991e-07
I3946 n1_m1_158400_408000 0 2.400567e-07
I3947 n1_m1_158400_412800 0 1.618508e-07
I3948 n1_m1_158400_417600 0 2.616752e-07
I3949 n1_m1_158400_422400 0 1.797447e-07
I3950 n1_m1_158400_427200 0 1.629269e-07
I3951 n1_m1_158400_432000 0 2.588550e-07
I3952 n1_m1_158400_436800 0 1.945773e-07
I3953 n1_m1_158400_441600 0 2.675918e-07
I3954 n1_m1_158400_446400 0 1.685003e-07
I3955 n1_m1_158400_451200 0 1.741771e-07
I3956 n1_m1_158400_456000 0 3.051497e-07
I3957 n1_m1_158400_460800 0 1.853531e-07
I3958 n1_m1_158400_465600 0 2.579964e-07
I3959 n1_m1_158400_470400 0 1.641846e-07
I3960 n1_m1_158400_475200 0 1.599569e-07
I3961 n1_m1_158400_480000 0 2.393697e-07
I3962 n1_m1_158400_484800 0 1.604137e-07
I3963 n1_m1_158400_489600 0 2.406229e-07
I3964 n1_m1_158400_494400 0 1.645418e-07
I3965 n1_m1_158400_499200 0 1.655530e-07
I3966 n1_m1_158400_504000 0 2.481368e-07
I3967 n1_m1_158400_508800 0 1.637828e-07
I3968 n1_m1_158400_513600 0 2.365162e-07
I3969 n1_m1_158400_518400 0 1.532282e-07
I3970 n1_m1_158400_523200 0 1.533702e-07
I3971 n1_m1_158400_528000 0 2.345625e-07
I3972 n1_m1_158400_532800 0 1.598903e-07
I3973 n1_m1_158400_537600 0 2.449326e-07
I3974 n1_m1_158400_542400 0 1.613505e-07
I3975 n1_m1_158400_547200 0 1.592608e-07
I3976 n1_m1_158400_552000 0 2.317029e-07
I3977 n1_m1_158400_556800 0 1.532282e-07
I3978 n1_m1_163200_0 0 1.480888e-07
I3979 n1_m1_163200_4800 0 1.520385e-07
I3980 n1_m1_163200_9600 0 2.298422e-07
I3981 n1_m1_163200_14400 0 1.519433e-07
I3982 n1_m1_163200_19200 0 1.470895e-07
I3983 n1_m1_163200_24000 0 2.198491e-07
I3984 n1_m1_163200_28800 0 1.468550e-07
I3985 n1_m1_163200_33600 0 2.267372e-07
I3986 n1_m1_163200_38400 0 1.549413e-07
I3987 n1_m1_163200_43200 0 1.544906e-07
I3988 n1_m1_163200_48000 0 2.310499e-07
I3989 n1_m1_163200_52800 0 1.534321e-07
I3990 n1_m1_163200_57600 0 2.289680e-07
I3991 n1_m1_163200_62400 0 1.525144e-07
I3992 n1_m1_163200_67200 0 1.526112e-07
I3993 n1_m1_163200_72000 0 2.297454e-07
I3994 n1_m1_163200_76800 0 1.532282e-07
I3995 n1_m1_163200_81600 0 2.298422e-07
I3996 n1_m1_163200_86400 0 1.532282e-07
I3997 n1_m1_163200_91200 0 1.532282e-07
I3998 n1_m1_163200_96000 0 2.298422e-07
I3999 n1_m1_163200_100800 0 1.532282e-07
I4000 n1_m1_163200_105600 0 2.310744e-07
I4001 n1_m1_163200_110400 0 1.600215e-07
I4002 n1_m1_163200_115200 0 1.658471e-07
I4003 n1_m1_163200_120000 0 2.474016e-07
I4004 n1_m1_163200_124800 0 1.599569e-07
I4005 n1_m1_163200_129600 0 2.398361e-07
I4006 n1_m1_163200_134400 0 1.603083e-07
I4007 n1_m1_163200_139200 0 1.665524e-07
I4008 n1_m1_163200_144000 0 2.536786e-07
I4009 n1_m1_163200_148800 0 1.615130e-07
I4010 n1_m1_163200_153600 0 2.355159e-07
I4011 n1_m1_163200_158400 0 1.602002e-07
I4012 n1_m1_163200_163200 0 1.605276e-07
I4013 n1_m1_163200_168000 0 2.399527e-07
I4014 n1_m1_163200_172800 0 1.598903e-07
I4015 n1_m1_163200_177600 0 2.398354e-07
I4016 n1_m1_163200_182400 0 1.566292e-07
I4017 n1_m1_163200_187200 0 1.540371e-07
I4018 n1_m1_163200_192000 0 2.310557e-07
I4019 n1_m1_163200_196800 0 1.540371e-07
I4020 n1_m1_163200_201600 0 2.312002e-07
I4021 n1_m1_163200_206400 0 1.555653e-07
I4022 n1_m1_163200_211200 0 1.603821e-07
I4023 n1_m1_163200_216000 0 2.480746e-07
I4024 n1_m1_163200_220800 0 1.665524e-07
I4025 n1_m1_163200_225600 0 2.502670e-07
I4026 n1_m1_163200_230400 0 1.641220e-07
I4027 n1_m1_163200_235200 0 1.613178e-07
I4028 n1_m1_163200_240000 0 2.414190e-07
I4029 n1_m1_163200_244800 0 1.624416e-07
I4030 n1_m1_163200_249600 0 2.431957e-07
I4031 n1_m1_163200_254400 0 1.710513e-07
I4032 n1_m1_163200_259200 0 1.670425e-07
I4033 n1_m1_163200_264000 0 2.514845e-07
I4034 n1_m1_163200_268800 0 2.308072e-07
I4035 n1_m1_163200_273600 0 4.609724e-07
I4036 n1_m1_163200_278400 0 2.428571e-07
I4037 n1_m1_163200_283200 0 2.214507e-07
I4038 n1_m1_163200_288000 0 2.887528e-07
I4039 n1_m1_163200_292800 0 2.259687e-07
I4040 n1_m1_163200_297600 0 3.095946e-07
I4041 n1_m1_163200_302400 0 1.744830e-07
I4042 n1_m1_163200_307200 0 1.718834e-07
I4043 n1_m1_163200_312000 0 2.936852e-07
I4044 n1_m1_163200_316800 0 1.640010e-07
I4045 n1_m1_163200_321600 0 2.500416e-07
I4046 n1_m1_163200_326400 0 1.650337e-07
I4047 n1_m1_163200_331200 0 1.620051e-07
I4048 n1_m1_163200_336000 0 2.415454e-07
I4049 n1_m1_163200_340800 0 1.601248e-07
I4050 n1_m1_163200_345600 0 2.400550e-07
I4051 n1_m1_163200_350400 0 1.612135e-07
I4052 n1_m1_163200_355200 0 1.608032e-07
I4053 n1_m1_163200_360000 0 2.400145e-07
I4054 n1_m1_163200_364800 0 1.598903e-07
I4055 n1_m1_163200_369600 0 2.394581e-07
I4056 n1_m1_163200_374400 0 1.569005e-07
I4057 n1_m1_163200_379200 0 1.540371e-07
I4058 n1_m1_163200_384000 0 2.354455e-07
I4059 n1_m1_163200_388800 0 1.598903e-07
I4060 n1_m1_163200_393600 0 2.389802e-07
I4061 n1_m1_163200_398400 0 1.591449e-07
I4062 n1_m1_163200_403200 0 1.597342e-07
I4063 n1_m1_163200_408000 0 2.411314e-07
I4064 n1_m1_163200_412800 0 1.657226e-07
I4065 n1_m1_163200_417600 0 2.986773e-07
I4066 n1_m1_163200_422400 0 2.385608e-07
I4067 n1_m1_163200_427200 0 1.993101e-07
I4068 n1_m1_163200_432000 0 2.900326e-07
I4069 n1_m1_163200_436800 0 2.048200e-07
I4070 n1_m1_163200_441600 0 3.063214e-07
I4071 n1_m1_163200_446400 0 1.964441e-07
I4072 n1_m1_163200_451200 0 1.892959e-07
I4073 n1_m1_163200_456000 0 2.988051e-07
I4074 n1_m1_163200_460800 0 1.843364e-07
I4075 n1_m1_163200_465600 0 2.569614e-07
I4076 n1_m1_163200_470400 0 1.635442e-07
I4077 n1_m1_163200_475200 0 1.583485e-07
I4078 n1_m1_163200_480000 0 2.356138e-07
I4079 n1_m1_163200_484800 0 1.598903e-07
I4080 n1_m1_163200_489600 0 2.398442e-07
I4081 n1_m1_163200_494400 0 1.599684e-07
I4082 n1_m1_163200_499200 0 1.599854e-07
I4083 n1_m1_163200_504000 0 2.389870e-07
I4084 n1_m1_163200_508800 0 1.551286e-07
I4085 n1_m1_163200_513600 0 2.311118e-07
I4086 n1_m1_163200_518400 0 1.539420e-07
I4087 n1_m1_163200_523200 0 1.539420e-07
I4088 n1_m1_163200_528000 0 2.347368e-07
I4089 n1_m1_163200_532800 0 1.598903e-07
I4090 n1_m1_163200_537600 0 2.398643e-07
I4091 n1_m1_163200_542400 0 1.591489e-07
I4092 n1_m1_163200_547200 0 1.552853e-07
I4093 n1_m1_163200_552000 0 2.301080e-07
I4094 n1_m1_163200_556800 0 1.532282e-07
I4095 n1_m1_168000_0 0 2.221333e-07
I4096 n1_m1_168000_4800 0 2.280578e-07
I4097 n1_m1_168000_9600 0 3.447634e-07
I4098 n1_m1_168000_14400 0 2.279150e-07
I4099 n1_m1_168000_19200 0 2.206343e-07
I4100 n1_m1_168000_24000 0 3.297737e-07
I4101 n1_m1_168000_28800 0 2.198491e-07
I4102 n1_m1_168000_33600 0 3.341635e-07
I4103 n1_m1_168000_38400 0 2.257022e-07
I4104 n1_m1_168000_43200 0 2.257022e-07
I4105 n1_m1_168000_48000 0 3.420628e-07
I4106 n1_m1_168000_52800 0 2.244952e-07
I4107 n1_m1_168000_57600 0 3.319932e-07
I4108 n1_m1_168000_62400 0 2.209436e-07
I4109 n1_m1_168000_67200 0 2.221513e-07
I4110 n1_m1_168000_72000 0 3.435557e-07
I4111 n1_m1_168000_76800 0 2.298422e-07
I4112 n1_m1_168000_81600 0 3.447634e-07
I4113 n1_m1_168000_86400 0 2.298422e-07
I4114 n1_m1_168000_91200 0 2.298422e-07
I4115 n1_m1_168000_96000 0 3.447634e-07
I4116 n1_m1_168000_100800 0 2.298422e-07
I4117 n1_m1_168000_105600 0 3.449901e-07
I4118 n1_m1_168000_110400 0 2.321172e-07
I4119 n1_m1_168000_115200 0 2.377348e-07
I4120 n1_m1_168000_120000 0 3.558068e-07
I4121 n1_m1_168000_124800 0 2.352719e-07
I4122 n1_m1_168000_129600 0 3.597065e-07
I4123 n1_m1_168000_134400 0 2.464411e-07
I4124 n1_m1_168000_139200 0 2.510182e-07
I4125 n1_m1_168000_144000 0 3.750032e-07
I4126 n1_m1_168000_148800 0 2.439394e-07
I4127 n1_m1_168000_153600 0 3.705018e-07
I4128 n1_m1_168000_158400 0 2.508404e-07
I4129 n1_m1_168000_163200 0 2.501599e-07
I4130 n1_m1_168000_168000 0 3.639342e-07
I4131 n1_m1_168000_172800 0 2.404812e-07
I4132 n1_m1_168000_177600 0 3.617415e-07
I4133 n1_m1_168000_182400 0 2.355934e-07
I4134 n1_m1_168000_187200 0 2.322216e-07
I4135 n1_m1_168000_192000 0 3.483323e-07
I4136 n1_m1_168000_196800 0 2.322216e-07
I4137 n1_m1_168000_201600 0 3.479075e-07
I4138 n1_m1_168000_206400 0 2.310965e-07
I4139 n1_m1_168000_211200 0 2.367453e-07
I4140 n1_m1_168000_216000 0 3.629166e-07
I4141 n1_m1_168000_220800 0 2.486049e-07
I4142 n1_m1_168000_225600 0 3.836081e-07
I4143 n1_m1_168000_230400 0 2.605280e-07
I4144 n1_m1_168000_235200 0 2.600120e-07
I4145 n1_m1_168000_240000 0 3.841883e-07
I4146 n1_m1_168000_244800 0 2.452759e-07
I4147 n1_m1_168000_249600 0 3.670810e-07
I4148 n1_m1_168000_254400 0 2.501120e-07
I4149 n1_m1_168000_259200 0 2.495814e-07
I4150 n1_m1_168000_264000 0 3.678434e-07
I4151 n1_m1_168000_268800 0 2.489676e-07
I4152 n1_m1_168000_273600 0 3.870898e-07
I4153 n1_m1_168000_278400 0 2.597741e-07
I4154 n1_m1_168000_283200 0 2.918874e-07
I4155 n1_m1_168000_288000 0 6.106190e-07
I4156 n1_m1_168000_292800 0 4.533079e-07
I4157 n1_m1_168000_297600 0 5.077760e-07
I4158 n1_m1_168000_302400 0 2.989723e-07
I4159 n1_m1_168000_307200 0 3.091681e-07
I4160 n1_m1_168000_312000 0 5.318139e-07
I4161 n1_m1_168000_316800 0 2.866978e-07
I4162 n1_m1_168000_321600 0 3.767220e-07
I4163 n1_m1_168000_326400 0 2.404139e-07
I4164 n1_m1_168000_331200 0 2.407531e-07
I4165 n1_m1_168000_336000 0 3.703774e-07
I4166 n1_m1_168000_340800 0 2.467361e-07
I4167 n1_m1_168000_345600 0 3.636620e-07
I4168 n1_m1_168000_350400 0 2.383228e-07
I4169 n1_m1_168000_355200 0 2.395295e-07
I4170 n1_m1_168000_360000 0 3.627952e-07
I4171 n1_m1_168000_364800 0 2.417558e-07
I4172 n1_m1_168000_369600 0 3.552365e-07
I4173 n1_m1_168000_374400 0 2.304520e-07
I4174 n1_m1_168000_379200 0 2.298422e-07
I4175 n1_m1_168000_384000 0 3.522582e-07
I4176 n1_m1_168000_388800 0 2.398354e-07
I4177 n1_m1_168000_393600 0 3.597531e-07
I4178 n1_m1_168000_398400 0 2.398354e-07
I4179 n1_m1_168000_403200 0 2.398354e-07
I4180 n1_m1_168000_408000 0 3.619658e-07
I4181 n1_m1_168000_412800 0 2.509179e-07
I4182 n1_m1_168000_417600 0 5.129639e-07
I4183 n1_m1_168000_422400 0 5.952724e-07
I4184 n1_m1_168000_427200 0 7.151670e-07
I4185 n1_m1_168000_432000 0 9.842112e-07
I4186 n1_m1_168000_436800 0 6.329302e-07
I4187 n1_m1_168000_441600 0 1.139904e-06
I4188 n1_m1_168000_446400 0 6.916814e-07
I4189 n1_m1_168000_451200 0 4.116946e-07
I4190 n1_m1_168000_456000 0 4.236541e-07
I4191 n1_m1_168000_460800 0 2.585929e-07
I4192 n1_m1_168000_465600 0 3.704141e-07
I4193 n1_m1_168000_470400 0 2.405077e-07
I4194 n1_m1_168000_475200 0 2.395070e-07
I4195 n1_m1_168000_480000 0 3.588540e-07
I4196 n1_m1_168000_484800 0 2.398354e-07
I4197 n1_m1_168000_489600 0 3.591477e-07
I4198 n1_m1_168000_494400 0 2.344802e-07
I4199 n1_m1_168000_499200 0 2.332991e-07
I4200 n1_m1_168000_504000 0 3.473667e-07
I4201 n1_m1_168000_508800 0 2.321206e-07
I4202 n1_m1_168000_513600 0 3.522732e-07
I4203 n1_m1_168000_518400 0 2.419700e-07
I4204 n1_m1_168000_523200 0 2.428537e-07
I4205 n1_m1_168000_528000 0 3.624349e-07
I4206 n1_m1_168000_532800 0 2.408891e-07
I4207 n1_m1_168000_537600 0 3.511087e-07
I4208 n1_m1_168000_542400 0 2.308976e-07
I4209 n1_m1_168000_547200 0 2.301080e-07
I4210 n1_m1_168000_552000 0 3.447634e-07
I4211 n1_m1_168000_556800 0 2.298422e-07
I4212 n1_m1_172800_0 0 7.532925e-08
I4213 n1_m1_172800_4800 0 7.631667e-08
I4214 n1_m1_172800_9600 0 1.149211e-07
I4215 n1_m1_172800_14400 0 7.629287e-08
I4216 n1_m1_172800_19200 0 7.507942e-08
I4217 n1_m1_172800_24000 0 1.116852e-07
I4218 n1_m1_172800_28800 0 7.328303e-08
I4219 n1_m1_172800_33600 0 1.136720e-07
I4220 n1_m1_172800_38400 0 7.827961e-08
I4221 n1_m1_172800_43200 0 7.827961e-08
I4222 n1_m1_172800_48000 0 1.158015e-07
I4223 n1_m1_172800_52800 0 7.655460e-08
I4224 n1_m1_172800_57600 0 1.128273e-07
I4225 n1_m1_172800_62400 0 7.494856e-08
I4226 n1_m1_172800_67200 0 7.517459e-08
I4227 n1_m1_172800_72000 0 1.146951e-07
I4228 n1_m1_172800_76800 0 7.661408e-08
I4229 n1_m1_172800_81600 0 1.149211e-07
I4230 n1_m1_172800_86400 0 7.661408e-08
I4231 n1_m1_172800_91200 0 7.661408e-08
I4232 n1_m1_172800_96000 0 1.149211e-07
I4233 n1_m1_172800_100800 0 7.661408e-08
I4234 n1_m1_172800_105600 0 1.149211e-07
I4235 n1_m1_172800_110400 0 7.688770e-08
I4236 n1_m1_172800_115200 0 7.810116e-08
I4237 n1_m1_172800_120000 0 1.180618e-07
I4238 n1_m1_172800_124800 0 7.994513e-08
I4239 n1_m1_172800_129600 0 1.199177e-07
I4240 n1_m1_172800_134400 0 8.287169e-08
I4241 n1_m1_172800_139200 0 8.327618e-08
I4242 n1_m1_172800_144000 0 1.270675e-07
I4243 n1_m1_172800_148800 0 8.788016e-08
I4244 n1_m1_172800_153600 0 1.287331e-07
I4245 n1_m1_172800_158400 0 8.672619e-08
I4246 n1_m1_172800_163200 0 8.771361e-08
I4247 n1_m1_172800_168000 0 1.255805e-07
I4248 n1_m1_172800_172800 0 7.963582e-08
I4249 n1_m1_172800_177600 0 1.226658e-07
I4250 n1_m1_172800_182400 0 7.901719e-08
I4251 n1_m1_172800_187200 0 7.827961e-08
I4252 n1_m1_172800_192000 0 1.174194e-07
I4253 n1_m1_172800_196800 0 7.827961e-08
I4254 n1_m1_172800_201600 0 1.171220e-07
I4255 n1_m1_172800_206400 0 7.722081e-08
I4256 n1_m1_172800_211200 0 7.964771e-08
I4257 n1_m1_172800_216000 0 1.226658e-07
I4258 n1_m1_172800_220800 0 8.408514e-08
I4259 n1_m1_172800_225600 0 1.318381e-07
I4260 n1_m1_172800_230400 0 9.345966e-08
I4261 n1_m1_172800_235200 0 1.017635e-07
I4262 n1_m1_172800_240000 0 1.688127e-07
I4263 n1_m1_172800_244800 0 9.231759e-08
I4264 n1_m1_172800_249600 0 1.268177e-07
I4265 n1_m1_172800_254400 0 8.494170e-08
I4266 n1_m1_172800_259200 0 8.507256e-08
I4267 n1_m1_172800_264000 0 1.290900e-07
I4268 n1_m1_172800_268800 0 8.421601e-08
I4269 n1_m1_172800_273600 0 1.245336e-07
I4270 n1_m1_172800_278400 0 8.410894e-08
I4271 n1_m1_172800_283200 0 9.569622e-08
I4272 n1_m1_172800_288000 0 1.987207e-07
I4273 n1_m1_172800_292800 0 1.342412e-07
I4274 n1_m1_172800_297600 0 1.732025e-07
I4275 n1_m1_172800_302400 0 1.168841e-07
I4276 n1_m1_172800_307200 0 1.138623e-07
I4277 n1_m1_172800_312000 0 1.450552e-07
I4278 n1_m1_172800_316800 0 1.030364e-07
I4279 n1_m1_172800_321600 0 1.261277e-07
I4280 n1_m1_172800_326400 0 8.151548e-08
I4281 n1_m1_172800_331200 0 8.327618e-08
I4282 n1_m1_172800_336000 0 1.235937e-07
I4283 n1_m1_172800_340800 0 8.161065e-08
I4284 n1_m1_172800_345600 0 1.237722e-07
I4285 n1_m1_172800_350400 0 8.055186e-08
I4286 n1_m1_172800_355200 0 8.131324e-08
I4287 n1_m1_172800_360000 0 1.224160e-07
I4288 n1_m1_172800_364800 0 8.128944e-08
I4289 n1_m1_172800_369600 0 1.191682e-07
I4290 n1_m1_172800_374400 0 7.827961e-08
I4291 n1_m1_172800_379200 0 7.827961e-08
I4292 n1_m1_172800_384000 0 1.186686e-07
I4293 n1_m1_172800_388800 0 8.101582e-08
I4294 n1_m1_172800_393600 0 1.222137e-07
I4295 n1_m1_172800_398400 0 8.019496e-08
I4296 n1_m1_172800_403200 0 8.006409e-08
I4297 n1_m1_172800_408000 0 1.244741e-07
I4298 n1_m1_172800_412800 0 8.485842e-08
I4299 n1_m1_172800_417600 0 1.598903e-07
I4300 n1_m1_172800_422400 0 1.871573e-07
I4301 n1_m1_172800_427200 0 2.474968e-07
I4302 n1_m1_172800_432000 0 4.006179e-07
I4303 n1_m1_172800_436800 0 3.430978e-07
I4304 n1_m1_172800_441600 0 6.368843e-07
I4305 n1_m1_172800_446400 0 3.363763e-07
I4306 n1_m1_172800_451200 0 1.876807e-07
I4307 n1_m1_172800_456000 0 1.473037e-07
I4308 n1_m1_172800_460800 0 8.321669e-08
I4309 n1_m1_172800_465600 0 1.225944e-07
I4310 n1_m1_172800_470400 0 8.096824e-08
I4311 n1_m1_172800_475200 0 7.994513e-08
I4312 n1_m1_172800_480000 0 1.199177e-07
I4313 n1_m1_172800_484800 0 7.994513e-08
I4314 n1_m1_172800_489600 0 1.199177e-07
I4315 n1_m1_172800_494400 0 7.986185e-08
I4316 n1_m1_172800_499200 0 7.863650e-08
I4317 n1_m1_172800_504000 0 1.160632e-07
I4318 n1_m1_172800_508800 0 7.968340e-08
I4319 n1_m1_172800_513600 0 1.213929e-07
I4320 n1_m1_172800_518400 0 8.446584e-08
I4321 n1_m1_172800_523200 0 8.660722e-08
I4322 n1_m1_172800_528000 0 1.277694e-07
I4323 n1_m1_172800_532800 0 8.049237e-08
I4324 n1_m1_172800_537600 0 1.158015e-07
I4325 n1_m1_172800_542400 0 7.667356e-08
I4326 n1_m1_172800_547200 0 7.787512e-08
I4327 n1_m1_172800_552000 0 1.171220e-07
I4328 n1_m1_172800_556800 0 7.699477e-08
I4329 n1_m1_177600_0 0 2.297321e-07
I4330 n1_m1_177600_4800 0 2.298168e-07
I4331 n1_m1_177600_9600 0 3.447634e-07
I4332 n1_m1_177600_14400 0 2.298147e-07
I4333 n1_m1_177600_19200 0 2.297107e-07
I4334 n1_m1_177600_24000 0 3.401869e-07
I4335 n1_m1_177600_28800 0 2.198491e-07
I4336 n1_m1_177600_33600 0 3.373756e-07
I4337 n1_m1_177600_38400 0 2.299850e-07
I4338 n1_m1_177600_43200 0 2.299850e-07
I4339 n1_m1_177600_48000 0 3.448388e-07
I4340 n1_m1_177600_52800 0 2.298371e-07
I4341 n1_m1_177600_57600 0 3.445839e-07
I4342 n1_m1_177600_62400 0 2.296995e-07
I4343 n1_m1_177600_67200 0 2.297189e-07
I4344 n1_m1_177600_72000 0 3.447440e-07
I4345 n1_m1_177600_76800 0 2.298422e-07
I4346 n1_m1_177600_81600 0 3.447634e-07
I4347 n1_m1_177600_86400 0 2.298422e-07
I4348 n1_m1_177600_91200 0 2.298422e-07
I4349 n1_m1_177600_96000 0 3.447634e-07
I4350 n1_m1_177600_100800 0 2.298422e-07
I4351 n1_m1_177600_105600 0 3.447634e-07
I4352 n1_m1_177600_110400 0 2.314605e-07
I4353 n1_m1_177600_115200 0 2.391573e-07
I4354 n1_m1_177600_120000 0 3.637238e-07
I4355 n1_m1_177600_124800 0 2.398354e-07
I4356 n1_m1_177600_129600 0 3.626287e-07
I4357 n1_m1_177600_134400 0 2.500549e-07
I4358 n1_m1_177600_139200 0 2.471161e-07
I4359 n1_m1_177600_144000 0 3.757309e-07
I4360 n1_m1_177600_148800 0 2.643012e-07
I4361 n1_m1_177600_153600 0 3.932536e-07
I4362 n1_m1_177600_158400 0 2.736775e-07
I4363 n1_m1_177600_163200 0 2.995566e-07
I4364 n1_m1_177600_168000 0 4.040492e-07
I4365 n1_m1_177600_172800 0 2.447320e-07
I4366 n1_m1_177600_177600 0 3.681687e-07
I4367 n1_m1_177600_182400 0 2.367334e-07
I4368 n1_m1_177600_187200 0 2.322488e-07
I4369 n1_m1_177600_192000 0 3.449775e-07
I4370 n1_m1_177600_196800 0 2.299850e-07
I4371 n1_m1_177600_201600 0 3.449520e-07
I4372 n1_m1_177600_206400 0 2.325292e-07
I4373 n1_m1_177600_211200 0 2.468826e-07
I4374 n1_m1_177600_216000 0 3.763325e-07
I4375 n1_m1_177600_220800 0 2.553227e-07
I4376 n1_m1_177600_225600 0 3.894368e-07
I4377 n1_m1_177600_230400 0 2.795673e-07
I4378 n1_m1_177600_235200 0 3.112415e-07
I4379 n1_m1_177600_240000 0 5.279315e-07
I4380 n1_m1_177600_244800 0 2.786373e-07
I4381 n1_m1_177600_249600 0 3.700766e-07
I4382 n1_m1_177600_254400 0 2.543560e-07
I4383 n1_m1_177600_259200 0 2.554074e-07
I4384 n1_m1_177600_264000 0 3.832380e-07
I4385 n1_m1_177600_268800 0 2.541327e-07
I4386 n1_m1_177600_273600 0 3.724729e-07
I4387 n1_m1_177600_278400 0 2.456171e-07
I4388 n1_m1_177600_283200 0 2.483846e-07
I4389 n1_m1_177600_288000 0 3.810691e-07
I4390 n1_m1_177600_292800 0 2.541970e-07
I4391 n1_m1_177600_297600 0 3.849266e-07
I4392 n1_m1_177600_302400 0 2.581341e-07
I4393 n1_m1_177600_307200 0 2.575997e-07
I4394 n1_m1_177600_312000 0 3.805419e-07
I4395 n1_m1_177600_316800 0 2.546018e-07
I4396 n1_m1_177600_321600 0 3.637177e-07
I4397 n1_m1_177600_326400 0 2.493676e-07
I4398 n1_m1_177600_331200 0 2.515090e-07
I4399 n1_m1_177600_336000 0 3.596032e-07
I4400 n1_m1_177600_340800 0 2.403045e-07
I4401 n1_m1_177600_345600 0 3.754117e-07
I4402 n1_m1_177600_350400 0 2.464747e-07
I4403 n1_m1_177600_355200 0 2.451063e-07
I4404 n1_m1_177600_360000 0 3.611684e-07
I4405 n1_m1_177600_364800 0 2.399506e-07
I4406 n1_m1_177600_369600 0 3.596888e-07
I4407 n1_m1_177600_374400 0 2.396926e-07
I4408 n1_m1_177600_379200 0 2.396926e-07
I4409 n1_m1_177600_384000 0 3.596460e-07
I4410 n1_m1_177600_388800 0 2.461678e-07
I4411 n1_m1_177600_393600 0 3.733325e-07
I4412 n1_m1_177600_398400 0 2.416494e-07
I4413 n1_m1_177600_403200 0 2.438428e-07
I4414 n1_m1_177600_408000 0 3.855915e-07
I4415 n1_m1_177600_412800 0 2.571735e-07
I4416 n1_m1_177600_417600 0 3.888902e-07
I4417 n1_m1_177600_422400 0 2.905475e-07
I4418 n1_m1_177600_427200 0 3.035508e-07
I4419 n1_m1_177600_432000 0 5.930634e-07
I4420 n1_m1_177600_436800 0 6.997932e-07
I4421 n1_m1_177600_441600 0 1.229900e-06
I4422 n1_m1_177600_446400 0 6.048695e-07
I4423 n1_m1_177600_451200 0 4.718537e-07
I4424 n1_m1_177600_456000 0 4.398960e-07
I4425 n1_m1_177600_460800 0 2.504475e-07
I4426 n1_m1_177600_465600 0 3.745439e-07
I4427 n1_m1_177600_470400 0 2.458863e-07
I4428 n1_m1_177600_475200 0 2.398354e-07
I4429 n1_m1_177600_480000 0 3.597531e-07
I4430 n1_m1_177600_484800 0 2.423439e-07
I4431 n1_m1_177600_489600 0 3.618945e-07
I4432 n1_m1_177600_494400 0 2.395570e-07
I4433 n1_m1_177600_499200 0 2.354996e-07
I4434 n1_m1_177600_504000 0 3.523316e-07
I4435 n1_m1_177600_508800 0 2.393867e-07
I4436 n1_m1_177600_513600 0 3.641786e-07
I4437 n1_m1_177600_518400 0 2.518679e-07
I4438 n1_m1_177600_523200 0 2.570114e-07
I4439 n1_m1_177600_528000 0 3.814178e-07
I4440 n1_m1_177600_532800 0 2.392623e-07
I4441 n1_m1_177600_537600 0 3.471026e-07
I4442 n1_m1_177600_542400 0 2.301940e-07
I4443 n1_m1_177600_547200 0 2.373004e-07
I4444 n1_m1_177600_552000 0 3.527630e-07
I4445 n1_m1_177600_556800 0 2.278110e-07
I4446 n1_m1_182400_0 0 1.532282e-07
I4447 n1_m1_182400_4800 0 1.532282e-07
I4448 n1_m1_182400_9600 0 2.298422e-07
I4449 n1_m1_182400_14400 0 1.532282e-07
I4450 n1_m1_182400_19200 0 1.532282e-07
I4451 n1_m1_182400_24000 0 2.268919e-07
I4452 n1_m1_182400_28800 0 1.465661e-07
I4453 n1_m1_182400_33600 0 2.248457e-07
I4454 n1_m1_182400_38400 0 1.532282e-07
I4455 n1_m1_182400_43200 0 1.532282e-07
I4456 n1_m1_182400_48000 0 2.298422e-07
I4457 n1_m1_182400_52800 0 1.532282e-07
I4458 n1_m1_182400_57600 0 2.298422e-07
I4459 n1_m1_182400_62400 0 1.532282e-07
I4460 n1_m1_182400_67200 0 1.532282e-07
I4461 n1_m1_182400_72000 0 2.298422e-07
I4462 n1_m1_182400_76800 0 1.532282e-07
I4463 n1_m1_182400_81600 0 2.298422e-07
I4464 n1_m1_182400_86400 0 1.532282e-07
I4465 n1_m1_182400_91200 0 1.532282e-07
I4466 n1_m1_182400_96000 0 2.298422e-07
I4467 n1_m1_182400_100800 0 1.532282e-07
I4468 n1_m1_182400_105600 0 2.298422e-07
I4469 n1_m1_182400_110400 0 1.543227e-07
I4470 n1_m1_182400_115200 0 1.595347e-07
I4471 n1_m1_182400_120000 0 2.426804e-07
I4472 n1_m1_182400_124800 0 1.610038e-07
I4473 n1_m1_182400_129600 0 2.498496e-07
I4474 n1_m1_182400_134400 0 1.719922e-07
I4475 n1_m1_182400_139200 0 1.684082e-07
I4476 n1_m1_182400_144000 0 2.455505e-07
I4477 n1_m1_182400_148800 0 1.660792e-07
I4478 n1_m1_182400_153600 0 2.912532e-07
I4479 n1_m1_182400_158400 0 2.447347e-07
I4480 n1_m1_182400_163200 0 2.409605e-07
I4481 n1_m1_182400_168000 0 2.842797e-07
I4482 n1_m1_182400_172800 0 1.714062e-07
I4483 n1_m1_182400_177600 0 2.456885e-07
I4484 n1_m1_182400_182400 0 1.598903e-07
I4485 n1_m1_182400_187200 0 1.567496e-07
I4486 n1_m1_182400_192000 0 2.298422e-07
I4487 n1_m1_182400_196800 0 1.532282e-07
I4488 n1_m1_182400_201600 0 2.298422e-07
I4489 n1_m1_182400_206400 0 1.545327e-07
I4490 n1_m1_182400_211200 0 1.615361e-07
I4491 n1_m1_182400_216000 0 2.442609e-07
I4492 n1_m1_182400_220800 0 1.628406e-07
I4493 n1_m1_182400_225600 0 2.460733e-07
I4494 n1_m1_182400_230400 0 1.693124e-07
I4495 n1_m1_182400_235200 0 1.737597e-07
I4496 n1_m1_182400_240000 0 2.684198e-07
I4497 n1_m1_182400_244800 0 1.686135e-07
I4498 n1_m1_182400_249600 0 2.458877e-07
I4499 n1_m1_182400_254400 0 1.662362e-07
I4500 n1_m1_182400_259200 0 1.665524e-07
I4501 n1_m1_182400_264000 0 2.498285e-07
I4502 n1_m1_182400_268800 0 1.657305e-07
I4503 n1_m1_182400_273600 0 2.427184e-07
I4504 n1_m1_182400_278400 0 1.598903e-07
I4505 n1_m1_182400_283200 0 1.611125e-07
I4506 n1_m1_182400_288000 0 2.473364e-07
I4507 n1_m1_182400_292800 0 1.665524e-07
I4508 n1_m1_182400_297600 0 2.534077e-07
I4509 n1_m1_182400_302400 0 1.670031e-07
I4510 n1_m1_182400_307200 0 1.661241e-07
I4511 n1_m1_182400_312000 0 2.412154e-07
I4512 n1_m1_182400_316800 0 1.614280e-07
I4513 n1_m1_182400_321600 0 2.500692e-07
I4514 n1_m1_182400_326400 0 1.648025e-07
I4515 n1_m1_182400_331200 0 1.602709e-07
I4516 n1_m1_182400_336000 0 2.372107e-07
I4517 n1_m1_182400_340800 0 1.663443e-07
I4518 n1_m1_182400_345600 0 2.489196e-07
I4519 n1_m1_182400_350400 0 1.574831e-07
I4520 n1_m1_182400_355200 0 1.561785e-07
I4521 n1_m1_182400_360000 0 2.351692e-07
I4522 n1_m1_182400_364800 0 1.597577e-07
I4523 n1_m1_182400_369600 0 2.398354e-07
I4524 n1_m1_182400_374400 0 1.598903e-07
I4525 n1_m1_182400_379200 0 1.598903e-07
I4526 n1_m1_182400_384000 0 2.398354e-07
I4527 n1_m1_182400_388800 0 1.641730e-07
I4528 n1_m1_182400_393600 0 2.490196e-07
I4529 n1_m1_182400_398400 0 1.614130e-07
I4530 n1_m1_182400_403200 0 1.655055e-07
I4531 n1_m1_182400_408000 0 2.582037e-07
I4532 n1_m1_182400_412800 0 1.714979e-07
I4533 n1_m1_182400_417600 0 2.481514e-07
I4534 n1_m1_182400_422400 0 1.712960e-07
I4535 n1_m1_182400_427200 0 1.776454e-07
I4536 n1_m1_182400_432000 0 2.660480e-07
I4537 n1_m1_182400_436800 0 1.776835e-07
I4538 n1_m1_182400_441600 0 2.660358e-07
I4539 n1_m1_182400_446400 0 1.894598e-07
I4540 n1_m1_182400_451200 0 3.020498e-07
I4541 n1_m1_182400_456000 0 3.040559e-07
I4542 n1_m1_182400_460800 0 1.704538e-07
I4543 n1_m1_182400_465600 0 2.536463e-07
I4544 n1_m1_182400_470400 0 1.639827e-07
I4545 n1_m1_182400_475200 0 1.598903e-07
I4546 n1_m1_182400_480000 0 2.423276e-07
I4547 n1_m1_182400_484800 0 1.653301e-07
I4548 n1_m1_182400_489600 0 2.431664e-07
I4549 n1_m1_182400_494400 0 1.598903e-07
I4550 n1_m1_182400_499200 0 1.599168e-07
I4551 n1_m1_182400_504000 0 2.442895e-07
I4552 n1_m1_182400_508800 0 1.636020e-07
I4553 n1_m1_182400_513600 0 2.450658e-07
I4554 n1_m1_182400_518400 0 1.628406e-07
I4555 n1_m1_182400_523200 0 1.628406e-07
I4556 n1_m1_182400_528000 0 2.423643e-07
I4557 n1_m1_182400_532800 0 1.598903e-07
I4558 n1_m1_182400_537600 0 2.372610e-07
I4559 n1_m1_182400_542400 0 1.599086e-07
I4560 n1_m1_182400_547200 0 1.600752e-07
I4561 n1_m1_182400_552000 0 2.308416e-07
I4562 n1_m1_182400_556800 0 1.480888e-07
I4563 n1_m1_187200_0 0 1.532282e-07
I4564 n1_m1_187200_4800 0 1.532282e-07
I4565 n1_m1_187200_9600 0 2.298422e-07
I4566 n1_m1_187200_14400 0 1.532282e-07
I4567 n1_m1_187200_19200 0 1.532282e-07
I4568 n1_m1_187200_24000 0 2.268919e-07
I4569 n1_m1_187200_28800 0 1.465661e-07
I4570 n1_m1_187200_33600 0 2.248457e-07
I4571 n1_m1_187200_38400 0 1.532282e-07
I4572 n1_m1_187200_43200 0 1.532282e-07
I4573 n1_m1_187200_48000 0 2.298422e-07
I4574 n1_m1_187200_52800 0 1.532282e-07
I4575 n1_m1_187200_57600 0 2.298422e-07
I4576 n1_m1_187200_62400 0 1.532282e-07
I4577 n1_m1_187200_67200 0 1.532282e-07
I4578 n1_m1_187200_72000 0 2.298422e-07
I4579 n1_m1_187200_76800 0 1.532282e-07
I4580 n1_m1_187200_81600 0 2.298422e-07
I4581 n1_m1_187200_86400 0 1.532282e-07
I4582 n1_m1_187200_91200 0 1.532282e-07
I4583 n1_m1_187200_96000 0 2.298422e-07
I4584 n1_m1_187200_100800 0 1.532282e-07
I4585 n1_m1_187200_105600 0 2.298422e-07
I4586 n1_m1_187200_110400 0 1.543227e-07
I4587 n1_m1_187200_115200 0 1.591765e-07
I4588 n1_m1_187200_120000 0 2.398354e-07
I4589 n1_m1_187200_124800 0 1.609467e-07
I4590 n1_m1_187200_129600 0 2.495654e-07
I4591 n1_m1_187200_134400 0 1.719133e-07
I4592 n1_m1_187200_139200 0 1.745945e-07
I4593 n1_m1_187200_144000 0 2.612472e-07
I4594 n1_m1_187200_148800 0 1.759235e-07
I4595 n1_m1_187200_153600 0 3.841608e-07
I4596 n1_m1_187200_158400 0 3.086671e-07
I4597 n1_m1_187200_163200 0 2.371066e-07
I4598 n1_m1_187200_168000 0 2.739113e-07
I4599 n1_m1_187200_172800 0 1.736944e-07
I4600 n1_m1_187200_177600 0 2.457558e-07
I4601 n1_m1_187200_182400 0 1.598903e-07
I4602 n1_m1_187200_187200 0 1.567496e-07
I4603 n1_m1_187200_192000 0 2.298422e-07
I4604 n1_m1_187200_196800 0 1.532282e-07
I4605 n1_m1_187200_201600 0 2.298422e-07
I4606 n1_m1_187200_206400 0 1.541323e-07
I4607 n1_m1_187200_211200 0 1.589861e-07
I4608 n1_m1_187200_216000 0 2.398354e-07
I4609 n1_m1_187200_220800 0 1.598903e-07
I4610 n1_m1_187200_225600 0 2.398354e-07
I4611 n1_m1_187200_230400 0 1.617516e-07
I4612 n1_m1_187200_235200 0 1.634117e-07
I4613 n1_m1_187200_240000 0 2.481277e-07
I4614 n1_m1_187200_244800 0 1.666557e-07
I4615 n1_m1_187200_249600 0 2.498285e-07
I4616 n1_m1_187200_254400 0 1.669337e-07
I4617 n1_m1_187200_259200 0 1.692219e-07
I4618 n1_m1_187200_264000 0 2.535974e-07
I4619 n1_m1_187200_268800 0 1.657950e-07
I4620 n1_m1_187200_273600 0 2.447225e-07
I4621 n1_m1_187200_278400 0 1.614606e-07
I4622 n1_m1_187200_283200 0 1.611914e-07
I4623 n1_m1_187200_288000 0 2.474866e-07
I4624 n1_m1_187200_292800 0 1.687508e-07
I4625 n1_m1_187200_297600 0 2.579352e-07
I4626 n1_m1_187200_302400 0 1.701207e-07
I4627 n1_m1_187200_307200 0 1.694667e-07
I4628 n1_m1_187200_312000 0 2.499869e-07
I4629 n1_m1_187200_316800 0 1.676305e-07
I4630 n1_m1_187200_321600 0 2.556572e-07
I4631 n1_m1_187200_326400 0 1.648923e-07
I4632 n1_m1_187200_331200 0 1.604613e-07
I4633 n1_m1_187200_336000 0 2.373453e-07
I4634 n1_m1_187200_340800 0 1.622546e-07
I4635 n1_m1_187200_345600 0 2.378327e-07
I4636 n1_m1_187200_350400 0 1.564205e-07
I4637 n1_m1_187200_355200 0 1.565259e-07
I4638 n1_m1_187200_360000 0 2.394241e-07
I4639 n1_m1_187200_364800 0 1.629052e-07
I4640 n1_m1_187200_369600 0 2.445464e-07
I4641 n1_m1_187200_374400 0 1.616401e-07
I4642 n1_m1_187200_379200 0 1.598903e-07
I4643 n1_m1_187200_384000 0 2.398354e-07
I4644 n1_m1_187200_388800 0 1.641730e-07
I4645 n1_m1_187200_393600 0 2.490196e-07
I4646 n1_m1_187200_398400 0 1.614130e-07
I4647 n1_m1_187200_403200 0 1.656176e-07
I4648 n1_m1_187200_408000 0 2.614566e-07
I4649 n1_m1_187200_412800 0 1.721818e-07
I4650 n1_m1_187200_417600 0 2.537782e-07
I4651 n1_m1_187200_422400 0 1.746733e-07
I4652 n1_m1_187200_427200 0 1.735149e-07
I4653 n1_m1_187200_432000 0 2.501304e-07
I4654 n1_m1_187200_436800 0 1.937962e-07
I4655 n1_m1_187200_441600 0 2.866482e-07
I4656 n1_m1_187200_446400 0 1.846984e-07
I4657 n1_m1_187200_451200 0 2.606456e-07
I4658 n1_m1_187200_456000 0 2.935122e-07
I4659 n1_m1_187200_460800 0 1.734163e-07
I4660 n1_m1_187200_465600 0 2.581616e-07
I4661 n1_m1_187200_470400 0 1.659120e-07
I4662 n1_m1_187200_475200 0 1.598903e-07
I4663 n1_m1_187200_480000 0 2.464173e-07
I4664 n1_m1_187200_484800 0 1.696931e-07
I4665 n1_m1_187200_489600 0 2.447368e-07
I4666 n1_m1_187200_494400 0 1.600473e-07
I4667 n1_m1_187200_499200 0 1.623607e-07
I4668 n1_m1_187200_504000 0 2.487721e-07
I4669 n1_m1_187200_508800 0 1.665524e-07
I4670 n1_m1_187200_513600 0 2.468782e-07
I4671 n1_m1_187200_518400 0 1.598903e-07
I4672 n1_m1_187200_523200 0 1.598903e-07
I4673 n1_m1_187200_528000 0 2.398354e-07
I4674 n1_m1_187200_532800 0 1.598903e-07
I4675 n1_m1_187200_537600 0 2.431630e-07
I4676 n1_m1_187200_542400 0 1.657475e-07
I4677 n1_m1_187200_547200 0 1.638862e-07
I4678 n1_m1_187200_552000 0 2.355526e-07
I4679 n1_m1_187200_556800 0 1.512295e-07
I4680 n1_m1_192000_0 0 2.298422e-07
I4681 n1_m1_192000_4800 0 2.298422e-07
I4682 n1_m1_192000_9600 0 3.447634e-07
I4683 n1_m1_192000_14400 0 2.298422e-07
I4684 n1_m1_192000_19200 0 2.298422e-07
I4685 n1_m1_192000_24000 0 3.403378e-07
I4686 n1_m1_192000_28800 0 2.198491e-07
I4687 n1_m1_192000_33600 0 3.370901e-07
I4688 n1_m1_192000_38400 0 2.296043e-07
I4689 n1_m1_192000_43200 0 2.296043e-07
I4690 n1_m1_192000_48000 0 3.444065e-07
I4691 n1_m1_192000_52800 0 2.296043e-07
I4692 n1_m1_192000_57600 0 3.444065e-07
I4693 n1_m1_192000_62400 0 2.296043e-07
I4694 n1_m1_192000_67200 0 2.296366e-07
I4695 n1_m1_192000_72000 0 3.447311e-07
I4696 n1_m1_192000_76800 0 2.298422e-07
I4697 n1_m1_192000_81600 0 3.447634e-07
I4698 n1_m1_192000_86400 0 2.298422e-07
I4699 n1_m1_192000_91200 0 2.298422e-07
I4700 n1_m1_192000_96000 0 3.447634e-07
I4701 n1_m1_192000_100800 0 2.298422e-07
I4702 n1_m1_192000_105600 0 3.459857e-07
I4703 n1_m1_192000_110400 0 2.360360e-07
I4704 n1_m1_192000_115200 0 2.387093e-07
I4705 n1_m1_192000_120000 0 3.542925e-07
I4706 n1_m1_192000_124800 0 2.398354e-07
I4707 n1_m1_192000_129600 0 3.625009e-07
I4708 n1_m1_192000_134400 0 2.499203e-07
I4709 n1_m1_192000_139200 0 2.610827e-07
I4710 n1_m1_192000_144000 0 3.987559e-07
I4711 n1_m1_192000_148800 0 2.726799e-07
I4712 n1_m1_192000_153600 0 6.102801e-07
I4713 n1_m1_192000_158400 0 4.272598e-07
I4714 n1_m1_192000_163200 0 3.040974e-07
I4715 n1_m1_192000_168000 0 4.210189e-07
I4716 n1_m1_192000_172800 0 3.013483e-07
I4717 n1_m1_192000_177600 0 3.698339e-07
I4718 n1_m1_192000_182400 0 2.398354e-07
I4719 n1_m1_192000_187200 0 2.351243e-07
I4720 n1_m1_192000_192000 0 3.447634e-07
I4721 n1_m1_192000_196800 0 2.298422e-07
I4722 n1_m1_192000_201600 0 3.447634e-07
I4723 n1_m1_192000_206400 0 2.311985e-07
I4724 n1_m1_192000_211200 0 2.384792e-07
I4725 n1_m1_192000_216000 0 3.597531e-07
I4726 n1_m1_192000_220800 0 2.398354e-07
I4727 n1_m1_192000_225600 0 3.597531e-07
I4728 n1_m1_192000_230400 0 2.369680e-07
I4729 n1_m1_192000_235200 0 2.343052e-07
I4730 n1_m1_192000_240000 0 3.564482e-07
I4731 n1_m1_192000_244800 0 2.512418e-07
I4732 n1_m1_192000_249600 0 3.822676e-07
I4733 n1_m1_192000_254400 0 2.507198e-07
I4734 n1_m1_192000_259200 0 2.530692e-07
I4735 n1_m1_192000_264000 0 3.792968e-07
I4736 n1_m1_192000_268800 0 2.496198e-07
I4737 n1_m1_192000_273600 0 3.743859e-07
I4738 n1_m1_192000_278400 0 2.477823e-07
I4739 n1_m1_192000_283200 0 2.476695e-07
I4740 n1_m1_192000_288000 0 3.751694e-07
I4741 n1_m1_192000_292800 0 2.568951e-07
I4742 n1_m1_192000_297600 0 3.897325e-07
I4743 n1_m1_192000_302400 0 2.598217e-07
I4744 n1_m1_192000_307200 0 2.598217e-07
I4745 n1_m1_192000_312000 0 3.944082e-07
I4746 n1_m1_192000_316800 0 2.719375e-07
I4747 n1_m1_192000_321600 0 3.772747e-07
I4748 n1_m1_192000_326400 0 2.497429e-07
I4749 n1_m1_192000_331200 0 2.563349e-07
I4750 n1_m1_192000_336000 0 3.767812e-07
I4751 n1_m1_192000_340800 0 2.417742e-07
I4752 n1_m1_192000_345600 0 3.616970e-07
I4753 n1_m1_192000_350400 0 2.406389e-07
I4754 n1_m1_192000_355200 0 2.446916e-07
I4755 n1_m1_192000_360000 0 3.734797e-07
I4756 n1_m1_192000_364800 0 2.484985e-07
I4757 n1_m1_192000_369600 0 3.663367e-07
I4758 n1_m1_192000_374400 0 2.421155e-07
I4759 n1_m1_192000_379200 0 2.398354e-07
I4760 n1_m1_192000_384000 0 3.597531e-07
I4761 n1_m1_192000_388800 0 2.462595e-07
I4762 n1_m1_192000_393600 0 3.742459e-07
I4763 n1_m1_192000_398400 0 2.471351e-07
I4764 n1_m1_192000_403200 0 2.543050e-07
I4765 n1_m1_192000_408000 0 4.003953e-07
I4766 n1_m1_192000_412800 0 2.631313e-07
I4767 n1_m1_192000_417600 0 3.756493e-07
I4768 n1_m1_192000_422400 0 2.485539e-07
I4769 n1_m1_192000_427200 0 2.520365e-07
I4770 n1_m1_192000_432000 0 4.675026e-07
I4771 n1_m1_192000_436800 0 4.713330e-07
I4772 n1_m1_192000_441600 0 5.702545e-07
I4773 n1_m1_192000_446400 0 2.680833e-07
I4774 n1_m1_192000_451200 0 2.636439e-07
I4775 n1_m1_192000_456000 0 3.950540e-07
I4776 n1_m1_192000_460800 0 2.598859e-07
I4777 n1_m1_192000_465600 0 3.897070e-07
I4778 n1_m1_192000_470400 0 2.543887e-07
I4779 n1_m1_192000_475200 0 2.439659e-07
I4780 n1_m1_192000_480000 0 3.730548e-07
I4781 n1_m1_192000_484800 0 2.595837e-07
I4782 n1_m1_192000_489600 0 3.698431e-07
I4783 n1_m1_192000_494400 0 2.403775e-07
I4784 n1_m1_192000_499200 0 2.476158e-07
I4785 n1_m1_192000_504000 0 3.747428e-07
I4786 n1_m1_192000_508800 0 2.497928e-07
I4787 n1_m1_192000_513600 0 3.700946e-07
I4788 n1_m1_192000_518400 0 2.398354e-07
I4789 n1_m1_192000_523200 0 2.398354e-07
I4790 n1_m1_192000_528000 0 3.597531e-07
I4791 n1_m1_192000_532800 0 2.398354e-07
I4792 n1_m1_192000_537600 0 3.632650e-07
I4793 n1_m1_192000_542400 0 2.391651e-07
I4794 n1_m1_192000_547200 0 2.380271e-07
I4795 n1_m1_192000_552000 0 3.581494e-07
I4796 n1_m1_192000_556800 0 2.364404e-07
I4797 n1_m1_196800_0 0 1.532282e-07
I4798 n1_m1_196800_4800 0 1.532282e-07
I4799 n1_m1_196800_9600 0 2.298422e-07
I4800 n1_m1_196800_14400 0 1.532282e-07
I4801 n1_m1_196800_19200 0 1.532282e-07
I4802 n1_m1_196800_24000 0 2.268919e-07
I4803 n1_m1_196800_28800 0 1.465661e-07
I4804 n1_m1_196800_33600 0 2.210626e-07
I4805 n1_m1_196800_38400 0 1.481840e-07
I4806 n1_m1_196800_43200 0 1.481840e-07
I4807 n1_m1_196800_48000 0 2.222760e-07
I4808 n1_m1_196800_52800 0 1.481840e-07
I4809 n1_m1_196800_57600 0 2.222760e-07
I4810 n1_m1_196800_62400 0 1.481840e-07
I4811 n1_m1_196800_67200 0 1.488686e-07
I4812 n1_m1_196800_72000 0 2.291577e-07
I4813 n1_m1_196800_76800 0 1.532282e-07
I4814 n1_m1_196800_81600 0 2.298422e-07
I4815 n1_m1_196800_86400 0 1.532282e-07
I4816 n1_m1_196800_91200 0 1.532282e-07
I4817 n1_m1_196800_96000 0 2.298422e-07
I4818 n1_m1_196800_100800 0 1.532282e-07
I4819 n1_m1_196800_105600 0 2.312223e-07
I4820 n1_m1_196800_110400 0 1.594620e-07
I4821 n1_m1_196800_115200 0 1.596938e-07
I4822 n1_m1_196800_120000 0 2.382752e-07
I4823 n1_m1_196800_124800 0 1.598903e-07
I4824 n1_m1_196800_129600 0 2.398354e-07
I4825 n1_m1_196800_134400 0 1.667468e-07
I4826 n1_m1_196800_139200 0 1.724055e-07
I4827 n1_m1_196800_144000 0 2.599026e-07
I4828 n1_m1_196800_148800 0 1.746604e-07
I4829 n1_m1_196800_153600 0 2.925686e-07
I4830 n1_m1_196800_158400 0 1.931069e-07
I4831 n1_m1_196800_163200 0 1.768460e-07
I4832 n1_m1_196800_168000 0 2.625130e-07
I4833 n1_m1_196800_172800 0 1.831940e-07
I4834 n1_m1_196800_177600 0 2.460352e-07
I4835 n1_m1_196800_182400 0 1.598903e-07
I4836 n1_m1_196800_187200 0 1.567496e-07
I4837 n1_m1_196800_192000 0 2.298422e-07
I4838 n1_m1_196800_196800 0 1.532282e-07
I4839 n1_m1_196800_201600 0 2.298422e-07
I4840 n1_m1_196800_206400 0 1.541323e-07
I4841 n1_m1_196800_211200 0 1.589861e-07
I4842 n1_m1_196800_216000 0 2.398354e-07
I4843 n1_m1_196800_220800 0 1.598903e-07
I4844 n1_m1_196800_225600 0 2.398354e-07
I4845 n1_m1_196800_230400 0 1.617013e-07
I4846 n1_m1_196800_235200 0 1.610826e-07
I4847 n1_m1_196800_240000 0 2.389727e-07
I4848 n1_m1_196800_244800 0 1.659229e-07
I4849 n1_m1_196800_249600 0 2.511609e-07
I4850 n1_m1_196800_254400 0 1.622220e-07
I4851 n1_m1_196800_259200 0 1.615082e-07
I4852 n1_m1_196800_264000 0 2.422623e-07
I4853 n1_m1_196800_268800 0 1.615082e-07
I4854 n1_m1_196800_273600 0 2.422623e-07
I4855 n1_m1_196800_278400 0 1.665524e-07
I4856 n1_m1_196800_283200 0 1.715965e-07
I4857 n1_m1_196800_288000 0 2.574063e-07
I4858 n1_m1_196800_292800 0 1.727291e-07
I4859 n1_m1_196800_297600 0 2.598217e-07
I4860 n1_m1_196800_302400 0 1.732144e-07
I4861 n1_m1_196800_307200 0 1.732144e-07
I4862 n1_m1_196800_312000 0 2.625083e-07
I4863 n1_m1_196800_316800 0 1.805149e-07
I4864 n1_m1_196800_321600 0 2.572336e-07
I4865 n1_m1_196800_326400 0 1.715041e-07
I4866 n1_m1_196800_331200 0 1.738385e-07
I4867 n1_m1_196800_336000 0 2.556837e-07
I4868 n1_m1_196800_340800 0 1.620792e-07
I4869 n1_m1_196800_345600 0 2.509563e-07
I4870 n1_m1_196800_350400 0 1.616292e-07
I4871 n1_m1_196800_355200 0 1.612193e-07
I4872 n1_m1_196800_360000 0 2.422623e-07
I4873 n1_m1_196800_364800 0 1.611962e-07
I4874 n1_m1_196800_369600 0 2.399625e-07
I4875 n1_m1_196800_374400 0 1.598903e-07
I4876 n1_m1_196800_379200 0 1.598903e-07
I4877 n1_m1_196800_384000 0 2.398354e-07
I4878 n1_m1_196800_388800 0 1.641730e-07
I4879 n1_m1_196800_393600 0 2.498285e-07
I4880 n1_m1_196800_398400 0 1.670758e-07
I4881 n1_m1_196800_403200 0 1.721675e-07
I4882 n1_m1_196800_408000 0 2.681969e-07
I4883 n1_m1_196800_412800 0 1.783980e-07
I4884 n1_m1_196800_417600 0 2.548326e-07
I4885 n1_m1_196800_422400 0 1.712036e-07
I4886 n1_m1_196800_427200 0 2.242216e-07
I4887 n1_m1_196800_432000 0 6.837409e-07
I4888 n1_m1_196800_436800 0 7.282852e-07
I4889 n1_m1_196800_441600 0 8.691565e-07
I4890 n1_m1_196800_446400 0 2.941029e-07
I4891 n1_m1_196800_451200 0 2.099899e-07
I4892 n1_m1_196800_456000 0 2.604702e-07
I4893 n1_m1_196800_460800 0 1.689990e-07
I4894 n1_m1_196800_465600 0 2.592812e-07
I4895 n1_m1_196800_470400 0 1.706448e-07
I4896 n1_m1_196800_475200 0 1.645537e-07
I4897 n1_m1_196800_480000 0 2.454424e-07
I4898 n1_m1_196800_484800 0 1.681703e-07
I4899 n1_m1_196800_489600 0 2.485512e-07
I4900 n1_m1_196800_494400 0 1.611241e-07
I4901 n1_m1_196800_499200 0 1.650772e-07
I4902 n1_m1_196800_504000 0 2.498285e-07
I4903 n1_m1_196800_508800 0 1.657957e-07
I4904 n1_m1_196800_513600 0 2.421583e-07
I4905 n1_m1_196800_518400 0 1.598903e-07
I4906 n1_m1_196800_523200 0 1.598903e-07
I4907 n1_m1_196800_528000 0 2.398354e-07
I4908 n1_m1_196800_532800 0 1.598903e-07
I4909 n1_m1_196800_537600 0 2.393119e-07
I4910 n1_m1_196800_542400 0 1.545130e-07
I4911 n1_m1_196800_547200 0 1.532282e-07
I4912 n1_m1_196800_552000 0 2.317375e-07
I4913 n1_m1_196800_556800 0 1.548461e-07
I4914 n1_m1_201600_0 0 1.532282e-07
I4915 n1_m1_201600_4800 0 1.532282e-07
I4916 n1_m1_201600_9600 0 2.298422e-07
I4917 n1_m1_201600_14400 0 1.532282e-07
I4918 n1_m1_201600_19200 0 1.532282e-07
I4919 n1_m1_201600_24000 0 2.268919e-07
I4920 n1_m1_201600_28800 0 1.465661e-07
I4921 n1_m1_201600_33600 0 2.198491e-07
I4922 n1_m1_201600_38400 0 1.465661e-07
I4923 n1_m1_201600_43200 0 1.465661e-07
I4924 n1_m1_201600_48000 0 2.198491e-07
I4925 n1_m1_201600_52800 0 1.465661e-07
I4926 n1_m1_201600_57600 0 2.198491e-07
I4927 n1_m1_201600_62400 0 1.467785e-07
I4928 n1_m1_201600_67200 0 1.483879e-07
I4929 n1_m1_201600_72000 0 2.290996e-07
I4930 n1_m1_201600_76800 0 1.532282e-07
I4931 n1_m1_201600_81600 0 2.298422e-07
I4932 n1_m1_201600_86400 0 1.532282e-07
I4933 n1_m1_201600_91200 0 1.532282e-07
I4934 n1_m1_201600_96000 0 2.298422e-07
I4935 n1_m1_201600_100800 0 1.532282e-07
I4936 n1_m1_201600_105600 0 2.299112e-07
I4937 n1_m1_201600_110400 0 1.545796e-07
I4938 n1_m1_201600_115200 0 1.592122e-07
I4939 n1_m1_201600_120000 0 2.402943e-07
I4940 n1_m1_201600_124800 0 1.629786e-07
I4941 n1_m1_201600_129600 0 2.619634e-07
I4942 n1_m1_201600_134400 0 1.933075e-07
I4943 n1_m1_201600_139200 0 2.551344e-07
I4944 n1_m1_201600_144000 0 3.854973e-07
I4945 n1_m1_201600_148800 0 1.848255e-07
I4946 n1_m1_201600_153600 0 2.560773e-07
I4947 n1_m1_201600_158400 0 1.923850e-07
I4948 n1_m1_201600_163200 0 2.347260e-07
I4949 n1_m1_201600_168000 0 3.324861e-07
I4950 n1_m1_201600_172800 0 1.801192e-07
I4951 n1_m1_201600_177600 0 2.476943e-07
I4952 n1_m1_201600_182400 0 1.597543e-07
I4953 n1_m1_201600_187200 0 1.561207e-07
I4954 n1_m1_201600_192000 0 2.298422e-07
I4955 n1_m1_201600_196800 0 1.532282e-07
I4956 n1_m1_201600_201600 0 2.298422e-07
I4957 n1_m1_201600_206400 0 1.532734e-07
I4958 n1_m1_201600_211200 0 1.535161e-07
I4959 n1_m1_201600_216000 0 2.320305e-07
I4960 n1_m1_201600_220800 0 1.589895e-07
I4961 n1_m1_201600_225600 0 2.436807e-07
I4962 n1_m1_201600_230400 0 1.670241e-07
I4963 n1_m1_201600_235200 0 1.675945e-07
I4964 n1_m1_201600_240000 0 2.501263e-07
I4965 n1_m1_201600_244800 0 1.673287e-07
I4966 n1_m1_201600_249600 0 2.491589e-07
I4967 n1_m1_201600_254400 0 1.606041e-07
I4968 n1_m1_201600_259200 0 1.594865e-07
I4969 n1_m1_201600_264000 0 2.331175e-07
I4970 n1_m1_201600_268800 0 1.561523e-07
I4971 n1_m1_201600_273600 0 2.420002e-07
I4972 n1_m1_201600_278400 0 1.671472e-07
I4973 n1_m1_201600_283200 0 1.725176e-07
I4974 n1_m1_201600_288000 0 2.598302e-07
I4975 n1_m1_201600_292800 0 1.740472e-07
I4976 n1_m1_201600_297600 0 2.732533e-07
I4977 n1_m1_201600_302400 0 2.045073e-07
I4978 n1_m1_201600_307200 0 2.328616e-07
I4979 n1_m1_201600_312000 0 4.228761e-07
I4980 n1_m1_201600_316800 0 4.132055e-07
I4981 n1_m1_201600_321600 0 9.614289e-07
I4982 n1_m1_201600_326400 0 4.782004e-07
I4983 n1_m1_201600_331200 0 2.303528e-07
I4984 n1_m1_201600_336000 0 2.432983e-07
I4985 n1_m1_201600_340800 0 1.666285e-07
I4986 n1_m1_201600_345600 0 2.442375e-07
I4987 n1_m1_201600_350400 0 1.610089e-07
I4988 n1_m1_201600_355200 0 1.610204e-07
I4989 n1_m1_201600_360000 0 2.400988e-07
I4990 n1_m1_201600_364800 0 1.603491e-07
I4991 n1_m1_201600_369600 0 2.471916e-07
I4992 n1_m1_201600_374400 0 1.762790e-07
I4993 n1_m1_201600_379200 0 1.901042e-07
I4994 n1_m1_201600_384000 0 2.710283e-07
I4995 n1_m1_201600_388800 0 1.645979e-07
I4996 n1_m1_201600_393600 0 2.498285e-07
I4997 n1_m1_201600_398400 0 1.670758e-07
I4998 n1_m1_201600_403200 0 1.723936e-07
I4999 n1_m1_201600_408000 0 2.750153e-07
I5000 n1_m1_201600_412800 0 1.812637e-07
I5001 n1_m1_201600_417600 0 2.806716e-07
I5002 n1_m1_201600_422400 0 3.615716e-07
I5003 n1_m1_201600_427200 0 7.213811e-07
I5004 n1_m1_201600_432000 0 1.666097e-06
I5005 n1_m1_201600_436800 0 1.251974e-06
I5006 n1_m1_201600_441600 0 1.354623e-06
I5007 n1_m1_201600_446400 0 4.022770e-07
I5008 n1_m1_201600_451200 0 2.467028e-07
I5009 n1_m1_201600_456000 0 2.724395e-07
I5010 n1_m1_201600_460800 0 1.691669e-07
I5011 n1_m1_201600_465600 0 2.614532e-07
I5012 n1_m1_201600_470400 0 1.754653e-07
I5013 n1_m1_201600_475200 0 1.751607e-07
I5014 n1_m1_201600_480000 0 2.583679e-07
I5015 n1_m1_201600_484800 0 1.689317e-07
I5016 n1_m1_201600_489600 0 2.520664e-07
I5017 n1_m1_201600_494400 0 1.661914e-07
I5018 n1_m1_201600_499200 0 1.615510e-07
I5019 n1_m1_201600_504000 0 2.403350e-07
I5020 n1_m1_201600_508800 0 1.601734e-07
I5021 n1_m1_201600_513600 0 2.398758e-07
I5022 n1_m1_201600_518400 0 1.598903e-07
I5023 n1_m1_201600_523200 0 1.598903e-07
I5024 n1_m1_201600_528000 0 2.413649e-07
I5025 n1_m1_201600_532800 0 1.693219e-07
I5026 n1_m1_201600_537600 0 2.579376e-07
I5027 n1_m1_201600_542400 0 1.643719e-07
I5028 n1_m1_201600_547200 0 1.574334e-07
I5029 n1_m1_201600_552000 0 2.318052e-07
I5030 n1_m1_201600_556800 0 1.535001e-07
I5031 n1_m1_206400_0 0 1.525307e-07
I5032 n1_m1_206400_4800 0 1.530667e-07
I5033 n1_m1_206400_9600 0 2.298422e-07
I5034 n1_m1_206400_14400 0 1.532282e-07
I5035 n1_m1_206400_19200 0 1.532282e-07
I5036 n1_m1_206400_24000 0 2.272923e-07
I5037 n1_m1_206400_28800 0 1.471473e-07
I5038 n1_m1_206400_33600 0 2.198491e-07
I5039 n1_m1_206400_38400 0 1.465661e-07
I5040 n1_m1_206400_43200 0 1.465661e-07
I5041 n1_m1_206400_48000 0 2.199201e-07
I5042 n1_m1_206400_52800 0 1.472958e-07
I5043 n1_m1_206400_57600 0 2.212053e-07
I5044 n1_m1_206400_62400 0 1.483879e-07
I5045 n1_m1_206400_67200 0 1.522163e-07
I5046 n1_m1_206400_72000 0 2.301329e-07
I5047 n1_m1_206400_76800 0 1.541323e-07
I5048 n1_m1_206400_81600 0 2.305591e-07
I5049 n1_m1_206400_86400 0 1.532282e-07
I5050 n1_m1_206400_91200 0 1.532282e-07
I5051 n1_m1_206400_96000 0 2.307528e-07
I5052 n1_m1_206400_100800 0 1.548104e-07
I5053 n1_m1_206400_105600 0 2.303331e-07
I5054 n1_m1_206400_110400 0 1.544712e-07
I5055 n1_m1_206400_115200 0 1.602033e-07
I5056 n1_m1_206400_120000 0 2.456151e-07
I5057 n1_m1_206400_124800 0 1.694694e-07
I5058 n1_m1_206400_129600 0 2.789001e-07
I5059 n1_m1_206400_134400 0 2.351468e-07
I5060 n1_m1_206400_139200 0 3.131422e-07
I5061 n1_m1_206400_144000 0 4.471988e-07
I5062 n1_m1_206400_148800 0 1.921307e-07
I5063 n1_m1_206400_153600 0 2.767019e-07
I5064 n1_m1_206400_158400 0 2.719212e-07
I5065 n1_m1_206400_163200 0 4.396000e-07
I5066 n1_m1_206400_168000 0 6.213293e-07
I5067 n1_m1_206400_172800 0 2.395866e-07
I5068 n1_m1_206400_177600 0 2.588264e-07
I5069 n1_m1_206400_182400 0 1.591996e-07
I5070 n1_m1_206400_187200 0 1.535552e-07
I5071 n1_m1_206400_192000 0 2.298422e-07
I5072 n1_m1_206400_196800 0 1.532282e-07
I5073 n1_m1_206400_201600 0 2.298422e-07
I5074 n1_m1_206400_206400 0 1.532282e-07
I5075 n1_m1_206400_211200 0 1.532282e-07
I5076 n1_m1_206400_216000 0 2.303426e-07
I5077 n1_m1_206400_220800 0 1.564382e-07
I5078 n1_m1_206400_225600 0 2.463921e-07
I5079 n1_m1_206400_230400 0 1.715550e-07
I5080 n1_m1_206400_235200 0 1.744041e-07
I5081 n1_m1_206400_240000 0 2.565555e-07
I5082 n1_m1_206400_244800 0 1.727637e-07
I5083 n1_m1_206400_249600 0 2.525715e-07
I5084 n1_m1_206400_254400 0 1.613984e-07
I5085 n1_m1_206400_259200 0 1.599773e-07
I5086 n1_m1_206400_264000 0 2.395692e-07
I5087 n1_m1_206400_268800 0 1.629426e-07
I5088 n1_m1_206400_273600 0 2.616782e-07
I5089 n1_m1_206400_278400 0 1.759031e-07
I5090 n1_m1_206400_283200 0 1.714830e-07
I5091 n1_m1_206400_288000 0 2.625773e-07
I5092 n1_m1_206400_292800 0 1.792532e-07
I5093 n1_m1_206400_297600 0 2.996066e-07
I5094 n1_m1_206400_302400 0 2.737743e-07
I5095 n1_m1_206400_307200 0 3.472946e-07
I5096 n1_m1_206400_312000 0 6.547921e-07
I5097 n1_m1_206400_316800 0 6.680272e-07
I5098 n1_m1_206400_321600 0 1.480917e-06
I5099 n1_m1_206400_326400 0 7.496807e-07
I5100 n1_m1_206400_331200 0 3.450047e-07
I5101 n1_m1_206400_336000 0 2.536147e-07
I5102 n1_m1_206400_340800 0 1.749391e-07
I5103 n1_m1_206400_345600 0 2.486555e-07
I5104 n1_m1_206400_350400 0 1.660177e-07
I5105 n1_m1_206400_355200 0 1.665357e-07
I5106 n1_m1_206400_360000 0 2.423102e-07
I5107 n1_m1_206400_364800 0 1.620792e-07
I5108 n1_m1_206400_369600 0 2.619688e-07
I5109 n1_m1_206400_374400 0 2.021572e-07
I5110 n1_m1_206400_379200 0 2.434791e-07
I5111 n1_m1_206400_384000 0 3.307730e-07
I5112 n1_m1_206400_388800 0 1.666543e-07
I5113 n1_m1_206400_393600 0 2.499383e-07
I5114 n1_m1_206400_398400 0 1.677733e-07
I5115 n1_m1_206400_403200 0 1.725476e-07
I5116 n1_m1_206400_408000 0 2.752985e-07
I5117 n1_m1_206400_412800 0 1.850468e-07
I5118 n1_m1_206400_417600 0 3.086691e-07
I5119 n1_m1_206400_422400 0 5.368315e-07
I5120 n1_m1_206400_427200 0 1.083237e-06
I5121 n1_m1_206400_432000 0 2.057004e-06
I5122 n1_m1_206400_436800 0 1.367283e-06
I5123 n1_m1_206400_441600 0 1.360138e-06
I5124 n1_m1_206400_446400 0 3.257713e-07
I5125 n1_m1_206400_451200 0 2.397980e-07
I5126 n1_m1_206400_456000 0 2.801336e-07
I5127 n1_m1_206400_460800 0 1.743953e-07
I5128 n1_m1_206400_465600 0 2.707122e-07
I5129 n1_m1_206400_470400 0 1.851593e-07
I5130 n1_m1_206400_475200 0 1.832219e-07
I5131 n1_m1_206400_480000 0 2.718450e-07
I5132 n1_m1_206400_484800 0 1.790139e-07
I5133 n1_m1_206400_489600 0 2.623424e-07
I5134 n1_m1_206400_494400 0 1.689453e-07
I5135 n1_m1_206400_499200 0 1.631608e-07
I5136 n1_m1_206400_504000 0 2.403779e-07
I5137 n1_m1_206400_508800 0 1.598903e-07
I5138 n1_m1_206400_513600 0 2.398354e-07
I5139 n1_m1_206400_518400 0 1.598903e-07
I5140 n1_m1_206400_523200 0 1.598903e-07
I5141 n1_m1_206400_528000 0 2.481868e-07
I5142 n1_m1_206400_532800 0 1.848384e-07
I5143 n1_m1_206400_537600 0 2.987307e-07
I5144 n1_m1_206400_542400 0 1.866756e-07
I5145 n1_m1_206400_547200 0 1.704028e-07
I5146 n1_m1_206400_552000 0 2.392134e-07
I5147 n1_m1_206400_556800 0 1.544029e-07
I5148 n1_m1_211200_0 0 1.487863e-07
I5149 n1_m1_211200_4800 0 1.522000e-07
I5150 n1_m1_211200_9600 0 2.298422e-07
I5151 n1_m1_211200_14400 0 1.532282e-07
I5152 n1_m1_211200_19200 0 1.532282e-07
I5153 n1_m1_211200_24000 0 2.294418e-07
I5154 n1_m1_211200_28800 0 1.502676e-07
I5155 n1_m1_211200_33600 0 2.198491e-07
I5156 n1_m1_211200_38400 0 1.465661e-07
I5157 n1_m1_211200_43200 0 1.465661e-07
I5158 n1_m1_211200_48000 0 2.203015e-07
I5159 n1_m1_211200_52800 0 1.512136e-07
I5160 n1_m1_211200_57600 0 2.284860e-07
I5161 n1_m1_211200_62400 0 1.524855e-07
I5162 n1_m1_211200_67200 0 1.532282e-07
I5163 n1_m1_211200_72000 0 2.328154e-07
I5164 n1_m1_211200_76800 0 1.587829e-07
I5165 n1_m1_211200_81600 0 2.339170e-07
I5166 n1_m1_211200_86400 0 1.532282e-07
I5167 n1_m1_211200_91200 0 1.532282e-07
I5168 n1_m1_211200_96000 0 2.356016e-07
I5169 n1_m1_211200_100800 0 1.628539e-07
I5170 n1_m1_211200_105600 0 2.341920e-07
I5171 n1_m1_211200_110400 0 1.557237e-07
I5172 n1_m1_211200_115200 0 1.651547e-07
I5173 n1_m1_211200_120000 0 2.628431e-07
I5174 n1_m1_211200_124800 0 1.779065e-07
I5175 n1_m1_211200_129600 0 2.753491e-07
I5176 n1_m1_211200_134400 0 2.330380e-07
I5177 n1_m1_211200_139200 0 2.710521e-07
I5178 n1_m1_211200_144000 0 3.844049e-07
I5179 n1_m1_211200_148800 0 1.945936e-07
I5180 n1_m1_211200_153600 0 3.589863e-07
I5181 n1_m1_211200_158400 0 3.225949e-07
I5182 n1_m1_211200_163200 0 4.372733e-07
I5183 n1_m1_211200_168000 0 7.238630e-07
I5184 n1_m1_211200_172800 0 2.717312e-07
I5185 n1_m1_211200_177600 0 2.717104e-07
I5186 n1_m1_211200_182400 0 1.594735e-07
I5187 n1_m1_211200_187200 0 1.541384e-07
I5188 n1_m1_211200_192000 0 2.316539e-07
I5189 n1_m1_211200_196800 0 1.535286e-07
I5190 n1_m1_211200_201600 0 2.298422e-07
I5191 n1_m1_211200_206400 0 1.532282e-07
I5192 n1_m1_211200_211200 0 1.532282e-07
I5193 n1_m1_211200_216000 0 2.315309e-07
I5194 n1_m1_211200_220800 0 1.615340e-07
I5195 n1_m1_211200_225600 0 2.622561e-07
I5196 n1_m1_211200_230400 0 1.843911e-07
I5197 n1_m1_211200_235200 0 1.861797e-07
I5198 n1_m1_211200_240000 0 2.700830e-07
I5199 n1_m1_211200_244800 0 1.821355e-07
I5200 n1_m1_211200_249600 0 2.614841e-07
I5201 n1_m1_211200_254400 0 1.651856e-07
I5202 n1_m1_211200_259200 0 1.606612e-07
I5203 n1_m1_211200_264000 0 2.432902e-07
I5204 n1_m1_211200_268800 0 1.752121e-07
I5205 n1_m1_211200_273600 0 3.112785e-07
I5206 n1_m1_211200_278400 0 2.157567e-07
I5207 n1_m1_211200_283200 0 1.960376e-07
I5208 n1_m1_211200_288000 0 2.983619e-07
I5209 n1_m1_211200_292800 0 2.004053e-07
I5210 n1_m1_211200_297600 0 3.300561e-07
I5211 n1_m1_211200_302400 0 2.660837e-07
I5212 n1_m1_211200_307200 0 3.191225e-07
I5213 n1_m1_211200_312000 0 5.130363e-07
I5214 n1_m1_211200_316800 0 2.667693e-07
I5215 n1_m1_211200_321600 0 4.887870e-07
I5216 n1_m1_211200_326400 0 2.890615e-07
I5217 n1_m1_211200_331200 0 2.091714e-07
I5218 n1_m1_211200_336000 0 2.546171e-07
I5219 n1_m1_211200_340800 0 1.680636e-07
I5220 n1_m1_211200_345600 0 2.504162e-07
I5221 n1_m1_211200_350400 0 1.708715e-07
I5222 n1_m1_211200_355200 0 1.713895e-07
I5223 n1_m1_211200_360000 0 2.485624e-07
I5224 n1_m1_211200_364800 0 1.620323e-07
I5225 n1_m1_211200_369600 0 2.546382e-07
I5226 n1_m1_211200_374400 0 1.827780e-07
I5227 n1_m1_211200_379200 0 1.972762e-07
I5228 n1_m1_211200_384000 0 2.831271e-07
I5229 n1_m1_211200_388800 0 1.683878e-07
I5230 n1_m1_211200_393600 0 2.504526e-07
I5231 n1_m1_211200_398400 0 1.710404e-07
I5232 n1_m1_211200_403200 0 1.731689e-07
I5233 n1_m1_211200_408000 0 2.685558e-07
I5234 n1_m1_211200_412800 0 1.801621e-07
I5235 n1_m1_211200_417600 0 2.765959e-07
I5236 n1_m1_211200_422400 0 3.631011e-07
I5237 n1_m1_211200_427200 0 7.967966e-07
I5238 n1_m1_211200_432000 0 1.871005e-06
I5239 n1_m1_211200_436800 0 1.364322e-06
I5240 n1_m1_211200_441600 0 1.375517e-06
I5241 n1_m1_211200_446400 0 2.768613e-07
I5242 n1_m1_211200_451200 0 1.915182e-07
I5243 n1_m1_211200_456000 0 2.791438e-07
I5244 n1_m1_211200_460800 0 1.785849e-07
I5245 n1_m1_211200_465600 0 2.696843e-07
I5246 n1_m1_211200_470400 0 1.846352e-07
I5247 n1_m1_211200_475200 0 1.728623e-07
I5248 n1_m1_211200_480000 0 2.645096e-07
I5249 n1_m1_211200_484800 0 1.820057e-07
I5250 n1_m1_211200_489600 0 2.682081e-07
I5251 n1_m1_211200_494400 0 1.772780e-07
I5252 n1_m1_211200_499200 0 1.721893e-07
I5253 n1_m1_211200_504000 0 2.438469e-07
I5254 n1_m1_211200_508800 0 1.605089e-07
I5255 n1_m1_211200_513600 0 2.407633e-07
I5256 n1_m1_211200_518400 0 1.605089e-07
I5257 n1_m1_211200_523200 0 1.603410e-07
I5258 n1_m1_211200_528000 0 2.513204e-07
I5259 n1_m1_211200_532800 0 2.109287e-07
I5260 n1_m1_211200_537600 0 3.781829e-07
I5261 n1_m1_211200_542400 0 2.196985e-07
I5262 n1_m1_211200_547200 0 1.811682e-07
I5263 n1_m1_211200_552000 0 2.375312e-07
I5264 n1_m1_211200_556800 0 1.540534e-07
I5265 n1_m1_216000_0 0 2.221333e-07
I5266 n1_m1_216000_4800 0 2.280578e-07
I5267 n1_m1_216000_9600 0 3.447634e-07
I5268 n1_m1_216000_14400 0 2.298422e-07
I5269 n1_m1_216000_19200 0 2.298422e-07
I5270 n1_m1_216000_24000 0 3.447634e-07
I5271 n1_m1_216000_28800 0 2.262733e-07
I5272 n1_m1_216000_33600 0 3.314154e-07
I5273 n1_m1_216000_38400 0 2.206309e-07
I5274 n1_m1_216000_43200 0 2.198491e-07
I5275 n1_m1_216000_48000 0 3.305588e-07
I5276 n1_m1_216000_52800 0 2.279150e-07
I5277 n1_m1_216000_57600 0 3.447634e-07
I5278 n1_m1_216000_62400 0 2.298422e-07
I5279 n1_m1_216000_67200 0 2.310370e-07
I5280 n1_m1_216000_72000 0 3.563598e-07
I5281 n1_m1_216000_76800 0 2.354731e-07
I5282 n1_m1_216000_81600 0 3.457066e-07
I5283 n1_m1_216000_86400 0 2.311869e-07
I5284 n1_m1_216000_91200 0 2.320312e-07
I5285 n1_m1_216000_96000 0 3.534176e-07
I5286 n1_m1_216000_100800 0 2.388211e-07
I5287 n1_m1_216000_105600 0 3.692483e-07
I5288 n1_m1_216000_110400 0 2.397433e-07
I5289 n1_m1_216000_115200 0 2.421280e-07
I5290 n1_m1_216000_120000 0 3.800300e-07
I5291 n1_m1_216000_124800 0 2.629957e-07
I5292 n1_m1_216000_129600 0 4.095709e-07
I5293 n1_m1_216000_134400 0 3.255738e-07
I5294 n1_m1_216000_139200 0 3.414085e-07
I5295 n1_m1_216000_144000 0 5.231314e-07
I5296 n1_m1_216000_148800 0 3.332233e-07
I5297 n1_m1_216000_153600 0 7.937103e-07
I5298 n1_m1_216000_158400 0 6.964020e-07
I5299 n1_m1_216000_163200 0 7.435206e-07
I5300 n1_m1_216000_168000 0 1.062791e-06
I5301 n1_m1_216000_172800 0 3.642038e-07
I5302 n1_m1_216000_177600 0 3.948076e-07
I5303 n1_m1_216000_182400 0 2.448177e-07
I5304 n1_m1_216000_187200 0 2.439530e-07
I5305 n1_m1_216000_192000 0 3.686844e-07
I5306 n1_m1_216000_196800 0 2.335866e-07
I5307 n1_m1_216000_201600 0 3.481094e-07
I5308 n1_m1_216000_206400 0 2.360026e-07
I5309 n1_m1_216000_211200 0 2.360026e-07
I5310 n1_m1_216000_216000 0 3.499387e-07
I5311 n1_m1_216000_220800 0 2.429333e-07
I5312 n1_m1_216000_225600 0 4.665862e-07
I5313 n1_m1_216000_230400 0 3.929854e-07
I5314 n1_m1_216000_235200 0 3.642262e-07
I5315 n1_m1_216000_240000 0 4.197395e-07
I5316 n1_m1_216000_244800 0 2.654960e-07
I5317 n1_m1_216000_249600 0 3.877145e-07
I5318 n1_m1_216000_254400 0 2.426600e-07
I5319 n1_m1_216000_259200 0 2.400138e-07
I5320 n1_m1_216000_264000 0 3.650923e-07
I5321 n1_m1_216000_268800 0 2.617098e-07
I5322 n1_m1_216000_273600 0 4.331561e-07
I5323 n1_m1_216000_278400 0 3.733628e-07
I5324 n1_m1_216000_283200 0 4.387662e-07
I5325 n1_m1_216000_288000 0 6.535875e-07
I5326 n1_m1_216000_292800 0 4.126406e-07
I5327 n1_m1_216000_297600 0 5.634745e-07
I5328 n1_m1_216000_302400 0 3.307703e-07
I5329 n1_m1_216000_307200 0 3.131273e-07
I5330 n1_m1_216000_312000 0 4.517158e-07
I5331 n1_m1_216000_316800 0 2.623060e-07
I5332 n1_m1_216000_321600 0 3.988987e-07
I5333 n1_m1_216000_326400 0 2.675837e-07
I5334 n1_m1_216000_331200 0 2.612833e-07
I5335 n1_m1_216000_336000 0 3.835449e-07
I5336 n1_m1_216000_340800 0 2.505478e-07
I5337 n1_m1_216000_345600 0 3.749042e-07
I5338 n1_m1_216000_350400 0 2.508567e-07
I5339 n1_m1_216000_355200 0 2.510682e-07
I5340 n1_m1_216000_360000 0 3.775161e-07
I5341 n1_m1_216000_364800 0 2.510998e-07
I5342 n1_m1_216000_369600 0 3.820578e-07
I5343 n1_m1_216000_374400 0 2.599060e-07
I5344 n1_m1_216000_379200 0 2.604369e-07
I5345 n1_m1_216000_384000 0 3.841649e-07
I5346 n1_m1_216000_388800 0 2.502534e-07
I5347 n1_m1_216000_393600 0 3.748873e-07
I5348 n1_m1_216000_398400 0 2.513595e-07
I5349 n1_m1_216000_403200 0 2.563995e-07
I5350 n1_m1_216000_408000 0 3.884293e-07
I5351 n1_m1_216000_412800 0 2.609019e-07
I5352 n1_m1_216000_417600 0 4.167616e-07
I5353 n1_m1_216000_422400 0 3.492929e-07
I5354 n1_m1_216000_427200 0 5.337337e-07
I5355 n1_m1_216000_432000 0 1.390449e-06
I5356 n1_m1_216000_436800 0 1.382228e-06
I5357 n1_m1_216000_441600 0 1.486403e-06
I5358 n1_m1_216000_446400 0 3.594893e-07
I5359 n1_m1_216000_451200 0 2.678930e-07
I5360 n1_m1_216000_456000 0 4.148347e-07
I5361 n1_m1_216000_460800 0 2.659416e-07
I5362 n1_m1_216000_465600 0 3.981838e-07
I5363 n1_m1_216000_470400 0 2.640263e-07
I5364 n1_m1_216000_475200 0 2.506613e-07
I5365 n1_m1_216000_480000 0 3.874997e-07
I5366 n1_m1_216000_484800 0 2.668366e-07
I5367 n1_m1_216000_489600 0 3.917440e-07
I5368 n1_m1_216000_494400 0 2.601208e-07
I5369 n1_m1_216000_499200 0 2.531983e-07
I5370 n1_m1_216000_504000 0 3.710453e-07
I5371 n1_m1_216000_508800 0 2.464499e-07
I5372 n1_m1_216000_513600 0 3.696748e-07
I5373 n1_m1_216000_518400 0 2.464499e-07
I5374 n1_m1_216000_523200 0 2.446545e-07
I5375 n1_m1_216000_528000 0 3.664413e-07
I5376 n1_m1_216000_532800 0 2.658998e-07
I5377 n1_m1_216000_537600 0 4.285341e-07
I5378 n1_m1_216000_542400 0 2.752968e-07
I5379 n1_m1_216000_547200 0 2.545960e-07
I5380 n1_m1_216000_552000 0 3.617055e-07
I5381 n1_m1_216000_556800 0 2.403344e-07
I5382 n1_m1_220800_0 0 1.480888e-07
I5383 n1_m1_220800_4800 0 1.520385e-07
I5384 n1_m1_220800_9600 0 2.298422e-07
I5385 n1_m1_220800_14400 0 1.532282e-07
I5386 n1_m1_220800_19200 0 1.532282e-07
I5387 n1_m1_220800_24000 0 2.298422e-07
I5388 n1_m1_220800_28800 0 1.508488e-07
I5389 n1_m1_220800_33600 0 2.248457e-07
I5390 n1_m1_220800_38400 0 1.499855e-07
I5391 n1_m1_220800_43200 0 1.481840e-07
I5392 n1_m1_220800_48000 0 2.226723e-07
I5393 n1_m1_220800_52800 0 1.522554e-07
I5394 n1_m1_220800_57600 0 2.298422e-07
I5395 n1_m1_220800_62400 0 1.532282e-07
I5396 n1_m1_220800_67200 0 1.539127e-07
I5397 n1_m1_220800_72000 0 2.346342e-07
I5398 n1_m1_220800_76800 0 1.532282e-07
I5399 n1_m1_220800_81600 0 2.298422e-07
I5400 n1_m1_220800_86400 0 1.563267e-07
I5401 n1_m1_220800_91200 0 1.591275e-07
I5402 n1_m1_220800_96000 0 2.335540e-07
I5403 n1_m1_220800_100800 0 1.536218e-07
I5404 n1_m1_220800_105600 0 2.499842e-07
I5405 n1_m1_220800_110400 0 1.609086e-07
I5406 n1_m1_220800_115200 0 1.621438e-07
I5407 n1_m1_220800_120000 0 2.532017e-07
I5408 n1_m1_220800_124800 0 1.727291e-07
I5409 n1_m1_220800_129600 0 2.663526e-07
I5410 n1_m1_220800_134400 0 2.053788e-07
I5411 n1_m1_220800_139200 0 2.141863e-07
I5412 n1_m1_220800_144000 0 2.958452e-07
I5413 n1_m1_220800_148800 0 1.971701e-07
I5414 n1_m1_220800_153600 0 6.677274e-07
I5415 n1_m1_220800_158400 0 8.208414e-07
I5416 n1_m1_220800_163200 0 8.057674e-07
I5417 n1_m1_220800_168000 0 8.519126e-07
I5418 n1_m1_220800_172800 0 2.186554e-07
I5419 n1_m1_220800_177600 0 2.592547e-07
I5420 n1_m1_220800_182400 0 1.672689e-07
I5421 n1_m1_220800_187200 0 1.665524e-07
I5422 n1_m1_220800_192000 0 2.437477e-07
I5423 n1_m1_220800_196800 0 1.560711e-07
I5424 n1_m1_220800_201600 0 2.466593e-07
I5425 n1_m1_220800_206400 0 1.851981e-07
I5426 n1_m1_220800_211200 0 1.769697e-07
I5427 n1_m1_220800_216000 0 2.487259e-07
I5428 n1_m1_220800_220800 0 1.785713e-07
I5429 n1_m1_220800_225600 0 4.611841e-07
I5430 n1_m1_220800_230400 0 4.779509e-07
I5431 n1_m1_220800_235200 0 4.299063e-07
I5432 n1_m1_220800_240000 0 3.922838e-07
I5433 n1_m1_220800_244800 0 1.808704e-07
I5434 n1_m1_220800_249600 0 2.489523e-07
I5435 n1_m1_220800_254400 0 1.604307e-07
I5436 n1_m1_220800_259200 0 1.598903e-07
I5437 n1_m1_220800_264000 0 2.413486e-07
I5438 n1_m1_220800_268800 0 1.663736e-07
I5439 n1_m1_220800_273600 0 2.600161e-07
I5440 n1_m1_220800_278400 0 1.783538e-07
I5441 n1_m1_220800_283200 0 1.821566e-07
I5442 n1_m1_220800_288000 0 2.874496e-07
I5443 n1_m1_220800_292800 0 2.050117e-07
I5444 n1_m1_220800_297600 0 2.995169e-07
I5445 n1_m1_220800_302400 0 1.858480e-07
I5446 n1_m1_220800_307200 0 1.790288e-07
I5447 n1_m1_220800_312000 0 2.608665e-07
I5448 n1_m1_220800_316800 0 1.732144e-07
I5449 n1_m1_220800_321600 0 2.589202e-07
I5450 n1_m1_220800_326400 0 1.723593e-07
I5451 n1_m1_220800_331200 0 1.738385e-07
I5452 n1_m1_220800_336000 0 2.635314e-07
I5453 n1_m1_220800_340800 0 1.719772e-07
I5454 n1_m1_220800_345600 0 2.527061e-07
I5455 n1_m1_220800_350400 0 1.667719e-07
I5456 n1_m1_220800_355200 0 1.668855e-07
I5457 n1_m1_220800_360000 0 2.587394e-07
I5458 n1_m1_220800_364800 0 1.747746e-07
I5459 n1_m1_220800_369600 0 2.622486e-07
I5460 n1_m1_220800_374400 0 1.718820e-07
I5461 n1_m1_220800_379200 0 1.675925e-07
I5462 n1_m1_220800_384000 0 2.510420e-07
I5463 n1_m1_220800_388800 0 1.681703e-07
I5464 n1_m1_220800_393600 0 2.520590e-07
I5465 n1_m1_220800_398400 0 1.667950e-07
I5466 n1_m1_220800_403200 0 1.665524e-07
I5467 n1_m1_220800_408000 0 2.513037e-07
I5468 n1_m1_220800_412800 0 1.731703e-07
I5469 n1_m1_220800_417600 0 2.957895e-07
I5470 n1_m1_220800_422400 0 2.198981e-07
I5471 n1_m1_220800_427200 0 2.223073e-07
I5472 n1_m1_220800_432000 0 4.508151e-07
I5473 n1_m1_220800_436800 0 3.727754e-07
I5474 n1_m1_220800_441600 0 4.808761e-07
I5475 n1_m1_220800_446400 0 2.603676e-07
I5476 n1_m1_220800_451200 0 2.103883e-07
I5477 n1_m1_220800_456000 0 2.687210e-07
I5478 n1_m1_220800_460800 0 1.703599e-07
I5479 n1_m1_220800_465600 0 2.670698e-07
I5480 n1_m1_220800_470400 0 1.753613e-07
I5481 n1_m1_220800_475200 0 1.681703e-07
I5482 n1_m1_220800_480000 0 2.556422e-07
I5483 n1_m1_220800_484800 0 1.683647e-07
I5484 n1_m1_220800_489600 0 2.511059e-07
I5485 n1_m1_220800_494400 0 1.719806e-07
I5486 n1_m1_220800_499200 0 1.679915e-07
I5487 n1_m1_220800_504000 0 2.434635e-07
I5488 n1_m1_220800_508800 0 1.600174e-07
I5489 n1_m1_220800_513600 0 2.398354e-07
I5490 n1_m1_220800_518400 0 1.598903e-07
I5491 n1_m1_220800_523200 0 1.598903e-07
I5492 n1_m1_220800_528000 0 2.398354e-07
I5493 n1_m1_220800_532800 0 1.627006e-07
I5494 n1_m1_220800_537600 0 2.474016e-07
I5495 n1_m1_220800_542400 0 1.647543e-07
I5496 n1_m1_220800_547200 0 1.611153e-07
I5497 n1_m1_220800_552000 0 2.407361e-07
I5498 n1_m1_220800_556800 0 1.637815e-07
I5499 n1_m1_225600_0 0 1.480888e-07
I5500 n1_m1_225600_4800 0 1.520385e-07
I5501 n1_m1_225600_9600 0 2.298422e-07
I5502 n1_m1_225600_14400 0 1.532282e-07
I5503 n1_m1_225600_19200 0 1.532282e-07
I5504 n1_m1_225600_24000 0 2.298422e-07
I5505 n1_m1_225600_28800 0 1.508488e-07
I5506 n1_m1_225600_33600 0 2.248457e-07
I5507 n1_m1_225600_38400 0 1.530752e-07
I5508 n1_m1_225600_43200 0 1.529902e-07
I5509 n1_m1_225600_48000 0 2.295040e-07
I5510 n1_m1_225600_52800 0 1.531823e-07
I5511 n1_m1_225600_57600 0 2.298422e-07
I5512 n1_m1_225600_62400 0 1.532282e-07
I5513 n1_m1_225600_67200 0 1.532605e-07
I5514 n1_m1_225600_72000 0 2.300683e-07
I5515 n1_m1_225600_76800 0 1.532282e-07
I5516 n1_m1_225600_81600 0 2.298422e-07
I5517 n1_m1_225600_86400 0 1.533743e-07
I5518 n1_m1_225600_91200 0 1.568617e-07
I5519 n1_m1_225600_96000 0 2.347654e-07
I5520 n1_m1_225600_100800 0 1.547761e-07
I5521 n1_m1_225600_105600 0 2.459560e-07
I5522 n1_m1_225600_110400 0 1.640048e-07
I5523 n1_m1_225600_115200 0 1.699959e-07
I5524 n1_m1_225600_120000 0 2.616133e-07
I5525 n1_m1_225600_124800 0 1.712872e-07
I5526 n1_m1_225600_129600 0 2.583149e-07
I5527 n1_m1_225600_134400 0 2.051130e-07
I5528 n1_m1_225600_139200 0 1.992918e-07
I5529 n1_m1_225600_144000 0 3.155844e-07
I5530 n1_m1_225600_148800 0 3.113384e-07
I5531 n1_m1_225600_153600 0 9.495371e-07
I5532 n1_m1_225600_158400 0 8.158380e-07
I5533 n1_m1_225600_163200 0 5.753011e-07
I5534 n1_m1_225600_168000 0 5.276484e-07
I5535 n1_m1_225600_172800 0 2.038383e-07
I5536 n1_m1_225600_177600 0 2.658869e-07
I5537 n1_m1_225600_182400 0 1.701132e-07
I5538 n1_m1_225600_187200 0 1.684429e-07
I5539 n1_m1_225600_192000 0 2.500498e-07
I5540 n1_m1_225600_196800 0 1.648494e-07
I5541 n1_m1_225600_201600 0 2.764966e-07
I5542 n1_m1_225600_206400 0 2.336400e-07
I5543 n1_m1_225600_211200 0 1.912680e-07
I5544 n1_m1_225600_216000 0 2.594087e-07
I5545 n1_m1_225600_220800 0 1.900206e-07
I5546 n1_m1_225600_225600 0 5.057603e-07
I5547 n1_m1_225600_230400 0 5.109337e-07
I5548 n1_m1_225600_235200 0 4.905878e-07
I5549 n1_m1_225600_240000 0 5.069714e-07
I5550 n1_m1_225600_244800 0 1.981314e-07
I5551 n1_m1_225600_249600 0 2.442487e-07
I5552 n1_m1_225600_254400 0 1.600534e-07
I5553 n1_m1_225600_259200 0 1.598903e-07
I5554 n1_m1_225600_264000 0 2.399068e-07
I5555 n1_m1_225600_268800 0 1.613172e-07
I5556 n1_m1_225600_273600 0 2.481287e-07
I5557 n1_m1_225600_278400 0 1.645775e-07
I5558 n1_m1_225600_283200 0 1.635102e-07
I5559 n1_m1_225600_288000 0 2.501579e-07
I5560 n1_m1_225600_292800 0 1.722960e-07
I5561 n1_m1_225600_297600 0 2.605263e-07
I5562 n1_m1_225600_302400 0 1.765689e-07
I5563 n1_m1_225600_307200 0 1.741094e-07
I5564 n1_m1_225600_312000 0 2.598710e-07
I5565 n1_m1_225600_316800 0 1.729483e-07
I5566 n1_m1_225600_321600 0 2.551137e-07
I5567 n1_m1_225600_326400 0 1.698188e-07
I5568 n1_m1_225600_331200 0 1.756923e-07
I5569 n1_m1_225600_336000 0 2.745514e-07
I5570 n1_m1_225600_340800 0 1.815897e-07
I5571 n1_m1_225600_345600 0 2.614287e-07
I5572 n1_m1_225600_350400 0 1.685347e-07
I5573 n1_m1_225600_355200 0 1.681060e-07
I5574 n1_m1_225600_360000 0 2.598791e-07
I5575 n1_m1_225600_364800 0 1.781702e-07
I5576 n1_m1_225600_369600 0 2.675307e-07
I5577 n1_m1_225600_374400 0 1.759724e-07
I5578 n1_m1_225600_379200 0 1.711410e-07
I5579 n1_m1_225600_384000 0 2.565739e-07
I5580 n1_m1_225600_388800 0 1.742613e-07
I5581 n1_m1_225600_393600 0 2.606119e-07
I5582 n1_m1_225600_398400 0 1.688008e-07
I5583 n1_m1_225600_403200 0 1.677913e-07
I5584 n1_m1_225600_408000 0 2.516157e-07
I5585 n1_m1_225600_412800 0 1.740285e-07
I5586 n1_m1_225600_417600 0 2.647452e-07
I5587 n1_m1_225600_422400 0 1.719187e-07
I5588 n1_m1_225600_427200 0 1.979573e-07
I5589 n1_m1_225600_432000 0 3.626501e-07
I5590 n1_m1_225600_436800 0 2.062578e-07
I5591 n1_m1_225600_441600 0 3.078877e-07
I5592 n1_m1_225600_446400 0 3.081504e-07
I5593 n1_m1_225600_451200 0 3.225528e-07
I5594 n1_m1_225600_456000 0 3.803634e-07
I5595 n1_m1_225600_460800 0 1.825594e-07
I5596 n1_m1_225600_465600 0 2.608709e-07
I5597 n1_m1_225600_470400 0 1.764258e-07
I5598 n1_m1_225600_475200 0 1.729765e-07
I5599 n1_m1_225600_480000 0 2.596245e-07
I5600 n1_m1_225600_484800 0 1.663022e-07
I5601 n1_m1_225600_489600 0 2.562748e-07
I5602 n1_m1_225600_494400 0 1.754085e-07
I5603 n1_m1_225600_499200 0 1.705863e-07
I5604 n1_m1_225600_504000 0 2.506168e-07
I5605 n1_m1_225600_508800 0 1.616798e-07
I5606 n1_m1_225600_513600 0 2.417626e-07
I5607 n1_m1_225600_518400 0 1.611751e-07
I5608 n1_m1_225600_523200 0 1.611751e-07
I5609 n1_m1_225600_528000 0 2.417626e-07
I5610 n1_m1_225600_532800 0 1.613077e-07
I5611 n1_m1_225600_537600 0 2.421195e-07
I5612 n1_m1_225600_542400 0 1.613586e-07
I5613 n1_m1_225600_547200 0 1.602601e-07
I5614 n1_m1_225600_552000 0 2.383728e-07
I5615 n1_m1_225600_556800 0 1.587890e-07
I5616 n1_m1_230400_0 0 1.480888e-07
I5617 n1_m1_230400_4800 0 1.520385e-07
I5618 n1_m1_230400_9600 0 2.298422e-07
I5619 n1_m1_230400_14400 0 1.532282e-07
I5620 n1_m1_230400_19200 0 1.532282e-07
I5621 n1_m1_230400_24000 0 2.298422e-07
I5622 n1_m1_230400_28800 0 1.508488e-07
I5623 n1_m1_230400_33600 0 2.248457e-07
I5624 n1_m1_230400_38400 0 1.532282e-07
I5625 n1_m1_230400_43200 0 1.532282e-07
I5626 n1_m1_230400_48000 0 2.298422e-07
I5627 n1_m1_230400_52800 0 1.532282e-07
I5628 n1_m1_230400_57600 0 2.298422e-07
I5629 n1_m1_230400_62400 0 1.532282e-07
I5630 n1_m1_230400_67200 0 1.532282e-07
I5631 n1_m1_230400_72000 0 2.298422e-07
I5632 n1_m1_230400_76800 0 1.532282e-07
I5633 n1_m1_230400_81600 0 2.298422e-07
I5634 n1_m1_230400_86400 0 1.532282e-07
I5635 n1_m1_230400_91200 0 1.567496e-07
I5636 n1_m1_230400_96000 0 2.433819e-07
I5637 n1_m1_230400_100800 0 1.664218e-07
I5638 n1_m1_230400_105600 0 2.657496e-07
I5639 n1_m1_230400_110400 0 1.950219e-07
I5640 n1_m1_230400_115200 0 2.163005e-07
I5641 n1_m1_230400_120000 0 2.982871e-07
I5642 n1_m1_230400_124800 0 1.736808e-07
I5643 n1_m1_230400_129600 0 2.567388e-07
I5644 n1_m1_230400_134400 0 2.219443e-07
I5645 n1_m1_230400_139200 0 2.382174e-07
I5646 n1_m1_230400_144000 0 3.399483e-07
I5647 n1_m1_230400_148800 0 3.005590e-07
I5648 n1_m1_230400_153600 0 1.304656e-06
I5649 n1_m1_230400_158400 0 1.240343e-06
I5650 n1_m1_230400_163200 0 1.021268e-06
I5651 n1_m1_230400_168000 0 7.710986e-07
I5652 n1_m1_230400_172800 0 2.285221e-07
I5653 n1_m1_230400_177600 0 3.407641e-07
I5654 n1_m1_230400_182400 0 2.154712e-07
I5655 n1_m1_230400_187200 0 2.202719e-07
I5656 n1_m1_230400_192000 0 3.338940e-07
I5657 n1_m1_230400_196800 0 1.977568e-07
I5658 n1_m1_230400_201600 0 2.951002e-07
I5659 n1_m1_230400_206400 0 2.205554e-07
I5660 n1_m1_230400_211200 0 1.776509e-07
I5661 n1_m1_230400_216000 0 2.468931e-07
I5662 n1_m1_230400_220800 0 1.680778e-07
I5663 n1_m1_230400_225600 0 2.920580e-07
I5664 n1_m1_230400_230400 0 2.434084e-07
I5665 n1_m1_230400_235200 0 2.529991e-07
I5666 n1_m1_230400_240000 0 3.493806e-07
I5667 n1_m1_230400_244800 0 1.870607e-07
I5668 n1_m1_230400_249600 0 2.551378e-07
I5669 n1_m1_230400_254400 0 1.636978e-07
I5670 n1_m1_230400_259200 0 1.604185e-07
I5671 n1_m1_230400_264000 0 2.398354e-07
I5672 n1_m1_230400_268800 0 1.598903e-07
I5673 n1_m1_230400_273600 0 2.398354e-07
I5674 n1_m1_230400_278400 0 1.665524e-07
I5675 n1_m1_230400_283200 0 1.732144e-07
I5676 n1_m1_230400_288000 0 2.568564e-07
I5677 n1_m1_230400_292800 0 1.650296e-07
I5678 n1_m1_230400_297600 0 2.450746e-07
I5679 n1_m1_230400_302400 0 1.668386e-07
I5680 n1_m1_230400_307200 0 1.721200e-07
I5681 n1_m1_230400_312000 0 2.588659e-07
I5682 n1_m1_230400_316800 0 1.691179e-07
I5683 n1_m1_230400_321600 0 2.500304e-07
I5684 n1_m1_230400_326400 0 1.680330e-07
I5685 n1_m1_230400_331200 0 1.709045e-07
I5686 n1_m1_230400_336000 0 2.645327e-07
I5687 n1_m1_230400_340800 0 1.773871e-07
I5688 n1_m1_230400_345600 0 2.611228e-07
I5689 n1_m1_230400_350400 0 1.732144e-07
I5690 n1_m1_230400_355200 0 1.730384e-07
I5691 n1_m1_230400_360000 0 2.553193e-07
I5692 n1_m1_230400_364800 0 1.696931e-07
I5693 n1_m1_230400_369600 0 2.545396e-07
I5694 n1_m1_230400_374400 0 1.712525e-07
I5695 n1_m1_230400_379200 0 1.732144e-07
I5696 n1_m1_230400_384000 0 2.621772e-07
I5697 n1_m1_230400_388800 0 1.786189e-07
I5698 n1_m1_230400_393600 0 2.727285e-07
I5699 n1_m1_230400_398400 0 1.771818e-07
I5700 n1_m1_230400_403200 0 1.709391e-07
I5701 n1_m1_230400_408000 0 2.512867e-07
I5702 n1_m1_230400_412800 0 1.707257e-07
I5703 n1_m1_230400_417600 0 2.623437e-07
I5704 n1_m1_230400_422400 0 1.762899e-07
I5705 n1_m1_230400_427200 0 1.816699e-07
I5706 n1_m1_230400_432000 0 3.199518e-07
I5707 n1_m1_230400_436800 0 2.014441e-07
I5708 n1_m1_230400_441600 0 3.910520e-07
I5709 n1_m1_230400_446400 0 6.063423e-07
I5710 n1_m1_230400_451200 0 9.004364e-07
I5711 n1_m1_230400_456000 0 1.267068e-06
I5712 n1_m1_230400_460800 0 4.160899e-07
I5713 n1_m1_230400_465600 0 2.862770e-07
I5714 n1_m1_230400_470400 0 1.753776e-07
I5715 n1_m1_230400_475200 0 1.732144e-07
I5716 n1_m1_230400_480000 0 2.598217e-07
I5717 n1_m1_230400_484800 0 1.734374e-07
I5718 n1_m1_230400_489600 0 2.765306e-07
I5719 n1_m1_230400_494400 0 1.868343e-07
I5720 n1_m1_230400_499200 0 1.813041e-07
I5721 n1_m1_230400_504000 0 2.605355e-07
I5722 n1_m1_230400_508800 0 1.665476e-07
I5723 n1_m1_230400_513600 0 2.465335e-07
I5724 n1_m1_230400_518400 0 1.665524e-07
I5725 n1_m1_230400_523200 0 1.675082e-07
I5726 n1_m1_230400_528000 0 2.550352e-07
I5727 n1_m1_230400_532800 0 1.700737e-07
I5728 n1_m1_230400_537600 0 2.548339e-07
I5729 n1_m1_230400_542400 0 1.669935e-07
I5730 n1_m1_230400_547200 0 1.615082e-07
I5731 n1_m1_230400_552000 0 2.314024e-07
I5732 n1_m1_230400_556800 0 1.505117e-07
I5733 n1_m1_235200_0 0 1.480888e-07
I5734 n1_m1_235200_4800 0 1.520385e-07
I5735 n1_m1_235200_9600 0 2.298422e-07
I5736 n1_m1_235200_14400 0 1.532282e-07
I5737 n1_m1_235200_19200 0 1.532282e-07
I5738 n1_m1_235200_24000 0 2.298422e-07
I5739 n1_m1_235200_28800 0 1.519025e-07
I5740 n1_m1_235200_33600 0 2.270584e-07
I5741 n1_m1_235200_38400 0 1.532282e-07
I5742 n1_m1_235200_43200 0 1.532282e-07
I5743 n1_m1_235200_48000 0 2.298422e-07
I5744 n1_m1_235200_52800 0 1.532282e-07
I5745 n1_m1_235200_57600 0 2.298422e-07
I5746 n1_m1_235200_62400 0 1.532282e-07
I5747 n1_m1_235200_67200 0 1.532282e-07
I5748 n1_m1_235200_72000 0 2.310645e-07
I5749 n1_m1_235200_76800 0 1.571479e-07
I5750 n1_m1_235200_81600 0 2.386933e-07
I5751 n1_m1_235200_86400 0 1.573165e-07
I5752 n1_m1_235200_91200 0 1.581404e-07
I5753 n1_m1_235200_96000 0 2.540053e-07
I5754 n1_m1_235200_100800 0 2.029301e-07
I5755 n1_m1_235200_105600 0 4.100417e-07
I5756 n1_m1_235200_110400 0 2.620038e-07
I5757 n1_m1_235200_115200 0 2.441392e-07
I5758 n1_m1_235200_120000 0 3.070872e-07
I5759 n1_m1_235200_124800 0 1.776495e-07
I5760 n1_m1_235200_129600 0 2.656979e-07
I5761 n1_m1_235200_134400 0 2.370101e-07
I5762 n1_m1_235200_139200 0 2.517320e-07
I5763 n1_m1_235200_144000 0 3.213101e-07
I5764 n1_m1_235200_148800 0 2.632282e-07
I5765 n1_m1_235200_153600 0 1.329151e-06
I5766 n1_m1_235200_158400 0 1.301712e-06
I5767 n1_m1_235200_163200 0 1.167215e-06
I5768 n1_m1_235200_168000 0 1.095430e-06
I5769 n1_m1_235200_172800 0 5.266508e-07
I5770 n1_m1_235200_177600 0 7.969306e-07
I5771 n1_m1_235200_182400 0 4.201919e-07
I5772 n1_m1_235200_187200 0 3.513656e-07
I5773 n1_m1_235200_192000 0 4.200070e-07
I5774 n1_m1_235200_196800 0 2.032945e-07
I5775 n1_m1_235200_201600 0 2.612227e-07
I5776 n1_m1_235200_206400 0 1.675551e-07
I5777 n1_m1_235200_211200 0 1.663110e-07
I5778 n1_m1_235200_216000 0 2.461433e-07
I5779 n1_m1_235200_220800 0 1.672689e-07
I5780 n1_m1_235200_225600 0 2.564288e-07
I5781 n1_m1_235200_230400 0 1.767358e-07
I5782 n1_m1_235200_235200 0 1.828269e-07
I5783 n1_m1_235200_240000 0 2.870458e-07
I5784 n1_m1_235200_244800 0 1.835325e-07
I5785 n1_m1_235200_249600 0 2.642064e-07
I5786 n1_m1_235200_254400 0 1.694075e-07
I5787 n1_m1_235200_259200 0 1.636081e-07
I5788 n1_m1_235200_264000 0 2.404044e-07
I5789 n1_m1_235200_268800 0 1.605436e-07
I5790 n1_m1_235200_273600 0 2.441134e-07
I5791 n1_m1_235200_278400 0 1.650772e-07
I5792 n1_m1_235200_283200 0 1.673137e-07
I5793 n1_m1_235200_288000 0 2.478686e-07
I5794 n1_m1_235200_292800 0 1.610038e-07
I5795 n1_m1_235200_297600 0 2.408347e-07
I5796 n1_m1_235200_302400 0 1.661411e-07
I5797 n1_m1_235200_307200 0 1.698440e-07
I5798 n1_m1_235200_312000 0 2.574022e-07
I5799 n1_m1_235200_316800 0 1.666951e-07
I5800 n1_m1_235200_321600 0 2.498285e-07
I5801 n1_m1_235200_326400 0 1.665524e-07
I5802 n1_m1_235200_331200 0 1.665524e-07
I5803 n1_m1_235200_336000 0 2.527714e-07
I5804 n1_m1_235200_340800 0 1.722450e-07
I5805 n1_m1_235200_345600 0 2.598217e-07
I5806 n1_m1_235200_350400 0 1.732144e-07
I5807 n1_m1_235200_355200 0 1.728813e-07
I5808 n1_m1_235200_360000 0 2.513037e-07
I5809 n1_m1_235200_364800 0 1.665524e-07
I5810 n1_m1_235200_369600 0 2.498285e-07
I5811 n1_m1_235200_374400 0 1.695027e-07
I5812 n1_m1_235200_379200 0 1.732144e-07
I5813 n1_m1_235200_384000 0 2.598217e-07
I5814 n1_m1_235200_388800 0 1.793939e-07
I5815 n1_m1_235200_393600 0 2.863538e-07
I5816 n1_m1_235200_398400 0 1.859404e-07
I5817 n1_m1_235200_403200 0 1.725360e-07
I5818 n1_m1_235200_408000 0 2.505450e-07
I5819 n1_m1_235200_412800 0 1.677420e-07
I5820 n1_m1_235200_417600 0 2.577279e-07
I5821 n1_m1_235200_422400 0 1.773218e-07
I5822 n1_m1_235200_427200 0 1.863306e-07
I5823 n1_m1_235200_432000 0 3.685919e-07
I5824 n1_m1_235200_436800 0 2.277281e-07
I5825 n1_m1_235200_441600 0 3.596613e-07
I5826 n1_m1_235200_446400 0 6.471225e-07
I5827 n1_m1_235200_451200 0 1.169147e-06
I5828 n1_m1_235200_456000 0 1.819582e-06
I5829 n1_m1_235200_460800 0 6.555229e-07
I5830 n1_m1_235200_465600 0 3.410945e-07
I5831 n1_m1_235200_470400 0 2.072741e-07
I5832 n1_m1_235200_475200 0 1.988825e-07
I5833 n1_m1_235200_480000 0 2.644790e-07
I5834 n1_m1_235200_484800 0 1.852511e-07
I5835 n1_m1_235200_489600 0 3.407056e-07
I5836 n1_m1_235200_494400 0 2.313133e-07
I5837 n1_m1_235200_499200 0 1.956555e-07
I5838 n1_m1_235200_504000 0 2.623057e-07
I5839 n1_m1_235200_508800 0 1.660765e-07
I5840 n1_m1_235200_513600 0 2.422881e-07
I5841 n1_m1_235200_518400 0 1.636020e-07
I5842 n1_m1_235200_523200 0 1.670119e-07
I5843 n1_m1_235200_528000 0 2.620813e-07
I5844 n1_m1_235200_532800 0 1.732144e-07
I5845 n1_m1_235200_537600 0 2.566640e-07
I5846 n1_m1_235200_542400 0 1.671356e-07
I5847 n1_m1_235200_547200 0 1.637420e-07
I5848 n1_m1_235200_552000 0 2.318110e-07
I5849 n1_m1_235200_556800 0 1.480888e-07
I5850 n1_m1_240000_0 0 2.221006e-07
I5851 n1_m1_240000_4800 0 2.279476e-07
I5852 n1_m1_240000_9600 0 3.447318e-07
I5853 n1_m1_240000_14400 0 2.298422e-07
I5854 n1_m1_240000_19200 0 2.298422e-07
I5855 n1_m1_240000_24000 0 3.447634e-07
I5856 n1_m1_240000_28800 0 2.298422e-07
I5857 n1_m1_240000_33600 0 3.447634e-07
I5858 n1_m1_240000_38400 0 2.298422e-07
I5859 n1_m1_240000_43200 0 2.298422e-07
I5860 n1_m1_240000_48000 0 3.449020e-07
I5861 n1_m1_240000_52800 0 2.299901e-07
I5862 n1_m1_240000_57600 0 3.451886e-07
I5863 n1_m1_240000_62400 0 2.302634e-07
I5864 n1_m1_240000_67200 0 2.302511e-07
I5865 n1_m1_240000_72000 0 3.514802e-07
I5866 n1_m1_240000_76800 0 2.485437e-07
I5867 n1_m1_240000_81600 0 3.831829e-07
I5868 n1_m1_240000_86400 0 2.460352e-07
I5869 n1_m1_240000_91200 0 2.429210e-07
I5870 n1_m1_240000_96000 0 4.234594e-07
I5871 n1_m1_240000_100800 0 4.385102e-07
I5872 n1_m1_240000_105600 0 1.079508e-06
I5873 n1_m1_240000_110400 0 5.366714e-07
I5874 n1_m1_240000_115200 0 3.408446e-07
I5875 n1_m1_240000_120000 0 4.226548e-07
I5876 n1_m1_240000_124800 0 2.769099e-07
I5877 n1_m1_240000_129600 0 4.518440e-07
I5878 n1_m1_240000_134400 0 3.892859e-07
I5879 n1_m1_240000_139200 0 4.030091e-07
I5880 n1_m1_240000_144000 0 5.733289e-07
I5881 n1_m1_240000_148800 0 4.307513e-07
I5882 n1_m1_240000_153600 0 1.882744e-06
I5883 n1_m1_240000_158400 0 1.884232e-06
I5884 n1_m1_240000_163200 0 1.764410e-06
I5885 n1_m1_240000_168000 0 2.403134e-06
I5886 n1_m1_240000_172800 0 1.690156e-06
I5887 n1_m1_240000_177600 0 2.499504e-06
I5888 n1_m1_240000_182400 0 1.271058e-06
I5889 n1_m1_240000_187200 0 8.792312e-07
I5890 n1_m1_240000_192000 0 7.573455e-07
I5891 n1_m1_240000_196800 0 2.993496e-07
I5892 n1_m1_240000_201600 0 3.770473e-07
I5893 n1_m1_240000_206400 0 2.502079e-07
I5894 n1_m1_240000_211200 0 2.495573e-07
I5895 n1_m1_240000_216000 0 3.674111e-07
I5896 n1_m1_240000_220800 0 2.480053e-07
I5897 n1_m1_240000_225600 0 3.958956e-07
I5898 n1_m1_240000_230400 0 3.027249e-07
I5899 n1_m1_240000_235200 0 3.378865e-07
I5900 n1_m1_240000_240000 0 5.293846e-07
I5901 n1_m1_240000_244800 0 3.136643e-07
I5902 n1_m1_240000_249600 0 4.181140e-07
I5903 n1_m1_240000_254400 0 2.602581e-07
I5904 n1_m1_240000_259200 0 2.508697e-07
I5905 n1_m1_240000_264000 0 3.673030e-07
I5906 n1_m1_240000_268800 0 2.421981e-07
I5907 n1_m1_240000_273600 0 3.743339e-07
I5908 n1_m1_240000_278400 0 2.449033e-07
I5909 n1_m1_240000_283200 0 2.398354e-07
I5910 n1_m1_240000_288000 0 3.646028e-07
I5911 n1_m1_240000_292800 0 2.456885e-07
I5912 n1_m1_240000_297600 0 3.680219e-07
I5913 n1_m1_240000_302400 0 2.442742e-07
I5914 n1_m1_240000_307200 0 2.443935e-07
I5915 n1_m1_240000_312000 0 3.721017e-07
I5916 n1_m1_240000_316800 0 2.509512e-07
I5917 n1_m1_240000_321600 0 3.827363e-07
I5918 n1_m1_240000_326400 0 2.553961e-07
I5919 n1_m1_240000_331200 0 2.533037e-07
I5920 n1_m1_240000_336000 0 3.750701e-07
I5921 n1_m1_240000_340800 0 2.568237e-07
I5922 n1_m1_240000_345600 0 4.008555e-07
I5923 n1_m1_240000_350400 0 2.614879e-07
I5924 n1_m1_240000_355200 0 2.595229e-07
I5925 n1_m1_240000_360000 0 3.842251e-07
I5926 n1_m1_240000_364800 0 2.555114e-07
I5927 n1_m1_240000_369600 0 3.831054e-07
I5928 n1_m1_240000_374400 0 2.575457e-07
I5929 n1_m1_240000_379200 0 2.608108e-07
I5930 n1_m1_240000_384000 0 3.955142e-07
I5931 n1_m1_240000_388800 0 2.852634e-07
I5932 n1_m1_240000_393600 0 5.255158e-07
I5933 n1_m1_240000_398400 0 3.484241e-07
I5934 n1_m1_240000_403200 0 2.863800e-07
I5935 n1_m1_240000_408000 0 3.873739e-07
I5936 n1_m1_240000_412800 0 2.563108e-07
I5937 n1_m1_240000_417600 0 3.956162e-07
I5938 n1_m1_240000_422400 0 2.743953e-07
I5939 n1_m1_240000_427200 0 2.721255e-07
I5940 n1_m1_240000_432000 0 6.203630e-07
I5941 n1_m1_240000_436800 0 5.311803e-07
I5942 n1_m1_240000_441600 0 5.788231e-07
I5943 n1_m1_240000_446400 0 6.919016e-07
I5944 n1_m1_240000_451200 0 1.628828e-06
I5945 n1_m1_240000_456000 0 2.709002e-06
I5946 n1_m1_240000_460800 0 8.738380e-07
I5947 n1_m1_240000_465600 0 4.906989e-07
I5948 n1_m1_240000_470400 0 3.906502e-07
I5949 n1_m1_240000_475200 0 4.404548e-07
I5950 n1_m1_240000_480000 0 4.758438e-07
I5951 n1_m1_240000_484800 0 3.758074e-07
I5952 n1_m1_240000_489600 0 9.433964e-07
I5953 n1_m1_240000_494400 0 6.495583e-07
I5954 n1_m1_240000_499200 0 5.013916e-07
I5955 n1_m1_240000_504000 0 5.073191e-07
I5956 n1_m1_240000_508800 0 2.588631e-07
I5957 n1_m1_240000_513600 0 3.670664e-07
I5958 n1_m1_240000_518400 0 2.399781e-07
I5959 n1_m1_240000_523200 0 2.494716e-07
I5960 n1_m1_240000_528000 0 4.018619e-07
I5961 n1_m1_240000_532800 0 2.565770e-07
I5962 n1_m1_240000_537600 0 3.765579e-07
I5963 n1_m1_240000_542400 0 2.454183e-07
I5964 n1_m1_240000_547200 0 2.483336e-07
I5965 n1_m1_240000_552000 0 3.560209e-07
I5966 n1_m1_240000_556800 0 2.277009e-07
I5967 n1_m1_244800_0 0 1.469794e-07
I5968 n1_m1_244800_4800 0 1.482941e-07
I5969 n1_m1_244800_9600 0 2.287675e-07
I5970 n1_m1_244800_14400 0 1.532282e-07
I5971 n1_m1_244800_19200 0 1.532282e-07
I5972 n1_m1_244800_24000 0 2.298422e-07
I5973 n1_m1_244800_28800 0 1.532282e-07
I5974 n1_m1_244800_33600 0 2.298422e-07
I5975 n1_m1_244800_38400 0 1.532282e-07
I5976 n1_m1_244800_43200 0 1.532282e-07
I5977 n1_m1_244800_48000 0 2.345574e-07
I5978 n1_m1_244800_52800 0 1.582553e-07
I5979 n1_m1_244800_57600 0 2.442997e-07
I5980 n1_m1_244800_62400 0 1.675469e-07
I5981 n1_m1_244800_67200 0 1.671309e-07
I5982 n1_m1_244800_72000 0 2.425390e-07
I5983 n1_m1_244800_76800 0 1.590337e-07
I5984 n1_m1_244800_81600 0 2.555572e-07
I5985 n1_m1_244800_86400 0 1.698834e-07
I5986 n1_m1_244800_91200 0 1.656999e-07
I5987 n1_m1_244800_96000 0 2.718848e-07
I5988 n1_m1_244800_100800 0 2.226873e-07
I5989 n1_m1_244800_105600 0 4.807748e-07
I5990 n1_m1_244800_110400 0 2.848174e-07
I5991 n1_m1_244800_115200 0 2.174406e-07
I5992 n1_m1_244800_120000 0 2.735510e-07
I5993 n1_m1_244800_124800 0 1.773735e-07
I5994 n1_m1_244800_129600 0 3.318477e-07
I5995 n1_m1_244800_134400 0 3.608285e-07
I5996 n1_m1_244800_139200 0 3.562317e-07
I5997 n1_m1_244800_144000 0 3.969711e-07
I5998 n1_m1_244800_148800 0 1.955569e-07
I5999 n1_m1_244800_153600 0 7.773277e-07
I6000 n1_m1_244800_158400 0 1.260261e-06
I6001 n1_m1_244800_163200 0 1.302017e-06
I6002 n1_m1_244800_168000 0 2.072073e-06
I6003 n1_m1_244800_172800 0 1.384376e-06
I6004 n1_m1_244800_177600 0 1.924669e-06
I6005 n1_m1_244800_182400 0 1.103632e-06
I6006 n1_m1_244800_187200 0 8.461934e-07
I6007 n1_m1_244800_192000 0 6.654399e-07
I6008 n1_m1_244800_196800 0 2.031286e-07
I6009 n1_m1_244800_201600 0 2.463819e-07
I6010 n1_m1_244800_206400 0 1.606666e-07
I6011 n1_m1_244800_211200 0 1.690568e-07
I6012 n1_m1_244800_216000 0 2.483058e-07
I6013 n1_m1_244800_220800 0 1.656224e-07
I6014 n1_m1_244800_225600 0 2.576150e-07
I6015 n1_m1_244800_230400 0 1.889547e-07
I6016 n1_m1_244800_235200 0 2.013693e-07
I6017 n1_m1_244800_240000 0 3.049356e-07
I6018 n1_m1_244800_244800 0 1.985997e-07
I6019 n1_m1_244800_249600 0 2.765401e-07
I6020 n1_m1_244800_254400 0 1.727236e-07
I6021 n1_m1_244800_259200 0 1.634259e-07
I6022 n1_m1_244800_264000 0 2.434615e-07
I6023 n1_m1_244800_268800 0 1.651227e-07
I6024 n1_m1_244800_273600 0 2.525811e-07
I6025 n1_m1_244800_278400 0 1.656482e-07
I6026 n1_m1_244800_283200 0 1.598903e-07
I6027 n1_m1_244800_288000 0 2.493771e-07
I6028 n1_m1_244800_292800 0 1.714062e-07
I6029 n1_m1_244800_297600 0 2.460209e-07
I6030 n1_m1_244800_302400 0 1.601098e-07
I6031 n1_m1_244800_307200 0 1.598903e-07
I6032 n1_m1_244800_312000 0 2.416437e-07
I6033 n1_m1_244800_316800 0 1.667842e-07
I6034 n1_m1_244800_321600 0 2.524247e-07
I6035 n1_m1_244800_326400 0 1.683606e-07
I6036 n1_m1_244800_331200 0 1.695353e-07
I6037 n1_m1_244800_336000 0 2.609576e-07
I6038 n1_m1_244800_340800 0 1.807331e-07
I6039 n1_m1_244800_345600 0 2.817712e-07
I6040 n1_m1_244800_350400 0 1.789751e-07
I6041 n1_m1_244800_355200 0 1.703368e-07
I6042 n1_m1_244800_360000 0 2.587469e-07
I6043 n1_m1_244800_364800 0 1.722784e-07
I6044 n1_m1_244800_369600 0 2.529223e-07
I6045 n1_m1_244800_374400 0 1.769588e-07
I6046 n1_m1_244800_379200 0 2.068444e-07
I6047 n1_m1_244800_384000 0 3.157833e-07
I6048 n1_m1_244800_388800 0 1.814061e-07
I6049 n1_m1_244800_393600 0 2.968432e-07
I6050 n1_m1_244800_398400 0 2.070348e-07
I6051 n1_m1_244800_403200 0 2.016541e-07
I6052 n1_m1_244800_408000 0 2.716211e-07
I6053 n1_m1_244800_412800 0 1.734571e-07
I6054 n1_m1_244800_417600 0 2.649610e-07
I6055 n1_m1_244800_422400 0 2.088852e-07
I6056 n1_m1_244800_427200 0 3.036052e-07
I6057 n1_m1_244800_432000 0 7.404938e-07
I6058 n1_m1_244800_436800 0 4.661114e-07
I6059 n1_m1_244800_441600 0 3.872893e-07
I6060 n1_m1_244800_446400 0 2.705551e-07
I6061 n1_m1_244800_451200 0 5.630401e-07
I6062 n1_m1_244800_456000 0 1.001397e-06
I6063 n1_m1_244800_460800 0 2.980057e-07
I6064 n1_m1_244800_465600 0 2.709263e-07
I6065 n1_m1_244800_470400 0 2.351991e-07
I6066 n1_m1_244800_475200 0 3.043911e-07
I6067 n1_m1_244800_480000 0 4.386765e-07
I6068 n1_m1_244800_484800 0 3.863770e-07
I6069 n1_m1_244800_489600 0 7.735595e-07
I6070 n1_m1_244800_494400 0 5.503937e-07
I6071 n1_m1_244800_499200 0 4.732541e-07
I6072 n1_m1_244800_504000 0 4.103469e-07
I6073 n1_m1_244800_508800 0 1.774496e-07
I6074 n1_m1_244800_513600 0 2.498367e-07
I6075 n1_m1_244800_518400 0 1.647441e-07
I6076 n1_m1_244800_523200 0 1.653899e-07
I6077 n1_m1_244800_528000 0 2.514295e-07
I6078 n1_m1_244800_532800 0 1.673532e-07
I6079 n1_m1_244800_537600 0 2.493051e-07
I6080 n1_m1_244800_542400 0 1.612397e-07
I6081 n1_m1_244800_547200 0 1.612594e-07
I6082 n1_m1_244800_552000 0 2.335540e-07
I6083 n1_m1_244800_556800 0 1.498971e-07
I6084 n1_m1_249600_0 0 2.198491e-07
I6085 n1_m1_249600_4800 0 2.203488e-07
I6086 n1_m1_249600_9600 0 3.425506e-07
I6087 n1_m1_249600_14400 0 2.298422e-07
I6088 n1_m1_249600_19200 0 2.298422e-07
I6089 n1_m1_249600_24000 0 3.447634e-07
I6090 n1_m1_249600_28800 0 2.298422e-07
I6091 n1_m1_249600_33600 0 3.455842e-07
I6092 n1_m1_249600_38400 0 2.302331e-07
I6093 n1_m1_249600_43200 0 2.298422e-07
I6094 n1_m1_249600_48000 0 3.475869e-07
I6095 n1_m1_249600_52800 0 2.378405e-07
I6096 n1_m1_249600_57600 0 3.731293e-07
I6097 n1_m1_249600_62400 0 2.592673e-07
I6098 n1_m1_249600_67200 0 2.594988e-07
I6099 n1_m1_249600_72000 0 3.759590e-07
I6100 n1_m1_249600_76800 0 2.370971e-07
I6101 n1_m1_249600_81600 0 3.754474e-07
I6102 n1_m1_249600_86400 0 2.465648e-07
I6103 n1_m1_249600_91200 0 2.479747e-07
I6104 n1_m1_249600_96000 0 4.035812e-07
I6105 n1_m1_249600_100800 0 2.666037e-07
I6106 n1_m1_249600_105600 0 4.363763e-07
I6107 n1_m1_249600_110400 0 2.870452e-07
I6108 n1_m1_249600_115200 0 2.705001e-07
I6109 n1_m1_249600_120000 0 3.826160e-07
I6110 n1_m1_249600_124800 0 2.609162e-07
I6111 n1_m1_249600_129600 0 4.272870e-07
I6112 n1_m1_249600_134400 0 3.527830e-07
I6113 n1_m1_249600_139200 0 3.384820e-07
I6114 n1_m1_249600_144000 0 4.317356e-07
I6115 n1_m1_249600_148800 0 2.601813e-07
I6116 n1_m1_249600_153600 0 6.634691e-07
I6117 n1_m1_249600_158400 0 1.293696e-06
I6118 n1_m1_249600_163200 0 1.923479e-06
I6119 n1_m1_249600_168000 0 3.182851e-06
I6120 n1_m1_249600_172800 0 2.049397e-06
I6121 n1_m1_249600_177600 0 2.640933e-06
I6122 n1_m1_249600_182400 0 1.383440e-06
I6123 n1_m1_249600_187200 0 9.659438e-07
I6124 n1_m1_249600_192000 0 7.064994e-07
I6125 n1_m1_249600_196800 0 2.598339e-07
I6126 n1_m1_249600_201600 0 3.785031e-07
I6127 n1_m1_249600_206400 0 2.511919e-07
I6128 n1_m1_249600_211200 0 2.565334e-07
I6129 n1_m1_249600_216000 0 3.748856e-07
I6130 n1_m1_249600_220800 0 2.508489e-07
I6131 n1_m1_249600_225600 0 3.873141e-07
I6132 n1_m1_249600_230400 0 2.679712e-07
I6133 n1_m1_249600_235200 0 2.752397e-07
I6134 n1_m1_249600_240000 0 4.126586e-07
I6135 n1_m1_249600_244800 0 2.684097e-07
I6136 n1_m1_249600_249600 0 3.831958e-07
I6137 n1_m1_249600_254400 0 2.451025e-07
I6138 n1_m1_249600_259200 0 2.420777e-07
I6139 n1_m1_249600_264000 0 3.723893e-07
I6140 n1_m1_249600_268800 0 2.505491e-07
I6141 n1_m1_249600_273600 0 3.655073e-07
I6142 n1_m1_249600_278400 0 2.454982e-07
I6143 n1_m1_249600_283200 0 2.529801e-07
I6144 n1_m1_249600_288000 0 3.872179e-07
I6145 n1_m1_249600_292800 0 2.544920e-07
I6146 n1_m1_249600_297600 0 3.655807e-07
I6147 n1_m1_249600_302400 0 2.399683e-07
I6148 n1_m1_249600_307200 0 2.398354e-07
I6149 n1_m1_249600_312000 0 3.603989e-07
I6150 n1_m1_249600_316800 0 2.439676e-07
I6151 n1_m1_249600_321600 0 3.806765e-07
I6152 n1_m1_249600_326400 0 2.591154e-07
I6153 n1_m1_249600_331200 0 2.590324e-07
I6154 n1_m1_249600_336000 0 3.967879e-07
I6155 n1_m1_249600_340800 0 2.805421e-07
I6156 n1_m1_249600_345600 0 5.018029e-07
I6157 n1_m1_249600_350400 0 2.751244e-07
I6158 n1_m1_249600_355200 0 2.525376e-07
I6159 n1_m1_249600_360000 0 3.891030e-07
I6160 n1_m1_249600_364800 0 2.671177e-07
I6161 n1_m1_249600_369600 0 5.363380e-07
I6162 n1_m1_249600_374400 0 6.621918e-07
I6163 n1_m1_249600_379200 0 8.697398e-07
I6164 n1_m1_249600_384000 0 9.614116e-07
I6165 n1_m1_249600_388800 0 3.707829e-07
I6166 n1_m1_249600_393600 0 4.571277e-07
I6167 n1_m1_249600_398400 0 2.657615e-07
I6168 n1_m1_249600_403200 0 2.639172e-07
I6169 n1_m1_249600_408000 0 3.966087e-07
I6170 n1_m1_249600_412800 0 2.742115e-07
I6171 n1_m1_249600_417600 0 4.078694e-07
I6172 n1_m1_249600_422400 0 4.715512e-07
I6173 n1_m1_249600_427200 0 9.221718e-07
I6174 n1_m1_249600_432000 0 1.751395e-06
I6175 n1_m1_249600_436800 0 7.454775e-07
I6176 n1_m1_249600_441600 0 5.446578e-07
I6177 n1_m1_249600_446400 0 3.505499e-07
I6178 n1_m1_249600_451200 0 4.600604e-07
I6179 n1_m1_249600_456000 0 7.329537e-07
I6180 n1_m1_249600_460800 0 2.887277e-07
I6181 n1_m1_249600_465600 0 3.844392e-07
I6182 n1_m1_249600_470400 0 2.953313e-07
I6183 n1_m1_249600_475200 0 3.602860e-07
I6184 n1_m1_249600_480000 0 5.572169e-07
I6185 n1_m1_249600_484800 0 4.278499e-07
I6186 n1_m1_249600_489600 0 8.921496e-07
I6187 n1_m1_249600_494400 0 6.968408e-07
I6188 n1_m1_249600_499200 0 6.339543e-07
I6189 n1_m1_249600_504000 0 5.678062e-07
I6190 n1_m1_249600_508800 0 2.631055e-07
I6191 n1_m1_249600_513600 0 3.758233e-07
I6192 n1_m1_249600_518400 0 2.498285e-07
I6193 n1_m1_249600_523200 0 2.494798e-07
I6194 n1_m1_249600_528000 0 3.743726e-07
I6195 n1_m1_249600_532800 0 2.545552e-07
I6196 n1_m1_249600_537600 0 3.853783e-07
I6197 n1_m1_249600_542400 0 2.491045e-07
I6198 n1_m1_249600_547200 0 2.416845e-07
I6199 n1_m1_249600_552000 0 3.462623e-07
I6200 n1_m1_249600_556800 0 2.221333e-07
I6201 n1_m1_254400_0 0 7.328303e-08
I6202 n1_m1_254400_4800 0 7.344959e-08
I6203 n1_m1_254400_9600 0 1.141835e-07
I6204 n1_m1_254400_14400 0 7.661408e-08
I6205 n1_m1_254400_19200 0 7.661408e-08
I6206 n1_m1_254400_24000 0 1.149211e-07
I6207 n1_m1_254400_28800 0 7.661408e-08
I6208 n1_m1_254400_33600 0 1.168841e-07
I6209 n1_m1_254400_38400 0 7.754881e-08
I6210 n1_m1_254400_43200 0 7.661408e-08
I6211 n1_m1_254400_48000 0 1.149772e-07
I6212 n1_m1_254400_52800 0 7.730918e-08
I6213 n1_m1_254400_57600 0 1.214965e-07
I6214 n1_m1_254400_62400 0 8.630981e-08
I6215 n1_m1_254400_67200 0 8.660722e-08
I6216 n1_m1_254400_72000 0 1.279394e-07
I6217 n1_m1_254400_76800 0 8.231765e-08
I6218 n1_m1_254400_81600 0 1.230635e-07
I6219 n1_m1_254400_86400 0 8.022045e-08
I6220 n1_m1_254400_91200 0 8.585604e-08
I6221 n1_m1_254400_96000 0 1.560511e-07
I6222 n1_m1_254400_100800 0 9.231929e-08
I6223 n1_m1_254400_105600 0 1.372578e-07
I6224 n1_m1_254400_110400 0 8.936723e-08
I6225 n1_m1_254400_115200 0 8.850048e-08
I6226 n1_m1_254400_120000 0 1.323530e-07
I6227 n1_m1_254400_124800 0 8.922447e-08
I6228 n1_m1_254400_129600 0 1.347952e-07
I6229 n1_m1_254400_134400 0 8.911910e-08
I6230 n1_m1_254400_139200 0 9.089000e-08
I6231 n1_m1_254400_144000 0 1.340916e-07
I6232 n1_m1_254400_148800 0 8.665141e-08
I6233 n1_m1_254400_153600 0 1.516510e-07
I6234 n1_m1_254400_158400 0 2.291488e-07
I6235 n1_m1_254400_163200 0 5.773537e-07
I6236 n1_m1_254400_168000 0 1.031148e-06
I6237 n1_m1_254400_172800 0 5.578790e-07
I6238 n1_m1_254400_177600 0 6.389441e-07
I6239 n1_m1_254400_182400 0 2.815822e-07
I6240 n1_m1_254400_187200 0 1.778779e-07
I6241 n1_m1_254400_192000 0 1.522424e-07
I6242 n1_m1_254400_196800 0 8.290908e-08
I6243 n1_m1_254400_201600 0 1.271797e-07
I6244 n1_m1_254400_206400 0 8.019496e-08
I6245 n1_m1_254400_211200 0 8.297026e-08
I6246 n1_m1_254400_216000 0 1.215832e-07
I6247 n1_m1_254400_220800 0 8.210351e-08
I6248 n1_m1_254400_225600 0 1.296984e-07
I6249 n1_m1_254400_230400 0 8.736181e-08
I6250 n1_m1_254400_235200 0 8.803481e-08
I6251 n1_m1_254400_240000 0 1.319655e-07
I6252 n1_m1_254400_244800 0 8.508786e-08
I6253 n1_m1_254400_249600 0 1.220608e-07
I6254 n1_m1_254400_254400 0 8.033942e-08
I6255 n1_m1_254400_259200 0 8.243152e-08
I6256 n1_m1_254400_264000 0 1.289829e-07
I6257 n1_m1_254400_268800 0 8.833393e-08
I6258 n1_m1_254400_273600 0 1.297800e-07
I6259 n1_m1_254400_278400 0 8.779688e-08
I6260 n1_m1_254400_283200 0 9.033936e-08
I6261 n1_m1_254400_288000 0 1.316443e-07
I6262 n1_m1_254400_292800 0 8.427549e-08
I6263 n1_m1_254400_297600 0 1.237263e-07
I6264 n1_m1_254400_302400 0 8.026294e-08
I6265 n1_m1_254400_307200 0 7.994513e-08
I6266 n1_m1_254400_312000 0 1.199177e-07
I6267 n1_m1_254400_316800 0 8.117728e-08
I6268 n1_m1_254400_321600 0 1.317718e-07
I6269 n1_m1_254400_326400 0 9.060788e-08
I6270 n1_m1_254400_331200 0 8.821496e-08
I6271 n1_m1_254400_336000 0 1.304768e-07
I6272 n1_m1_254400_340800 0 9.179414e-08
I6273 n1_m1_254400_345600 0 1.598648e-07
I6274 n1_m1_254400_350400 0 9.014051e-08
I6275 n1_m1_254400_355200 0 8.403756e-08
I6276 n1_m1_254400_360000 0 1.293466e-07
I6277 n1_m1_254400_364800 0 8.793794e-08
I6278 n1_m1_254400_369600 0 2.013652e-07
I6279 n1_m1_254400_374400 0 2.768100e-07
I6280 n1_m1_254400_379200 0 3.528021e-07
I6281 n1_m1_254400_384000 0 3.618945e-07
I6282 n1_m1_254400_388800 0 1.416545e-07
I6283 n1_m1_254400_393600 0 1.696217e-07
I6284 n1_m1_254400_398400 0 8.650355e-08
I6285 n1_m1_254400_403200 0 8.353280e-08
I6286 n1_m1_254400_408000 0 1.305770e-07
I6287 n1_m1_254400_412800 0 9.246885e-08
I6288 n1_m1_254400_417600 0 1.332470e-07
I6289 n1_m1_254400_422400 0 1.842613e-07
I6290 n1_m1_254400_427200 0 3.879480e-07
I6291 n1_m1_254400_432000 0 6.535157e-07
I6292 n1_m1_254400_436800 0 2.079049e-07
I6293 n1_m1_254400_441600 0 1.490253e-07
I6294 n1_m1_254400_446400 0 9.626386e-08
I6295 n1_m1_254400_451200 0 9.878934e-08
I6296 n1_m1_254400_456000 0 1.485800e-07
I6297 n1_m1_254400_460800 0 8.745358e-08
I6298 n1_m1_254400_465600 0 1.292531e-07
I6299 n1_m1_254400_470400 0 9.055349e-08
I6300 n1_m1_254400_475200 0 1.002645e-07
I6301 n1_m1_254400_480000 0 1.519229e-07
I6302 n1_m1_254400_484800 0 9.627746e-08
I6303 n1_m1_254400_489600 0 1.966745e-07
I6304 n1_m1_254400_494400 0 1.636734e-07
I6305 n1_m1_254400_499200 0 1.583998e-07
I6306 n1_m1_254400_504000 0 1.605531e-07
I6307 n1_m1_254400_508800 0 8.489241e-08
I6308 n1_m1_254400_513600 0 1.250009e-07
I6309 n1_m1_254400_518400 0 8.327618e-08
I6310 n1_m1_254400_523200 0 8.398657e-08
I6311 n1_m1_254400_528000 0 1.287841e-07
I6312 n1_m1_254400_532800 0 8.629111e-08
I6313 n1_m1_254400_537600 0 1.296491e-07
I6314 n1_m1_254400_542400 0 8.379963e-08
I6315 n1_m1_254400_547200 0 8.075410e-08
I6316 n1_m1_254400_552000 0 1.154208e-07
I6317 n1_m1_254400_556800 0 7.404442e-08
I6318 n1_m1_259200_0 0 1.478604e-07
I6319 n1_m1_259200_4800 0 1.515507e-07
I6320 n1_m1_259200_9600 0 2.356131e-07
I6321 n1_m1_259200_14400 0 1.538342e-07
I6322 n1_m1_259200_19200 0 1.532693e-07
I6323 n1_m1_259200_24000 0 2.298422e-07
I6324 n1_m1_259200_28800 0 1.532282e-07
I6325 n1_m1_259200_33600 0 2.348388e-07
I6326 n1_m1_259200_38400 0 1.556075e-07
I6327 n1_m1_259200_43200 0 1.532282e-07
I6328 n1_m1_259200_48000 0 2.298422e-07
I6329 n1_m1_259200_52800 0 1.534661e-07
I6330 n1_m1_259200_57600 0 2.399139e-07
I6331 n1_m1_259200_62400 0 1.681798e-07
I6332 n1_m1_259200_67200 0 1.719201e-07
I6333 n1_m1_259200_72000 0 2.516820e-07
I6334 n1_m1_259200_76800 0 1.665524e-07
I6335 n1_m1_259200_81600 0 2.451175e-07
I6336 n1_m1_259200_86400 0 1.636904e-07
I6337 n1_m1_259200_91200 0 2.512187e-07
I6338 n1_m1_259200_96000 0 5.717963e-07
I6339 n1_m1_259200_100800 0 2.614294e-07
I6340 n1_m1_259200_105600 0 2.989659e-07
I6341 n1_m1_259200_110400 0 2.826557e-07
I6342 n1_m1_259200_115200 0 3.786105e-07
I6343 n1_m1_259200_120000 0 4.852608e-07
I6344 n1_m1_259200_124800 0 1.949234e-07
I6345 n1_m1_259200_129600 0 2.657625e-07
I6346 n1_m1_259200_134400 0 2.151625e-07
I6347 n1_m1_259200_139200 0 2.546110e-07
I6348 n1_m1_259200_144000 0 3.323698e-07
I6349 n1_m1_259200_148800 0 1.708395e-07
I6350 n1_m1_259200_153600 0 2.652373e-07
I6351 n1_m1_259200_158400 0 3.269317e-07
I6352 n1_m1_259200_163200 0 1.032007e-06
I6353 n1_m1_259200_168000 0 1.863631e-06
I6354 n1_m1_259200_172800 0 6.573441e-07
I6355 n1_m1_259200_177600 0 5.342853e-07
I6356 n1_m1_259200_182400 0 2.182325e-07
I6357 n1_m1_259200_187200 0 1.865964e-07
I6358 n1_m1_259200_192000 0 2.565681e-07
I6359 n1_m1_259200_196800 0 1.712362e-07
I6360 n1_m1_259200_201600 0 2.522201e-07
I6361 n1_m1_259200_206400 0 1.573910e-07
I6362 n1_m1_259200_211200 0 1.653430e-07
I6363 n1_m1_259200_216000 0 2.544291e-07
I6364 n1_m1_259200_220800 0 1.833055e-07
I6365 n1_m1_259200_225600 0 3.019322e-07
I6366 n1_m1_259200_230400 0 2.011932e-07
I6367 n1_m1_259200_235200 0 1.870995e-07
I6368 n1_m1_259200_240000 0 2.530253e-07
I6369 n1_m1_259200_244800 0 1.742036e-07
I6370 n1_m1_259200_249600 0 2.690368e-07
I6371 n1_m1_259200_254400 0 1.773167e-07
I6372 n1_m1_259200_259200 0 1.747423e-07
I6373 n1_m1_259200_264000 0 2.818239e-07
I6374 n1_m1_259200_268800 0 2.542075e-07
I6375 n1_m1_259200_273600 0 5.755777e-07
I6376 n1_m1_259200_278400 0 3.519013e-07
I6377 n1_m1_259200_283200 0 2.312855e-07
I6378 n1_m1_259200_288000 0 2.732611e-07
I6379 n1_m1_259200_292800 0 1.689174e-07
I6380 n1_m1_259200_297600 0 2.498805e-07
I6381 n1_m1_259200_302400 0 1.650677e-07
I6382 n1_m1_259200_307200 0 1.608206e-07
I6383 n1_m1_259200_312000 0 2.399775e-07
I6384 n1_m1_259200_316800 0 1.630541e-07
I6385 n1_m1_259200_321600 0 2.661306e-07
I6386 n1_m1_259200_326400 0 1.901878e-07
I6387 n1_m1_259200_331200 0 1.919295e-07
I6388 n1_m1_259200_336000 0 2.747288e-07
I6389 n1_m1_259200_340800 0 1.773232e-07
I6390 n1_m1_259200_345600 0 2.769059e-07
I6391 n1_m1_259200_350400 0 2.380730e-07
I6392 n1_m1_259200_355200 0 2.909411e-07
I6393 n1_m1_259200_360000 0 4.624816e-07
I6394 n1_m1_259200_364800 0 2.015606e-07
I6395 n1_m1_259200_369600 0 2.939506e-07
I6396 n1_m1_259200_374400 0 3.108057e-07
I6397 n1_m1_259200_379200 0 3.656028e-07
I6398 n1_m1_259200_384000 0 3.754209e-07
I6399 n1_m1_259200_388800 0 2.008825e-07
I6400 n1_m1_259200_393600 0 2.877053e-07
I6401 n1_m1_259200_398400 0 1.809353e-07
I6402 n1_m1_259200_403200 0 1.897470e-07
I6403 n1_m1_259200_408000 0 3.109526e-07
I6404 n1_m1_259200_412800 0 1.858779e-07
I6405 n1_m1_259200_417600 0 2.619406e-07
I6406 n1_m1_259200_422400 0 3.937651e-07
I6407 n1_m1_259200_427200 0 8.144383e-07
I6408 n1_m1_259200_432000 0 1.296173e-06
I6409 n1_m1_259200_436800 0 4.167160e-07
I6410 n1_m1_259200_441600 0 3.114903e-07
I6411 n1_m1_259200_446400 0 1.963938e-07
I6412 n1_m1_259200_451200 0 1.790091e-07
I6413 n1_m1_259200_456000 0 2.628237e-07
I6414 n1_m1_259200_460800 0 1.843354e-07
I6415 n1_m1_259200_465600 0 2.720092e-07
I6416 n1_m1_259200_470400 0 1.759677e-07
I6417 n1_m1_259200_475200 0 1.846495e-07
I6418 n1_m1_259200_480000 0 2.819748e-07
I6419 n1_m1_259200_484800 0 1.759745e-07
I6420 n1_m1_259200_489600 0 2.729426e-07
I6421 n1_m1_259200_494400 0 1.989451e-07
I6422 n1_m1_259200_499200 0 1.967789e-07
I6423 n1_m1_259200_504000 0 2.671880e-07
I6424 n1_m1_259200_508800 0 1.672328e-07
I6425 n1_m1_259200_513600 0 2.498285e-07
I6426 n1_m1_259200_518400 0 1.665524e-07
I6427 n1_m1_259200_523200 0 1.683606e-07
I6428 n1_m1_259200_528000 0 2.596789e-07
I6429 n1_m1_259200_532800 0 1.732144e-07
I6430 n1_m1_259200_537600 0 2.592982e-07
I6431 n1_m1_259200_542400 0 1.675993e-07
I6432 n1_m1_259200_547200 0 1.615082e-07
I6433 n1_m1_259200_552000 0 2.257389e-07
I6434 n1_m1_259200_556800 0 1.469141e-07
I6435 n1_m1_264000_0 0 2.221333e-07
I6436 n1_m1_264000_4800 0 2.285574e-07
I6437 n1_m1_264000_9600 0 3.572283e-07
I6438 n1_m1_264000_14400 0 2.369170e-07
I6439 n1_m1_264000_19200 0 2.305265e-07
I6440 n1_m1_264000_24000 0 3.447634e-07
I6441 n1_m1_264000_28800 0 2.298422e-07
I6442 n1_m1_264000_33600 0 3.507593e-07
I6443 n1_m1_264000_38400 0 2.326974e-07
I6444 n1_m1_264000_43200 0 2.298422e-07
I6445 n1_m1_264000_48000 0 3.447634e-07
I6446 n1_m1_264000_52800 0 2.301991e-07
I6447 n1_m1_264000_57600 0 3.590964e-07
I6448 n1_m1_264000_62400 0 2.488578e-07
I6449 n1_m1_264000_67200 0 2.542683e-07
I6450 n1_m1_264000_72000 0 3.747285e-07
I6451 n1_m1_264000_76800 0 2.484866e-07
I6452 n1_m1_264000_81600 0 3.676762e-07
I6453 n1_m1_264000_86400 0 2.500957e-07
I6454 n1_m1_264000_91200 0 4.127371e-07
I6455 n1_m1_264000_96000 0 9.768642e-07
I6456 n1_m1_264000_100800 0 4.707065e-07
I6457 n1_m1_264000_105600 0 4.516798e-07
I6458 n1_m1_264000_110400 0 3.753322e-07
I6459 n1_m1_264000_115200 0 5.124534e-07
I6460 n1_m1_264000_120000 0 7.076521e-07
I6461 n1_m1_264000_124800 0 3.289885e-07
I6462 n1_m1_264000_129600 0 4.384960e-07
I6463 n1_m1_264000_134400 0 3.184304e-07
I6464 n1_m1_264000_139200 0 4.832398e-07
I6465 n1_m1_264000_144000 0 9.910800e-07
I6466 n1_m1_264000_148800 0 4.159258e-07
I6467 n1_m1_264000_153600 0 5.026295e-07
I6468 n1_m1_264000_158400 0 3.543619e-07
I6469 n1_m1_264000_163200 0 8.367961e-07
I6470 n1_m1_264000_168000 0 2.119658e-06
I6471 n1_m1_264000_172800 0 8.280459e-07
I6472 n1_m1_264000_177600 0 5.791566e-07
I6473 n1_m1_264000_182400 0 2.632173e-07
I6474 n1_m1_264000_187200 0 2.710201e-07
I6475 n1_m1_264000_192000 0 4.286395e-07
I6476 n1_m1_264000_196800 0 3.029900e-07
I6477 n1_m1_264000_201600 0 4.499799e-07
I6478 n1_m1_264000_206400 0 2.567789e-07
I6479 n1_m1_264000_211200 0 2.557112e-07
I6480 n1_m1_264000_216000 0 4.349851e-07
I6481 n1_m1_264000_220800 0 3.949534e-07
I6482 n1_m1_264000_225600 0 7.756799e-07
I6483 n1_m1_264000_230400 0 5.154992e-07
I6484 n1_m1_264000_235200 0 4.054013e-07
I6485 n1_m1_264000_240000 0 4.281826e-07
I6486 n1_m1_264000_244800 0 2.694661e-07
I6487 n1_m1_264000_249600 0 4.642100e-07
I6488 n1_m1_264000_254400 0 3.586141e-07
I6489 n1_m1_264000_259200 0 3.085698e-07
I6490 n1_m1_264000_264000 0 4.148143e-07
I6491 n1_m1_264000_268800 0 3.425098e-07
I6492 n1_m1_264000_273600 0 9.018147e-07
I6493 n1_m1_264000_278400 0 5.963764e-07
I6494 n1_m1_264000_283200 0 3.996379e-07
I6495 n1_m1_264000_288000 0 4.348821e-07
I6496 n1_m1_264000_292800 0 2.595219e-07
I6497 n1_m1_264000_297600 0 3.781017e-07
I6498 n1_m1_264000_302400 0 2.487578e-07
I6499 n1_m1_264000_307200 0 2.414771e-07
I6500 n1_m1_264000_312000 0 3.615743e-07
I6501 n1_m1_264000_316800 0 2.483234e-07
I6502 n1_m1_264000_321600 0 3.905371e-07
I6503 n1_m1_264000_326400 0 3.047704e-07
I6504 n1_m1_264000_331200 0 3.765354e-07
I6505 n1_m1_264000_336000 0 6.162546e-07
I6506 n1_m1_264000_340800 0 3.297777e-07
I6507 n1_m1_264000_345600 0 4.398114e-07
I6508 n1_m1_264000_350400 0 4.775926e-07
I6509 n1_m1_264000_355200 0 6.824275e-07
I6510 n1_m1_264000_360000 0 1.216856e-06
I6511 n1_m1_264000_364800 0 5.365797e-07
I6512 n1_m1_264000_369600 0 4.318750e-07
I6513 n1_m1_264000_374400 0 2.957541e-07
I6514 n1_m1_264000_379200 0 3.043319e-07
I6515 n1_m1_264000_384000 0 4.213180e-07
I6516 n1_m1_264000_388800 0 2.757801e-07
I6517 n1_m1_264000_393600 0 3.995859e-07
I6518 n1_m1_264000_398400 0 2.810143e-07
I6519 n1_m1_264000_403200 0 3.558292e-07
I6520 n1_m1_264000_408000 0 5.143052e-07
I6521 n1_m1_264000_412800 0 2.778297e-07
I6522 n1_m1_264000_417600 0 3.963045e-07
I6523 n1_m1_264000_422400 0 4.206439e-07
I6524 n1_m1_264000_427200 0 7.418378e-07
I6525 n1_m1_264000_432000 0 1.217446e-06
I6526 n1_m1_264000_436800 0 4.759203e-07
I6527 n1_m1_264000_441600 0 4.414623e-07
I6528 n1_m1_264000_446400 0 2.775167e-07
I6529 n1_m1_264000_451200 0 2.744708e-07
I6530 n1_m1_264000_456000 0 4.077997e-07
I6531 n1_m1_264000_460800 0 2.850329e-07
I6532 n1_m1_264000_465600 0 4.153496e-07
I6533 n1_m1_264000_470400 0 2.595463e-07
I6534 n1_m1_264000_475200 0 2.645042e-07
I6535 n1_m1_264000_480000 0 4.092844e-07
I6536 n1_m1_264000_484800 0 2.631337e-07
I6537 n1_m1_264000_489600 0 3.838845e-07
I6538 n1_m1_264000_494400 0 2.606701e-07
I6539 n1_m1_264000_499200 0 2.613818e-07
I6540 n1_m1_264000_504000 0 3.885762e-07
I6541 n1_m1_264000_508800 0 2.524553e-07
I6542 n1_m1_264000_513600 0 3.777407e-07
I6543 n1_m1_264000_518400 0 2.518272e-07
I6544 n1_m1_264000_523200 0 2.539971e-07
I6545 n1_m1_264000_528000 0 3.895612e-07
I6546 n1_m1_264000_532800 0 2.598217e-07
I6547 n1_m1_264000_537600 0 3.889473e-07
I6548 n1_m1_264000_542400 0 2.513989e-07
I6549 n1_m1_264000_547200 0 2.422623e-07
I6550 n1_m1_264000_552000 0 3.449867e-07
I6551 n1_m1_264000_556800 0 2.218396e-07
I6552 n1_m1_268800_0 0 1.480888e-07
I6553 n1_m1_268800_4800 0 1.523716e-07
I6554 n1_m1_268800_9600 0 2.383602e-07
I6555 n1_m1_268800_14400 0 1.586054e-07
I6556 n1_m1_268800_19200 0 1.537516e-07
I6557 n1_m1_268800_24000 0 2.298422e-07
I6558 n1_m1_268800_28800 0 1.532282e-07
I6559 n1_m1_268800_33600 0 2.298779e-07
I6560 n1_m1_268800_38400 0 1.532452e-07
I6561 n1_m1_268800_43200 0 1.532282e-07
I6562 n1_m1_268800_48000 0 2.312753e-07
I6563 n1_m1_268800_52800 0 1.548886e-07
I6564 n1_m1_268800_57600 0 2.385862e-07
I6565 n1_m1_268800_62400 0 1.599440e-07
I6566 n1_m1_268800_67200 0 1.610724e-07
I6567 n1_m1_268800_72000 0 2.475984e-07
I6568 n1_m1_268800_76800 0 1.621112e-07
I6569 n1_m1_268800_81600 0 2.472038e-07
I6570 n1_m1_268800_86400 0 1.642437e-07
I6571 n1_m1_268800_91200 0 2.028791e-07
I6572 n1_m1_268800_96000 0 4.294879e-07
I6573 n1_m1_268800_100800 0 2.263351e-07
I6574 n1_m1_268800_105600 0 2.786808e-07
I6575 n1_m1_268800_110400 0 1.801590e-07
I6576 n1_m1_268800_115200 0 1.794394e-07
I6577 n1_m1_268800_120000 0 3.038047e-07
I6578 n1_m1_268800_124800 0 2.647897e-07
I6579 n1_m1_268800_129600 0 3.839378e-07
I6580 n1_m1_268800_134400 0 1.965692e-07
I6581 n1_m1_268800_139200 0 2.738834e-07
I6582 n1_m1_268800_144000 0 6.747651e-07
I6583 n1_m1_268800_148800 0 3.628809e-07
I6584 n1_m1_268800_153600 0 4.529626e-07
I6585 n1_m1_268800_158400 0 2.208875e-07
I6586 n1_m1_268800_163200 0 2.065426e-07
I6587 n1_m1_268800_168000 0 4.814332e-07
I6588 n1_m1_268800_172800 0 2.845938e-07
I6589 n1_m1_268800_177600 0 3.876727e-07
I6590 n1_m1_268800_182400 0 2.146581e-07
I6591 n1_m1_268800_187200 0 2.806326e-07
I6592 n1_m1_268800_192000 0 4.881486e-07
I6593 n1_m1_268800_196800 0 3.351795e-07
I6594 n1_m1_268800_201600 0 4.491560e-07
I6595 n1_m1_268800_206400 0 1.934050e-07
I6596 n1_m1_268800_211200 0 1.644361e-07
I6597 n1_m1_268800_216000 0 2.623172e-07
I6598 n1_m1_268800_220800 0 2.174752e-07
I6599 n1_m1_268800_225600 0 4.533242e-07
I6600 n1_m1_268800_230400 0 3.225949e-07
I6601 n1_m1_268800_235200 0 2.780119e-07
I6602 n1_m1_268800_240000 0 3.090195e-07
I6603 n1_m1_268800_244800 0 1.712546e-07
I6604 n1_m1_268800_249600 0 2.825673e-07
I6605 n1_m1_268800_254400 0 2.497656e-07
I6606 n1_m1_268800_259200 0 2.275248e-07
I6607 n1_m1_268800_264000 0 2.681517e-07
I6608 n1_m1_268800_268800 0 1.705194e-07
I6609 n1_m1_268800_273600 0 3.062306e-07
I6610 n1_m1_268800_278400 0 2.570141e-07
I6611 n1_m1_268800_283200 0 2.517109e-07
I6612 n1_m1_268800_288000 0 2.957977e-07
I6613 n1_m1_268800_292800 0 1.756414e-07
I6614 n1_m1_268800_297600 0 2.521769e-07
I6615 n1_m1_268800_302400 0 1.647006e-07
I6616 n1_m1_268800_307200 0 1.608372e-07
I6617 n1_m1_268800_312000 0 2.413551e-07
I6618 n1_m1_268800_316800 0 1.599783e-07
I6619 n1_m1_268800_321600 0 2.465502e-07
I6620 n1_m1_268800_326400 0 1.903394e-07
I6621 n1_m1_268800_331200 0 2.512092e-07
I6622 n1_m1_268800_336000 0 4.863417e-07
I6623 n1_m1_268800_340800 0 2.739365e-07
I6624 n1_m1_268800_345600 0 3.043489e-07
I6625 n1_m1_268800_350400 0 1.984719e-07
I6626 n1_m1_268800_355200 0 2.856828e-07
I6627 n1_m1_268800_360000 0 6.141628e-07
I6628 n1_m1_268800_364800 0 3.273600e-07
I6629 n1_m1_268800_369600 0 2.870700e-07
I6630 n1_m1_268800_374400 0 1.857773e-07
I6631 n1_m1_268800_379200 0 1.871165e-07
I6632 n1_m1_268800_384000 0 3.581470e-07
I6633 n1_m1_268800_388800 0 3.095019e-07
I6634 n1_m1_268800_393600 0 4.255419e-07
I6635 n1_m1_268800_398400 0 1.931310e-07
I6636 n1_m1_268800_403200 0 1.735401e-07
I6637 n1_m1_268800_408000 0 2.587445e-07
I6638 n1_m1_268800_412800 0 1.729877e-07
I6639 n1_m1_268800_417600 0 2.559658e-07
I6640 n1_m1_268800_422400 0 1.716434e-07
I6641 n1_m1_268800_427200 0 1.827236e-07
I6642 n1_m1_268800_432000 0 2.906668e-07
I6643 n1_m1_268800_436800 0 1.858547e-07
I6644 n1_m1_268800_441600 0 2.669484e-07
I6645 n1_m1_268800_446400 0 1.761573e-07
I6646 n1_m1_268800_451200 0 1.751679e-07
I6647 n1_m1_268800_456000 0 2.677047e-07
I6648 n1_m1_268800_460800 0 1.824550e-07
I6649 n1_m1_268800_465600 0 2.658053e-07
I6650 n1_m1_268800_470400 0 1.706631e-07
I6651 n1_m1_268800_475200 0 1.686128e-07
I6652 n1_m1_268800_480000 0 2.598846e-07
I6653 n1_m1_268800_484800 0 1.723701e-07
I6654 n1_m1_268800_489600 0 2.589039e-07
I6655 n1_m1_268800_494400 0 1.719942e-07
I6656 n1_m1_268800_499200 0 1.717498e-07
I6657 n1_m1_268800_504000 0 2.593699e-07
I6658 n1_m1_268800_508800 0 1.731706e-07
I6659 n1_m1_268800_513600 0 2.590970e-07
I6660 n1_m1_268800_518400 0 1.722185e-07
I6661 n1_m1_268800_523200 0 1.727794e-07
I6662 n1_m1_268800_528000 0 2.576395e-07
I6663 n1_m1_268800_532800 0 1.717393e-07
I6664 n1_m1_268800_537600 0 2.585185e-07
I6665 n1_m1_268800_542400 0 1.675993e-07
I6666 n1_m1_268800_547200 0 1.615082e-07
I6667 n1_m1_268800_552000 0 2.308416e-07
I6668 n1_m1_268800_556800 0 1.480888e-07
I6669 n1_m1_273600_0 0 2.221333e-07
I6670 n1_m1_273600_4800 0 2.285574e-07
I6671 n1_m1_273600_9600 0 3.575403e-07
I6672 n1_m1_273600_14400 0 2.379081e-07
I6673 n1_m1_273600_19200 0 2.306274e-07
I6674 n1_m1_273600_24000 0 3.447634e-07
I6675 n1_m1_273600_28800 0 2.298422e-07
I6676 n1_m1_273600_33600 0 3.447634e-07
I6677 n1_m1_273600_38400 0 2.298422e-07
I6678 n1_m1_273600_43200 0 2.320163e-07
I6679 n1_m1_273600_48000 0 3.565165e-07
I6680 n1_m1_273600_52800 0 2.425244e-07
I6681 n1_m1_273600_57600 0 3.606198e-07
I6682 n1_m1_273600_62400 0 2.398354e-07
I6683 n1_m1_273600_67200 0 2.425026e-07
I6684 n1_m1_273600_72000 0 3.784236e-07
I6685 n1_m1_273600_76800 0 2.431188e-07
I6686 n1_m1_273600_81600 0 3.840976e-07
I6687 n1_m1_273600_86400 0 2.513941e-07
I6688 n1_m1_273600_91200 0 2.524465e-07
I6689 n1_m1_273600_96000 0 4.173126e-07
I6690 n1_m1_273600_100800 0 2.754215e-07
I6691 n1_m1_273600_105600 0 4.216405e-07
I6692 n1_m1_273600_110400 0 2.719242e-07
I6693 n1_m1_273600_115200 0 2.602166e-07
I6694 n1_m1_273600_120000 0 4.074917e-07
I6695 n1_m1_273600_124800 0 3.223645e-07
I6696 n1_m1_273600_129600 0 5.037389e-07
I6697 n1_m1_273600_134400 0 2.833389e-07
I6698 n1_m1_273600_139200 0 2.751445e-07
I6699 n1_m1_273600_144000 0 4.154744e-07
I6700 n1_m1_273600_148800 0 3.099794e-07
I6701 n1_m1_273600_153600 0 6.112091e-07
I6702 n1_m1_273600_158400 0 3.885833e-07
I6703 n1_m1_273600_163200 0 3.036253e-07
I6704 n1_m1_273600_168000 0 4.101661e-07
I6705 n1_m1_273600_172800 0 2.738114e-07
I6706 n1_m1_273600_177600 0 4.119101e-07
I6707 n1_m1_273600_182400 0 3.169213e-07
I6708 n1_m1_273600_187200 0 4.353033e-07
I6709 n1_m1_273600_192000 0 7.855452e-07
I6710 n1_m1_273600_196800 0 5.861691e-07
I6711 n1_m1_273600_201600 0 9.002168e-07
I6712 n1_m1_273600_206400 0 4.296813e-07
I6713 n1_m1_273600_211200 0 2.760785e-07
I6714 n1_m1_273600_216000 0 3.671453e-07
I6715 n1_m1_273600_220800 0 2.462582e-07
I6716 n1_m1_273600_225600 0 3.935007e-07
I6717 n1_m1_273600_230400 0 2.723274e-07
I6718 n1_m1_273600_235200 0 2.714810e-07
I6719 n1_m1_273600_240000 0 3.906604e-07
I6720 n1_m1_273600_244800 0 2.545056e-07
I6721 n1_m1_273600_249600 0 3.849847e-07
I6722 n1_m1_273600_254400 0 2.624209e-07
I6723 n1_m1_273600_259200 0 2.610487e-07
I6724 n1_m1_273600_264000 0 3.842230e-07
I6725 n1_m1_273600_268800 0 2.539675e-07
I6726 n1_m1_273600_273600 0 3.873685e-07
I6727 n1_m1_273600_278400 0 2.992946e-07
I6728 n1_m1_273600_283200 0 3.246962e-07
I6729 n1_m1_273600_288000 0 4.430772e-07
I6730 n1_m1_273600_292800 0 2.668882e-07
I6731 n1_m1_273600_297600 0 3.771483e-07
I6732 n1_m1_273600_302400 0 2.413058e-07
I6733 n1_m1_273600_307200 0 2.405111e-07
I6734 n1_m1_273600_312000 0 3.696201e-07
I6735 n1_m1_273600_316800 0 2.400424e-07
I6736 n1_m1_273600_321600 0 3.633323e-07
I6737 n1_m1_273600_326400 0 2.527877e-07
I6738 n1_m1_273600_331200 0 2.729372e-07
I6739 n1_m1_273600_336000 0 4.634095e-07
I6740 n1_m1_273600_340800 0 3.102694e-07
I6741 n1_m1_273600_345600 0 4.280164e-07
I6742 n1_m1_273600_350400 0 2.882807e-07
I6743 n1_m1_273600_355200 0 2.656140e-07
I6744 n1_m1_273600_360000 0 4.158017e-07
I6745 n1_m1_273600_364800 0 2.822753e-07
I6746 n1_m1_273600_369600 0 4.094710e-07
I6747 n1_m1_273600_374400 0 3.115549e-07
I6748 n1_m1_273600_379200 0 3.448042e-07
I6749 n1_m1_273600_384000 0 9.707623e-07
I6750 n1_m1_273600_388800 0 1.220033e-06
I6751 n1_m1_273600_393600 0 1.865457e-06
I6752 n1_m1_273600_398400 0 5.882041e-07
I6753 n1_m1_273600_403200 0 2.965509e-07
I6754 n1_m1_273600_408000 0 4.056437e-07
I6755 n1_m1_273600_412800 0 3.005366e-07
I6756 n1_m1_273600_417600 0 3.839246e-07
I6757 n1_m1_273600_422400 0 2.613431e-07
I6758 n1_m1_273600_427200 0 2.717020e-07
I6759 n1_m1_273600_432000 0 4.075274e-07
I6760 n1_m1_273600_436800 0 2.697067e-07
I6761 n1_m1_273600_441600 0 4.147725e-07
I6762 n1_m1_273600_446400 0 2.750089e-07
I6763 n1_m1_273600_451200 0 2.644542e-07
I6764 n1_m1_273600_456000 0 3.907145e-07
I6765 n1_m1_273600_460800 0 2.604117e-07
I6766 n1_m1_273600_465600 0 3.901108e-07
I6767 n1_m1_273600_470400 0 2.589774e-07
I6768 n1_m1_273600_475200 0 2.582894e-07
I6769 n1_m1_273600_480000 0 3.870969e-07
I6770 n1_m1_273600_484800 0 2.525471e-07
I6771 n1_m1_273600_489600 0 3.840055e-07
I6772 n1_m1_273600_494400 0 2.518866e-07
I6773 n1_m1_273600_499200 0 2.502028e-07
I6774 n1_m1_273600_504000 0 3.821520e-07
I6775 n1_m1_273600_508800 0 2.559196e-07
I6776 n1_m1_273600_513600 0 3.796014e-07
I6777 n1_m1_273600_518400 0 2.497096e-07
I6778 n1_m1_273600_523200 0 2.543567e-07
I6779 n1_m1_273600_528000 0 3.728574e-07
I6780 n1_m1_273600_532800 0 2.484336e-07
I6781 n1_m1_273600_537600 0 3.838413e-07
I6782 n1_m1_273600_542400 0 2.513989e-07
I6783 n1_m1_273600_547200 0 2.422623e-07
I6784 n1_m1_273600_552000 0 3.469591e-07
I6785 n1_m1_273600_556800 0 2.251434e-07
I6786 n1_m1_278400_0 0 1.506585e-07
I6787 n1_m1_278400_4800 0 1.527999e-07
I6788 n1_m1_278400_9600 0 2.341012e-07
I6789 n1_m1_278400_14400 0 1.559168e-07
I6790 n1_m1_278400_19200 0 1.534899e-07
I6791 n1_m1_278400_24000 0 2.298422e-07
I6792 n1_m1_278400_28800 0 1.532282e-07
I6793 n1_m1_278400_33600 0 2.348388e-07
I6794 n1_m1_278400_38400 0 1.598903e-07
I6795 n1_m1_278400_43200 0 1.598903e-07
I6796 n1_m1_278400_48000 0 2.368612e-07
I6797 n1_m1_278400_52800 0 1.592478e-07
I6798 n1_m1_278400_57600 0 2.398354e-07
I6799 n1_m1_278400_62400 0 1.604851e-07
I6800 n1_m1_278400_67200 0 1.638161e-07
I6801 n1_m1_278400_72000 0 2.497809e-07
I6802 n1_m1_278400_76800 0 1.609847e-07
I6803 n1_m1_278400_81600 0 2.495430e-07
I6804 n1_m1_278400_86400 0 1.678372e-07
I6805 n1_m1_278400_91200 0 1.683130e-07
I6806 n1_m1_278400_96000 0 2.611065e-07
I6807 n1_m1_278400_100800 0 1.779731e-07
I6808 n1_m1_278400_105600 0 3.342468e-07
I6809 n1_m1_278400_110400 0 1.859676e-07
I6810 n1_m1_278400_115200 0 1.772593e-07
I6811 n1_m1_278400_120000 0 2.673879e-07
I6812 n1_m1_278400_124800 0 1.812090e-07
I6813 n1_m1_278400_129600 0 2.626293e-07
I6814 n1_m1_278400_134400 0 1.751655e-07
I6815 n1_m1_278400_139200 0 1.815421e-07
I6816 n1_m1_278400_144000 0 2.738359e-07
I6817 n1_m1_278400_148800 0 2.257498e-07
I6818 n1_m1_278400_153600 0 3.381251e-07
I6819 n1_m1_278400_158400 0 1.828031e-07
I6820 n1_m1_278400_163200 0 1.740234e-07
I6821 n1_m1_278400_168000 0 2.610113e-07
I6822 n1_m1_278400_172800 0 1.765455e-07
I6823 n1_m1_278400_177600 0 2.605355e-07
I6824 n1_m1_278400_182400 0 1.717393e-07
I6825 n1_m1_278400_187200 0 1.794958e-07
I6826 n1_m1_278400_192000 0 2.942266e-07
I6827 n1_m1_278400_196800 0 2.553485e-07
I6828 n1_m1_278400_201600 0 4.890215e-07
I6829 n1_m1_278400_206400 0 2.942028e-07
I6830 n1_m1_278400_211200 0 1.882517e-07
I6831 n1_m1_278400_216000 0 2.449271e-07
I6832 n1_m1_278400_220800 0 1.606992e-07
I6833 n1_m1_278400_225600 0 2.447130e-07
I6834 n1_m1_278400_230400 0 1.649820e-07
I6835 n1_m1_278400_235200 0 1.650772e-07
I6836 n1_m1_278400_240000 0 2.476871e-07
I6837 n1_m1_278400_244800 0 1.665524e-07
I6838 n1_m1_278400_249600 0 2.454744e-07
I6839 n1_m1_278400_254400 0 1.602472e-07
I6840 n1_m1_278400_259200 0 1.604137e-07
I6841 n1_m1_278400_264000 0 2.495430e-07
I6842 n1_m1_278400_268800 0 1.705972e-07
I6843 n1_m1_278400_273600 0 2.596551e-07
I6844 n1_m1_278400_278400 0 1.765455e-07
I6845 n1_m1_278400_283200 0 1.840166e-07
I6846 n1_m1_278400_288000 0 2.764531e-07
I6847 n1_m1_278400_292800 0 1.728813e-07
I6848 n1_m1_278400_297600 0 2.506137e-07
I6849 n1_m1_278400_302400 0 1.632689e-07
I6850 n1_m1_278400_307200 0 1.606516e-07
I6851 n1_m1_278400_312000 0 2.432378e-07
I6852 n1_m1_278400_316800 0 1.606516e-07
I6853 n1_m1_278400_321600 0 2.464737e-07
I6854 n1_m1_278400_326400 0 1.649820e-07
I6855 n1_m1_278400_331200 0 1.645061e-07
I6856 n1_m1_278400_336000 0 2.524696e-07
I6857 n1_m1_278400_340800 0 1.877759e-07
I6858 n1_m1_278400_345600 0 3.589917e-07
I6859 n1_m1_278400_350400 0 2.085473e-07
I6860 n1_m1_278400_355200 0 1.792341e-07
I6861 n1_m1_278400_360000 0 2.760486e-07
I6862 n1_m1_278400_364800 0 1.910355e-07
I6863 n1_m1_278400_369600 0 3.809290e-07
I6864 n1_m1_278400_374400 0 3.341516e-07
I6865 n1_m1_278400_379200 0 3.302495e-07
I6866 n1_m1_278400_384000 0 6.320662e-07
I6867 n1_m1_278400_388800 0 9.236518e-07
I6868 n1_m1_278400_393600 0 1.666761e-06
I6869 n1_m1_278400_398400 0 5.435079e-07
I6870 n1_m1_278400_403200 0 2.242271e-07
I6871 n1_m1_278400_408000 0 3.288695e-07
I6872 n1_m1_278400_412800 0 2.641282e-07
I6873 n1_m1_278400_417600 0 2.646041e-07
I6874 n1_m1_278400_422400 0 1.773545e-07
I6875 n1_m1_278400_427200 0 1.843021e-07
I6876 n1_m1_278400_432000 0 2.750969e-07
I6877 n1_m1_278400_436800 0 1.778303e-07
I6878 n1_m1_278400_441600 0 2.713138e-07
I6879 n1_m1_278400_446400 0 1.802096e-07
I6880 n1_m1_278400_451200 0 1.771641e-07
I6881 n1_m1_278400_456000 0 2.607258e-07
I6882 n1_m1_278400_460800 0 1.726672e-07
I6883 n1_m1_278400_465600 0 2.567523e-07
I6884 n1_m1_278400_470400 0 1.757841e-07
I6885 n1_m1_278400_475200 0 1.798765e-07
I6886 n1_m1_278400_480000 0 2.631051e-07
I6887 n1_m1_278400_484800 0 1.679324e-07
I6888 n1_m1_278400_489600 0 2.531596e-07
I6889 n1_m1_278400_494400 0 1.702165e-07
I6890 n1_m1_278400_499200 0 1.750465e-07
I6891 n1_m1_278400_504000 0 2.588937e-07
I6892 n1_m1_278400_508800 0 1.645061e-07
I6893 n1_m1_278400_513600 0 2.494240e-07
I6894 n1_m1_278400_518400 0 1.653627e-07
I6895 n1_m1_278400_523200 0 1.641254e-07
I6896 n1_m1_278400_528000 0 2.476158e-07
I6897 n1_m1_278400_532800 0 1.669330e-07
I6898 n1_m1_278400_537600 0 2.577992e-07
I6899 n1_m1_278400_542400 0 1.702879e-07
I6900 n1_m1_278400_547200 0 1.648392e-07
I6901 n1_m1_278400_552000 0 2.364330e-07
I6902 n1_m1_278400_556800 0 1.539895e-07
I6903 n1_m1_283200_0 0 7.661408e-08
I6904 n1_m1_283200_4800 0 7.661408e-08
I6905 n1_m1_283200_9600 0 1.149211e-07
I6906 n1_m1_283200_14400 0 7.661408e-08
I6907 n1_m1_283200_19200 0 7.670688e-08
I6908 n1_m1_283200_24000 0 1.157739e-07
I6909 n1_m1_283200_28800 0 7.723270e-08
I6910 n1_m1_283200_33600 0 1.194537e-07
I6911 n1_m1_283200_38400 0 8.203893e-08
I6912 n1_m1_283200_43200 0 8.052772e-08
I6913 n1_m1_283200_48000 0 1.164034e-07
I6914 n1_m1_283200_52800 0 7.721027e-08
I6915 n1_m1_283200_57600 0 1.192590e-07
I6916 n1_m1_283200_62400 0 8.042949e-08
I6917 n1_m1_283200_67200 0 8.240569e-08
I6918 n1_m1_283200_72000 0 1.228626e-07
I6919 n1_m1_283200_76800 0 7.994513e-08
I6920 n1_m1_283200_81600 0 1.199177e-07
I6921 n1_m1_283200_86400 0 8.161133e-08
I6922 n1_m1_283200_91200 0 8.441825e-08
I6923 n1_m1_283200_96000 0 1.296457e-07
I6924 n1_m1_283200_100800 0 8.944813e-08
I6925 n1_m1_283200_105600 0 2.264962e-07
I6926 n1_m1_283200_110400 0 1.191879e-07
I6927 n1_m1_283200_115200 0 1.075357e-07
I6928 n1_m1_283200_120000 0 1.517316e-07
I6929 n1_m1_283200_124800 0 9.379753e-08
I6930 n1_m1_283200_129600 0 1.316977e-07
I6931 n1_m1_283200_134400 0 9.167993e-08
I6932 n1_m1_283200_139200 0 9.050931e-08
I6933 n1_m1_283200_144000 0 1.359886e-07
I6934 n1_m1_283200_148800 0 1.089711e-07
I6935 n1_m1_283200_153600 0 1.551201e-07
I6936 n1_m1_283200_158400 0 1.020004e-07
I6937 n1_m1_283200_163200 0 1.062618e-07
I6938 n1_m1_283200_168000 0 1.529287e-07
I6939 n1_m1_283200_172800 0 9.201576e-08
I6940 n1_m1_283200_177600 0 1.300699e-07
I6941 n1_m1_283200_182400 0 8.660722e-08
I6942 n1_m1_283200_187200 0 8.788594e-08
I6943 n1_m1_283200_192000 0 1.340763e-07
I6944 n1_m1_283200_196800 0 9.137334e-08
I6945 n1_m1_283200_201600 0 1.472258e-07
I6946 n1_m1_283200_206400 0 9.329719e-08
I6947 n1_m1_283200_211200 0 8.195361e-08
I6948 n1_m1_283200_216000 0 1.199177e-07
I6949 n1_m1_283200_220800 0 8.060386e-08
I6950 n1_m1_283200_225600 0 1.238895e-07
I6951 n1_m1_283200_230400 0 8.265755e-08
I6952 n1_m1_283200_235200 0 8.145634e-08
I6953 n1_m1_283200_240000 0 1.221978e-07
I6954 n1_m1_283200_244800 0 8.113207e-08
I6955 n1_m1_283200_249600 0 1.208456e-07
I6956 n1_m1_283200_254400 0 8.056375e-08
I6957 n1_m1_283200_259200 0 8.077687e-08
I6958 n1_m1_283200_264000 0 1.243912e-07
I6959 n1_m1_283200_268800 0 8.401376e-08
I6960 n1_m1_283200_273600 0 1.297443e-07
I6961 n1_m1_283200_278400 0 8.494170e-08
I6962 n1_m1_283200_283200 0 8.439989e-08
I6963 n1_m1_283200_288000 0 1.267355e-07
I6964 n1_m1_283200_292800 0 8.327618e-08
I6965 n1_m1_283200_297600 0 1.242249e-07
I6966 n1_m1_283200_302400 0 8.236694e-08
I6967 n1_m1_283200_307200 0 8.039074e-08
I6968 n1_m1_283200_312000 0 1.199177e-07
I6969 n1_m1_283200_316800 0 8.050699e-08
I6970 n1_m1_283200_321600 0 1.256678e-07
I6971 n1_m1_283200_326400 0 8.441825e-08
I6972 n1_m1_283200_331200 0 8.265755e-08
I6973 n1_m1_283200_336000 0 1.271179e-07
I6974 n1_m1_283200_340800 0 1.035092e-07
I6975 n1_m1_283200_345600 0 2.257746e-07
I6976 n1_m1_283200_350400 0 1.168511e-07
I6977 n1_m1_283200_355200 0 9.588827e-08
I6978 n1_m1_283200_360000 0 1.459196e-07
I6979 n1_m1_283200_364800 0 1.041853e-07
I6980 n1_m1_283200_369600 0 2.777091e-07
I6981 n1_m1_283200_374400 0 2.464071e-07
I6982 n1_m1_283200_379200 0 2.059777e-07
I6983 n1_m1_283200_384000 0 2.106054e-07
I6984 n1_m1_283200_388800 0 3.255861e-07
I6985 n1_m1_283200_393600 0 6.751125e-07
I6986 n1_m1_283200_398400 0 2.292345e-07
I6987 n1_m1_283200_403200 0 1.191097e-07
I6988 n1_m1_283200_408000 0 1.780530e-07
I6989 n1_m1_283200_412800 0 1.358391e-07
I6990 n1_m1_283200_417600 0 1.436137e-07
I6991 n1_m1_283200_422400 0 9.905106e-08
I6992 n1_m1_283200_427200 0 1.204697e-07
I6993 n1_m1_283200_432000 0 1.768388e-07
I6994 n1_m1_283200_436800 0 9.284920e-08
I6995 n1_m1_283200_441600 0 1.331841e-07
I6996 n1_m1_283200_446400 0 8.986961e-08
I6997 n1_m1_283200_451200 0 9.148211e-08
I6998 n1_m1_283200_456000 0 1.313833e-07
I6999 n1_m1_283200_460800 0 8.616161e-08
I7000 n1_m1_283200_465600 0 1.277032e-07
I7001 n1_m1_283200_470400 0 8.803346e-08
I7002 n1_m1_283200_475200 0 9.013337e-08
I7003 n1_m1_283200_480000 0 1.343863e-07
I7004 n1_m1_283200_484800 0 8.538085e-08
I7005 n1_m1_283200_489600 0 1.264034e-07
I7006 n1_m1_283200_494400 0 8.633224e-08
I7007 n1_m1_283200_499200 0 8.984820e-08
I7008 n1_m1_283200_504000 0 1.313680e-07
I7009 n1_m1_283200_508800 0 8.099135e-08
I7010 n1_m1_283200_513600 0 1.248582e-07
I7011 n1_m1_283200_518400 0 8.343253e-08
I7012 n1_m1_283200_523200 0 8.152092e-08
I7013 n1_m1_283200_528000 0 1.281039e-07
I7014 n1_m1_283200_532800 0 8.629859e-08
I7015 n1_m1_283200_537600 0 1.307902e-07
I7016 n1_m1_283200_542400 0 8.660756e-08
I7017 n1_m1_283200_547200 0 8.408514e-08
I7018 n1_m1_283200_552000 0 1.196927e-07
I7019 n1_m1_283200_556800 0 7.675684e-08
I7020 n1_m1_288000_0 0 1.532282e-07
I7021 n1_m1_288000_4800 0 1.532282e-07
I7022 n1_m1_288000_9600 0 2.298422e-07
I7023 n1_m1_288000_14400 0 1.532282e-07
I7024 n1_m1_288000_19200 0 1.542275e-07
I7025 n1_m1_288000_24000 0 2.390264e-07
I7026 n1_m1_288000_28800 0 1.598903e-07
I7027 n1_m1_288000_33600 0 2.348745e-07
I7028 n1_m1_288000_38400 0 1.532758e-07
I7029 n1_m1_288000_43200 0 1.532758e-07
I7030 n1_m1_288000_48000 0 2.354296e-07
I7031 n1_m1_288000_52800 0 1.637923e-07
I7032 n1_m1_288000_57600 0 2.464778e-07
I7033 n1_m1_288000_62400 0 1.601863e-07
I7034 n1_m1_288000_67200 0 1.605986e-07
I7035 n1_m1_288000_72000 0 2.490607e-07
I7036 n1_m1_288000_76800 0 1.702797e-07
I7037 n1_m1_288000_81600 0 2.554675e-07
I7038 n1_m1_288000_86400 0 1.671547e-07
I7039 n1_m1_288000_91200 0 1.687189e-07
I7040 n1_m1_288000_96000 0 2.793328e-07
I7041 n1_m1_288000_100800 0 2.613954e-07
I7042 n1_m1_288000_105600 0 1.023485e-06
I7043 n1_m1_288000_110400 0 5.311745e-07
I7044 n1_m1_288000_115200 0 3.290619e-07
I7045 n1_m1_288000_120000 0 3.749926e-07
I7046 n1_m1_288000_124800 0 2.085283e-07
I7047 n1_m1_288000_129600 0 3.243879e-07
I7048 n1_m1_288000_134400 0 2.927134e-07
I7049 n1_m1_288000_139200 0 3.117860e-07
I7050 n1_m1_288000_144000 0 4.146423e-07
I7051 n1_m1_288000_148800 0 2.462249e-07
I7052 n1_m1_288000_153600 0 3.306618e-07
I7053 n1_m1_288000_158400 0 2.219195e-07
I7054 n1_m1_288000_163200 0 2.362018e-07
I7055 n1_m1_288000_168000 0 3.371978e-07
I7056 n1_m1_288000_172800 0 2.065616e-07
I7057 n1_m1_288000_177600 0 2.687890e-07
I7058 n1_m1_288000_182400 0 1.756488e-07
I7059 n1_m1_288000_187200 0 1.732872e-07
I7060 n1_m1_288000_192000 0 2.598492e-07
I7061 n1_m1_288000_196800 0 1.731784e-07
I7062 n1_m1_288000_201600 0 2.551946e-07
I7063 n1_m1_288000_206400 0 1.677641e-07
I7064 n1_m1_288000_211200 0 1.650004e-07
I7065 n1_m1_288000_216000 0 2.408245e-07
I7066 n1_m1_288000_220800 0 1.599378e-07
I7067 n1_m1_288000_225600 0 2.399068e-07
I7068 n1_m1_288000_230400 0 1.599378e-07
I7069 n1_m1_288000_235200 0 1.622349e-07
I7070 n1_m1_288000_240000 0 2.478289e-07
I7071 n1_m1_288000_244800 0 1.699439e-07
I7072 n1_m1_288000_249600 0 2.576011e-07
I7073 n1_m1_288000_254400 0 1.710727e-07
I7074 n1_m1_288000_259200 0 1.673233e-07
I7075 n1_m1_288000_264000 0 2.498285e-07
I7076 n1_m1_288000_268800 0 1.680170e-07
I7077 n1_m1_288000_273600 0 2.594196e-07
I7078 n1_m1_288000_278400 0 1.698358e-07
I7079 n1_m1_288000_283200 0 1.643756e-07
I7080 n1_m1_288000_288000 0 2.420482e-07
I7081 n1_m1_288000_292800 0 1.613654e-07
I7082 n1_m1_288000_297600 0 2.403972e-07
I7083 n1_m1_288000_302400 0 1.598535e-07
I7084 n1_m1_288000_307200 0 1.598824e-07
I7085 n1_m1_288000_312000 0 2.398354e-07
I7086 n1_m1_288000_316800 0 1.598903e-07
I7087 n1_m1_288000_321600 0 2.406838e-07
I7088 n1_m1_288000_326400 0 1.607176e-07
I7089 n1_m1_288000_331200 0 1.619018e-07
I7090 n1_m1_288000_336000 0 2.498836e-07
I7091 n1_m1_288000_340800 0 1.882687e-07
I7092 n1_m1_288000_345600 0 3.638343e-07
I7093 n1_m1_288000_350400 0 2.343687e-07
I7094 n1_m1_288000_355200 0 1.957663e-07
I7095 n1_m1_288000_360000 0 3.253094e-07
I7096 n1_m1_288000_364800 0 3.363154e-07
I7097 n1_m1_288000_369600 0 7.096344e-07
I7098 n1_m1_288000_374400 0 4.446390e-07
I7099 n1_m1_288000_379200 0 3.089716e-07
I7100 n1_m1_288000_384000 0 3.326645e-07
I7101 n1_m1_288000_388800 0 2.058281e-07
I7102 n1_m1_288000_393600 0 3.646507e-07
I7103 n1_m1_288000_398400 0 2.792196e-07
I7104 n1_m1_288000_403200 0 2.730371e-07
I7105 n1_m1_288000_408000 0 4.689604e-07
I7106 n1_m1_288000_412800 0 3.571596e-07
I7107 n1_m1_288000_417600 0 4.142300e-07
I7108 n1_m1_288000_422400 0 2.538503e-07
I7109 n1_m1_288000_427200 0 4.267710e-07
I7110 n1_m1_288000_432000 0 6.185224e-07
I7111 n1_m1_288000_436800 0 2.072768e-07
I7112 n1_m1_288000_441600 0 2.905394e-07
I7113 n1_m1_288000_446400 0 3.615542e-07
I7114 n1_m1_288000_451200 0 5.205342e-07
I7115 n1_m1_288000_456000 0 8.353675e-07
I7116 n1_m1_288000_460800 0 3.729032e-07
I7117 n1_m1_288000_465600 0 3.656490e-07
I7118 n1_m1_288000_470400 0 2.205411e-07
I7119 n1_m1_288000_475200 0 2.010049e-07
I7120 n1_m1_288000_480000 0 2.648883e-07
I7121 n1_m1_288000_484800 0 1.891770e-07
I7122 n1_m1_288000_489600 0 2.739174e-07
I7123 n1_m1_288000_494400 0 1.765910e-07
I7124 n1_m1_288000_499200 0 1.641543e-07
I7125 n1_m1_288000_504000 0 2.729310e-07
I7126 n1_m1_288000_508800 0 2.498472e-07
I7127 n1_m1_288000_513600 0 2.697614e-07
I7128 n1_m1_288000_518400 0 1.636598e-07
I7129 n1_m1_288000_523200 0 1.753450e-07
I7130 n1_m1_288000_528000 0 2.780785e-07
I7131 n1_m1_288000_532800 0 1.777508e-07
I7132 n1_m1_288000_537600 0 2.569012e-07
I7133 n1_m1_288000_542400 0 1.682226e-07
I7134 n1_m1_288000_547200 0 1.668991e-07
I7135 n1_m1_288000_552000 0 2.452385e-07
I7136 n1_m1_288000_556800 0 1.585103e-07
I7137 n1_m1_292800_0 0 1.532282e-07
I7138 n1_m1_292800_4800 0 1.532282e-07
I7139 n1_m1_292800_9600 0 2.298422e-07
I7140 n1_m1_292800_14400 0 1.532282e-07
I7141 n1_m1_292800_19200 0 1.542275e-07
I7142 n1_m1_292800_24000 0 2.390264e-07
I7143 n1_m1_292800_28800 0 1.598903e-07
I7144 n1_m1_292800_33600 0 2.383364e-07
I7145 n1_m1_292800_38400 0 1.578916e-07
I7146 n1_m1_292800_43200 0 1.578916e-07
I7147 n1_m1_292800_48000 0 2.393024e-07
I7148 n1_m1_292800_52800 0 1.652675e-07
I7149 n1_m1_292800_57600 0 2.493860e-07
I7150 n1_m1_292800_62400 0 1.638209e-07
I7151 n1_m1_292800_67200 0 1.612274e-07
I7152 n1_m1_292800_72000 0 2.516844e-07
I7153 n1_m1_292800_76800 0 1.747467e-07
I7154 n1_m1_292800_81600 0 2.668169e-07
I7155 n1_m1_292800_86400 0 1.766502e-07
I7156 n1_m1_292800_91200 0 1.818657e-07
I7157 n1_m1_292800_96000 0 3.634077e-07
I7158 n1_m1_292800_100800 0 3.575546e-07
I7159 n1_m1_292800_105600 0 9.671981e-07
I7160 n1_m1_292800_110400 0 4.122028e-07
I7161 n1_m1_292800_115200 0 2.336349e-07
I7162 n1_m1_292800_120000 0 3.208655e-07
I7163 n1_m1_292800_124800 0 2.643519e-07
I7164 n1_m1_292800_129600 0 5.766328e-07
I7165 n1_m1_292800_134400 0 5.652121e-07
I7166 n1_m1_292800_139200 0 7.354952e-07
I7167 n1_m1_292800_144000 0 1.211154e-06
I7168 n1_m1_292800_148800 0 7.378364e-07
I7169 n1_m1_292800_153600 0 8.939436e-07
I7170 n1_m1_292800_158400 0 4.045842e-07
I7171 n1_m1_292800_163200 0 2.766197e-07
I7172 n1_m1_292800_168000 0 3.169920e-07
I7173 n1_m1_292800_172800 0 2.136819e-07
I7174 n1_m1_292800_177600 0 3.059614e-07
I7175 n1_m1_292800_182400 0 1.896222e-07
I7176 n1_m1_292800_187200 0 1.803429e-07
I7177 n1_m1_292800_192000 0 2.625198e-07
I7178 n1_m1_292800_196800 0 1.696835e-07
I7179 n1_m1_292800_201600 0 2.504852e-07
I7180 n1_m1_292800_206400 0 1.665524e-07
I7181 n1_m1_292800_211200 0 1.663668e-07
I7182 n1_m1_292800_216000 0 2.471875e-07
I7183 n1_m1_292800_220800 0 1.645537e-07
I7184 n1_m1_292800_225600 0 2.468306e-07
I7185 n1_m1_292800_230400 0 1.645537e-07
I7186 n1_m1_292800_235200 0 1.675041e-07
I7187 n1_m1_292800_240000 0 2.568666e-07
I7188 n1_m1_292800_244800 0 1.726720e-07
I7189 n1_m1_292800_249600 0 2.590555e-07
I7190 n1_m1_292800_254400 0 1.688079e-07
I7191 n1_m1_292800_259200 0 1.668521e-07
I7192 n1_m1_292800_264000 0 2.498285e-07
I7193 n1_m1_292800_268800 0 1.669949e-07
I7194 n1_m1_292800_273600 0 2.527265e-07
I7195 n1_m1_292800_278400 0 1.652199e-07
I7196 n1_m1_292800_283200 0 1.610609e-07
I7197 n1_m1_292800_288000 0 2.398354e-07
I7198 n1_m1_292800_292800 0 1.598903e-07
I7199 n1_m1_292800_297600 0 2.391359e-07
I7200 n1_m1_292800_302400 0 1.562927e-07
I7201 n1_m1_292800_307200 0 1.591241e-07
I7202 n1_m1_292800_312000 0 2.398354e-07
I7203 n1_m1_292800_316800 0 1.598903e-07
I7204 n1_m1_292800_321600 0 2.424336e-07
I7205 n1_m1_292800_326400 0 1.645537e-07
I7206 n1_m1_292800_331200 0 1.635259e-07
I7207 n1_m1_292800_336000 0 2.428333e-07
I7208 n1_m1_292800_340800 0 1.690459e-07
I7209 n1_m1_292800_345600 0 2.778997e-07
I7210 n1_m1_292800_350400 0 1.777114e-07
I7211 n1_m1_292800_355200 0 2.362474e-07
I7212 n1_m1_292800_360000 0 7.907525e-07
I7213 n1_m1_292800_364800 0 6.371008e-07
I7214 n1_m1_292800_369600 0 6.439485e-07
I7215 n1_m1_292800_374400 0 2.292807e-07
I7216 n1_m1_292800_379200 0 1.863483e-07
I7217 n1_m1_292800_384000 0 2.683158e-07
I7218 n1_m1_292800_388800 0 2.549203e-07
I7219 n1_m1_292800_393600 0 5.293462e-07
I7220 n1_m1_292800_398400 0 3.200660e-07
I7221 n1_m1_292800_403200 0 4.264121e-07
I7222 n1_m1_292800_408000 0 1.287788e-06
I7223 n1_m1_292800_412800 0 8.705739e-07
I7224 n1_m1_292800_417600 0 6.154205e-07
I7225 n1_m1_292800_422400 0 2.447653e-07
I7226 n1_m1_292800_427200 0 2.524458e-07
I7227 n1_m1_292800_432000 0 4.055502e-07
I7228 n1_m1_292800_436800 0 2.220476e-07
I7229 n1_m1_292800_441600 0 3.815952e-07
I7230 n1_m1_292800_446400 0 5.440504e-07
I7231 n1_m1_292800_451200 0 9.136681e-07
I7232 n1_m1_292800_456000 0 1.574348e-06
I7233 n1_m1_292800_460800 0 6.941331e-07
I7234 n1_m1_292800_465600 0 5.009704e-07
I7235 n1_m1_292800_470400 0 2.863558e-07
I7236 n1_m1_292800_475200 0 2.880689e-07
I7237 n1_m1_292800_480000 0 3.191904e-07
I7238 n1_m1_292800_484800 0 1.837310e-07
I7239 n1_m1_292800_489600 0 2.682016e-07
I7240 n1_m1_292800_494400 0 1.817514e-07
I7241 n1_m1_292800_499200 0 1.733382e-07
I7242 n1_m1_292800_504000 0 4.410259e-07
I7243 n1_m1_292800_508800 0 5.442741e-07
I7244 n1_m1_292800_513600 0 4.851480e-07
I7245 n1_m1_292800_518400 0 1.709779e-07
I7246 n1_m1_292800_523200 0 2.026133e-07
I7247 n1_m1_292800_528000 0 3.458912e-07
I7248 n1_m1_292800_532800 0 1.870240e-07
I7249 n1_m1_292800_537600 0 2.554485e-07
I7250 n1_m1_292800_542400 0 1.629548e-07
I7251 n1_m1_292800_547200 0 1.654198e-07
I7252 n1_m1_292800_552000 0 2.541018e-07
I7253 n1_m1_292800_556800 0 1.660765e-07
I7254 n1_m1_297600_0 0 2.308416e-07
I7255 n1_m1_297600_4800 0 2.308416e-07
I7256 n1_m1_297600_9600 0 3.462623e-07
I7257 n1_m1_297600_14400 0 2.320805e-07
I7258 n1_m1_297600_19200 0 2.371464e-07
I7259 n1_m1_297600_24000 0 3.594410e-07
I7260 n1_m1_297600_28800 0 2.398354e-07
I7261 n1_m1_297600_33600 0 3.645712e-07
I7262 n1_m1_297600_38400 0 2.475444e-07
I7263 n1_m1_297600_43200 0 2.488149e-07
I7264 n1_m1_297600_48000 0 3.667197e-07
I7265 n1_m1_297600_52800 0 2.422949e-07
I7266 n1_m1_297600_57600 0 3.636076e-07
I7267 n1_m1_297600_62400 0 2.434503e-07
I7268 n1_m1_297600_67200 0 2.471916e-07
I7269 n1_m1_297600_72000 0 3.735161e-07
I7270 n1_m1_297600_76800 0 2.606660e-07
I7271 n1_m1_297600_81600 0 3.981298e-07
I7272 n1_m1_297600_86400 0 2.733756e-07
I7273 n1_m1_297600_91200 0 2.896706e-07
I7274 n1_m1_297600_96000 0 5.789057e-07
I7275 n1_m1_297600_100800 0 5.209720e-07
I7276 n1_m1_297600_105600 0 8.628455e-07
I7277 n1_m1_297600_110400 0 4.665889e-07
I7278 n1_m1_297600_115200 0 4.160909e-07
I7279 n1_m1_297600_120000 0 6.245968e-07
I7280 n1_m1_297600_124800 0 4.960595e-07
I7281 n1_m1_297600_129600 0 1.340517e-06
I7282 n1_m1_297600_134400 0 1.496556e-06
I7283 n1_m1_297600_139200 0 1.697906e-06
I7284 n1_m1_297600_144000 0 2.354251e-06
I7285 n1_m1_297600_148800 0 1.270073e-06
I7286 n1_m1_297600_153600 0 1.661527e-06
I7287 n1_m1_297600_158400 0 9.614880e-07
I7288 n1_m1_297600_163200 0 7.298429e-07
I7289 n1_m1_297600_168000 0 5.959134e-07
I7290 n1_m1_297600_172800 0 2.957888e-07
I7291 n1_m1_297600_177600 0 4.989616e-07
I7292 n1_m1_297600_182400 0 3.004693e-07
I7293 n1_m1_297600_187200 0 2.805217e-07
I7294 n1_m1_297600_192000 0 3.990761e-07
I7295 n1_m1_297600_196800 0 2.571194e-07
I7296 n1_m1_297600_201600 0 3.745358e-07
I7297 n1_m1_297600_206400 0 2.450165e-07
I7298 n1_m1_297600_211200 0 2.552371e-07
I7299 n1_m1_297600_216000 0 3.858780e-07
I7300 n1_m1_297600_220800 0 2.574947e-07
I7301 n1_m1_297600_225600 0 3.873413e-07
I7302 n1_m1_297600_230400 0 2.582513e-07
I7303 n1_m1_297600_235200 0 2.589468e-07
I7304 n1_m1_297600_240000 0 3.950799e-07
I7305 n1_m1_297600_244800 0 2.608373e-07
I7306 n1_m1_297600_249600 0 3.803053e-07
I7307 n1_m1_297600_254400 0 2.484315e-07
I7308 n1_m1_297600_259200 0 2.433687e-07
I7309 n1_m1_297600_264000 0 3.636076e-07
I7310 n1_m1_297600_268800 0 2.424051e-07
I7311 n1_m1_297600_273600 0 3.636076e-07
I7312 n1_m1_297600_278400 0 2.416199e-07
I7313 n1_m1_297600_283200 0 2.404207e-07
I7314 n1_m1_297600_288000 0 3.597531e-07
I7315 n1_m1_297600_292800 0 2.398354e-07
I7316 n1_m1_297600_297600 0 3.584040e-07
I7317 n1_m1_297600_302400 0 2.322090e-07
I7318 n1_m1_297600_307200 0 2.334020e-07
I7319 n1_m1_297600_312000 0 3.584224e-07
I7320 n1_m1_297600_316800 0 2.411661e-07
I7321 n1_m1_297600_321600 0 3.709648e-07
I7322 n1_m1_297600_326400 0 2.498285e-07
I7323 n1_m1_297600_331200 0 2.488374e-07
I7324 n1_m1_297600_336000 0 3.657949e-07
I7325 n1_m1_297600_340800 0 2.425600e-07
I7326 n1_m1_297600_345600 0 3.774868e-07
I7327 n1_m1_297600_350400 0 2.698260e-07
I7328 n1_m1_297600_355200 0 3.386176e-07
I7329 n1_m1_297600_360000 0 9.240423e-07
I7330 n1_m1_297600_364800 0 7.612816e-07
I7331 n1_m1_297600_369600 0 8.366839e-07
I7332 n1_m1_297600_374400 0 3.538408e-07
I7333 n1_m1_297600_379200 0 3.411128e-07
I7334 n1_m1_297600_384000 0 5.003352e-07
I7335 n1_m1_297600_388800 0 3.089308e-07
I7336 n1_m1_297600_393600 0 6.867276e-07
I7337 n1_m1_297600_398400 0 8.519958e-07
I7338 n1_m1_297600_403200 0 1.440339e-06
I7339 n1_m1_297600_408000 0 2.957859e-06
I7340 n1_m1_297600_412800 0 1.772474e-06
I7341 n1_m1_297600_417600 0 1.268068e-06
I7342 n1_m1_297600_422400 0 5.426582e-07
I7343 n1_m1_297600_427200 0 5.082817e-07
I7344 n1_m1_297600_432000 0 8.713550e-07
I7345 n1_m1_297600_436800 0 4.892846e-07
I7346 n1_m1_297600_441600 0 5.985178e-07
I7347 n1_m1_297600_446400 0 6.762970e-07
I7348 n1_m1_297600_451200 0 1.163537e-06
I7349 n1_m1_297600_456000 0 2.454440e-06
I7350 n1_m1_297600_460800 0 1.094712e-06
I7351 n1_m1_297600_465600 0 7.409935e-07
I7352 n1_m1_297600_470400 0 4.378668e-07
I7353 n1_m1_297600_475200 0 4.661800e-07
I7354 n1_m1_297600_480000 0 4.959361e-07
I7355 n1_m1_297600_484800 0 2.619773e-07
I7356 n1_m1_297600_489600 0 3.926876e-07
I7357 n1_m1_297600_494400 0 2.732767e-07
I7358 n1_m1_297600_499200 0 2.586561e-07
I7359 n1_m1_297600_504000 0 7.348263e-07
I7360 n1_m1_297600_508800 0 9.667732e-07
I7361 n1_m1_297600_513600 0 8.776242e-07
I7362 n1_m1_297600_518400 0 2.785639e-07
I7363 n1_m1_297600_523200 0 4.517328e-07
I7364 n1_m1_297600_528000 0 1.092906e-06
I7365 n1_m1_297600_532800 0 5.089670e-07
I7366 n1_m1_297600_537600 0 4.726358e-07
I7367 n1_m1_297600_542400 0 2.452592e-07
I7368 n1_m1_297600_547200 0 2.371597e-07
I7369 n1_m1_297600_552000 0 3.628775e-07
I7370 n1_m1_297600_556800 0 2.419931e-07
I7371 n1_m1_302400_0 0 1.590813e-07
I7372 n1_m1_302400_4800 0 1.590813e-07
I7373 n1_m1_302400_9600 0 2.386219e-07
I7374 n1_m1_302400_14400 0 1.592373e-07
I7375 n1_m1_302400_19200 0 1.598267e-07
I7376 n1_m1_302400_24000 0 2.398354e-07
I7377 n1_m1_302400_28800 0 1.598903e-07
I7378 n1_m1_302400_33600 0 2.399068e-07
I7379 n1_m1_302400_38400 0 1.684286e-07
I7380 n1_m1_302400_43200 0 1.823456e-07
I7381 n1_m1_302400_48000 0 2.751238e-07
I7382 n1_m1_302400_52800 0 1.657526e-07
I7383 n1_m1_302400_57600 0 2.412528e-07
I7384 n1_m1_302400_62400 0 1.629664e-07
I7385 n1_m1_302400_67200 0 1.750136e-07
I7386 n1_m1_302400_72000 0 2.803127e-07
I7387 n1_m1_302400_76800 0 1.782416e-07
I7388 n1_m1_302400_81600 0 2.609597e-07
I7389 n1_m1_302400_86400 0 1.781158e-07
I7390 n1_m1_302400_91200 0 1.861940e-07
I7391 n1_m1_302400_96000 0 3.399289e-07
I7392 n1_m1_302400_100800 0 2.726754e-07
I7393 n1_m1_302400_105600 0 5.571764e-07
I7394 n1_m1_302400_110400 0 3.470006e-07
I7395 n1_m1_302400_115200 0 3.390187e-07
I7396 n1_m1_302400_120000 0 5.845498e-07
I7397 n1_m1_302400_124800 0 4.897305e-07
I7398 n1_m1_302400_129600 0 1.138356e-06
I7399 n1_m1_302400_134400 0 1.101388e-06
I7400 n1_m1_302400_139200 0 9.361194e-07
I7401 n1_m1_302400_144000 0 8.502814e-07
I7402 n1_m1_302400_148800 0 4.012100e-07
I7403 n1_m1_302400_153600 0 5.869665e-07
I7404 n1_m1_302400_158400 0 3.955513e-07
I7405 n1_m1_302400_163200 0 3.133373e-07
I7406 n1_m1_302400_168000 0 3.096130e-07
I7407 n1_m1_302400_172800 0 1.820342e-07
I7408 n1_m1_302400_177600 0 2.861240e-07
I7409 n1_m1_302400_182400 0 1.844897e-07
I7410 n1_m1_302400_187200 0 1.776400e-07
I7411 n1_m1_302400_192000 0 2.595613e-07
I7412 n1_m1_302400_196800 0 1.686094e-07
I7413 n1_m1_302400_201600 0 2.438021e-07
I7414 n1_m1_302400_206400 0 1.617431e-07
I7415 n1_m1_302400_211200 0 1.708555e-07
I7416 n1_m1_302400_216000 0 2.596942e-07
I7417 n1_m1_302400_220800 0 1.746359e-07
I7418 n1_m1_302400_225600 0 2.683923e-07
I7419 n1_m1_302400_230400 0 1.786903e-07
I7420 n1_m1_302400_235200 0 1.760778e-07
I7421 n1_m1_302400_240000 0 2.597758e-07
I7422 n1_m1_302400_244800 0 1.689759e-07
I7423 n1_m1_302400_249600 0 2.492731e-07
I7424 n1_m1_302400_254400 0 1.617788e-07
I7425 n1_m1_302400_259200 0 1.601187e-07
I7426 n1_m1_302400_264000 0 2.400495e-07
I7427 n1_m1_302400_268800 0 1.605990e-07
I7428 n1_m1_302400_273600 0 2.409061e-07
I7429 n1_m1_302400_278400 0 1.631737e-07
I7430 n1_m1_302400_283200 0 1.636142e-07
I7431 n1_m1_302400_288000 0 2.409061e-07
I7432 n1_m1_302400_292800 0 1.606041e-07
I7433 n1_m1_302400_297600 0 2.399894e-07
I7434 n1_m1_302400_302400 0 1.591795e-07
I7435 n1_m1_302400_307200 0 1.591333e-07
I7436 n1_m1_302400_312000 0 2.396678e-07
I7437 n1_m1_302400_316800 0 1.600578e-07
I7438 n1_m1_302400_321600 0 2.442579e-07
I7439 n1_m1_302400_326400 0 1.668889e-07
I7440 n1_m1_302400_331200 0 1.672661e-07
I7441 n1_m1_302400_336000 0 2.502578e-07
I7442 n1_m1_302400_340800 0 1.664572e-07
I7443 n1_m1_302400_345600 0 2.571579e-07
I7444 n1_m1_302400_350400 0 1.800424e-07
I7445 n1_m1_302400_355200 0 1.911532e-07
I7446 n1_m1_302400_360000 0 3.120032e-07
I7447 n1_m1_302400_364800 0 2.145745e-07
I7448 n1_m1_302400_369600 0 3.110297e-07
I7449 n1_m1_302400_374400 0 2.005909e-07
I7450 n1_m1_302400_379200 0 1.976229e-07
I7451 n1_m1_302400_384000 0 3.792754e-07
I7452 n1_m1_302400_388800 0 2.240435e-07
I7453 n1_m1_302400_393600 0 4.371986e-07
I7454 n1_m1_302400_398400 0 5.969491e-07
I7455 n1_m1_302400_403200 0 9.913600e-07
I7456 n1_m1_302400_408000 0 2.013487e-06
I7457 n1_m1_302400_412800 0 1.285976e-06
I7458 n1_m1_302400_417600 0 1.220615e-06
I7459 n1_m1_302400_422400 0 7.200153e-07
I7460 n1_m1_302400_427200 0 9.370385e-07
I7461 n1_m1_302400_432000 0 1.431378e-06
I7462 n1_m1_302400_436800 0 5.638939e-07
I7463 n1_m1_302400_441600 0 4.591777e-07
I7464 n1_m1_302400_446400 0 2.918752e-07
I7465 n1_m1_302400_451200 0 3.430343e-07
I7466 n1_m1_302400_456000 0 7.958759e-07
I7467 n1_m1_302400_460800 0 3.611803e-07
I7468 n1_m1_302400_465600 0 3.289314e-07
I7469 n1_m1_302400_470400 0 2.186594e-07
I7470 n1_m1_302400_475200 0 2.170177e-07
I7471 n1_m1_302400_480000 0 2.660864e-07
I7472 n1_m1_302400_484800 0 1.710853e-07
I7473 n1_m1_302400_489600 0 2.606194e-07
I7474 n1_m1_302400_494400 0 1.739643e-07
I7475 n1_m1_302400_499200 0 1.640293e-07
I7476 n1_m1_302400_504000 0 3.112568e-07
I7477 n1_m1_302400_508800 0 3.474622e-07
I7478 n1_m1_302400_513600 0 3.779878e-07
I7479 n1_m1_302400_518400 0 1.888500e-07
I7480 n1_m1_302400_523200 0 2.966100e-07
I7481 n1_m1_302400_528000 0 6.949475e-07
I7482 n1_m1_302400_532800 0 3.281965e-07
I7483 n1_m1_302400_537600 0 3.119896e-07
I7484 n1_m1_302400_542400 0 1.686696e-07
I7485 n1_m1_302400_547200 0 1.614130e-07
I7486 n1_m1_302400_552000 0 2.336563e-07
I7487 n1_m1_302400_556800 0 1.542003e-07
I7488 n1_m1_307200_0 0 1.598903e-07
I7489 n1_m1_307200_4800 0 1.598903e-07
I7490 n1_m1_307200_9600 0 2.398354e-07
I7491 n1_m1_307200_14400 0 1.598903e-07
I7492 n1_m1_307200_19200 0 1.598903e-07
I7493 n1_m1_307200_24000 0 2.398354e-07
I7494 n1_m1_307200_28800 0 1.598903e-07
I7495 n1_m1_307200_33600 0 2.359809e-07
I7496 n1_m1_307200_38400 0 1.713008e-07
I7497 n1_m1_307200_43200 0 2.357470e-07
I7498 n1_m1_307200_48000 0 3.984089e-07
I7499 n1_m1_307200_52800 0 1.991297e-07
I7500 n1_m1_307200_57600 0 2.544733e-07
I7501 n1_m1_307200_62400 0 1.713644e-07
I7502 n1_m1_307200_67200 0 2.103784e-07
I7503 n1_m1_307200_72000 0 4.616230e-07
I7504 n1_m1_307200_76800 0 2.257580e-07
I7505 n1_m1_307200_81600 0 2.692560e-07
I7506 n1_m1_307200_86400 0 1.781634e-07
I7507 n1_m1_307200_91200 0 1.953469e-07
I7508 n1_m1_307200_96000 0 3.488238e-07
I7509 n1_m1_307200_100800 0 2.655045e-07
I7510 n1_m1_307200_105600 0 8.031994e-07
I7511 n1_m1_307200_110400 0 3.952372e-07
I7512 n1_m1_307200_115200 0 3.068900e-07
I7513 n1_m1_307200_120000 0 6.022581e-07
I7514 n1_m1_307200_124800 0 5.664303e-07
I7515 n1_m1_307200_129600 0 1.039445e-06
I7516 n1_m1_307200_134400 0 8.104308e-07
I7517 n1_m1_307200_139200 0 6.805329e-07
I7518 n1_m1_307200_144000 0 6.297501e-07
I7519 n1_m1_307200_148800 0 2.943568e-07
I7520 n1_m1_307200_153600 0 4.313947e-07
I7521 n1_m1_307200_158400 0 2.627496e-07
I7522 n1_m1_307200_163200 0 2.149147e-07
I7523 n1_m1_307200_168000 0 2.917909e-07
I7524 n1_m1_307200_172800 0 2.014141e-07
I7525 n1_m1_307200_177600 0 2.681241e-07
I7526 n1_m1_307200_182400 0 1.747936e-07
I7527 n1_m1_307200_187200 0 1.711682e-07
I7528 n1_m1_307200_192000 0 2.514312e-07
I7529 n1_m1_307200_196800 0 1.668182e-07
I7530 n1_m1_307200_201600 0 2.476287e-07
I7531 n1_m1_307200_206400 0 1.617322e-07
I7532 n1_m1_307200_211200 0 1.667991e-07
I7533 n1_m1_307200_216000 0 2.583258e-07
I7534 n1_m1_307200_220800 0 1.748324e-07
I7535 n1_m1_307200_225600 0 2.695769e-07
I7536 n1_m1_307200_230400 0 1.769337e-07
I7537 n1_m1_307200_235200 0 1.736346e-07
I7538 n1_m1_307200_240000 0 2.547507e-07
I7539 n1_m1_307200_244800 0 1.668494e-07
I7540 n1_m1_307200_249600 0 2.496487e-07
I7541 n1_m1_307200_254400 0 1.649511e-07
I7542 n1_m1_307200_259200 0 1.610894e-07
I7543 n1_m1_307200_264000 0 2.420196e-07
I7544 n1_m1_307200_268800 0 1.655160e-07
I7545 n1_m1_307200_273600 0 2.488078e-07
I7546 n1_m1_307200_278400 0 1.662192e-07
I7547 n1_m1_307200_283200 0 1.660989e-07
I7548 n1_m1_307200_288000 0 2.481868e-07
I7549 n1_m1_307200_292800 0 1.654579e-07
I7550 n1_m1_307200_297600 0 2.424601e-07
I7551 n1_m1_307200_302400 0 1.602726e-07
I7552 n1_m1_307200_307200 0 1.599606e-07
I7553 n1_m1_307200_312000 0 2.400679e-07
I7554 n1_m1_307200_316800 0 1.607285e-07
I7555 n1_m1_307200_321600 0 2.445933e-07
I7556 n1_m1_307200_326400 0 1.694035e-07
I7557 n1_m1_307200_331200 0 1.722852e-07
I7558 n1_m1_307200_336000 0 2.584828e-07
I7559 n1_m1_307200_340800 0 1.718324e-07
I7560 n1_m1_307200_345600 0 2.597462e-07
I7561 n1_m1_307200_350400 0 1.847327e-07
I7562 n1_m1_307200_355200 0 2.288654e-07
I7563 n1_m1_307200_360000 0 3.526957e-07
I7564 n1_m1_307200_364800 0 1.843949e-07
I7565 n1_m1_307200_369600 0 2.661812e-07
I7566 n1_m1_307200_374400 0 1.826835e-07
I7567 n1_m1_307200_379200 0 1.820723e-07
I7568 n1_m1_307200_384000 0 2.834483e-07
I7569 n1_m1_307200_388800 0 1.822763e-07
I7570 n1_m1_307200_393600 0 3.803522e-07
I7571 n1_m1_307200_398400 0 3.287951e-07
I7572 n1_m1_307200_403200 0 5.467149e-07
I7573 n1_m1_307200_408000 0 1.816814e-06
I7574 n1_m1_307200_412800 0 1.424434e-06
I7575 n1_m1_307200_417600 0 1.834002e-06
I7576 n1_m1_307200_422400 0 1.183808e-06
I7577 n1_m1_307200_427200 0 1.292090e-06
I7578 n1_m1_307200_432000 0 1.824869e-06
I7579 n1_m1_307200_436800 0 7.475780e-07
I7580 n1_m1_307200_441600 0 5.493740e-07
I7581 n1_m1_307200_446400 0 2.297909e-07
I7582 n1_m1_307200_451200 0 1.998050e-07
I7583 n1_m1_307200_456000 0 3.310779e-07
I7584 n1_m1_307200_460800 0 1.942317e-07
I7585 n1_m1_307200_465600 0 2.701595e-07
I7586 n1_m1_307200_470400 0 1.850009e-07
I7587 n1_m1_307200_475200 0 1.830315e-07
I7588 n1_m1_307200_480000 0 2.604631e-07
I7589 n1_m1_307200_484800 0 1.733667e-07
I7590 n1_m1_307200_489600 0 2.698372e-07
I7591 n1_m1_307200_494400 0 1.786910e-07
I7592 n1_m1_307200_499200 0 1.692957e-07
I7593 n1_m1_307200_504000 0 2.532364e-07
I7594 n1_m1_307200_508800 0 1.921351e-07
I7595 n1_m1_307200_513600 0 2.758389e-07
I7596 n1_m1_307200_518400 0 1.829867e-07
I7597 n1_m1_307200_523200 0 2.105684e-07
I7598 n1_m1_307200_528000 0 3.556722e-07
I7599 n1_m1_307200_532800 0 2.073957e-07
I7600 n1_m1_307200_537600 0 2.715286e-07
I7601 n1_m1_307200_542400 0 1.723042e-07
I7602 n1_m1_307200_547200 0 1.670758e-07
I7603 n1_m1_307200_552000 0 2.393119e-07
I7604 n1_m1_307200_556800 0 1.541704e-07
I7605 n1_m1_312000_0 0 2.362188e-07
I7606 n1_m1_312000_4800 0 2.364901e-07
I7607 n1_m1_312000_9600 0 3.617034e-07
I7608 n1_m1_312000_14400 0 2.433874e-07
I7609 n1_m1_312000_19200 0 2.431807e-07
I7610 n1_m1_312000_24000 0 3.618843e-07
I7611 n1_m1_312000_28800 0 2.398354e-07
I7612 n1_m1_312000_33600 0 3.587181e-07
I7613 n1_m1_312000_38400 0 2.737883e-07
I7614 n1_m1_312000_43200 0 4.470041e-07
I7615 n1_m1_312000_48000 0 8.542691e-07
I7616 n1_m1_312000_52800 0 4.253047e-07
I7617 n1_m1_312000_57600 0 4.410609e-07
I7618 n1_m1_312000_62400 0 2.980757e-07
I7619 n1_m1_312000_67200 0 4.503351e-07
I7620 n1_m1_312000_72000 0 1.258629e-06
I7621 n1_m1_312000_76800 0 5.934859e-07
I7622 n1_m1_312000_81600 0 4.931890e-07
I7623 n1_m1_312000_86400 0 2.795700e-07
I7624 n1_m1_312000_91200 0 3.472120e-07
I7625 n1_m1_312000_96000 0 6.598818e-07
I7626 n1_m1_312000_100800 0 4.567090e-07
I7627 n1_m1_312000_105600 0 1.079551e-06
I7628 n1_m1_312000_110400 0 5.790060e-07
I7629 n1_m1_312000_115200 0 4.830650e-07
I7630 n1_m1_312000_120000 0 8.032212e-07
I7631 n1_m1_312000_124800 0 5.747198e-07
I7632 n1_m1_312000_129600 0 8.728247e-07
I7633 n1_m1_312000_134400 0 6.256359e-07
I7634 n1_m1_312000_139200 0 1.008998e-06
I7635 n1_m1_312000_144000 0 1.512976e-06
I7636 n1_m1_312000_148800 0 4.854661e-07
I7637 n1_m1_312000_153600 0 5.894964e-07
I7638 n1_m1_312000_158400 0 4.395643e-07
I7639 n1_m1_312000_163200 0 3.900269e-07
I7640 n1_m1_312000_168000 0 4.345511e-07
I7641 n1_m1_312000_172800 0 2.703600e-07
I7642 n1_m1_312000_177600 0 3.926815e-07
I7643 n1_m1_312000_182400 0 2.588142e-07
I7644 n1_m1_312000_187200 0 2.541548e-07
I7645 n1_m1_312000_192000 0 3.747428e-07
I7646 n1_m1_312000_196800 0 2.498285e-07
I7647 n1_m1_312000_201600 0 3.741735e-07
I7648 n1_m1_312000_206400 0 2.464455e-07
I7649 n1_m1_312000_211200 0 2.441066e-07
I7650 n1_m1_312000_216000 0 3.763859e-07
I7651 n1_m1_312000_220800 0 2.741057e-07
I7652 n1_m1_312000_225600 0 4.969623e-07
I7653 n1_m1_312000_230400 0 3.285976e-07
I7654 n1_m1_312000_235200 0 2.846040e-07
I7655 n1_m1_312000_240000 0 3.806673e-07
I7656 n1_m1_312000_244800 0 2.516368e-07
I7657 n1_m1_312000_249600 0 3.774552e-07
I7658 n1_m1_312000_254400 0 2.514692e-07
I7659 n1_m1_312000_259200 0 2.504638e-07
I7660 n1_m1_312000_264000 0 3.757992e-07
I7661 n1_m1_312000_268800 0 2.531337e-07
I7662 n1_m1_312000_273600 0 3.873223e-07
I7663 n1_m1_312000_278400 0 2.541351e-07
I7664 n1_m1_312000_283200 0 2.498285e-07
I7665 n1_m1_312000_288000 0 3.747299e-07
I7666 n1_m1_312000_292800 0 2.485627e-07
I7667 n1_m1_312000_297600 0 3.704926e-07
I7668 n1_m1_312000_302400 0 2.459111e-07
I7669 n1_m1_312000_307200 0 2.409533e-07
I7670 n1_m1_312000_312000 0 3.639380e-07
I7671 n1_m1_312000_316800 0 2.556721e-07
I7672 n1_m1_312000_321600 0 3.928712e-07
I7673 n1_m1_312000_326400 0 2.664287e-07
I7674 n1_m1_312000_331200 0 2.657788e-07
I7675 n1_m1_312000_336000 0 3.931108e-07
I7676 n1_m1_312000_340800 0 2.534444e-07
I7677 n1_m1_312000_345600 0 3.822247e-07
I7678 n1_m1_312000_350400 0 2.795483e-07
I7679 n1_m1_312000_355200 0 3.166021e-07
I7680 n1_m1_312000_360000 0 4.279603e-07
I7681 n1_m1_312000_364800 0 2.576031e-07
I7682 n1_m1_312000_369600 0 3.914041e-07
I7683 n1_m1_312000_374400 0 2.778250e-07
I7684 n1_m1_312000_379200 0 2.743253e-07
I7685 n1_m1_312000_384000 0 3.999398e-07
I7686 n1_m1_312000_388800 0 2.621398e-07
I7687 n1_m1_312000_393600 0 4.167133e-07
I7688 n1_m1_312000_398400 0 3.023935e-07
I7689 n1_m1_312000_403200 0 5.034745e-07
I7690 n1_m1_312000_408000 0 2.352665e-06
I7691 n1_m1_312000_412800 0 2.100334e-06
I7692 n1_m1_312000_417600 0 3.126259e-06
I7693 n1_m1_312000_422400 0 2.135113e-06
I7694 n1_m1_312000_427200 0 2.160465e-06
I7695 n1_m1_312000_432000 0 2.885464e-06
I7696 n1_m1_312000_436800 0 1.274454e-06
I7697 n1_m1_312000_441600 0 8.647157e-07
I7698 n1_m1_312000_446400 0 2.936464e-07
I7699 n1_m1_312000_451200 0 2.653859e-07
I7700 n1_m1_312000_456000 0 4.069887e-07
I7701 n1_m1_312000_460800 0 2.663315e-07
I7702 n1_m1_312000_465600 0 3.928630e-07
I7703 n1_m1_312000_470400 0 2.735551e-07
I7704 n1_m1_312000_475200 0 2.962776e-07
I7705 n1_m1_312000_480000 0 5.066030e-07
I7706 n1_m1_312000_484800 0 3.863382e-07
I7707 n1_m1_312000_489600 0 7.801982e-07
I7708 n1_m1_312000_494400 0 5.554654e-07
I7709 n1_m1_312000_499200 0 4.888369e-07
I7710 n1_m1_312000_504000 0 4.877030e-07
I7711 n1_m1_312000_508800 0 2.571293e-07
I7712 n1_m1_312000_513600 0 4.128867e-07
I7713 n1_m1_312000_518400 0 2.907698e-07
I7714 n1_m1_312000_523200 0 2.671112e-07
I7715 n1_m1_312000_528000 0 3.881142e-07
I7716 n1_m1_312000_532800 0 2.559835e-07
I7717 n1_m1_312000_537600 0 3.832805e-07
I7718 n1_m1_312000_542400 0 2.541045e-07
I7719 n1_m1_312000_547200 0 2.481997e-07
I7720 n1_m1_312000_552000 0 3.570532e-07
I7721 n1_m1_312000_556800 0 2.264636e-07
I7722 n1_m1_316800_0 0 1.471670e-07
I7723 n1_m1_316800_4800 0 1.488251e-07
I7724 n1_m1_316800_9600 0 2.450729e-07
I7725 n1_m1_316800_14400 0 1.697192e-07
I7726 n1_m1_316800_19200 0 1.683334e-07
I7727 n1_m1_316800_24000 0 2.457249e-07
I7728 n1_m1_316800_28800 0 1.598903e-07
I7729 n1_m1_316800_33600 0 2.398354e-07
I7730 n1_m1_316800_38400 0 1.638365e-07
I7731 n1_m1_316800_43200 0 1.718351e-07
I7732 n1_m1_316800_48000 0 2.666527e-07
I7733 n1_m1_316800_52800 0 1.804381e-07
I7734 n1_m1_316800_57600 0 2.685799e-07
I7735 n1_m1_316800_62400 0 1.791318e-07
I7736 n1_m1_316800_67200 0 2.356638e-07
I7737 n1_m1_316800_72000 0 7.742676e-07
I7738 n1_m1_316800_76800 0 3.952750e-07
I7739 n1_m1_316800_81600 0 3.246109e-07
I7740 n1_m1_316800_86400 0 1.772770e-07
I7741 n1_m1_316800_91200 0 2.104494e-07
I7742 n1_m1_316800_96000 0 3.661630e-07
I7743 n1_m1_316800_100800 0 2.043295e-07
I7744 n1_m1_316800_105600 0 2.866760e-07
I7745 n1_m1_316800_110400 0 1.888048e-07
I7746 n1_m1_316800_115200 0 1.978982e-07
I7747 n1_m1_316800_120000 0 3.845942e-07
I7748 n1_m1_316800_124800 0 3.249960e-07
I7749 n1_m1_316800_129600 0 4.996788e-07
I7750 n1_m1_316800_134400 0 2.903517e-07
I7751 n1_m1_316800_139200 0 5.791263e-07
I7752 n1_m1_316800_144000 0 1.003019e-06
I7753 n1_m1_316800_148800 0 3.055614e-07
I7754 n1_m1_316800_153600 0 2.914122e-07
I7755 n1_m1_316800_158400 0 1.900257e-07
I7756 n1_m1_316800_163200 0 1.869356e-07
I7757 n1_m1_316800_168000 0 2.693189e-07
I7758 n1_m1_316800_172800 0 1.810927e-07
I7759 n1_m1_316800_177600 0 2.634202e-07
I7760 n1_m1_316800_182400 0 1.689711e-07
I7761 n1_m1_316800_187200 0 1.666278e-07
I7762 n1_m1_316800_192000 0 2.498285e-07
I7763 n1_m1_316800_196800 0 1.665524e-07
I7764 n1_m1_316800_201600 0 2.489108e-07
I7765 n1_m1_316800_206400 0 1.627556e-07
I7766 n1_m1_316800_211200 0 1.664602e-07
I7767 n1_m1_316800_216000 0 2.516800e-07
I7768 n1_m1_316800_220800 0 2.322678e-07
I7769 n1_m1_316800_225600 0 6.439757e-07
I7770 n1_m1_316800_230400 0 4.249505e-07
I7771 n1_m1_316800_235200 0 2.821159e-07
I7772 n1_m1_316800_240000 0 2.717747e-07
I7773 n1_m1_316800_244800 0 1.724408e-07
I7774 n1_m1_316800_249600 0 2.575375e-07
I7775 n1_m1_316800_254400 0 1.716917e-07
I7776 n1_m1_316800_259200 0 1.716917e-07
I7777 n1_m1_316800_264000 0 2.579515e-07
I7778 n1_m1_316800_268800 0 1.730934e-07
I7779 n1_m1_316800_273600 0 2.598145e-07
I7780 n1_m1_316800_278400 0 1.698834e-07
I7781 n1_m1_316800_283200 0 1.665524e-07
I7782 n1_m1_316800_288000 0 2.486484e-07
I7783 n1_m1_316800_292800 0 1.615748e-07
I7784 n1_m1_316800_297600 0 2.400495e-07
I7785 n1_m1_316800_302400 0 1.600177e-07
I7786 n1_m1_316800_307200 0 1.599137e-07
I7787 n1_m1_316800_312000 0 2.413078e-07
I7788 n1_m1_316800_316800 0 1.678997e-07
I7789 n1_m1_316800_321600 0 2.796835e-07
I7790 n1_m1_316800_326400 0 1.968255e-07
I7791 n1_m1_316800_331200 0 1.844360e-07
I7792 n1_m1_316800_336000 0 2.536596e-07
I7793 n1_m1_316800_340800 0 1.652193e-07
I7794 n1_m1_316800_345600 0 2.564770e-07
I7795 n1_m1_316800_350400 0 1.822045e-07
I7796 n1_m1_316800_355200 0 1.843840e-07
I7797 n1_m1_316800_360000 0 2.756074e-07
I7798 n1_m1_316800_364800 0 1.774578e-07
I7799 n1_m1_316800_369600 0 2.595083e-07
I7800 n1_m1_316800_374400 0 1.727943e-07
I7801 n1_m1_316800_379200 0 1.734898e-07
I7802 n1_m1_316800_384000 0 2.621058e-07
I7803 n1_m1_316800_388800 0 1.808181e-07
I7804 n1_m1_316800_393600 0 2.747373e-07
I7805 n1_m1_316800_398400 0 1.908880e-07
I7806 n1_m1_316800_403200 0 3.001222e-07
I7807 n1_m1_316800_408000 0 9.931483e-07
I7808 n1_m1_316800_412800 0 1.021199e-06
I7809 n1_m1_316800_417600 0 1.843968e-06
I7810 n1_m1_316800_422400 0 1.434210e-06
I7811 n1_m1_316800_427200 0 1.461180e-06
I7812 n1_m1_316800_432000 0 2.081569e-06
I7813 n1_m1_316800_436800 0 1.102504e-06
I7814 n1_m1_316800_441600 0 7.940193e-07
I7815 n1_m1_316800_446400 0 2.041888e-07
I7816 n1_m1_316800_451200 0 1.843096e-07
I7817 n1_m1_316800_456000 0 3.019373e-07
I7818 n1_m1_316800_460800 0 2.138349e-07
I7819 n1_m1_316800_465600 0 3.398127e-07
I7820 n1_m1_316800_470400 0 2.325689e-07
I7821 n1_m1_316800_475200 0 2.775000e-07
I7822 n1_m1_316800_480000 0 6.838242e-07
I7823 n1_m1_316800_484800 0 6.955654e-07
I7824 n1_m1_316800_489600 0 1.507248e-06
I7825 n1_m1_316800_494400 0 1.029605e-06
I7826 n1_m1_316800_499200 0 7.714467e-07
I7827 n1_m1_316800_504000 0 5.479780e-07
I7828 n1_m1_316800_508800 0 2.092870e-07
I7829 n1_m1_316800_513600 0 3.252574e-07
I7830 n1_m1_316800_518400 0 2.062496e-07
I7831 n1_m1_316800_523200 0 1.701900e-07
I7832 n1_m1_316800_528000 0 2.520831e-07
I7833 n1_m1_316800_532800 0 1.643797e-07
I7834 n1_m1_316800_537600 0 2.360006e-07
I7835 n1_m1_316800_542400 0 1.549821e-07
I7836 n1_m1_316800_547200 0 1.538835e-07
I7837 n1_m1_316800_552000 0 2.316689e-07
I7838 n1_m1_316800_556800 0 1.545307e-07
I7839 n1_m1_321600_0 0 2.220354e-07
I7840 n1_m1_321600_4800 0 2.280629e-07
I7841 n1_m1_321600_9600 0 3.533514e-07
I7842 n1_m1_321600_14400 0 2.358361e-07
I7843 n1_m1_321600_19200 0 2.329575e-07
I7844 n1_m1_321600_24000 0 3.590964e-07
I7845 n1_m1_321600_28800 0 2.398354e-07
I7846 n1_m1_321600_33600 0 3.597531e-07
I7847 n1_m1_321600_38400 0 2.401107e-07
I7848 n1_m1_321600_43200 0 2.405023e-07
I7849 n1_m1_321600_48000 0 3.708230e-07
I7850 n1_m1_321600_52800 0 2.553268e-07
I7851 n1_m1_321600_57600 0 3.839854e-07
I7852 n1_m1_321600_62400 0 2.536749e-07
I7853 n1_m1_321600_67200 0 2.917844e-07
I7854 n1_m1_321600_72000 0 7.295778e-07
I7855 n1_m1_321600_76800 0 4.434752e-07
I7856 n1_m1_321600_81600 0 4.683490e-07
I7857 n1_m1_321600_86400 0 2.600623e-07
I7858 n1_m1_321600_91200 0 2.621221e-07
I7859 n1_m1_321600_96000 0 4.059245e-07
I7860 n1_m1_321600_100800 0 2.606609e-07
I7861 n1_m1_321600_105600 0 3.783750e-07
I7862 n1_m1_321600_110400 0 2.527551e-07
I7863 n1_m1_321600_115200 0 2.619253e-07
I7864 n1_m1_321600_120000 0 4.386571e-07
I7865 n1_m1_321600_124800 0 3.664913e-07
I7866 n1_m1_321600_129600 0 6.416474e-07
I7867 n1_m1_321600_134400 0 4.158085e-07
I7868 n1_m1_321600_139200 0 5.114347e-07
I7869 n1_m1_321600_144000 0 7.137468e-07
I7870 n1_m1_321600_148800 0 2.938279e-07
I7871 n1_m1_321600_153600 0 4.214403e-07
I7872 n1_m1_321600_158400 0 3.314694e-07
I7873 n1_m1_321600_163200 0 3.090726e-07
I7874 n1_m1_321600_168000 0 3.946913e-07
I7875 n1_m1_321600_172800 0 2.583125e-07
I7876 n1_m1_321600_177600 0 3.948107e-07
I7877 n1_m1_321600_182400 0 2.553737e-07
I7878 n1_m1_321600_187200 0 2.517904e-07
I7879 n1_m1_321600_192000 0 3.748754e-07
I7880 n1_m1_321600_196800 0 2.526388e-07
I7881 n1_m1_321600_201600 0 3.802339e-07
I7882 n1_m1_321600_206400 0 2.540042e-07
I7883 n1_m1_321600_211200 0 2.585011e-07
I7884 n1_m1_321600_216000 0 4.059265e-07
I7885 n1_m1_321600_220800 0 4.030071e-07
I7886 n1_m1_321600_225600 0 1.076937e-06
I7887 n1_m1_321600_230400 0 6.487874e-07
I7888 n1_m1_321600_235200 0 4.257404e-07
I7889 n1_m1_321600_240000 0 4.249186e-07
I7890 n1_m1_321600_244800 0 2.618652e-07
I7891 n1_m1_321600_249600 0 3.822784e-07
I7892 n1_m1_321600_254400 0 2.535178e-07
I7893 n1_m1_321600_259200 0 2.505219e-07
I7894 n1_m1_321600_264000 0 3.734029e-07
I7895 n1_m1_321600_268800 0 2.560416e-07
I7896 n1_m1_321600_273600 0 3.841649e-07
I7897 n1_m1_321600_278400 0 2.511134e-07
I7898 n1_m1_321600_283200 0 2.461168e-07
I7899 n1_m1_321600_288000 0 3.643224e-07
I7900 n1_m1_321600_292800 0 2.399639e-07
I7901 n1_m1_321600_297600 0 3.597531e-07
I7902 n1_m1_321600_302400 0 2.402331e-07
I7903 n1_m1_321600_307200 0 2.429373e-07
I7904 n1_m1_321600_312000 0 3.644295e-07
I7905 n1_m1_321600_316800 0 2.444740e-07
I7906 n1_m1_321600_321600 0 3.986346e-07
I7907 n1_m1_321600_326400 0 2.752274e-07
I7908 n1_m1_321600_331200 0 2.663702e-07
I7909 n1_m1_321600_336000 0 3.716011e-07
I7910 n1_m1_321600_340800 0 2.402637e-07
I7911 n1_m1_321600_345600 0 3.691334e-07
I7912 n1_m1_321600_350400 0 2.587602e-07
I7913 n1_m1_321600_355200 0 2.609709e-07
I7914 n1_m1_321600_360000 0 3.969755e-07
I7915 n1_m1_321600_364800 0 2.603917e-07
I7916 n1_m1_321600_369600 0 3.866724e-07
I7917 n1_m1_321600_374400 0 2.565606e-07
I7918 n1_m1_321600_379200 0 2.611473e-07
I7919 n1_m1_321600_384000 0 4.152150e-07
I7920 n1_m1_321600_388800 0 2.711812e-07
I7921 n1_m1_321600_393600 0 4.191694e-07
I7922 n1_m1_321600_398400 0 4.772377e-07
I7923 n1_m1_321600_403200 0 6.924727e-07
I7924 n1_m1_321600_408000 0 1.108887e-06
I7925 n1_m1_321600_412800 0 8.041705e-07
I7926 n1_m1_321600_417600 0 1.609133e-06
I7927 n1_m1_321600_422400 0 1.451102e-06
I7928 n1_m1_321600_427200 0 1.642022e-06
I7929 n1_m1_321600_432000 0 2.371840e-06
I7930 n1_m1_321600_436800 0 1.247268e-06
I7931 n1_m1_321600_441600 0 1.143183e-06
I7932 n1_m1_321600_446400 0 3.597184e-07
I7933 n1_m1_321600_451200 0 2.798324e-07
I7934 n1_m1_321600_456000 0 4.608521e-07
I7935 n1_m1_321600_460800 0 4.842329e-07
I7936 n1_m1_321600_465600 0 8.757571e-07
I7937 n1_m1_321600_470400 0 5.062077e-07
I7938 n1_m1_321600_475200 0 5.366317e-07
I7939 n1_m1_321600_480000 0 1.505652e-06
I7940 n1_m1_321600_484800 0 1.663187e-06
I7941 n1_m1_321600_489600 0 3.114160e-06
I7942 n1_m1_321600_494400 0 1.996931e-06
I7943 n1_m1_321600_499200 0 1.555745e-06
I7944 n1_m1_321600_504000 0 1.204589e-06
I7945 n1_m1_321600_508800 0 4.191878e-07
I7946 n1_m1_321600_513600 0 5.825053e-07
I7947 n1_m1_321600_518400 0 3.414901e-07
I7948 n1_m1_321600_523200 0 2.679222e-07
I7949 n1_m1_321600_528000 0 3.917271e-07
I7950 n1_m1_321600_532800 0 2.596055e-07
I7951 n1_m1_321600_537600 0 3.749447e-07
I7952 n1_m1_321600_542400 0 2.404972e-07
I7953 n1_m1_321600_547200 0 2.321651e-07
I7954 n1_m1_321600_552000 0 3.529455e-07
I7955 n1_m1_321600_556800 0 2.414221e-07
I7956 n1_m1_326400_0 0 1.480888e-07
I7957 n1_m1_326400_4800 0 1.520385e-07
I7958 n1_m1_326400_9600 0 2.298422e-07
I7959 n1_m1_326400_14400 0 1.538339e-07
I7960 n1_m1_326400_19200 0 1.566503e-07
I7961 n1_m1_326400_24000 0 2.394078e-07
I7962 n1_m1_326400_28800 0 1.610119e-07
I7963 n1_m1_326400_33600 0 2.421909e-07
I7964 n1_m1_326400_38400 0 1.598903e-07
I7965 n1_m1_326400_43200 0 1.616401e-07
I7966 n1_m1_326400_48000 0 2.479672e-07
I7967 n1_m1_326400_52800 0 1.665524e-07
I7968 n1_m1_326400_57600 0 2.490488e-07
I7969 n1_m1_326400_62400 0 1.643967e-07
I7970 n1_m1_326400_67200 0 1.705081e-07
I7971 n1_m1_326400_72000 0 2.788487e-07
I7972 n1_m1_326400_76800 0 2.018315e-07
I7973 n1_m1_326400_81600 0 2.787617e-07
I7974 n1_m1_326400_86400 0 1.691220e-07
I7975 n1_m1_326400_91200 0 1.665524e-07
I7976 n1_m1_326400_96000 0 2.525879e-07
I7977 n1_m1_326400_100800 0 1.672029e-07
I7978 n1_m1_326400_105600 0 2.504791e-07
I7979 n1_m1_326400_110400 0 1.705856e-07
I7980 n1_m1_326400_115200 0 1.756414e-07
I7981 n1_m1_326400_120000 0 2.658910e-07
I7982 n1_m1_326400_124800 0 1.799907e-07
I7983 n1_m1_326400_129600 0 2.795850e-07
I7984 n1_m1_326400_134400 0 1.879975e-07
I7985 n1_m1_326400_139200 0 1.820179e-07
I7986 n1_m1_326400_144000 0 2.608992e-07
I7987 n1_m1_326400_148800 0 1.674748e-07
I7988 n1_m1_326400_153600 0 2.900560e-07
I7989 n1_m1_326400_158400 0 2.648053e-07
I7990 n1_m1_326400_163200 0 2.697897e-07
I7991 n1_m1_326400_168000 0 3.479646e-07
I7992 n1_m1_326400_172800 0 2.293256e-07
I7993 n1_m1_326400_177600 0 3.714797e-07
I7994 n1_m1_326400_182400 0 2.036684e-07
I7995 n1_m1_326400_187200 0 1.780152e-07
I7996 n1_m1_326400_192000 0 2.565946e-07
I7997 n1_m1_326400_196800 0 1.723593e-07
I7998 n1_m1_326400_201600 0 2.592608e-07
I7999 n1_m1_326400_206400 0 1.707916e-07
I8000 n1_m1_326400_211200 0 1.727882e-07
I8001 n1_m1_326400_216000 0 2.632928e-07
I8002 n1_m1_326400_220800 0 2.101972e-07
I8003 n1_m1_326400_225600 0 4.373536e-07
I8004 n1_m1_326400_230400 0 2.573757e-07
I8005 n1_m1_326400_235200 0 2.051911e-07
I8006 n1_m1_326400_240000 0 2.919812e-07
I8007 n1_m1_326400_244800 0 2.271353e-07
I8008 n1_m1_326400_249600 0 3.141572e-07
I8009 n1_m1_326400_254400 0 1.809975e-07
I8010 n1_m1_326400_259200 0 1.703933e-07
I8011 n1_m1_326400_264000 0 2.427823e-07
I8012 n1_m1_326400_268800 0 1.633865e-07
I8013 n1_m1_326400_273600 0 2.451175e-07
I8014 n1_m1_326400_278400 0 1.616510e-07
I8015 n1_m1_326400_283200 0 1.598903e-07
I8016 n1_m1_326400_288000 0 2.398354e-07
I8017 n1_m1_326400_292800 0 1.598903e-07
I8018 n1_m1_326400_297600 0 2.403065e-07
I8019 n1_m1_326400_302400 0 1.630269e-07
I8020 n1_m1_326400_307200 0 1.659738e-07
I8021 n1_m1_326400_312000 0 2.488727e-07
I8022 n1_m1_326400_316800 0 1.645653e-07
I8023 n1_m1_326400_321600 0 2.583696e-07
I8024 n1_m1_326400_326400 0 1.750758e-07
I8025 n1_m1_326400_331200 0 1.706448e-07
I8026 n1_m1_326400_336000 0 2.445464e-07
I8027 n1_m1_326400_340800 0 1.598903e-07
I8028 n1_m1_326400_345600 0 2.416437e-07
I8029 n1_m1_326400_350400 0 1.714062e-07
I8030 n1_m1_326400_355200 0 1.730574e-07
I8031 n1_m1_326400_360000 0 2.565688e-07
I8032 n1_m1_326400_364800 0 1.731023e-07
I8033 n1_m1_326400_369600 0 2.614818e-07
I8034 n1_m1_326400_374400 0 1.763551e-07
I8035 n1_m1_326400_379200 0 1.798561e-07
I8036 n1_m1_326400_384000 0 3.157119e-07
I8037 n1_m1_326400_388800 0 1.952062e-07
I8038 n1_m1_326400_393600 0 3.853756e-07
I8039 n1_m1_326400_398400 0 6.460219e-07
I8040 n1_m1_326400_403200 0 8.515312e-07
I8041 n1_m1_326400_408000 0 8.486366e-07
I8042 n1_m1_326400_412800 0 2.310741e-07
I8043 n1_m1_326400_417600 0 3.139165e-07
I8044 n1_m1_326400_422400 0 3.265568e-07
I8045 n1_m1_326400_427200 0 5.053865e-07
I8046 n1_m1_326400_432000 0 6.784874e-07
I8047 n1_m1_326400_436800 0 3.270463e-07
I8048 n1_m1_326400_441600 0 4.132592e-07
I8049 n1_m1_326400_446400 0 2.052931e-07
I8050 n1_m1_326400_451200 0 1.776549e-07
I8051 n1_m1_326400_456000 0 2.811363e-07
I8052 n1_m1_326400_460800 0 2.479271e-07
I8053 n1_m1_326400_465600 0 4.222143e-07
I8054 n1_m1_326400_470400 0 2.537836e-07
I8055 n1_m1_326400_475200 0 2.937508e-07
I8056 n1_m1_326400_480000 0 9.165009e-07
I8057 n1_m1_326400_484800 0 1.039028e-06
I8058 n1_m1_326400_489600 0 1.783991e-06
I8059 n1_m1_326400_494400 0 9.855290e-07
I8060 n1_m1_326400_499200 0 6.211403e-07
I8061 n1_m1_326400_504000 0 4.877387e-07
I8062 n1_m1_326400_508800 0 2.040015e-07
I8063 n1_m1_326400_513600 0 2.810180e-07
I8064 n1_m1_326400_518400 0 1.746012e-07
I8065 n1_m1_326400_523200 0 1.726312e-07
I8066 n1_m1_326400_528000 0 2.814007e-07
I8067 n1_m1_326400_532800 0 2.074698e-07
I8068 n1_m1_326400_537600 0 2.894632e-07
I8069 n1_m1_326400_542400 0 1.689969e-07
I8070 n1_m1_326400_547200 0 1.587495e-07
I8071 n1_m1_326400_552000 0 2.358109e-07
I8072 n1_m1_326400_556800 0 1.618019e-07
I8073 n1_m1_331200_0 0 1.500711e-07
I8074 n1_m1_331200_4800 0 1.526259e-07
I8075 n1_m1_331200_9600 0 2.331277e-07
I8076 n1_m1_331200_14400 0 1.565871e-07
I8077 n1_m1_331200_19200 0 1.595687e-07
I8078 n1_m1_331200_24000 0 2.398354e-07
I8079 n1_m1_331200_28800 0 1.613518e-07
I8080 n1_m1_331200_33600 0 2.448320e-07
I8081 n1_m1_331200_38400 0 1.624599e-07
I8082 n1_m1_331200_43200 0 1.647400e-07
I8083 n1_m1_331200_48000 0 2.498285e-07
I8084 n1_m1_331200_52800 0 1.665524e-07
I8085 n1_m1_331200_57600 0 2.498285e-07
I8086 n1_m1_331200_62400 0 1.677420e-07
I8087 n1_m1_331200_67200 0 1.729446e-07
I8088 n1_m1_331200_72000 0 2.677829e-07
I8089 n1_m1_331200_76800 0 1.856943e-07
I8090 n1_m1_331200_81600 0 2.683485e-07
I8091 n1_m1_331200_86400 0 1.707005e-07
I8092 n1_m1_331200_91200 0 1.718385e-07
I8093 n1_m1_331200_96000 0 2.646571e-07
I8094 n1_m1_331200_100800 0 1.709792e-07
I8095 n1_m1_331200_105600 0 2.513737e-07
I8096 n1_m1_331200_110400 0 1.718983e-07
I8097 n1_m1_331200_115200 0 1.791995e-07
I8098 n1_m1_331200_120000 0 2.732839e-07
I8099 n1_m1_331200_124800 0 1.812185e-07
I8100 n1_m1_331200_129600 0 2.703077e-07
I8101 n1_m1_331200_134400 0 1.800492e-07
I8102 n1_m1_331200_139200 0 1.757841e-07
I8103 n1_m1_331200_144000 0 2.560800e-07
I8104 n1_m1_331200_148800 0 1.692281e-07
I8105 n1_m1_331200_153600 0 2.798875e-07
I8106 n1_m1_331200_158400 0 2.302698e-07
I8107 n1_m1_331200_163200 0 2.638686e-07
I8108 n1_m1_331200_168000 0 3.984170e-07
I8109 n1_m1_331200_172800 0 2.869717e-07
I8110 n1_m1_331200_177600 0 5.100560e-07
I8111 n1_m1_331200_182400 0 2.524934e-07
I8112 n1_m1_331200_187200 0 1.976385e-07
I8113 n1_m1_331200_192000 0 2.654926e-07
I8114 n1_m1_331200_196800 0 1.732144e-07
I8115 n1_m1_331200_201600 0 2.586320e-07
I8116 n1_m1_331200_206400 0 1.684239e-07
I8117 n1_m1_331200_211200 0 1.742926e-07
I8118 n1_m1_331200_216000 0 2.602805e-07
I8119 n1_m1_331200_220800 0 1.742083e-07
I8120 n1_m1_331200_225600 0 2.617217e-07
I8121 n1_m1_331200_230400 0 1.706448e-07
I8122 n1_m1_331200_235200 0 1.747331e-07
I8123 n1_m1_331200_240000 0 3.207125e-07
I8124 n1_m1_331200_244800 0 2.792328e-07
I8125 n1_m1_331200_249600 0 3.705756e-07
I8126 n1_m1_331200_254400 0 1.906311e-07
I8127 n1_m1_331200_259200 0 1.741662e-07
I8128 n1_m1_331200_264000 0 2.424051e-07
I8129 n1_m1_331200_268800 0 1.598903e-07
I8130 n1_m1_331200_273600 0 2.398354e-07
I8131 n1_m1_331200_278400 0 1.598903e-07
I8132 n1_m1_331200_283200 0 1.598903e-07
I8133 n1_m1_331200_288000 0 2.398354e-07
I8134 n1_m1_331200_292800 0 1.598903e-07
I8135 n1_m1_331200_297600 0 2.408347e-07
I8136 n1_m1_331200_302400 0 1.657434e-07
I8137 n1_m1_331200_307200 0 1.665524e-07
I8138 n1_m1_331200_312000 0 2.498285e-07
I8139 n1_m1_331200_316800 0 1.670846e-07
I8140 n1_m1_331200_321600 0 2.557979e-07
I8141 n1_m1_331200_326400 0 1.732144e-07
I8142 n1_m1_331200_331200 0 1.706448e-07
I8143 n1_m1_331200_336000 0 2.445464e-07
I8144 n1_m1_331200_340800 0 1.598903e-07
I8145 n1_m1_331200_345600 0 2.440849e-07
I8146 n1_m1_331200_350400 0 1.717549e-07
I8147 n1_m1_331200_355200 0 1.727529e-07
I8148 n1_m1_331200_360000 0 2.502602e-07
I8149 n1_m1_331200_364800 0 1.728847e-07
I8150 n1_m1_331200_369600 0 2.633431e-07
I8151 n1_m1_331200_374400 0 1.798765e-07
I8152 n1_m1_331200_379200 0 1.846352e-07
I8153 n1_m1_331200_384000 0 3.505451e-07
I8154 n1_m1_331200_388800 0 2.257974e-07
I8155 n1_m1_331200_393600 0 4.611651e-07
I8156 n1_m1_331200_398400 0 6.529009e-07
I8157 n1_m1_331200_403200 0 8.171425e-07
I8158 n1_m1_331200_408000 0 8.646344e-07
I8159 n1_m1_331200_412800 0 2.372154e-07
I8160 n1_m1_331200_417600 0 2.636374e-07
I8161 n1_m1_331200_422400 0 2.477415e-07
I8162 n1_m1_331200_427200 0 3.442522e-07
I8163 n1_m1_331200_432000 0 4.011023e-07
I8164 n1_m1_331200_436800 0 1.891083e-07
I8165 n1_m1_331200_441600 0 2.764511e-07
I8166 n1_m1_331200_446400 0 1.789642e-07
I8167 n1_m1_331200_451200 0 1.840614e-07
I8168 n1_m1_331200_456000 0 2.678046e-07
I8169 n1_m1_331200_460800 0 1.738079e-07
I8170 n1_m1_331200_465600 0 2.571786e-07
I8171 n1_m1_331200_470400 0 1.814550e-07
I8172 n1_m1_331200_475200 0 2.170701e-07
I8173 n1_m1_331200_480000 0 5.693929e-07
I8174 n1_m1_331200_484800 0 6.433734e-07
I8175 n1_m1_331200_489600 0 1.029178e-06
I8176 n1_m1_331200_494400 0 4.570237e-07
I8177 n1_m1_331200_499200 0 2.403119e-07
I8178 n1_m1_331200_504000 0 2.654097e-07
I8179 n1_m1_331200_508800 0 1.775645e-07
I8180 n1_m1_331200_513600 0 2.610378e-07
I8181 n1_m1_331200_518400 0 1.709575e-07
I8182 n1_m1_331200_523200 0 1.761988e-07
I8183 n1_m1_331200_528000 0 2.884041e-07
I8184 n1_m1_331200_532800 0 2.226961e-07
I8185 n1_m1_331200_537600 0 3.106174e-07
I8186 n1_m1_331200_542400 0 1.786672e-07
I8187 n1_m1_331200_547200 0 1.656958e-07
I8188 n1_m1_331200_552000 0 2.402208e-07
I8189 n1_m1_331200_556800 0 1.579079e-07
I8190 n1_m1_336000_0 0 2.351243e-07
I8191 n1_m1_336000_4800 0 2.353599e-07
I8192 n1_m1_336000_9600 0 3.587099e-07
I8193 n1_m1_336000_14400 0 2.398354e-07
I8194 n1_m1_336000_19200 0 2.398354e-07
I8195 n1_m1_336000_24000 0 3.597531e-07
I8196 n1_m1_336000_28800 0 2.417218e-07
I8197 n1_m1_336000_33600 0 3.712095e-07
I8198 n1_m1_336000_38400 0 2.498285e-07
I8199 n1_m1_336000_43200 0 2.498285e-07
I8200 n1_m1_336000_48000 0 3.743278e-07
I8201 n1_m1_336000_52800 0 2.455651e-07
I8202 n1_m1_336000_57600 0 3.679893e-07
I8203 n1_m1_336000_62400 0 2.513489e-07
I8204 n1_m1_336000_67200 0 2.602499e-07
I8205 n1_m1_336000_72000 0 4.075060e-07
I8206 n1_m1_336000_76800 0 2.765245e-07
I8207 n1_m1_336000_81600 0 3.976556e-07
I8208 n1_m1_336000_86400 0 2.598217e-07
I8209 n1_m1_336000_91200 0 2.675939e-07
I8210 n1_m1_336000_96000 0 4.058633e-07
I8211 n1_m1_336000_100800 0 2.574845e-07
I8212 n1_m1_336000_105600 0 3.760215e-07
I8213 n1_m1_336000_110400 0 2.513764e-07
I8214 n1_m1_336000_115200 0 2.594546e-07
I8215 n1_m1_336000_120000 0 4.044041e-07
I8216 n1_m1_336000_124800 0 2.745259e-07
I8217 n1_m1_336000_129600 0 4.082422e-07
I8218 n1_m1_336000_134400 0 2.692438e-07
I8219 n1_m1_336000_139200 0 2.645327e-07
I8220 n1_m1_336000_144000 0 4.079180e-07
I8221 n1_m1_336000_148800 0 3.331632e-07
I8222 n1_m1_336000_153600 0 5.048413e-07
I8223 n1_m1_336000_158400 0 3.091174e-07
I8224 n1_m1_336000_163200 0 3.092989e-07
I8225 n1_m1_336000_168000 0 4.729040e-07
I8226 n1_m1_336000_172800 0 3.800249e-07
I8227 n1_m1_336000_177600 0 7.636493e-07
I8228 n1_m1_336000_182400 0 3.747754e-07
I8229 n1_m1_336000_187200 0 2.972388e-07
I8230 n1_m1_336000_192000 0 3.987651e-07
I8231 n1_m1_336000_196800 0 2.598217e-07
I8232 n1_m1_336000_201600 0 3.888912e-07
I8233 n1_m1_336000_206400 0 2.561099e-07
I8234 n1_m1_336000_211200 0 2.587418e-07
I8235 n1_m1_336000_216000 0 3.896305e-07
I8236 n1_m1_336000_220800 0 2.611045e-07
I8237 n1_m1_336000_225600 0 3.913283e-07
I8238 n1_m1_336000_230400 0 2.551106e-07
I8239 n1_m1_336000_235200 0 2.592833e-07
I8240 n1_m1_336000_240000 0 4.540108e-07
I8241 n1_m1_336000_244800 0 3.375071e-07
I8242 n1_m1_336000_249600 0 4.651165e-07
I8243 n1_m1_336000_254400 0 2.667802e-07
I8244 n1_m1_336000_259200 0 2.507228e-07
I8245 n1_m1_336000_264000 0 3.615702e-07
I8246 n1_m1_336000_268800 0 2.398354e-07
I8247 n1_m1_336000_273600 0 3.628469e-07
I8248 n1_m1_336000_278400 0 2.424764e-07
I8249 n1_m1_336000_283200 0 2.398354e-07
I8250 n1_m1_336000_288000 0 3.597531e-07
I8251 n1_m1_336000_292800 0 2.398354e-07
I8252 n1_m1_336000_297600 0 3.612521e-07
I8253 n1_m1_336000_302400 0 2.486151e-07
I8254 n1_m1_336000_307200 0 2.498285e-07
I8255 n1_m1_336000_312000 0 3.761765e-07
I8256 n1_m1_336000_316800 0 2.559733e-07
I8257 n1_m1_336000_321600 0 3.894297e-07
I8258 n1_m1_336000_326400 0 2.598217e-07
I8259 n1_m1_336000_331200 0 2.559672e-07
I8260 n1_m1_336000_336000 0 3.710076e-07
I8261 n1_m1_336000_340800 0 2.415709e-07
I8262 n1_m1_336000_345600 0 3.719590e-07
I8263 n1_m1_336000_350400 0 2.584655e-07
I8264 n1_m1_336000_355200 0 2.588224e-07
I8265 n1_m1_336000_360000 0 3.677496e-07
I8266 n1_m1_336000_364800 0 2.550331e-07
I8267 n1_m1_336000_369600 0 3.918076e-07
I8268 n1_m1_336000_374400 0 2.645327e-07
I8269 n1_m1_336000_379200 0 2.697842e-07
I8270 n1_m1_336000_384000 0 4.603983e-07
I8271 n1_m1_336000_388800 0 3.270102e-07
I8272 n1_m1_336000_393600 0 5.920559e-07
I8273 n1_m1_336000_398400 0 5.107586e-07
I8274 n1_m1_336000_403200 0 6.030126e-07
I8275 n1_m1_336000_408000 0 8.587565e-07
I8276 n1_m1_336000_412800 0 4.051617e-07
I8277 n1_m1_336000_417600 0 4.179641e-07
I8278 n1_m1_336000_422400 0 3.063285e-07
I8279 n1_m1_336000_427200 0 3.682432e-07
I8280 n1_m1_336000_432000 0 4.781657e-07
I8281 n1_m1_336000_436800 0 2.775503e-07
I8282 n1_m1_336000_441600 0 4.029296e-07
I8283 n1_m1_336000_446400 0 2.583747e-07
I8284 n1_m1_336000_451200 0 2.808603e-07
I8285 n1_m1_336000_456000 0 3.900945e-07
I8286 n1_m1_336000_460800 0 2.502252e-07
I8287 n1_m1_336000_465600 0 3.849603e-07
I8288 n1_m1_336000_470400 0 2.681282e-07
I8289 n1_m1_336000_475200 0 2.627768e-07
I8290 n1_m1_336000_480000 0 4.133663e-07
I8291 n1_m1_336000_484800 0 3.380924e-07
I8292 n1_m1_336000_489600 0 5.024735e-07
I8293 n1_m1_336000_494400 0 2.624505e-07
I8294 n1_m1_336000_499200 0 2.421022e-07
I8295 n1_m1_336000_504000 0 3.929109e-07
I8296 n1_m1_336000_508800 0 2.771537e-07
I8297 n1_m1_336000_513600 0 4.085278e-07
I8298 n1_m1_336000_518400 0 3.054434e-07
I8299 n1_m1_336000_523200 0 3.306751e-07
I8300 n1_m1_336000_528000 0 3.935013e-07
I8301 n1_m1_336000_532800 0 2.771180e-07
I8302 n1_m1_336000_537600 0 4.151722e-07
I8303 n1_m1_336000_542400 0 2.658247e-07
I8304 n1_m1_336000_547200 0 2.533995e-07
I8305 n1_m1_336000_552000 0 3.612521e-07
I8306 n1_m1_336000_556800 0 2.321264e-07
I8307 n1_m1_340800_0 0 7.994513e-08
I8308 n1_m1_340800_4800 0 7.994513e-08
I8309 n1_m1_340800_9600 0 1.199177e-07
I8310 n1_m1_340800_14400 0 8.052330e-08
I8311 n1_m1_340800_19200 0 8.405659e-08
I8312 n1_m1_340800_24000 0 1.593835e-07
I8313 n1_m1_340800_28800 0 1.601520e-07
I8314 n1_m1_340800_33600 0 2.058587e-07
I8315 n1_m1_340800_38400 0 8.327618e-08
I8316 n1_m1_340800_43200 0 8.327618e-08
I8317 n1_m1_340800_48000 0 1.219758e-07
I8318 n1_m1_340800_52800 0 8.000937e-08
I8319 n1_m1_340800_57600 0 1.206553e-07
I8320 n1_m1_340800_62400 0 8.370445e-08
I8321 n1_m1_340800_67200 0 9.041175e-08
I8322 n1_m1_340800_72000 0 1.887918e-07
I8323 n1_m1_340800_76800 0 1.610847e-07
I8324 n1_m1_340800_81600 0 2.364948e-07
I8325 n1_m1_340800_86400 0 1.329897e-07
I8326 n1_m1_340800_91200 0 1.116662e-07
I8327 n1_m1_340800_96000 0 1.436942e-07
I8328 n1_m1_340800_100800 0 8.758512e-08
I8329 n1_m1_340800_105600 0 1.294112e-07
I8330 n1_m1_340800_110400 0 8.578160e-08
I8331 n1_m1_340800_115200 0 8.363783e-08
I8332 n1_m1_340800_120000 0 1.266488e-07
I8333 n1_m1_340800_124800 0 8.873909e-08
I8334 n1_m1_340800_129600 0 1.391378e-07
I8335 n1_m1_340800_134400 0 9.084717e-08
I8336 n1_m1_340800_139200 0 9.560105e-08
I8337 n1_m1_340800_144000 0 2.083189e-07
I8338 n1_m1_340800_148800 0 2.049593e-07
I8339 n1_m1_340800_153600 0 2.750683e-07
I8340 n1_m1_340800_158400 0 1.271247e-07
I8341 n1_m1_340800_163200 0 1.089324e-07
I8342 n1_m1_340800_168000 0 1.401609e-07
I8343 n1_m1_340800_172800 0 1.103576e-07
I8344 n1_m1_340800_177600 0 2.322763e-07
I8345 n1_m1_340800_182400 0 1.109715e-07
I8346 n1_m1_340800_187200 0 9.169897e-08
I8347 n1_m1_340800_192000 0 1.319570e-07
I8348 n1_m1_340800_196800 0 8.660722e-08
I8349 n1_m1_340800_201600 0 1.299108e-07
I8350 n1_m1_340800_206400 0 8.574829e-08
I8351 n1_m1_340800_211200 0 8.144648e-08
I8352 n1_m1_340800_216000 0 1.248191e-07
I8353 n1_m1_340800_220800 0 8.441825e-08
I8354 n1_m1_340800_225600 0 1.300869e-07
I8355 n1_m1_340800_230400 0 8.660722e-08
I8356 n1_m1_340800_235200 0 8.660722e-08
I8357 n1_m1_340800_240000 0 1.300607e-07
I8358 n1_m1_340800_244800 0 8.232921e-08
I8359 n1_m1_340800_249600 0 1.208623e-07
I8360 n1_m1_340800_254400 0 8.027348e-08
I8361 n1_m1_340800_259200 0 7.999509e-08
I8362 n1_m1_340800_264000 0 1.199177e-07
I8363 n1_m1_340800_268800 0 8.060896e-08
I8364 n1_m1_340800_273600 0 1.244598e-07
I8365 n1_m1_340800_278400 0 8.310962e-08
I8366 n1_m1_340800_283200 0 8.294307e-08
I8367 n1_m1_340800_288000 0 1.219306e-07
I8368 n1_m1_340800_292800 0 7.994513e-08
I8369 n1_m1_340800_297600 0 1.199677e-07
I8370 n1_m1_340800_302400 0 8.055899e-08
I8371 n1_m1_340800_307200 0 8.278366e-08
I8372 n1_m1_340800_312000 0 1.258184e-07
I8373 n1_m1_340800_316800 0 8.653584e-08
I8374 n1_m1_340800_321600 0 1.282406e-07
I8375 n1_m1_340800_326400 0 8.360928e-08
I8376 n1_m1_340800_331200 0 8.348080e-08
I8377 n1_m1_340800_336000 0 1.249143e-07
I8378 n1_m1_340800_340800 0 8.103962e-08
I8379 n1_m1_340800_345600 0 1.203246e-07
I8380 n1_m1_340800_350400 0 8.084451e-08
I8381 n1_m1_340800_355200 0 8.304062e-08
I8382 n1_m1_340800_360000 0 1.246430e-07
I8383 n1_m1_340800_364800 0 8.332852e-08
I8384 n1_m1_340800_369600 0 1.253877e-07
I8385 n1_m1_340800_374400 0 8.493694e-08
I8386 n1_m1_340800_379200 0 8.672619e-08
I8387 n1_m1_340800_384000 0 1.276624e-07
I8388 n1_m1_340800_388800 0 8.798723e-08
I8389 n1_m1_340800_393600 0 1.786179e-07
I8390 n1_m1_340800_398400 0 1.199201e-07
I8391 n1_m1_340800_403200 0 1.082709e-07
I8392 n1_m1_340800_408000 0 1.603162e-07
I8393 n1_m1_340800_412800 0 9.830158e-08
I8394 n1_m1_340800_417600 0 1.343126e-07
I8395 n1_m1_340800_422400 0 1.247001e-07
I8396 n1_m1_340800_427200 0 1.636543e-07
I8397 n1_m1_340800_432000 0 2.158661e-07
I8398 n1_m1_340800_436800 0 1.711302e-07
I8399 n1_m1_340800_441600 0 3.290170e-07
I8400 n1_m1_340800_446400 0 1.965675e-07
I8401 n1_m1_340800_451200 0 1.640279e-07
I8402 n1_m1_340800_456000 0 1.485005e-07
I8403 n1_m1_340800_460800 0 8.352363e-08
I8404 n1_m1_340800_465600 0 1.271056e-07
I8405 n1_m1_340800_470400 0 8.701647e-08
I8406 n1_m1_340800_475200 0 8.550798e-08
I8407 n1_m1_340800_480000 0 1.244408e-07
I8408 n1_m1_340800_484800 0 8.313818e-08
I8409 n1_m1_340800_489600 0 1.249071e-07
I8410 n1_m1_340800_494400 0 8.059944e-08
I8411 n1_m1_340800_499200 0 7.995227e-08
I8412 n1_m1_340800_504000 0 1.211811e-07
I8413 n1_m1_340800_508800 0 8.165110e-08
I8414 n1_m1_340800_513600 0 1.285403e-07
I8415 n1_m1_340800_518400 0 9.655278e-08
I8416 n1_m1_340800_523200 0 1.031911e-07
I8417 n1_m1_340800_528000 0 1.350859e-07
I8418 n1_m1_340800_532800 0 8.326666e-08
I8419 n1_m1_340800_537600 0 1.180047e-07
I8420 n1_m1_340800_542400 0 7.770857e-08
I8421 n1_m1_340800_547200 0 7.963106e-08
I8422 n1_m1_340800_552000 0 1.199677e-07
I8423 n1_m1_340800_556800 0 7.968816e-08
I8424 n1_m1_345600_0 0 2.414370e-07
I8425 n1_m1_345600_4800 0 2.408558e-07
I8426 n1_m1_345600_9600 0 3.599533e-07
I8427 n1_m1_345600_14400 0 2.457731e-07
I8428 n1_m1_345600_19200 0 2.987409e-07
I8429 n1_m1_345600_24000 0 8.278787e-07
I8430 n1_m1_345600_28800 0 8.703890e-07
I8431 n1_m1_345600_33600 0 9.503834e-07
I8432 n1_m1_345600_38400 0 2.573846e-07
I8433 n1_m1_345600_43200 0 2.530318e-07
I8434 n1_m1_345600_48000 0 3.703050e-07
I8435 n1_m1_345600_52800 0 2.452925e-07
I8436 n1_m1_345600_57600 0 3.712398e-07
I8437 n1_m1_345600_62400 0 2.563122e-07
I8438 n1_m1_345600_67200 0 3.093642e-07
I8439 n1_m1_345600_72000 0 9.832320e-07
I8440 n1_m1_345600_76800 0 8.992026e-07
I8441 n1_m1_345600_81600 0 1.440702e-06
I8442 n1_m1_345600_86400 0 8.001882e-07
I8443 n1_m1_345600_91200 0 6.416351e-07
I8444 n1_m1_345600_96000 0 7.691456e-07
I8445 n1_m1_345600_100800 0 4.279600e-07
I8446 n1_m1_345600_105600 0 4.556767e-07
I8447 n1_m1_345600_110400 0 2.692234e-07
I8448 n1_m1_345600_115200 0 2.607544e-07
I8449 n1_m1_345600_120000 0 4.757214e-07
I8450 n1_m1_345600_124800 0 5.059575e-07
I8451 n1_m1_345600_129600 0 9.188489e-07
I8452 n1_m1_345600_134400 0 6.203830e-07
I8453 n1_m1_345600_139200 0 5.099595e-07
I8454 n1_m1_345600_144000 0 7.603781e-07
I8455 n1_m1_345600_148800 0 6.439366e-07
I8456 n1_m1_345600_153600 0 7.433806e-07
I8457 n1_m1_345600_158400 0 3.229559e-07
I8458 n1_m1_345600_163200 0 2.936695e-07
I8459 n1_m1_345600_168000 0 4.163911e-07
I8460 n1_m1_345600_172800 0 3.550019e-07
I8461 n1_m1_345600_177600 0 8.083850e-07
I8462 n1_m1_345600_182400 0 3.972634e-07
I8463 n1_m1_345600_187200 0 3.027636e-07
I8464 n1_m1_345600_192000 0 3.979959e-07
I8465 n1_m1_345600_196800 0 2.609454e-07
I8466 n1_m1_345600_201600 0 3.897971e-07
I8467 n1_m1_345600_206400 0 2.557466e-07
I8468 n1_m1_345600_211200 0 2.626500e-07
I8469 n1_m1_345600_216000 0 3.825680e-07
I8470 n1_m1_345600_220800 0 2.482772e-07
I8471 n1_m1_345600_225600 0 3.728169e-07
I8472 n1_m1_345600_230400 0 2.564634e-07
I8473 n1_m1_345600_235200 0 2.819473e-07
I8474 n1_m1_345600_240000 0 4.707544e-07
I8475 n1_m1_345600_244800 0 2.680446e-07
I8476 n1_m1_345600_249600 0 3.719848e-07
I8477 n1_m1_345600_254400 0 2.463581e-07
I8478 n1_m1_345600_259200 0 2.461644e-07
I8479 n1_m1_345600_264000 0 3.692466e-07
I8480 n1_m1_345600_268800 0 2.469757e-07
I8481 n1_m1_345600_273600 0 3.745596e-07
I8482 n1_m1_345600_278400 0 2.489244e-07
I8483 n1_m1_345600_283200 0 2.487694e-07
I8484 n1_m1_345600_288000 0 3.739026e-07
I8485 n1_m1_345600_292800 0 2.438136e-07
I8486 n1_m1_345600_297600 0 3.594431e-07
I8487 n1_m1_345600_302400 0 2.393238e-07
I8488 n1_m1_345600_307200 0 2.425165e-07
I8489 n1_m1_345600_312000 0 3.763896e-07
I8490 n1_m1_345600_316800 0 2.584192e-07
I8491 n1_m1_345600_321600 0 3.853467e-07
I8492 n1_m1_345600_326400 0 2.498802e-07
I8493 n1_m1_345600_331200 0 2.489244e-07
I8494 n1_m1_345600_336000 0 3.741034e-07
I8495 n1_m1_345600_340800 0 2.437259e-07
I8496 n1_m1_345600_345600 0 3.603731e-07
I8497 n1_m1_345600_350400 0 2.421583e-07
I8498 n1_m1_345600_355200 0 2.486834e-07
I8499 n1_m1_345600_360000 0 3.828349e-07
I8500 n1_m1_345600_364800 0 2.549369e-07
I8501 n1_m1_345600_369600 0 3.718947e-07
I8502 n1_m1_345600_374400 0 2.507279e-07
I8503 n1_m1_345600_379200 0 2.598217e-07
I8504 n1_m1_345600_384000 0 3.971560e-07
I8505 n1_m1_345600_388800 0 2.738495e-07
I8506 n1_m1_345600_393600 0 4.590139e-07
I8507 n1_m1_345600_398400 0 2.944387e-07
I8508 n1_m1_345600_403200 0 2.715429e-07
I8509 n1_m1_345600_408000 0 4.081189e-07
I8510 n1_m1_345600_412800 0 2.746941e-07
I8511 n1_m1_345600_417600 0 4.022511e-07
I8512 n1_m1_345600_422400 0 3.359381e-07
I8513 n1_m1_345600_427200 0 4.481502e-07
I8514 n1_m1_345600_432000 0 6.865186e-07
I8515 n1_m1_345600_436800 0 7.636656e-07
I8516 n1_m1_345600_441600 0 2.035455e-06
I8517 n1_m1_345600_446400 0 1.563935e-06
I8518 n1_m1_345600_451200 0 1.506909e-06
I8519 n1_m1_345600_456000 0 9.846993e-07
I8520 n1_m1_345600_460800 0 2.758192e-07
I8521 n1_m1_345600_465600 0 3.763539e-07
I8522 n1_m1_345600_470400 0 2.590467e-07
I8523 n1_m1_345600_475200 0 2.542921e-07
I8524 n1_m1_345600_480000 0 3.842172e-07
I8525 n1_m1_345600_484800 0 2.566871e-07
I8526 n1_m1_345600_489600 0 3.829402e-07
I8527 n1_m1_345600_494400 0 2.474710e-07
I8528 n1_m1_345600_499200 0 2.412497e-07
I8529 n1_m1_345600_504000 0 3.617486e-07
I8530 n1_m1_345600_508800 0 2.419027e-07
I8531 n1_m1_345600_513600 0 3.767941e-07
I8532 n1_m1_345600_518400 0 2.650392e-07
I8533 n1_m1_345600_523200 0 3.188159e-07
I8534 n1_m1_345600_528000 0 5.549263e-07
I8535 n1_m1_345600_532800 0 2.575987e-07
I8536 n1_m1_345600_537600 0 3.505234e-07
I8537 n1_m1_345600_542400 0 2.301346e-07
I8538 n1_m1_345600_547200 0 2.360394e-07
I8539 n1_m1_345600_552000 0 3.643836e-07
I8540 n1_m1_345600_556800 0 2.403779e-07
I8541 n1_m1_350400_0 0 1.688528e-07
I8542 n1_m1_350400_4800 0 1.651822e-07
I8543 n1_m1_350400_9600 0 2.400454e-07
I8544 n1_m1_350400_14400 0 1.630619e-07
I8545 n1_m1_350400_19200 0 1.914281e-07
I8546 n1_m1_350400_24000 0 4.618504e-07
I8547 n1_m1_350400_28800 0 4.537294e-07
I8548 n1_m1_350400_33600 0 5.219632e-07
I8549 n1_m1_350400_38400 0 1.744313e-07
I8550 n1_m1_350400_43200 0 1.688841e-07
I8551 n1_m1_350400_48000 0 2.388670e-07
I8552 n1_m1_350400_52800 0 1.553614e-07
I8553 n1_m1_350400_57600 0 2.412684e-07
I8554 n1_m1_350400_62400 0 1.681516e-07
I8555 n1_m1_350400_67200 0 1.968656e-07
I8556 n1_m1_350400_72000 0 5.724455e-07
I8557 n1_m1_350400_76800 0 5.739231e-07
I8558 n1_m1_350400_81600 0 1.044033e-06
I8559 n1_m1_350400_86400 0 6.347093e-07
I8560 n1_m1_350400_91200 0 5.086611e-07
I8561 n1_m1_350400_96000 0 5.744435e-07
I8562 n1_m1_350400_100800 0 3.317125e-07
I8563 n1_m1_350400_105600 0 3.284640e-07
I8564 n1_m1_350400_110400 0 2.224694e-07
I8565 n1_m1_350400_115200 0 1.891664e-07
I8566 n1_m1_350400_120000 0 5.748534e-07
I8567 n1_m1_350400_124800 0 9.173228e-07
I8568 n1_m1_350400_129600 0 1.225479e-06
I8569 n1_m1_350400_134400 0 6.039685e-07
I8570 n1_m1_350400_139200 0 4.365337e-07
I8571 n1_m1_350400_144000 0 3.836690e-07
I8572 n1_m1_350400_148800 0 2.442351e-07
I8573 n1_m1_350400_153600 0 3.109111e-07
I8574 n1_m1_350400_158400 0 1.827059e-07
I8575 n1_m1_350400_163200 0 1.808154e-07
I8576 n1_m1_350400_168000 0 2.710691e-07
I8577 n1_m1_350400_172800 0 1.984359e-07
I8578 n1_m1_350400_177600 0 3.552878e-07
I8579 n1_m1_350400_182400 0 2.112890e-07
I8580 n1_m1_350400_187200 0 1.929791e-07
I8581 n1_m1_350400_192000 0 2.774232e-07
I8582 n1_m1_350400_196800 0 1.799024e-07
I8583 n1_m1_350400_201600 0 2.657268e-07
I8584 n1_m1_350400_206400 0 1.806614e-07
I8585 n1_m1_350400_211200 0 2.185595e-07
I8586 n1_m1_350400_216000 0 2.559121e-07
I8587 n1_m1_350400_220800 0 1.647481e-07
I8588 n1_m1_350400_225600 0 2.485607e-07
I8589 n1_m1_350400_230400 0 1.697488e-07
I8590 n1_m1_350400_235200 0 2.714090e-07
I8591 n1_m1_350400_240000 0 5.419372e-07
I8592 n1_m1_350400_244800 0 2.232366e-07
I8593 n1_m1_350400_249600 0 2.588332e-07
I8594 n1_m1_350400_254400 0 1.631329e-07
I8595 n1_m1_350400_259200 0 1.620316e-07
I8596 n1_m1_350400_264000 0 2.430475e-07
I8597 n1_m1_350400_268800 0 1.630327e-07
I8598 n1_m1_350400_273600 0 2.492402e-07
I8599 n1_m1_350400_278400 0 1.604851e-07
I8600 n1_m1_350400_283200 0 1.598073e-07
I8601 n1_m1_350400_288000 0 2.588101e-07
I8602 n1_m1_350400_292800 0 1.727862e-07
I8603 n1_m1_350400_297600 0 2.383119e-07
I8604 n1_m1_350400_302400 0 1.553016e-07
I8605 n1_m1_350400_307200 0 1.598444e-07
I8606 n1_m1_350400_312000 0 2.530124e-07
I8607 n1_m1_350400_316800 0 1.653759e-07
I8608 n1_m1_350400_321600 0 2.630929e-07
I8609 n1_m1_350400_326400 0 1.674647e-07
I8610 n1_m1_350400_331200 0 1.617930e-07
I8611 n1_m1_350400_336000 0 2.466848e-07
I8612 n1_m1_350400_340800 0 1.665639e-07
I8613 n1_m1_350400_345600 0 2.457191e-07
I8614 n1_m1_350400_350400 0 1.691672e-07
I8615 n1_m1_350400_355200 0 1.673538e-07
I8616 n1_m1_350400_360000 0 2.509845e-07
I8617 n1_m1_350400_364800 0 1.672821e-07
I8618 n1_m1_350400_369600 0 2.494217e-07
I8619 n1_m1_350400_374400 0 1.687250e-07
I8620 n1_m1_350400_379200 0 1.725958e-07
I8621 n1_m1_350400_384000 0 2.607139e-07
I8622 n1_m1_350400_388800 0 1.783266e-07
I8623 n1_m1_350400_393600 0 3.267261e-07
I8624 n1_m1_350400_398400 0 2.031762e-07
I8625 n1_m1_350400_403200 0 1.730639e-07
I8626 n1_m1_350400_408000 0 2.535783e-07
I8627 n1_m1_350400_412800 0 1.778011e-07
I8628 n1_m1_350400_417600 0 2.610100e-07
I8629 n1_m1_350400_422400 0 1.793089e-07
I8630 n1_m1_350400_427200 0 2.010708e-07
I8631 n1_m1_350400_432000 0 3.259355e-07
I8632 n1_m1_350400_436800 0 2.915081e-07
I8633 n1_m1_350400_441600 0 1.246104e-06
I8634 n1_m1_350400_446400 0 1.292799e-06
I8635 n1_m1_350400_451200 0 1.374969e-06
I8636 n1_m1_350400_456000 0 1.258485e-06
I8637 n1_m1_350400_460800 0 2.236842e-07
I8638 n1_m1_350400_465600 0 2.791482e-07
I8639 n1_m1_350400_470400 0 2.034032e-07
I8640 n1_m1_350400_475200 0 1.701737e-07
I8641 n1_m1_350400_480000 0 2.525494e-07
I8642 n1_m1_350400_484800 0 1.717039e-07
I8643 n1_m1_350400_489600 0 2.491497e-07
I8644 n1_m1_350400_494400 0 1.614983e-07
I8645 n1_m1_350400_499200 0 1.603009e-07
I8646 n1_m1_350400_504000 0 2.511786e-07
I8647 n1_m1_350400_508800 0 1.640272e-07
I8648 n1_m1_350400_513600 0 2.372973e-07
I8649 n1_m1_350400_518400 0 1.633131e-07
I8650 n1_m1_350400_523200 0 1.748215e-07
I8651 n1_m1_350400_528000 0 2.816577e-07
I8652 n1_m1_350400_532800 0 1.695816e-07
I8653 n1_m1_350400_537600 0 2.360801e-07
I8654 n1_m1_350400_542400 0 1.530769e-07
I8655 n1_m1_350400_547200 0 1.500215e-07
I8656 n1_m1_350400_552000 0 2.302970e-07
I8657 n1_m1_350400_556800 0 1.538617e-07
I8658 n1_m1_355200_0 0 1.605660e-07
I8659 n1_m1_355200_4800 0 1.569518e-07
I8660 n1_m1_355200_9600 0 2.323898e-07
I8661 n1_m1_355200_14400 0 1.564304e-07
I8662 n1_m1_355200_19200 0 1.658657e-07
I8663 n1_m1_355200_24000 0 2.892100e-07
I8664 n1_m1_355200_28800 0 2.274153e-07
I8665 n1_m1_355200_33600 0 3.079315e-07
I8666 n1_m1_355200_38400 0 1.678338e-07
I8667 n1_m1_355200_43200 0 1.638828e-07
I8668 n1_m1_355200_48000 0 2.389047e-07
I8669 n1_m1_355200_52800 0 1.547785e-07
I8670 n1_m1_355200_57600 0 2.397735e-07
I8671 n1_m1_355200_62400 0 1.674089e-07
I8672 n1_m1_355200_67200 0 1.760509e-07
I8673 n1_m1_355200_72000 0 3.124750e-07
I8674 n1_m1_355200_76800 0 2.681812e-07
I8675 n1_m1_355200_81600 0 5.271586e-07
I8676 n1_m1_355200_86400 0 3.709604e-07
I8677 n1_m1_355200_91200 0 3.405880e-07
I8678 n1_m1_355200_96000 0 4.302914e-07
I8679 n1_m1_355200_100800 0 2.446729e-07
I8680 n1_m1_355200_105600 0 2.856132e-07
I8681 n1_m1_355200_110400 0 1.842117e-07
I8682 n1_m1_355200_115200 0 1.845757e-07
I8683 n1_m1_355200_120000 0 6.010772e-07
I8684 n1_m1_355200_124800 0 8.981502e-07
I8685 n1_m1_355200_129600 0 1.111814e-06
I8686 n1_m1_355200_134400 0 4.523929e-07
I8687 n1_m1_355200_139200 0 3.172346e-07
I8688 n1_m1_355200_144000 0 2.891774e-07
I8689 n1_m1_355200_148800 0 1.852239e-07
I8690 n1_m1_355200_153600 0 2.653383e-07
I8691 n1_m1_355200_158400 0 1.752423e-07
I8692 n1_m1_355200_163200 0 1.789551e-07
I8693 n1_m1_355200_168000 0 2.715956e-07
I8694 n1_m1_355200_172800 0 1.870437e-07
I8695 n1_m1_355200_177600 0 2.909870e-07
I8696 n1_m1_355200_182400 0 1.962197e-07
I8697 n1_m1_355200_187200 0 1.940002e-07
I8698 n1_m1_355200_192000 0 2.859010e-07
I8699 n1_m1_355200_196800 0 1.795829e-07
I8700 n1_m1_355200_201600 0 2.562513e-07
I8701 n1_m1_355200_206400 0 1.694565e-07
I8702 n1_m1_355200_211200 0 1.743942e-07
I8703 n1_m1_355200_216000 0 2.502327e-07
I8704 n1_m1_355200_220800 0 1.853898e-07
I8705 n1_m1_355200_225600 0 2.742132e-07
I8706 n1_m1_355200_230400 0 1.658447e-07
I8707 n1_m1_355200_235200 0 2.276064e-07
I8708 n1_m1_355200_240000 0 4.270722e-07
I8709 n1_m1_355200_244800 0 2.080871e-07
I8710 n1_m1_355200_249600 0 2.639134e-07
I8711 n1_m1_355200_254400 0 1.714541e-07
I8712 n1_m1_355200_259200 0 1.708589e-07
I8713 n1_m1_355200_264000 0 2.558173e-07
I8714 n1_m1_355200_268800 0 1.695537e-07
I8715 n1_m1_355200_273600 0 2.467279e-07
I8716 n1_m1_355200_278400 0 1.576537e-07
I8717 n1_m1_355200_283200 0 1.591384e-07
I8718 n1_m1_355200_288000 0 2.560131e-07
I8719 n1_m1_355200_292800 0 1.696407e-07
I8720 n1_m1_355200_297600 0 2.419095e-07
I8721 n1_m1_355200_302400 0 1.591612e-07
I8722 n1_m1_355200_307200 0 1.608416e-07
I8723 n1_m1_355200_312000 0 2.532643e-07
I8724 n1_m1_355200_316800 0 1.633630e-07
I8725 n1_m1_355200_321600 0 2.595535e-07
I8726 n1_m1_355200_326400 0 1.719167e-07
I8727 n1_m1_355200_331200 0 1.687243e-07
I8728 n1_m1_355200_336000 0 2.530620e-07
I8729 n1_m1_355200_340800 0 1.716917e-07
I8730 n1_m1_355200_345600 0 2.610701e-07
I8731 n1_m1_355200_350400 0 1.687488e-07
I8732 n1_m1_355200_355200 0 1.667648e-07
I8733 n1_m1_355200_360000 0 2.498285e-07
I8734 n1_m1_355200_364800 0 1.664881e-07
I8735 n1_m1_355200_369600 0 2.495311e-07
I8736 n1_m1_355200_374400 0 1.670792e-07
I8737 n1_m1_355200_379200 0 1.677420e-07
I8738 n1_m1_355200_384000 0 2.557173e-07
I8739 n1_m1_355200_388800 0 1.737651e-07
I8740 n1_m1_355200_393600 0 2.852284e-07
I8741 n1_m1_355200_398400 0 1.894061e-07
I8742 n1_m1_355200_403200 0 1.710952e-07
I8743 n1_m1_355200_408000 0 2.515671e-07
I8744 n1_m1_355200_412800 0 1.728813e-07
I8745 n1_m1_355200_417600 0 2.552700e-07
I8746 n1_m1_355200_422400 0 1.752056e-07
I8747 n1_m1_355200_427200 0 1.987690e-07
I8748 n1_m1_355200_432000 0 3.340238e-07
I8749 n1_m1_355200_436800 0 1.967242e-07
I8750 n1_m1_355200_441600 0 6.040058e-07
I8751 n1_m1_355200_446400 0 9.288040e-07
I8752 n1_m1_355200_451200 0 1.221111e-06
I8753 n1_m1_355200_456000 0 1.443402e-06
I8754 n1_m1_355200_460800 0 3.046746e-07
I8755 n1_m1_355200_465600 0 2.797101e-07
I8756 n1_m1_355200_470400 0 1.763008e-07
I8757 n1_m1_355200_475200 0 1.651961e-07
I8758 n1_m1_355200_480000 0 2.611945e-07
I8759 n1_m1_355200_484800 0 1.773327e-07
I8760 n1_m1_355200_489600 0 2.545396e-07
I8761 n1_m1_355200_494400 0 1.654222e-07
I8762 n1_m1_355200_499200 0 1.614474e-07
I8763 n1_m1_355200_504000 0 2.421613e-07
I8764 n1_m1_355200_508800 0 1.606333e-07
I8765 n1_m1_355200_513600 0 2.395971e-07
I8766 n1_m1_355200_518400 0 1.585748e-07
I8767 n1_m1_355200_523200 0 1.587203e-07
I8768 n1_m1_355200_528000 0 2.503680e-07
I8769 n1_m1_355200_532800 0 1.637352e-07
I8770 n1_m1_355200_537600 0 2.342899e-07
I8771 n1_m1_355200_542400 0 1.532499e-07
I8772 n1_m1_355200_547200 0 1.523274e-07
I8773 n1_m1_355200_552000 0 2.281434e-07
I8774 n1_m1_355200_556800 0 1.489304e-07
I8775 n1_m1_360000_0 0 2.325574e-07
I8776 n1_m1_360000_4800 0 2.358544e-07
I8777 n1_m1_360000_9600 0 3.575750e-07
I8778 n1_m1_360000_14400 0 2.402049e-07
I8779 n1_m1_360000_19200 0 2.415587e-07
I8780 n1_m1_360000_24000 0 3.648037e-07
I8781 n1_m1_360000_28800 0 2.423235e-07
I8782 n1_m1_360000_33600 0 3.601100e-07
I8783 n1_m1_360000_38400 0 2.423507e-07
I8784 n1_m1_360000_43200 0 2.421066e-07
I8785 n1_m1_360000_48000 0 3.620641e-07
I8786 n1_m1_360000_52800 0 2.403153e-07
I8787 n1_m1_360000_57600 0 3.636762e-07
I8788 n1_m1_360000_62400 0 2.511943e-07
I8789 n1_m1_360000_67200 0 2.577571e-07
I8790 n1_m1_360000_72000 0 3.766700e-07
I8791 n1_m1_360000_76800 0 2.535947e-07
I8792 n1_m1_360000_81600 0 4.154373e-07
I8793 n1_m1_360000_86400 0 2.934211e-07
I8794 n1_m1_360000_91200 0 2.953782e-07
I8795 n1_m1_360000_96000 0 4.314712e-07
I8796 n1_m1_360000_100800 0 2.739881e-07
I8797 n1_m1_360000_105600 0 4.413117e-07
I8798 n1_m1_360000_110400 0 2.487446e-07
I8799 n1_m1_360000_115200 0 2.704198e-07
I8800 n1_m1_360000_120000 0 7.065905e-07
I8801 n1_m1_360000_124800 0 8.521532e-07
I8802 n1_m1_360000_129600 0 1.079240e-06
I8803 n1_m1_360000_134400 0 4.347968e-07
I8804 n1_m1_360000_139200 0 3.363644e-07
I8805 n1_m1_360000_144000 0 3.864198e-07
I8806 n1_m1_360000_148800 0 2.531266e-07
I8807 n1_m1_360000_153600 0 3.787288e-07
I8808 n1_m1_360000_158400 0 2.578829e-07
I8809 n1_m1_360000_163200 0 2.604124e-07
I8810 n1_m1_360000_168000 0 4.014228e-07
I8811 n1_m1_360000_172800 0 2.719841e-07
I8812 n1_m1_360000_177600 0 4.323981e-07
I8813 n1_m1_360000_182400 0 3.397104e-07
I8814 n1_m1_360000_187200 0 3.944204e-07
I8815 n1_m1_360000_192000 0 6.193113e-07
I8816 n1_m1_360000_196800 0 3.517008e-07
I8817 n1_m1_360000_201600 0 4.434613e-07
I8818 n1_m1_360000_206400 0 2.727013e-07
I8819 n1_m1_360000_211200 0 2.772444e-07
I8820 n1_m1_360000_216000 0 4.100957e-07
I8821 n1_m1_360000_220800 0 2.855387e-07
I8822 n1_m1_360000_225600 0 4.246922e-07
I8823 n1_m1_360000_230400 0 2.743185e-07
I8824 n1_m1_360000_235200 0 3.578326e-07
I8825 n1_m1_360000_240000 0 6.387626e-07
I8826 n1_m1_360000_244800 0 4.037888e-07
I8827 n1_m1_360000_249600 0 5.005592e-07
I8828 n1_m1_360000_254400 0 2.723780e-07
I8829 n1_m1_360000_259200 0 2.578067e-07
I8830 n1_m1_360000_264000 0 3.758594e-07
I8831 n1_m1_360000_268800 0 2.485478e-07
I8832 n1_m1_360000_273600 0 3.702540e-07
I8833 n1_m1_360000_278400 0 2.484247e-07
I8834 n1_m1_360000_283200 0 2.474302e-07
I8835 n1_m1_360000_288000 0 3.735392e-07
I8836 n1_m1_360000_292800 0 2.497857e-07
I8837 n1_m1_360000_297600 0 3.749019e-07
I8838 n1_m1_360000_302400 0 2.499713e-07
I8839 n1_m1_360000_307200 0 2.500569e-07
I8840 n1_m1_360000_312000 0 3.824661e-07
I8841 n1_m1_360000_316800 0 2.680847e-07
I8842 n1_m1_360000_321600 0 3.788461e-07
I8843 n1_m1_360000_326400 0 2.537014e-07
I8844 n1_m1_360000_331200 0 2.555974e-07
I8845 n1_m1_360000_336000 0 3.757737e-07
I8846 n1_m1_360000_340800 0 2.496858e-07
I8847 n1_m1_360000_345600 0 3.838219e-07
I8848 n1_m1_360000_350400 0 2.500675e-07
I8849 n1_m1_360000_355200 0 2.508686e-07
I8850 n1_m1_360000_360000 0 3.767768e-07
I8851 n1_m1_360000_364800 0 2.485556e-07
I8852 n1_m1_360000_369600 0 3.685821e-07
I8853 n1_m1_360000_374400 0 2.505450e-07
I8854 n1_m1_360000_379200 0 2.508686e-07
I8855 n1_m1_360000_384000 0 3.834511e-07
I8856 n1_m1_360000_388800 0 2.549237e-07
I8857 n1_m1_360000_393600 0 3.894375e-07
I8858 n1_m1_360000_398400 0 2.735333e-07
I8859 n1_m1_360000_403200 0 2.566041e-07
I8860 n1_m1_360000_408000 0 3.793825e-07
I8861 n1_m1_360000_412800 0 2.603876e-07
I8862 n1_m1_360000_417600 0 3.877356e-07
I8863 n1_m1_360000_422400 0 2.572969e-07
I8864 n1_m1_360000_427200 0 2.658808e-07
I8865 n1_m1_360000_432000 0 4.266398e-07
I8866 n1_m1_360000_436800 0 2.785524e-07
I8867 n1_m1_360000_441600 0 4.524517e-07
I8868 n1_m1_360000_446400 0 5.182589e-07
I8869 n1_m1_360000_451200 0 8.882009e-07
I8870 n1_m1_360000_456000 0 1.468136e-06
I8871 n1_m1_360000_460800 0 3.628142e-07
I8872 n1_m1_360000_465600 0 3.963004e-07
I8873 n1_m1_360000_470400 0 2.527367e-07
I8874 n1_m1_360000_475200 0 2.469638e-07
I8875 n1_m1_360000_480000 0 3.826999e-07
I8876 n1_m1_360000_484800 0 2.455016e-07
I8877 n1_m1_360000_489600 0 3.767326e-07
I8878 n1_m1_360000_494400 0 2.572690e-07
I8879 n1_m1_360000_499200 0 2.504444e-07
I8880 n1_m1_360000_504000 0 3.520869e-07
I8881 n1_m1_360000_508800 0 2.351505e-07
I8882 n1_m1_360000_513600 0 3.791483e-07
I8883 n1_m1_360000_518400 0 2.427823e-07
I8884 n1_m1_360000_523200 0 2.306431e-07
I8885 n1_m1_360000_528000 0 3.491257e-07
I8886 n1_m1_360000_532800 0 2.358150e-07
I8887 n1_m1_360000_537600 0 3.567956e-07
I8888 n1_m1_360000_542400 0 2.314850e-07
I8889 n1_m1_360000_547200 0 2.298422e-07
I8890 n1_m1_360000_552000 0 3.345218e-07
I8891 n1_m1_360000_556800 0 2.201863e-07
I8892 n1_m1_364800_0 0 1.522914e-07
I8893 n1_m1_364800_4800 0 1.534511e-07
I8894 n1_m1_364800_9600 0 2.380183e-07
I8895 n1_m1_364800_14400 0 1.635612e-07
I8896 n1_m1_364800_19200 0 1.639375e-07
I8897 n1_m1_364800_24000 0 2.451124e-07
I8898 n1_m1_364800_28800 0 1.593464e-07
I8899 n1_m1_364800_33600 0 2.386933e-07
I8900 n1_m1_364800_38400 0 1.640201e-07
I8901 n1_m1_364800_43200 0 1.663144e-07
I8902 n1_m1_364800_48000 0 2.494716e-07
I8903 n1_m1_364800_52800 0 1.663144e-07
I8904 n1_m1_364800_57600 0 2.495243e-07
I8905 n1_m1_364800_62400 0 1.675007e-07
I8906 n1_m1_364800_67200 0 1.712236e-07
I8907 n1_m1_364800_72000 0 2.562507e-07
I8908 n1_m1_364800_76800 0 1.698433e-07
I8909 n1_m1_364800_81600 0 2.499968e-07
I8910 n1_m1_364800_86400 0 1.661472e-07
I8911 n1_m1_364800_91200 0 1.691390e-07
I8912 n1_m1_364800_96000 0 2.595300e-07
I8913 n1_m1_364800_100800 0 1.745384e-07
I8914 n1_m1_364800_105600 0 2.703906e-07
I8915 n1_m1_364800_110400 0 1.732022e-07
I8916 n1_m1_364800_115200 0 2.387980e-07
I8917 n1_m1_364800_120000 0 3.998133e-07
I8918 n1_m1_364800_124800 0 2.254976e-07
I8919 n1_m1_364800_129600 0 3.292166e-07
I8920 n1_m1_364800_134400 0 2.202040e-07
I8921 n1_m1_364800_139200 0 1.992918e-07
I8922 n1_m1_364800_144000 0 2.581725e-07
I8923 n1_m1_364800_148800 0 1.676903e-07
I8924 n1_m1_364800_153600 0 2.498744e-07
I8925 n1_m1_364800_158400 0 1.669643e-07
I8926 n1_m1_364800_163200 0 1.684952e-07
I8927 n1_m1_364800_168000 0 2.592952e-07
I8928 n1_m1_364800_172800 0 1.745632e-07
I8929 n1_m1_364800_177600 0 2.708182e-07
I8930 n1_m1_364800_182400 0 2.214025e-07
I8931 n1_m1_364800_187200 0 2.850703e-07
I8932 n1_m1_364800_192000 0 5.107301e-07
I8933 n1_m1_364800_196800 0 3.211014e-07
I8934 n1_m1_364800_201600 0 3.871149e-07
I8935 n1_m1_364800_206400 0 2.200044e-07
I8936 n1_m1_364800_211200 0 2.517874e-07
I8937 n1_m1_364800_216000 0 4.408019e-07
I8938 n1_m1_364800_220800 0 3.067534e-07
I8939 n1_m1_364800_225600 0 3.641688e-07
I8940 n1_m1_364800_230400 0 1.963170e-07
I8941 n1_m1_364800_235200 0 2.252359e-07
I8942 n1_m1_364800_240000 0 4.779913e-07
I8943 n1_m1_364800_244800 0 4.337723e-07
I8944 n1_m1_364800_249600 0 5.193116e-07
I8945 n1_m1_364800_254400 0 1.948119e-07
I8946 n1_m1_364800_259200 0 1.644579e-07
I8947 n1_m1_364800_264000 0 2.408714e-07
I8948 n1_m1_364800_268800 0 1.641961e-07
I8949 n1_m1_364800_273600 0 2.620491e-07
I8950 n1_m1_364800_278400 0 1.723341e-07
I8951 n1_m1_364800_283200 0 1.646435e-07
I8952 n1_m1_364800_288000 0 2.402290e-07
I8953 n1_m1_364800_292800 0 1.637257e-07
I8954 n1_m1_364800_297600 0 2.566840e-07
I8955 n1_m1_364800_302400 0 1.739677e-07
I8956 n1_m1_364800_307200 0 1.727746e-07
I8957 n1_m1_364800_312000 0 2.846383e-07
I8958 n1_m1_364800_316800 0 2.643648e-07
I8959 n1_m1_364800_321600 0 2.661826e-07
I8960 n1_m1_364800_326400 0 1.639480e-07
I8961 n1_m1_364800_331200 0 1.691764e-07
I8962 n1_m1_364800_336000 0 2.513153e-07
I8963 n1_m1_364800_340800 0 1.626979e-07
I8964 n1_m1_364800_345600 0 2.475858e-07
I8965 n1_m1_364800_350400 0 1.622254e-07
I8966 n1_m1_364800_355200 0 1.707464e-07
I8967 n1_m1_364800_360000 0 2.592353e-07
I8968 n1_m1_364800_364800 0 1.665340e-07
I8969 n1_m1_364800_369600 0 2.484689e-07
I8970 n1_m1_364800_374400 0 1.693973e-07
I8971 n1_m1_364800_379200 0 1.706822e-07
I8972 n1_m1_364800_384000 0 2.596432e-07
I8973 n1_m1_364800_388800 0 1.712260e-07
I8974 n1_m1_364800_393600 0 2.515420e-07
I8975 n1_m1_364800_398400 0 1.765638e-07
I8976 n1_m1_364800_403200 0 1.742430e-07
I8977 n1_m1_364800_408000 0 2.660701e-07
I8978 n1_m1_364800_412800 0 1.823157e-07
I8979 n1_m1_364800_417600 0 2.576833e-07
I8980 n1_m1_364800_422400 0 1.752083e-07
I8981 n1_m1_364800_427200 0 1.847331e-07
I8982 n1_m1_364800_432000 0 2.690745e-07
I8983 n1_m1_364800_436800 0 2.085290e-07
I8984 n1_m1_364800_441600 0 3.189617e-07
I8985 n1_m1_364800_446400 0 1.793157e-07
I8986 n1_m1_364800_451200 0 1.969050e-07
I8987 n1_m1_364800_456000 0 5.829414e-07
I8988 n1_m1_364800_460800 0 1.965678e-07
I8989 n1_m1_364800_465600 0 2.579944e-07
I8990 n1_m1_364800_470400 0 1.705530e-07
I8991 n1_m1_364800_475200 0 1.683844e-07
I8992 n1_m1_364800_480000 0 2.475352e-07
I8993 n1_m1_364800_484800 0 1.571071e-07
I8994 n1_m1_364800_489600 0 2.407426e-07
I8995 n1_m1_364800_494400 0 1.696601e-07
I8996 n1_m1_364800_499200 0 1.686482e-07
I8997 n1_m1_364800_504000 0 2.355190e-07
I8998 n1_m1_364800_508800 0 1.563271e-07
I8999 n1_m1_364800_513600 0 2.572894e-07
I9000 n1_m1_364800_518400 0 1.663824e-07
I9001 n1_m1_364800_523200 0 1.541643e-07
I9002 n1_m1_364800_528000 0 2.298698e-07
I9003 n1_m1_364800_532800 0 1.533607e-07
I9004 n1_m1_364800_537600 0 2.359163e-07
I9005 n1_m1_364800_542400 0 1.545130e-07
I9006 n1_m1_364800_547200 0 1.532282e-07
I9007 n1_m1_364800_552000 0 2.220381e-07
I9008 n1_m1_364800_556800 0 1.465661e-07
I9009 n1_m1_369600_0 0 1.508053e-07
I9010 n1_m1_369600_4800 0 1.526673e-07
I9011 n1_m1_369600_9600 0 2.298422e-07
I9012 n1_m1_369600_14400 0 1.532282e-07
I9013 n1_m1_369600_19200 0 1.536993e-07
I9014 n1_m1_369600_24000 0 2.341719e-07
I9015 n1_m1_369600_28800 0 1.552472e-07
I9016 n1_m1_369600_33600 0 2.348388e-07
I9017 n1_m1_369600_38400 0 1.619093e-07
I9018 n1_m1_369600_43200 0 1.649929e-07
I9019 n1_m1_369600_48000 0 2.498285e-07
I9020 n1_m1_369600_52800 0 1.666781e-07
I9021 n1_m1_369600_57600 0 2.550352e-07
I9022 n1_m1_369600_62400 0 1.740479e-07
I9023 n1_m1_369600_67200 0 1.754075e-07
I9024 n1_m1_369600_72000 0 2.545416e-07
I9025 n1_m1_369600_76800 0 1.735951e-07
I9026 n1_m1_369600_81600 0 2.554125e-07
I9027 n1_m1_369600_86400 0 1.624599e-07
I9028 n1_m1_369600_91200 0 1.615503e-07
I9029 n1_m1_369600_96000 0 2.512561e-07
I9030 n1_m1_369600_100800 0 1.751261e-07
I9031 n1_m1_369600_105600 0 2.987942e-07
I9032 n1_m1_369600_110400 0 3.946285e-07
I9033 n1_m1_369600_115200 0 8.380323e-07
I9034 n1_m1_369600_120000 0 1.344542e-06
I9035 n1_m1_369600_124800 0 6.338697e-07
I9036 n1_m1_369600_129600 0 7.331444e-07
I9037 n1_m1_369600_134400 0 4.217337e-07
I9038 n1_m1_369600_139200 0 2.915142e-07
I9039 n1_m1_369600_144000 0 2.516681e-07
I9040 n1_m1_369600_148800 0 1.665524e-07
I9041 n1_m1_369600_153600 0 2.498285e-07
I9042 n1_m1_369600_158400 0 1.675517e-07
I9043 n1_m1_369600_163200 0 1.724055e-07
I9044 n1_m1_369600_168000 0 2.610793e-07
I9045 n1_m1_369600_172800 0 1.749276e-07
I9046 n1_m1_369600_177600 0 2.572724e-07
I9047 n1_m1_369600_182400 0 1.786760e-07
I9048 n1_m1_369600_187200 0 1.948622e-07
I9049 n1_m1_369600_192000 0 3.227669e-07
I9050 n1_m1_369600_196800 0 2.085276e-07
I9051 n1_m1_369600_201600 0 2.759317e-07
I9052 n1_m1_369600_206400 0 1.774082e-07
I9053 n1_m1_369600_211200 0 2.148920e-07
I9054 n1_m1_369600_216000 0 5.861453e-07
I9055 n1_m1_369600_220800 0 5.431755e-07
I9056 n1_m1_369600_225600 0 9.489609e-07
I9057 n1_m1_369600_230400 0 5.960875e-07
I9058 n1_m1_369600_235200 0 4.311109e-07
I9059 n1_m1_369600_240000 0 4.198486e-07
I9060 n1_m1_369600_244800 0 3.123394e-07
I9061 n1_m1_369600_249600 0 4.044177e-07
I9062 n1_m1_369600_254400 0 1.871824e-07
I9063 n1_m1_369600_259200 0 1.712403e-07
I9064 n1_m1_369600_264000 0 2.519475e-07
I9065 n1_m1_369600_268800 0 1.714422e-07
I9066 n1_m1_369600_273600 0 2.678978e-07
I9067 n1_m1_369600_278400 0 1.779255e-07
I9068 n1_m1_369600_283200 0 1.676944e-07
I9069 n1_m1_369600_288000 0 2.398354e-07
I9070 n1_m1_369600_292800 0 1.598903e-07
I9071 n1_m1_369600_297600 0 2.551534e-07
I9072 n1_m1_369600_302400 0 1.756373e-07
I9073 n1_m1_369600_307200 0 1.730758e-07
I9074 n1_m1_369600_312000 0 2.888147e-07
I9075 n1_m1_369600_316800 0 2.904014e-07
I9076 n1_m1_369600_321600 0 2.904802e-07
I9077 n1_m1_369600_326400 0 1.667536e-07
I9078 n1_m1_369600_331200 0 1.656006e-07
I9079 n1_m1_369600_336000 0 2.573315e-07
I9080 n1_m1_369600_340800 0 1.732144e-07
I9081 n1_m1_369600_345600 0 2.483391e-07
I9082 n1_m1_369600_350400 0 1.615537e-07
I9083 n1_m1_369600_355200 0 1.711682e-07
I9084 n1_m1_369600_360000 0 2.642486e-07
I9085 n1_m1_369600_364800 0 1.630269e-07
I9086 n1_m1_369600_369600 0 2.436035e-07
I9087 n1_m1_369600_374400 0 1.695027e-07
I9088 n1_m1_369600_379200 0 1.708351e-07
I9089 n1_m1_369600_384000 0 2.571806e-07
I9090 n1_m1_369600_388800 0 1.700534e-07
I9091 n1_m1_369600_393600 0 2.502099e-07
I9092 n1_m1_369600_398400 0 1.694986e-07
I9093 n1_m1_369600_403200 0 1.755129e-07
I9094 n1_m1_369600_408000 0 3.699209e-07
I9095 n1_m1_369600_412800 0 2.601262e-07
I9096 n1_m1_369600_417600 0 2.682111e-07
I9097 n1_m1_369600_422400 0 1.790241e-07
I9098 n1_m1_369600_427200 0 1.854863e-07
I9099 n1_m1_369600_432000 0 2.620100e-07
I9100 n1_m1_369600_436800 0 1.805944e-07
I9101 n1_m1_369600_441600 0 2.640922e-07
I9102 n1_m1_369600_446400 0 1.749384e-07
I9103 n1_m1_369600_451200 0 1.997717e-07
I9104 n1_m1_369600_456000 0 5.337432e-07
I9105 n1_m1_369600_460800 0 3.082231e-07
I9106 n1_m1_369600_465600 0 5.415140e-07
I9107 n1_m1_369600_470400 0 2.612452e-07
I9108 n1_m1_369600_475200 0 1.759459e-07
I9109 n1_m1_369600_480000 0 2.509033e-07
I9110 n1_m1_369600_484800 0 1.736590e-07
I9111 n1_m1_369600_489600 0 2.653125e-07
I9112 n1_m1_369600_494400 0 1.707515e-07
I9113 n1_m1_369600_499200 0 1.697073e-07
I9114 n1_m1_369600_504000 0 2.421705e-07
I9115 n1_m1_369600_508800 0 1.589379e-07
I9116 n1_m1_369600_513600 0 2.529679e-07
I9117 n1_m1_369600_518400 0 1.674497e-07
I9118 n1_m1_369600_523200 0 1.606476e-07
I9119 n1_m1_369600_528000 0 2.300605e-07
I9120 n1_m1_369600_532800 0 1.551901e-07
I9121 n1_m1_369600_537600 0 2.376519e-07
I9122 n1_m1_369600_542400 0 1.545130e-07
I9123 n1_m1_369600_547200 0 1.532282e-07
I9124 n1_m1_369600_552000 0 2.220381e-07
I9125 n1_m1_369600_556800 0 1.465661e-07
I9126 n1_m1_374400_0 0 1.568529e-07
I9127 n1_m1_374400_4800 0 1.586020e-07
I9128 n1_m1_374400_9600 0 2.386933e-07
I9129 n1_m1_374400_14400 0 1.591289e-07
I9130 n1_m1_374400_19200 0 1.586863e-07
I9131 n1_m1_374400_24000 0 2.346260e-07
I9132 n1_m1_374400_28800 0 1.561785e-07
I9133 n1_m1_374400_33600 0 2.392644e-07
I9134 n1_m1_374400_38400 0 1.628406e-07
I9135 n1_m1_374400_43200 0 1.665524e-07
I9136 n1_m1_374400_48000 0 2.544859e-07
I9137 n1_m1_374400_52800 0 1.724381e-07
I9138 n1_m1_374400_57600 0 2.894564e-07
I9139 n1_m1_374400_62400 0 2.433228e-07
I9140 n1_m1_374400_67200 0 2.705572e-07
I9141 n1_m1_374400_72000 0 3.655661e-07
I9142 n1_m1_374400_76800 0 2.065983e-07
I9143 n1_m1_374400_81600 0 2.648182e-07
I9144 n1_m1_374400_86400 0 1.654103e-07
I9145 n1_m1_374400_91200 0 1.628406e-07
I9146 n1_m1_374400_96000 0 2.481888e-07
I9147 n1_m1_374400_100800 0 1.719935e-07
I9148 n1_m1_374400_105600 0 3.210667e-07
I9149 n1_m1_374400_110400 0 5.388213e-07
I9150 n1_m1_374400_115200 0 1.100162e-06
I9151 n1_m1_374400_120000 0 1.650963e-06
I9152 n1_m1_374400_124800 0 7.926655e-07
I9153 n1_m1_374400_129600 0 8.304470e-07
I9154 n1_m1_374400_134400 0 3.881146e-07
I9155 n1_m1_374400_139200 0 2.607734e-07
I9156 n1_m1_374400_144000 0 2.498285e-07
I9157 n1_m1_374400_148800 0 1.665524e-07
I9158 n1_m1_374400_153600 0 2.498285e-07
I9159 n1_m1_374400_158400 0 1.671091e-07
I9160 n1_m1_374400_163200 0 1.701295e-07
I9161 n1_m1_374400_168000 0 2.606626e-07
I9162 n1_m1_374400_172800 0 1.767195e-07
I9163 n1_m1_374400_177600 0 2.642635e-07
I9164 n1_m1_374400_182400 0 1.765890e-07
I9165 n1_m1_374400_187200 0 1.769262e-07
I9166 n1_m1_374400_192000 0 2.651513e-07
I9167 n1_m1_374400_196800 0 1.718820e-07
I9168 n1_m1_374400_201600 0 2.510481e-07
I9169 n1_m1_374400_206400 0 1.684640e-07
I9170 n1_m1_374400_211200 0 1.851335e-07
I9171 n1_m1_374400_216000 0 3.867774e-07
I9172 n1_m1_374400_220800 0 3.868325e-07
I9173 n1_m1_374400_225600 0 1.119968e-06
I9174 n1_m1_374400_230400 0 9.478202e-07
I9175 n1_m1_374400_235200 0 6.876042e-07
I9176 n1_m1_374400_240000 0 4.329212e-07
I9177 n1_m1_374400_244800 0 1.935094e-07
I9178 n1_m1_374400_249600 0 2.747679e-07
I9179 n1_m1_374400_254400 0 1.736516e-07
I9180 n1_m1_374400_259200 0 1.709385e-07
I9181 n1_m1_374400_264000 0 2.592527e-07
I9182 n1_m1_374400_268800 0 1.725612e-07
I9183 n1_m1_374400_273600 0 2.538156e-07
I9184 n1_m1_374400_278400 0 1.687889e-07
I9185 n1_m1_374400_283200 0 1.671886e-07
I9186 n1_m1_374400_288000 0 2.418163e-07
I9187 n1_m1_374400_292800 0 1.598903e-07
I9188 n1_m1_374400_297600 0 2.513948e-07
I9189 n1_m1_374400_302400 0 1.699480e-07
I9190 n1_m1_374400_307200 0 1.673212e-07
I9191 n1_m1_374400_312000 0 2.534628e-07
I9192 n1_m1_374400_316800 0 2.066507e-07
I9193 n1_m1_374400_321600 0 3.339483e-07
I9194 n1_m1_374400_326400 0 1.993448e-07
I9195 n1_m1_374400_331200 0 1.649467e-07
I9196 n1_m1_374400_336000 0 2.506851e-07
I9197 n1_m1_374400_340800 0 1.702641e-07
I9198 n1_m1_374400_345600 0 2.441331e-07
I9199 n1_m1_374400_350400 0 1.614015e-07
I9200 n1_m1_374400_355200 0 1.737393e-07
I9201 n1_m1_374400_360000 0 2.709671e-07
I9202 n1_m1_374400_364800 0 1.630908e-07
I9203 n1_m1_374400_369600 0 2.451481e-07
I9204 n1_m1_374400_374400 0 1.724531e-07
I9205 n1_m1_374400_379200 0 1.737855e-07
I9206 n1_m1_374400_384000 0 2.548251e-07
I9207 n1_m1_374400_388800 0 1.697746e-07
I9208 n1_m1_374400_393600 0 2.511351e-07
I9209 n1_m1_374400_398400 0 1.673076e-07
I9210 n1_m1_374400_403200 0 1.829955e-07
I9211 n1_m1_374400_408000 0 5.766647e-07
I9212 n1_m1_374400_412800 0 3.998562e-07
I9213 n1_m1_374400_417600 0 2.923225e-07
I9214 n1_m1_374400_422400 0 1.856277e-07
I9215 n1_m1_374400_427200 0 2.484458e-07
I9216 n1_m1_374400_432000 0 5.732739e-07
I9217 n1_m1_374400_436800 0 3.391115e-07
I9218 n1_m1_374400_441600 0 3.137234e-07
I9219 n1_m1_374400_446400 0 1.747596e-07
I9220 n1_m1_374400_451200 0 1.945467e-07
I9221 n1_m1_374400_456000 0 4.072878e-07
I9222 n1_m1_374400_460800 0 5.864315e-07
I9223 n1_m1_374400_465600 0 1.176927e-06
I9224 n1_m1_374400_470400 0 5.234978e-07
I9225 n1_m1_374400_475200 0 2.881641e-07
I9226 n1_m1_374400_480000 0 3.465200e-07
I9227 n1_m1_374400_484800 0 2.365288e-07
I9228 n1_m1_374400_489600 0 4.890997e-07
I9229 n1_m1_374400_494400 0 2.406953e-07
I9230 n1_m1_374400_499200 0 1.748501e-07
I9231 n1_m1_374400_504000 0 2.415179e-07
I9232 n1_m1_374400_508800 0 1.631656e-07
I9233 n1_m1_374400_513600 0 2.480712e-07
I9234 n1_m1_374400_518400 0 1.646557e-07
I9235 n1_m1_374400_523200 0 1.645374e-07
I9236 n1_m1_374400_528000 0 2.388524e-07
I9237 n1_m1_374400_532800 0 1.595531e-07
I9238 n1_m1_374400_537600 0 2.366777e-07
I9239 n1_m1_374400_542400 0 1.539440e-07
I9240 n1_m1_374400_547200 0 1.532282e-07
I9241 n1_m1_374400_552000 0 2.220381e-07
I9242 n1_m1_374400_556800 0 1.465661e-07
I9243 n1_m1_379200_0 0 1.566544e-07
I9244 n1_m1_379200_4800 0 1.607230e-07
I9245 n1_m1_379200_9600 0 2.468884e-07
I9246 n1_m1_379200_14400 0 1.687617e-07
I9247 n1_m1_379200_19200 0 1.679324e-07
I9248 n1_m1_379200_24000 0 2.431596e-07
I9249 n1_m1_379200_28800 0 1.598903e-07
I9250 n1_m1_379200_33600 0 2.466164e-07
I9251 n1_m1_379200_38400 0 1.689317e-07
I9252 n1_m1_379200_43200 0 1.726434e-07
I9253 n1_m1_379200_48000 0 2.679080e-07
I9254 n1_m1_379200_52800 0 2.028608e-07
I9255 n1_m1_379200_57600 0 4.136787e-07
I9256 n1_m1_379200_62400 0 3.969282e-07
I9257 n1_m1_379200_67200 0 4.497559e-07
I9258 n1_m1_379200_72000 0 4.927332e-07
I9259 n1_m1_379200_76800 0 2.274697e-07
I9260 n1_m1_379200_81600 0 2.632479e-07
I9261 n1_m1_379200_86400 0 1.687481e-07
I9262 n1_m1_379200_91200 0 1.714470e-07
I9263 n1_m1_379200_96000 0 2.585674e-07
I9264 n1_m1_379200_100800 0 1.747576e-07
I9265 n1_m1_379200_105600 0 3.229926e-07
I9266 n1_m1_379200_110400 0 5.324305e-07
I9267 n1_m1_379200_115200 0 9.697596e-07
I9268 n1_m1_379200_120000 0 1.252283e-06
I9269 n1_m1_379200_124800 0 5.193102e-07
I9270 n1_m1_379200_129600 0 5.264652e-07
I9271 n1_m1_379200_134400 0 2.182991e-07
I9272 n1_m1_379200_139200 0 1.829697e-07
I9273 n1_m1_379200_144000 0 2.512221e-07
I9274 n1_m1_379200_148800 0 1.665524e-07
I9275 n1_m1_379200_153600 0 2.498285e-07
I9276 n1_m1_379200_158400 0 1.665524e-07
I9277 n1_m1_379200_163200 0 1.670112e-07
I9278 n1_m1_379200_168000 0 2.555491e-07
I9279 n1_m1_379200_172800 0 1.726434e-07
I9280 n1_m1_379200_177600 0 2.661031e-07
I9281 n1_m1_379200_182400 0 1.737855e-07
I9282 n1_m1_379200_187200 0 1.697134e-07
I9283 n1_m1_379200_192000 0 2.525308e-07
I9284 n1_m1_379200_196800 0 1.652131e-07
I9285 n1_m1_379200_201600 0 2.494716e-07
I9286 n1_m1_379200_206400 0 1.686462e-07
I9287 n1_m1_379200_211200 0 1.713042e-07
I9288 n1_m1_379200_216000 0 2.893286e-07
I9289 n1_m1_379200_220800 0 2.282243e-07
I9290 n1_m1_379200_225600 0 7.617153e-07
I9291 n1_m1_379200_230400 0 7.217835e-07
I9292 n1_m1_379200_235200 0 5.466316e-07
I9293 n1_m1_379200_240000 0 4.173768e-07
I9294 n1_m1_379200_244800 0 2.191081e-07
I9295 n1_m1_379200_249600 0 2.878297e-07
I9296 n1_m1_379200_254400 0 1.758045e-07
I9297 n1_m1_379200_259200 0 1.702675e-07
I9298 n1_m1_379200_264000 0 2.589957e-07
I9299 n1_m1_379200_268800 0 1.722661e-07
I9300 n1_m1_379200_273600 0 2.511032e-07
I9301 n1_m1_379200_278400 0 1.656006e-07
I9302 n1_m1_379200_283200 0 1.665524e-07
I9303 n1_m1_379200_288000 0 2.462629e-07
I9304 n1_m1_379200_292800 0 1.606041e-07
I9305 n1_m1_379200_297600 0 2.446076e-07
I9306 n1_m1_379200_302400 0 1.637142e-07
I9307 n1_m1_379200_307200 0 1.605939e-07
I9308 n1_m1_379200_312000 0 2.398354e-07
I9309 n1_m1_379200_316800 0 1.939961e-07
I9310 n1_m1_379200_321600 0 5.313700e-07
I9311 n1_m1_379200_326400 0 3.346819e-07
I9312 n1_m1_379200_331200 0 2.069940e-07
I9313 n1_m1_379200_336000 0 2.486865e-07
I9314 n1_m1_379200_340800 0 1.689317e-07
I9315 n1_m1_379200_345600 0 2.442269e-07
I9316 n1_m1_379200_350400 0 1.667427e-07
I9317 n1_m1_379200_355200 0 1.901450e-07
I9318 n1_m1_379200_360000 0 3.118030e-07
I9319 n1_m1_379200_364800 0 1.712838e-07
I9320 n1_m1_379200_369600 0 2.511575e-07
I9321 n1_m1_379200_374400 0 1.795978e-07
I9322 n1_m1_379200_379200 0 1.814061e-07
I9323 n1_m1_379200_384000 0 2.566096e-07
I9324 n1_m1_379200_388800 0 1.723647e-07
I9325 n1_m1_379200_393600 0 2.582853e-07
I9326 n1_m1_379200_398400 0 1.686869e-07
I9327 n1_m1_379200_403200 0 1.968513e-07
I9328 n1_m1_379200_408000 0 8.371975e-07
I9329 n1_m1_379200_412800 0 5.773180e-07
I9330 n1_m1_379200_417600 0 3.449775e-07
I9331 n1_m1_379200_422400 0 3.117520e-07
I9332 n1_m1_379200_427200 0 6.217977e-07
I9333 n1_m1_379200_432000 0 1.346341e-06
I9334 n1_m1_379200_436800 0 6.854275e-07
I9335 n1_m1_379200_441600 0 4.855953e-07
I9336 n1_m1_379200_446400 0 1.868174e-07
I9337 n1_m1_379200_451200 0 1.731397e-07
I9338 n1_m1_379200_456000 0 4.603371e-07
I9339 n1_m1_379200_460800 0 9.762313e-07
I9340 n1_m1_379200_465600 0 1.814846e-06
I9341 n1_m1_379200_470400 0 8.412321e-07
I9342 n1_m1_379200_475200 0 5.128861e-07
I9343 n1_m1_379200_480000 0 7.222322e-07
I9344 n1_m1_379200_484800 0 5.378485e-07
I9345 n1_m1_379200_489600 0 9.996234e-07
I9346 n1_m1_379200_494400 0 3.853546e-07
I9347 n1_m1_379200_499200 0 1.945569e-07
I9348 n1_m1_379200_504000 0 2.415791e-07
I9349 n1_m1_379200_508800 0 1.678644e-07
I9350 n1_m1_379200_513600 0 2.461134e-07
I9351 n1_m1_379200_518400 0 1.598903e-07
I9352 n1_m1_379200_523200 0 1.654647e-07
I9353 n1_m1_379200_528000 0 2.532955e-07
I9354 n1_m1_379200_532800 0 1.652199e-07
I9355 n1_m1_379200_537600 0 2.346213e-07
I9356 n1_m1_379200_542400 0 1.531432e-07
I9357 n1_m1_379200_547200 0 1.514267e-07
I9358 n1_m1_379200_552000 0 2.240435e-07
I9359 n1_m1_379200_556800 0 1.489454e-07
I9360 n1_m1_384000_0 0 2.271298e-07
I9361 n1_m1_384000_4800 0 2.338038e-07
I9362 n1_m1_384000_9600 0 3.738505e-07
I9363 n1_m1_384000_14400 0 2.585011e-07
I9364 n1_m1_384000_19200 0 2.537187e-07
I9365 n1_m1_384000_24000 0 3.662486e-07
I9366 n1_m1_384000_28800 0 2.416199e-07
I9367 n1_m1_384000_33600 0 3.784902e-07
I9368 n1_m1_384000_38400 0 2.566096e-07
I9369 n1_m1_384000_43200 0 3.132850e-07
I9370 n1_m1_384000_48000 0 9.422104e-07
I9371 n1_m1_384000_52800 0 8.537711e-07
I9372 n1_m1_384000_57600 0 1.039537e-06
I9373 n1_m1_384000_62400 0 5.971616e-07
I9374 n1_m1_384000_67200 0 6.435940e-07
I9375 n1_m1_384000_72000 0 6.050133e-07
I9376 n1_m1_384000_76800 0 2.883735e-07
I9377 n1_m1_384000_81600 0 3.787044e-07
I9378 n1_m1_384000_86400 0 2.590365e-07
I9379 n1_m1_384000_91200 0 2.806645e-07
I9380 n1_m1_384000_96000 0 4.227099e-07
I9381 n1_m1_384000_100800 0 2.672095e-07
I9382 n1_m1_384000_105600 0 4.611835e-07
I9383 n1_m1_384000_110400 0 5.528348e-07
I9384 n1_m1_384000_115200 0 8.339276e-07
I9385 n1_m1_384000_120000 0 8.957423e-07
I9386 n1_m1_384000_124800 0 3.357695e-07
I9387 n1_m1_384000_129600 0 4.421965e-07
I9388 n1_m1_384000_134400 0 2.727414e-07
I9389 n1_m1_384000_139200 0 2.698148e-07
I9390 n1_m1_384000_144000 0 3.924092e-07
I9391 n1_m1_384000_148800 0 2.558958e-07
I9392 n1_m1_384000_153600 0 3.762418e-07
I9393 n1_m1_384000_158400 0 2.498285e-07
I9394 n1_m1_384000_163200 0 2.498285e-07
I9395 n1_m1_384000_168000 0 3.747428e-07
I9396 n1_m1_384000_172800 0 2.511847e-07
I9397 n1_m1_384000_177600 0 3.789185e-07
I9398 n1_m1_384000_182400 0 2.470447e-07
I9399 n1_m1_384000_187200 0 2.424764e-07
I9400 n1_m1_384000_192000 0 3.641786e-07
I9401 n1_m1_384000_196800 0 2.448320e-07
I9402 n1_m1_384000_201600 0 3.681402e-07
I9403 n1_m1_384000_206400 0 2.493646e-07
I9404 n1_m1_384000_211200 0 2.540042e-07
I9405 n1_m1_384000_216000 0 4.308828e-07
I9406 n1_m1_384000_220800 0 2.811642e-07
I9407 n1_m1_384000_225600 0 4.359508e-07
I9408 n1_m1_384000_230400 0 2.933701e-07
I9409 n1_m1_384000_235200 0 2.676020e-07
I9410 n1_m1_384000_240000 0 4.709982e-07
I9411 n1_m1_384000_244800 0 3.825232e-07
I9412 n1_m1_384000_249600 0 5.137188e-07
I9413 n1_m1_384000_254400 0 2.794154e-07
I9414 n1_m1_384000_259200 0 2.612850e-07
I9415 n1_m1_384000_264000 0 3.766700e-07
I9416 n1_m1_384000_268800 0 2.498285e-07
I9417 n1_m1_384000_273600 0 3.805959e-07
I9418 n1_m1_384000_278400 0 2.573234e-07
I9419 n1_m1_384000_283200 0 2.506851e-07
I9420 n1_m1_384000_288000 0 3.630722e-07
I9421 n1_m1_384000_292800 0 2.363378e-07
I9422 n1_m1_384000_297600 0 3.641429e-07
I9423 n1_m1_384000_302400 0 2.492218e-07
I9424 n1_m1_384000_307200 0 2.495073e-07
I9425 n1_m1_384000_312000 0 3.669267e-07
I9426 n1_m1_384000_316800 0 2.927277e-07
I9427 n1_m1_384000_321600 0 8.842859e-07
I9428 n1_m1_384000_326400 0 6.616887e-07
I9429 n1_m1_384000_331200 0 4.274923e-07
I9430 n1_m1_384000_336000 0 3.853427e-07
I9431 n1_m1_384000_340800 0 2.498285e-07
I9432 n1_m1_384000_345600 0 3.774552e-07
I9433 n1_m1_384000_350400 0 2.749898e-07
I9434 n1_m1_384000_355200 0 3.400880e-07
I9435 n1_m1_384000_360000 0 5.206427e-07
I9436 n1_m1_384000_364800 0 2.654963e-07
I9437 n1_m1_384000_369600 0 3.838437e-07
I9438 n1_m1_384000_374400 0 2.692438e-07
I9439 n1_m1_384000_379200 0 2.712424e-07
I9440 n1_m1_384000_384000 0 3.972274e-07
I9441 n1_m1_384000_388800 0 2.616062e-07
I9442 n1_m1_384000_393600 0 3.903392e-07
I9443 n1_m1_384000_398400 0 2.825204e-07
I9444 n1_m1_384000_403200 0 4.777435e-07
I9445 n1_m1_384000_408000 0 1.556860e-06
I9446 n1_m1_384000_412800 0 9.574857e-07
I9447 n1_m1_384000_417600 0 5.499083e-07
I9448 n1_m1_384000_422400 0 5.094361e-07
I9449 n1_m1_384000_427200 0 1.230584e-06
I9450 n1_m1_384000_432000 0 2.981240e-06
I9451 n1_m1_384000_436800 0 1.670996e-06
I9452 n1_m1_384000_441600 0 1.424130e-06
I9453 n1_m1_384000_446400 0 5.010133e-07
I9454 n1_m1_384000_451200 0 3.025423e-07
I9455 n1_m1_384000_456000 0 8.706881e-07
I9456 n1_m1_384000_460800 0 1.831814e-06
I9457 n1_m1_384000_465600 0 3.079315e-06
I9458 n1_m1_384000_470400 0 1.390902e-06
I9459 n1_m1_384000_475200 0 7.155089e-07
I9460 n1_m1_384000_480000 0 1.174622e-06
I9461 n1_m1_384000_484800 0 9.459936e-07
I9462 n1_m1_384000_489600 0 1.368846e-06
I9463 n1_m1_384000_494400 0 5.170380e-07
I9464 n1_m1_384000_499200 0 2.929418e-07
I9465 n1_m1_384000_504000 0 3.697105e-07
I9466 n1_m1_384000_508800 0 2.486865e-07
I9467 n1_m1_384000_513600 0 3.634291e-07
I9468 n1_m1_384000_518400 0 2.366233e-07
I9469 n1_m1_384000_523200 0 2.411916e-07
I9470 n1_m1_384000_528000 0 3.703529e-07
I9471 n1_m1_384000_532800 0 2.470447e-07
I9472 n1_m1_384000_537600 0 3.620015e-07
I9473 n1_m1_384000_542400 0 2.354455e-07
I9474 n1_m1_384000_547200 0 2.272726e-07
I9475 n1_m1_384000_552000 0 3.363763e-07
I9476 n1_m1_384000_556800 0 2.209912e-07
I9477 n1_m1_388800_0 0 1.514471e-07
I9478 n1_m1_388800_4800 0 1.583879e-07
I9479 n1_m1_388800_9600 0 2.513955e-07
I9480 n1_m1_388800_14400 0 1.684728e-07
I9481 n1_m1_388800_19200 0 1.657400e-07
I9482 n1_m1_388800_24000 0 2.406444e-07
I9483 n1_m1_388800_28800 0 1.607400e-07
I9484 n1_m1_388800_33600 0 2.484009e-07
I9485 n1_m1_388800_38400 0 1.618957e-07
I9486 n1_m1_388800_43200 0 1.940437e-07
I9487 n1_m1_388800_48000 0 7.284694e-07
I9488 n1_m1_388800_52800 0 6.688369e-07
I9489 n1_m1_388800_57600 0 5.819951e-07
I9490 n1_m1_388800_62400 0 2.095908e-07
I9491 n1_m1_388800_67200 0 2.157975e-07
I9492 n1_m1_388800_72000 0 2.892029e-07
I9493 n1_m1_388800_76800 0 1.912905e-07
I9494 n1_m1_388800_81600 0 2.779419e-07
I9495 n1_m1_388800_86400 0 1.710663e-07
I9496 n1_m1_388800_91200 0 1.720588e-07
I9497 n1_m1_388800_96000 0 2.691622e-07
I9498 n1_m1_388800_100800 0 2.139484e-07
I9499 n1_m1_388800_105600 0 2.792233e-07
I9500 n1_m1_388800_110400 0 1.858078e-07
I9501 n1_m1_388800_115200 0 2.274629e-07
I9502 n1_m1_388800_120000 0 3.196887e-07
I9503 n1_m1_388800_124800 0 1.695027e-07
I9504 n1_m1_388800_129600 0 2.623098e-07
I9505 n1_m1_388800_134400 0 1.787617e-07
I9506 n1_m1_388800_139200 0 1.789248e-07
I9507 n1_m1_388800_144000 0 2.694817e-07
I9508 n1_m1_388800_148800 0 1.746420e-07
I9509 n1_m1_388800_153600 0 2.518272e-07
I9510 n1_m1_388800_158400 0 1.659099e-07
I9511 n1_m1_388800_163200 0 1.632485e-07
I9512 n1_m1_388800_168000 0 2.491249e-07
I9513 n1_m1_388800_172800 0 1.665524e-07
I9514 n1_m1_388800_177600 0 2.455458e-07
I9515 n1_m1_388800_182400 0 1.598903e-07
I9516 n1_m1_388800_187200 0 1.619093e-07
I9517 n1_m1_388800_192000 0 2.483669e-07
I9518 n1_m1_388800_196800 0 1.665524e-07
I9519 n1_m1_388800_201600 0 2.520583e-07
I9520 n1_m1_388800_206400 0 1.679392e-07
I9521 n1_m1_388800_211200 0 1.655632e-07
I9522 n1_m1_388800_216000 0 2.540399e-07
I9523 n1_m1_388800_220800 0 1.742545e-07
I9524 n1_m1_388800_225600 0 2.660929e-07
I9525 n1_m1_388800_230400 0 1.752335e-07
I9526 n1_m1_388800_235200 0 1.742681e-07
I9527 n1_m1_388800_240000 0 2.639413e-07
I9528 n1_m1_388800_244800 0 1.943156e-07
I9529 n1_m1_388800_249600 0 2.939139e-07
I9530 n1_m1_388800_254400 0 1.789146e-07
I9531 n1_m1_388800_259200 0 1.699140e-07
I9532 n1_m1_388800_264000 0 2.458925e-07
I9533 n1_m1_388800_268800 0 1.599208e-07
I9534 n1_m1_388800_273600 0 2.426226e-07
I9535 n1_m1_388800_278400 0 1.646489e-07
I9536 n1_m1_388800_283200 0 1.626775e-07
I9537 n1_m1_388800_288000 0 2.343154e-07
I9538 n1_m1_388800_292800 0 1.532282e-07
I9539 n1_m1_388800_297600 0 2.402739e-07
I9540 n1_m1_388800_302400 0 1.648188e-07
I9541 n1_m1_388800_307200 0 1.677998e-07
I9542 n1_m1_388800_312000 0 2.441386e-07
I9543 n1_m1_388800_316800 0 1.651655e-07
I9544 n1_m1_388800_321600 0 3.203210e-07
I9545 n1_m1_388800_326400 0 2.569529e-07
I9546 n1_m1_388800_331200 0 2.212359e-07
I9547 n1_m1_388800_336000 0 2.526225e-07
I9548 n1_m1_388800_340800 0 1.598903e-07
I9549 n1_m1_388800_345600 0 2.508788e-07
I9550 n1_m1_388800_350400 0 1.793531e-07
I9551 n1_m1_388800_355200 0 2.004407e-07
I9552 n1_m1_388800_360000 0 2.877379e-07
I9553 n1_m1_388800_364800 0 1.693735e-07
I9554 n1_m1_388800_369600 0 2.512731e-07
I9555 n1_m1_388800_374400 0 1.708283e-07
I9556 n1_m1_388800_379200 0 1.732144e-07
I9557 n1_m1_388800_384000 0 2.601786e-07
I9558 n1_m1_388800_388800 0 1.691016e-07
I9559 n1_m1_388800_393600 0 2.557428e-07
I9560 n1_m1_388800_398400 0 1.885814e-07
I9561 n1_m1_388800_403200 0 2.712764e-07
I9562 n1_m1_388800_408000 0 6.491531e-07
I9563 n1_m1_388800_412800 0 4.010649e-07
I9564 n1_m1_388800_417600 0 3.281217e-07
I9565 n1_m1_388800_422400 0 2.056684e-07
I9566 n1_m1_388800_427200 0 3.240701e-07
I9567 n1_m1_388800_432000 0 1.252589e-06
I9568 n1_m1_388800_436800 0 1.275995e-06
I9569 n1_m1_388800_441600 0 1.690860e-06
I9570 n1_m1_388800_446400 0 5.719034e-07
I9571 n1_m1_388800_451200 0 2.535607e-07
I9572 n1_m1_388800_456000 0 5.530082e-07
I9573 n1_m1_388800_460800 0 9.369895e-07
I9574 n1_m1_388800_465600 0 1.605449e-06
I9575 n1_m1_388800_470400 0 5.541911e-07
I9576 n1_m1_388800_475200 0 2.218477e-07
I9577 n1_m1_388800_480000 0 3.345867e-07
I9578 n1_m1_388800_484800 0 2.289381e-07
I9579 n1_m1_388800_489600 0 3.031287e-07
I9580 n1_m1_388800_494400 0 1.728236e-07
I9581 n1_m1_388800_499200 0 1.656856e-07
I9582 n1_m1_388800_504000 0 2.428333e-07
I9583 n1_m1_388800_508800 0 1.567733e-07
I9584 n1_m1_388800_513600 0 2.374187e-07
I9585 n1_m1_388800_518400 0 1.556075e-07
I9586 n1_m1_388800_523200 0 1.549617e-07
I9587 n1_m1_388800_528000 0 2.314228e-07
I9588 n1_m1_388800_532800 0 1.556075e-07
I9589 n1_m1_388800_537600 0 2.396960e-07
I9590 n1_m1_388800_542400 0 1.601112e-07
I9591 n1_m1_388800_547200 0 1.548461e-07
I9592 n1_m1_388800_552000 0 2.216132e-07
I9593 n1_m1_388800_556800 0 1.447306e-07
I9594 n1_m1_393600_0 0 1.487632e-07
I9595 n1_m1_393600_4800 0 1.549807e-07
I9596 n1_m1_393600_9600 0 2.475315e-07
I9597 n1_m1_393600_14400 0 1.658365e-07
I9598 n1_m1_393600_19200 0 1.626897e-07
I9599 n1_m1_393600_24000 0 2.401936e-07
I9600 n1_m1_393600_28800 0 1.598903e-07
I9601 n1_m1_393600_33600 0 2.448320e-07
I9602 n1_m1_393600_38400 0 1.603729e-07
I9603 n1_m1_393600_43200 0 1.676509e-07
I9604 n1_m1_393600_48000 0 4.187541e-07
I9605 n1_m1_393600_52800 0 3.596137e-07
I9606 n1_m1_393600_57600 0 3.503643e-07
I9607 n1_m1_393600_62400 0 1.722804e-07
I9608 n1_m1_393600_67200 0 1.721791e-07
I9609 n1_m1_393600_72000 0 2.611242e-07
I9610 n1_m1_393600_76800 0 1.790730e-07
I9611 n1_m1_393600_81600 0 2.624688e-07
I9612 n1_m1_393600_86400 0 1.633042e-07
I9613 n1_m1_393600_91200 0 1.618522e-07
I9614 n1_m1_393600_96000 0 2.567422e-07
I9615 n1_m1_393600_100800 0 2.006058e-07
I9616 n1_m1_393600_105600 0 2.726115e-07
I9617 n1_m1_393600_110400 0 1.716618e-07
I9618 n1_m1_393600_115200 0 1.750819e-07
I9619 n1_m1_393600_120000 0 2.569604e-07
I9620 n1_m1_393600_124800 0 1.763456e-07
I9621 n1_m1_393600_129600 0 3.354330e-07
I9622 n1_m1_393600_134400 0 2.132509e-07
I9623 n1_m1_393600_139200 0 1.839690e-07
I9624 n1_m1_393600_144000 0 2.718413e-07
I9625 n1_m1_393600_148800 0 1.775319e-07
I9626 n1_m1_393600_153600 0 2.573948e-07
I9627 n1_m1_393600_158400 0 1.692648e-07
I9628 n1_m1_393600_163200 0 1.647271e-07
I9629 n1_m1_393600_168000 0 2.493438e-07
I9630 n1_m1_393600_172800 0 1.655449e-07
I9631 n1_m1_393600_177600 0 2.448299e-07
I9632 n1_m1_393600_182400 0 1.636020e-07
I9633 n1_m1_393600_187200 0 1.649929e-07
I9634 n1_m1_393600_192000 0 2.465410e-07
I9635 n1_m1_393600_196800 0 1.628406e-07
I9636 n1_m1_393600_201600 0 2.527279e-07
I9637 n1_m1_393600_206400 0 1.715652e-07
I9638 n1_m1_393600_211200 0 1.651805e-07
I9639 n1_m1_393600_216000 0 2.514907e-07
I9640 n1_m1_393600_220800 0 1.739310e-07
I9641 n1_m1_393600_225600 0 2.641418e-07
I9642 n1_m1_393600_230400 0 1.746053e-07
I9643 n1_m1_393600_235200 0 1.748582e-07
I9644 n1_m1_393600_240000 0 2.684749e-07
I9645 n1_m1_393600_244800 0 1.773789e-07
I9646 n1_m1_393600_249600 0 2.560236e-07
I9647 n1_m1_393600_254400 0 1.662811e-07
I9648 n1_m1_393600_259200 0 1.670214e-07
I9649 n1_m1_393600_264000 0 2.586470e-07
I9650 n1_m1_393600_268800 0 1.694028e-07
I9651 n1_m1_393600_273600 0 2.436001e-07
I9652 n1_m1_393600_278400 0 1.598903e-07
I9653 n1_m1_393600_283200 0 1.598903e-07
I9654 n1_m1_393600_288000 0 2.404662e-07
I9655 n1_m1_393600_292800 0 1.606516e-07
I9656 n1_m1_393600_297600 0 2.395723e-07
I9657 n1_m1_393600_302400 0 1.573430e-07
I9658 n1_m1_393600_307200 0 1.615565e-07
I9659 n1_m1_393600_312000 0 2.424615e-07
I9660 n1_m1_393600_316800 0 1.668392e-07
I9661 n1_m1_393600_321600 0 2.537157e-07
I9662 n1_m1_393600_326400 0 1.732512e-07
I9663 n1_m1_393600_331200 0 1.708474e-07
I9664 n1_m1_393600_336000 0 2.525185e-07
I9665 n1_m1_393600_340800 0 1.648216e-07
I9666 n1_m1_393600_345600 0 2.485029e-07
I9667 n1_m1_393600_350400 0 1.665129e-07
I9668 n1_m1_393600_355200 0 1.714490e-07
I9669 n1_m1_393600_360000 0 2.610909e-07
I9670 n1_m1_393600_364800 0 1.668957e-07
I9671 n1_m1_393600_369600 0 2.498285e-07
I9672 n1_m1_393600_374400 0 1.695027e-07
I9673 n1_m1_393600_379200 0 1.718888e-07
I9674 n1_m1_393600_384000 0 2.520413e-07
I9675 n1_m1_393600_388800 0 1.665524e-07
I9676 n1_m1_393600_393600 0 2.641758e-07
I9677 n1_m1_393600_398400 0 1.762525e-07
I9678 n1_m1_393600_403200 0 1.721240e-07
I9679 n1_m1_393600_408000 0 3.288274e-07
I9680 n1_m1_393600_412800 0 2.399897e-07
I9681 n1_m1_393600_417600 0 2.867739e-07
I9682 n1_m1_393600_422400 0 1.939009e-07
I9683 n1_m1_393600_427200 0 1.937514e-07
I9684 n1_m1_393600_432000 0 6.595616e-07
I9685 n1_m1_393600_436800 0 1.147211e-06
I9686 n1_m1_393600_441600 0 1.942277e-06
I9687 n1_m1_393600_446400 0 8.158027e-07
I9688 n1_m1_393600_451200 0 6.176563e-07
I9689 n1_m1_393600_456000 0 6.187753e-07
I9690 n1_m1_393600_460800 0 5.108140e-07
I9691 n1_m1_393600_465600 0 8.133030e-07
I9692 n1_m1_393600_470400 0 2.671636e-07
I9693 n1_m1_393600_475200 0 1.844448e-07
I9694 n1_m1_393600_480000 0 2.934952e-07
I9695 n1_m1_393600_484800 0 1.697733e-07
I9696 n1_m1_393600_489600 0 2.481385e-07
I9697 n1_m1_393600_494400 0 1.609440e-07
I9698 n1_m1_393600_499200 0 1.598903e-07
I9699 n1_m1_393600_504000 0 2.385506e-07
I9700 n1_m1_393600_508800 0 1.541942e-07
I9701 n1_m1_393600_513600 0 2.326029e-07
I9702 n1_m1_393600_518400 0 1.532282e-07
I9703 n1_m1_393600_523200 0 1.532282e-07
I9704 n1_m1_393600_528000 0 2.298422e-07
I9705 n1_m1_393600_532800 0 1.532282e-07
I9706 n1_m1_393600_537600 0 2.327083e-07
I9707 n1_m1_393600_542400 0 1.560731e-07
I9708 n1_m1_393600_547200 0 1.539447e-07
I9709 n1_m1_393600_552000 0 2.263861e-07
I9710 n1_m1_393600_556800 0 1.502778e-07
I9711 n1_m1_398400_0 0 1.484926e-07
I9712 n1_m1_398400_4800 0 1.525150e-07
I9713 n1_m1_398400_9600 0 2.396379e-07
I9714 n1_m1_398400_14400 0 1.597057e-07
I9715 n1_m1_398400_19200 0 1.560041e-07
I9716 n1_m1_398400_24000 0 2.392113e-07
I9717 n1_m1_398400_28800 0 1.598903e-07
I9718 n1_m1_398400_33600 0 2.486865e-07
I9719 n1_m1_398400_38400 0 1.677454e-07
I9720 n1_m1_398400_43200 0 1.663749e-07
I9721 n1_m1_398400_48000 0 2.537276e-07
I9722 n1_m1_398400_52800 0 1.725989e-07
I9723 n1_m1_398400_57600 0 2.520087e-07
I9724 n1_m1_398400_62400 0 1.656584e-07
I9725 n1_m1_398400_67200 0 1.640537e-07
I9726 n1_m1_398400_72000 0 2.640851e-07
I9727 n1_m1_398400_76800 0 1.740003e-07
I9728 n1_m1_398400_81600 0 2.451103e-07
I9729 n1_m1_398400_86400 0 1.667277e-07
I9730 n1_m1_398400_91200 0 1.742138e-07
I9731 n1_m1_398400_96000 0 2.669413e-07
I9732 n1_m1_398400_100800 0 1.768582e-07
I9733 n1_m1_398400_105600 0 2.597173e-07
I9734 n1_m1_398400_110400 0 1.716682e-07
I9735 n1_m1_398400_115200 0 1.742814e-07
I9736 n1_m1_398400_120000 0 2.568003e-07
I9737 n1_m1_398400_124800 0 2.674974e-07
I9738 n1_m1_398400_129600 0 9.683248e-07
I9739 n1_m1_398400_134400 0 8.675039e-07
I9740 n1_m1_398400_139200 0 5.720597e-07
I9741 n1_m1_398400_144000 0 3.397675e-07
I9742 n1_m1_398400_148800 0 1.888507e-07
I9743 n1_m1_398400_153600 0 3.335078e-07
I9744 n1_m1_398400_158400 0 2.427755e-07
I9745 n1_m1_398400_163200 0 1.981419e-07
I9746 n1_m1_398400_168000 0 2.602054e-07
I9747 n1_m1_398400_172800 0 1.664232e-07
I9748 n1_m1_398400_177600 0 2.573846e-07
I9749 n1_m1_398400_182400 0 1.899010e-07
I9750 n1_m1_398400_187200 0 1.962027e-07
I9751 n1_m1_398400_192000 0 2.732703e-07
I9752 n1_m1_398400_196800 0 1.647196e-07
I9753 n1_m1_398400_201600 0 2.489472e-07
I9754 n1_m1_398400_206400 0 1.796587e-07
I9755 n1_m1_398400_211200 0 2.377997e-07
I9756 n1_m1_398400_216000 0 3.070576e-07
I9757 n1_m1_398400_220800 0 1.765231e-07
I9758 n1_m1_398400_225600 0 2.517507e-07
I9759 n1_m1_398400_230400 0 1.705448e-07
I9760 n1_m1_398400_235200 0 1.902844e-07
I9761 n1_m1_398400_240000 0 3.839028e-07
I9762 n1_m1_398400_244800 0 2.054665e-07
I9763 n1_m1_398400_249600 0 2.591996e-07
I9764 n1_m1_398400_254400 0 1.723715e-07
I9765 n1_m1_398400_259200 0 1.732280e-07
I9766 n1_m1_398400_264000 0 2.682812e-07
I9767 n1_m1_398400_268800 0 1.777763e-07
I9768 n1_m1_398400_273600 0 2.520739e-07
I9769 n1_m1_398400_278400 0 1.604137e-07
I9770 n1_m1_398400_283200 0 1.645823e-07
I9771 n1_m1_398400_288000 0 2.623070e-07
I9772 n1_m1_398400_292800 0 1.742804e-07
I9773 n1_m1_398400_297600 0 2.501018e-07
I9774 n1_m1_398400_302400 0 1.598631e-07
I9775 n1_m1_398400_307200 0 1.604939e-07
I9776 n1_m1_398400_312000 0 2.490603e-07
I9777 n1_m1_398400_316800 0 1.706557e-07
I9778 n1_m1_398400_321600 0 2.458914e-07
I9779 n1_m1_398400_326400 0 1.606605e-07
I9780 n1_m1_398400_331200 0 1.633049e-07
I9781 n1_m1_398400_336000 0 2.599705e-07
I9782 n1_m1_398400_340800 0 1.785577e-07
I9783 n1_m1_398400_345600 0 2.650898e-07
I9784 n1_m1_398400_350400 0 1.629725e-07
I9785 n1_m1_398400_355200 0 1.652658e-07
I9786 n1_m1_398400_360000 0 2.560705e-07
I9787 n1_m1_398400_364800 0 1.667716e-07
I9788 n1_m1_398400_369600 0 2.498285e-07
I9789 n1_m1_398400_374400 0 1.669949e-07
I9790 n1_m1_398400_379200 0 1.671948e-07
I9791 n1_m1_398400_384000 0 2.540756e-07
I9792 n1_m1_398400_388800 0 1.689113e-07
I9793 n1_m1_398400_393600 0 2.601436e-07
I9794 n1_m1_398400_398400 0 1.743218e-07
I9795 n1_m1_398400_403200 0 1.682131e-07
I9796 n1_m1_398400_408000 0 2.668930e-07
I9797 n1_m1_398400_412800 0 1.817171e-07
I9798 n1_m1_398400_417600 0 2.474733e-07
I9799 n1_m1_398400_422400 0 1.697345e-07
I9800 n1_m1_398400_427200 0 1.736815e-07
I9801 n1_m1_398400_432000 0 3.049020e-07
I9802 n1_m1_398400_436800 0 6.245489e-07
I9803 n1_m1_398400_441600 0 1.744693e-06
I9804 n1_m1_398400_446400 0 1.298078e-06
I9805 n1_m1_398400_451200 0 1.227952e-06
I9806 n1_m1_398400_456000 0 7.658437e-07
I9807 n1_m1_398400_460800 0 2.026657e-07
I9808 n1_m1_398400_465600 0 2.772954e-07
I9809 n1_m1_398400_470400 0 1.726271e-07
I9810 n1_m1_398400_475200 0 1.731764e-07
I9811 n1_m1_398400_480000 0 2.505478e-07
I9812 n1_m1_398400_484800 0 1.615816e-07
I9813 n1_m1_398400_489600 0 2.485913e-07
I9814 n1_m1_398400_494400 0 1.653222e-07
I9815 n1_m1_398400_499200 0 1.619960e-07
I9816 n1_m1_398400_504000 0 2.473802e-07
I9817 n1_m1_398400_508800 0 1.643848e-07
I9818 n1_m1_398400_513600 0 2.377912e-07
I9819 n1_m1_398400_518400 0 1.535647e-07
I9820 n1_m1_398400_523200 0 1.565864e-07
I9821 n1_m1_398400_528000 0 2.477993e-07
I9822 n1_m1_398400_532800 0 1.619222e-07
I9823 n1_m1_398400_537600 0 2.335795e-07
I9824 n1_m1_398400_542400 0 1.533291e-07
I9825 n1_m1_398400_547200 0 1.532282e-07
I9826 n1_m1_398400_552000 0 2.292291e-07
I9827 n1_m1_398400_556800 0 1.527047e-07
I9828 n1_m1_403200_0 0 1.522370e-07
I9829 n1_m1_403200_4800 0 1.533318e-07
I9830 n1_m1_403200_9600 0 2.383602e-07
I9831 n1_m1_403200_14400 0 1.596425e-07
I9832 n1_m1_403200_19200 0 1.588991e-07
I9833 n1_m1_403200_24000 0 2.396794e-07
I9834 n1_m1_403200_28800 0 1.599752e-07
I9835 n1_m1_403200_33600 0 2.459740e-07
I9836 n1_m1_403200_38400 0 1.670112e-07
I9837 n1_m1_403200_43200 0 1.636890e-07
I9838 n1_m1_403200_48000 0 2.417157e-07
I9839 n1_m1_403200_52800 0 1.574484e-07
I9840 n1_m1_403200_57600 0 2.420621e-07
I9841 n1_m1_403200_62400 0 1.663770e-07
I9842 n1_m1_403200_67200 0 1.671802e-07
I9843 n1_m1_403200_72000 0 2.623975e-07
I9844 n1_m1_403200_76800 0 1.773368e-07
I9845 n1_m1_403200_81600 0 2.598472e-07
I9846 n1_m1_403200_86400 0 1.797589e-07
I9847 n1_m1_403200_91200 0 1.906956e-07
I9848 n1_m1_403200_96000 0 3.521399e-07
I9849 n1_m1_403200_100800 0 3.151473e-07
I9850 n1_m1_403200_105600 0 3.751034e-07
I9851 n1_m1_403200_110400 0 2.172794e-07
I9852 n1_m1_403200_115200 0 2.080450e-07
I9853 n1_m1_403200_120000 0 2.760034e-07
I9854 n1_m1_403200_124800 0 3.146317e-07
I9855 n1_m1_403200_129600 0 1.290363e-06
I9856 n1_m1_403200_134400 0 1.217261e-06
I9857 n1_m1_403200_139200 0 8.979313e-07
I9858 n1_m1_403200_144000 0 6.118131e-07
I9859 n1_m1_403200_148800 0 2.185738e-07
I9860 n1_m1_403200_153600 0 3.232893e-07
I9861 n1_m1_403200_158400 0 2.662265e-07
I9862 n1_m1_403200_163200 0 2.294194e-07
I9863 n1_m1_403200_168000 0 2.717570e-07
I9864 n1_m1_403200_172800 0 1.682940e-07
I9865 n1_m1_403200_177600 0 2.691540e-07
I9866 n1_m1_403200_182400 0 2.435519e-07
I9867 n1_m1_403200_187200 0 2.863640e-07
I9868 n1_m1_403200_192000 0 3.611419e-07
I9869 n1_m1_403200_196800 0 1.843660e-07
I9870 n1_m1_403200_201600 0 2.592391e-07
I9871 n1_m1_403200_206400 0 1.878296e-07
I9872 n1_m1_403200_211200 0 2.687730e-07
I9873 n1_m1_403200_216000 0 3.523150e-07
I9874 n1_m1_403200_220800 0 1.808276e-07
I9875 n1_m1_403200_225600 0 2.510471e-07
I9876 n1_m1_403200_230400 0 1.701859e-07
I9877 n1_m1_403200_235200 0 1.841308e-07
I9878 n1_m1_403200_240000 0 3.714308e-07
I9879 n1_m1_403200_244800 0 2.043169e-07
I9880 n1_m1_403200_249600 0 2.672006e-07
I9881 n1_m1_403200_254400 0 1.833738e-07
I9882 n1_m1_403200_259200 0 1.799734e-07
I9883 n1_m1_403200_264000 0 2.680456e-07
I9884 n1_m1_403200_268800 0 1.742532e-07
I9885 n1_m1_403200_273600 0 2.583808e-07
I9886 n1_m1_403200_278400 0 1.652675e-07
I9887 n1_m1_403200_283200 0 1.653117e-07
I9888 n1_m1_403200_288000 0 2.647785e-07
I9889 n1_m1_403200_292800 0 1.785013e-07
I9890 n1_m1_403200_297600 0 2.530600e-07
I9891 n1_m1_403200_302400 0 1.612210e-07
I9892 n1_m1_403200_307200 0 1.642832e-07
I9893 n1_m1_403200_312000 0 2.483377e-07
I9894 n1_m1_403200_316800 0 1.631625e-07
I9895 n1_m1_403200_321600 0 2.486253e-07
I9896 n1_m1_403200_326400 0 1.678025e-07
I9897 n1_m1_403200_331200 0 1.710486e-07
I9898 n1_m1_403200_336000 0 2.636497e-07
I9899 n1_m1_403200_340800 0 1.830111e-07
I9900 n1_m1_403200_345600 0 2.742414e-07
I9901 n1_m1_403200_350400 0 1.634518e-07
I9902 n1_m1_403200_355200 0 1.612669e-07
I9903 n1_m1_403200_360000 0 2.497221e-07
I9904 n1_m1_403200_364800 0 1.665897e-07
I9905 n1_m1_403200_369600 0 2.498285e-07
I9906 n1_m1_403200_374400 0 1.666577e-07
I9907 n1_m1_403200_379200 0 1.668753e-07
I9908 n1_m1_403200_384000 0 2.553604e-07
I9909 n1_m1_403200_388800 0 1.740030e-07
I9910 n1_m1_403200_393600 0 2.831152e-07
I9911 n1_m1_403200_398400 0 1.964522e-07
I9912 n1_m1_403200_403200 0 1.778582e-07
I9913 n1_m1_403200_408000 0 2.668478e-07
I9914 n1_m1_403200_412800 0 1.732236e-07
I9915 n1_m1_403200_417600 0 2.499754e-07
I9916 n1_m1_403200_422400 0 1.709928e-07
I9917 n1_m1_403200_427200 0 1.649439e-07
I9918 n1_m1_403200_432000 0 2.512041e-07
I9919 n1_m1_403200_436800 0 2.706795e-07
I9920 n1_m1_403200_441600 0 1.433459e-06
I9921 n1_m1_403200_446400 0 1.402169e-06
I9922 n1_m1_403200_451200 0 1.389081e-06
I9923 n1_m1_403200_456000 0 8.911101e-07
I9924 n1_m1_403200_460800 0 1.922619e-07
I9925 n1_m1_403200_465600 0 2.593220e-07
I9926 n1_m1_403200_470400 0 1.709024e-07
I9927 n1_m1_403200_475200 0 1.644443e-07
I9928 n1_m1_403200_480000 0 2.329513e-07
I9929 n1_m1_403200_484800 0 1.639439e-07
I9930 n1_m1_403200_489600 0 2.521603e-07
I9931 n1_m1_403200_494400 0 1.665071e-07
I9932 n1_m1_403200_499200 0 1.693263e-07
I9933 n1_m1_403200_504000 0 2.571266e-07
I9934 n1_m1_403200_508800 0 1.717182e-07
I9935 n1_m1_403200_513600 0 2.508968e-07
I9936 n1_m1_403200_518400 0 1.569229e-07
I9937 n1_m1_403200_523200 0 1.598726e-07
I9938 n1_m1_403200_528000 0 2.617938e-07
I9939 n1_m1_403200_532800 0 1.683504e-07
I9940 n1_m1_403200_537600 0 2.413639e-07
I9941 n1_m1_403200_542400 0 1.544946e-07
I9942 n1_m1_403200_547200 0 1.532859e-07
I9943 n1_m1_403200_552000 0 2.235432e-07
I9944 n1_m1_403200_556800 0 1.478509e-07
I9945 n1_m1_408000_0 0 2.298422e-07
I9946 n1_m1_408000_4800 0 2.303419e-07
I9947 n1_m1_408000_9600 0 3.575403e-07
I9948 n1_m1_408000_14400 0 2.398354e-07
I9949 n1_m1_408000_19200 0 2.398354e-07
I9950 n1_m1_408000_24000 0 3.604064e-07
I9951 n1_m1_408000_28800 0 2.443017e-07
I9952 n1_m1_408000_33600 0 3.757421e-07
I9953 n1_m1_408000_38400 0 2.503554e-07
I9954 n1_m1_408000_43200 0 2.489271e-07
I9955 n1_m1_408000_48000 0 3.736218e-07
I9956 n1_m1_408000_52800 0 2.483323e-07
I9957 n1_m1_408000_57600 0 3.729661e-07
I9958 n1_m1_408000_62400 0 2.632557e-07
I9959 n1_m1_408000_67200 0 2.893963e-07
I9960 n1_m1_408000_72000 0 4.700784e-07
I9961 n1_m1_408000_76800 0 3.646776e-07
I9962 n1_m1_408000_81600 0 8.496352e-07
I9963 n1_m1_408000_86400 0 8.776541e-07
I9964 n1_m1_408000_91200 0 1.089131e-06
I9965 n1_m1_408000_96000 0 1.919684e-06
I9966 n1_m1_408000_100800 0 1.408962e-06
I9967 n1_m1_408000_105600 0 1.887358e-06
I9968 n1_m1_408000_110400 0 9.551115e-07
I9969 n1_m1_408000_115200 0 6.910998e-07
I9970 n1_m1_408000_120000 0 5.486612e-07
I9971 n1_m1_408000_124800 0 3.380394e-07
I9972 n1_m1_408000_129600 0 1.237803e-06
I9973 n1_m1_408000_134400 0 1.437086e-06
I9974 n1_m1_408000_139200 0 1.367466e-06
I9975 n1_m1_408000_144000 0 1.231579e-06
I9976 n1_m1_408000_148800 0 3.585573e-07
I9977 n1_m1_408000_153600 0 4.198343e-07
I9978 n1_m1_408000_158400 0 2.962198e-07
I9979 n1_m1_408000_163200 0 2.815187e-07
I9980 n1_m1_408000_168000 0 3.958348e-07
I9981 n1_m1_408000_172800 0 2.624716e-07
I9982 n1_m1_408000_177600 0 3.850500e-07
I9983 n1_m1_408000_182400 0 2.994693e-07
I9984 n1_m1_408000_187200 0 3.510686e-07
I9985 n1_m1_408000_192000 0 5.007230e-07
I9986 n1_m1_408000_196800 0 2.774001e-07
I9987 n1_m1_408000_201600 0 3.908032e-07
I9988 n1_m1_408000_206400 0 2.634549e-07
I9989 n1_m1_408000_211200 0 2.899642e-07
I9990 n1_m1_408000_216000 0 4.284002e-07
I9991 n1_m1_408000_220800 0 2.754783e-07
I9992 n1_m1_408000_225600 0 3.960496e-07
I9993 n1_m1_408000_230400 0 2.605341e-07
I9994 n1_m1_408000_235200 0 2.658488e-07
I9995 n1_m1_408000_240000 0 4.273373e-07
I9996 n1_m1_408000_244800 0 2.717101e-07
I9997 n1_m1_408000_249600 0 4.255712e-07
I9998 n1_m1_408000_254400 0 3.137360e-07
I9999 n1_m1_408000_259200 0 3.100583e-07
I10000 n1_m1_408000_264000 0 4.363760e-07
I10001 n1_m1_408000_268800 0 2.686809e-07
I10002 n1_m1_408000_273600 0 3.927988e-07
I10003 n1_m1_408000_278400 0 2.505661e-07
I10004 n1_m1_408000_283200 0 2.448986e-07
I10005 n1_m1_408000_288000 0 3.762975e-07
I10006 n1_m1_408000_292800 0 2.515892e-07
I10007 n1_m1_408000_297600 0 3.674906e-07
I10008 n1_m1_408000_302400 0 2.416804e-07
I10009 n1_m1_408000_307200 0 2.431063e-07
I10010 n1_m1_408000_312000 0 3.687282e-07
I10011 n1_m1_408000_316800 0 2.353674e-07
I10012 n1_m1_408000_321600 0 3.675946e-07
I10013 n1_m1_408000_326400 0 2.538441e-07
I10014 n1_m1_408000_331200 0 2.556851e-07
I10015 n1_m1_408000_336000 0 3.784525e-07
I10016 n1_m1_408000_340800 0 2.597741e-07
I10017 n1_m1_408000_345600 0 4.067470e-07
I10018 n1_m1_408000_350400 0 2.498860e-07
I10019 n1_m1_408000_355200 0 2.433935e-07
I10020 n1_m1_408000_360000 0 3.679230e-07
I10021 n1_m1_408000_364800 0 2.510573e-07
I10022 n1_m1_408000_369600 0 3.769556e-07
I10023 n1_m1_408000_374400 0 2.543594e-07
I10024 n1_m1_408000_379200 0 2.633023e-07
I10025 n1_m1_408000_384000 0 4.254223e-07
I10026 n1_m1_408000_388800 0 3.394133e-07
I10027 n1_m1_408000_393600 0 8.529374e-07
I10028 n1_m1_408000_398400 0 6.327650e-07
I10029 n1_m1_408000_403200 0 3.721323e-07
I10030 n1_m1_408000_408000 0 4.059921e-07
I10031 n1_m1_408000_412800 0 2.614848e-07
I10032 n1_m1_408000_417600 0 3.754542e-07
I10033 n1_m1_408000_422400 0 2.533798e-07
I10034 n1_m1_408000_427200 0 2.673947e-07
I10035 n1_m1_408000_432000 0 3.827791e-07
I10036 n1_m1_408000_436800 0 2.573907e-07
I10037 n1_m1_408000_441600 0 9.566332e-07
I10038 n1_m1_408000_446400 0 1.397439e-06
I10039 n1_m1_408000_451200 0 1.857063e-06
I10040 n1_m1_408000_456000 0 1.671263e-06
I10041 n1_m1_408000_460800 0 3.345054e-07
I10042 n1_m1_408000_465600 0 3.733458e-07
I10043 n1_m1_408000_470400 0 2.466858e-07
I10044 n1_m1_408000_475200 0 2.392977e-07
I10045 n1_m1_408000_480000 0 3.438487e-07
I10046 n1_m1_408000_484800 0 2.387735e-07
I10047 n1_m1_408000_489600 0 3.651008e-07
I10048 n1_m1_408000_494400 0 2.411970e-07
I10049 n1_m1_408000_499200 0 2.416138e-07
I10050 n1_m1_408000_504000 0 3.725739e-07
I10051 n1_m1_408000_508800 0 2.575725e-07
I10052 n1_m1_408000_513600 0 3.830310e-07
I10053 n1_m1_408000_518400 0 2.446416e-07
I10054 n1_m1_408000_523200 0 2.433194e-07
I10055 n1_m1_408000_528000 0 3.850266e-07
I10056 n1_m1_408000_532800 0 2.559699e-07
I10057 n1_m1_408000_537600 0 3.739362e-07
I10058 n1_m1_408000_542400 0 2.395611e-07
I10059 n1_m1_408000_547200 0 2.318762e-07
I10060 n1_m1_408000_552000 0 3.345218e-07
I10061 n1_m1_408000_556800 0 2.201863e-07
I10062 n1_m1_412800_0 0 1.535001e-07
I10063 n1_m1_412800_4800 0 1.544790e-07
I10064 n1_m1_412800_9600 0 2.386236e-07
I10065 n1_m1_412800_14400 0 1.598903e-07
I10066 n1_m1_412800_19200 0 1.598903e-07
I10067 n1_m1_412800_24000 0 2.426382e-07
I10068 n1_m1_412800_28800 0 1.685986e-07
I10069 n1_m1_412800_33600 0 2.584298e-07
I10070 n1_m1_412800_38400 0 1.668583e-07
I10071 n1_m1_412800_43200 0 1.641730e-07
I10072 n1_m1_412800_48000 0 2.523142e-07
I10073 n1_m1_412800_52800 0 1.691747e-07
I10074 n1_m1_412800_57600 0 2.436600e-07
I10075 n1_m1_412800_62400 0 1.824391e-07
I10076 n1_m1_412800_67200 0 2.541701e-07
I10077 n1_m1_412800_72000 0 6.311104e-07
I10078 n1_m1_412800_76800 0 6.377589e-07
I10079 n1_m1_412800_81600 0 1.524490e-06
I10080 n1_m1_412800_86400 0 1.298781e-06
I10081 n1_m1_412800_91200 0 1.383884e-06
I10082 n1_m1_412800_96000 0 2.073879e-06
I10083 n1_m1_412800_100800 0 1.319876e-06
I10084 n1_m1_412800_105600 0 1.683201e-06
I10085 n1_m1_412800_110400 0 7.411651e-07
I10086 n1_m1_412800_115200 0 4.705774e-07
I10087 n1_m1_412800_120000 0 3.904381e-07
I10088 n1_m1_412800_124800 0 1.655102e-07
I10089 n1_m1_412800_129600 0 2.851257e-07
I10090 n1_m1_412800_134400 0 2.715735e-07
I10091 n1_m1_412800_139200 0 4.099805e-07
I10092 n1_m1_412800_144000 0 5.444664e-07
I10093 n1_m1_412800_148800 0 2.001592e-07
I10094 n1_m1_412800_153600 0 2.712567e-07
I10095 n1_m1_412800_158400 0 1.753749e-07
I10096 n1_m1_412800_163200 0 1.682808e-07
I10097 n1_m1_412800_168000 0 2.545977e-07
I10098 n1_m1_412800_172800 0 1.763619e-07
I10099 n1_m1_412800_177600 0 2.548149e-07
I10100 n1_m1_412800_182400 0 1.723932e-07
I10101 n1_m1_412800_187200 0 1.759792e-07
I10102 n1_m1_412800_192000 0 2.637047e-07
I10103 n1_m1_412800_196800 0 1.738711e-07
I10104 n1_m1_412800_201600 0 2.523047e-07
I10105 n1_m1_412800_206400 0 1.660129e-07
I10106 n1_m1_412800_211200 0 1.674891e-07
I10107 n1_m1_412800_216000 0 2.598081e-07
I10108 n1_m1_412800_220800 0 1.789391e-07
I10109 n1_m1_412800_225600 0 2.678376e-07
I10110 n1_m1_412800_230400 0 1.789826e-07
I10111 n1_m1_412800_235200 0 1.784687e-07
I10112 n1_m1_412800_240000 0 2.773209e-07
I10113 n1_m1_412800_244800 0 1.940852e-07
I10114 n1_m1_412800_249600 0 3.405642e-07
I10115 n1_m1_412800_254400 0 2.769925e-07
I10116 n1_m1_412800_259200 0 3.082133e-07
I10117 n1_m1_412800_264000 0 4.516920e-07
I10118 n1_m1_412800_268800 0 2.376981e-07
I10119 n1_m1_412800_273600 0 2.855023e-07
I10120 n1_m1_412800_278400 0 1.715013e-07
I10121 n1_m1_412800_283200 0 1.656217e-07
I10122 n1_m1_412800_288000 0 2.411338e-07
I10123 n1_m1_412800_292800 0 1.602234e-07
I10124 n1_m1_412800_297600 0 2.485202e-07
I10125 n1_m1_412800_302400 0 1.684541e-07
I10126 n1_m1_412800_307200 0 1.685435e-07
I10127 n1_m1_412800_312000 0 2.505376e-07
I10128 n1_m1_412800_316800 0 1.641122e-07
I10129 n1_m1_412800_321600 0 2.496980e-07
I10130 n1_m1_412800_326400 0 1.655197e-07
I10131 n1_m1_412800_331200 0 1.660262e-07
I10132 n1_m1_412800_336000 0 2.507718e-07
I10133 n1_m1_412800_340800 0 1.722151e-07
I10134 n1_m1_412800_345600 0 2.735925e-07
I10135 n1_m1_412800_350400 0 2.139015e-07
I10136 n1_m1_412800_355200 0 1.994260e-07
I10137 n1_m1_412800_360000 0 2.782522e-07
I10138 n1_m1_412800_364800 0 1.801774e-07
I10139 n1_m1_412800_369600 0 2.621007e-07
I10140 n1_m1_412800_374400 0 1.740826e-07
I10141 n1_m1_412800_379200 0 1.882891e-07
I10142 n1_m1_412800_384000 0 3.929803e-07
I10143 n1_m1_412800_388800 0 3.136895e-07
I10144 n1_m1_412800_393600 0 6.549433e-07
I10145 n1_m1_412800_398400 0 5.067814e-07
I10146 n1_m1_412800_403200 0 3.556352e-07
I10147 n1_m1_412800_408000 0 3.344742e-07
I10148 n1_m1_412800_412800 0 1.831872e-07
I10149 n1_m1_412800_417600 0 2.488384e-07
I10150 n1_m1_412800_422400 0 1.727597e-07
I10151 n1_m1_412800_427200 0 1.764041e-07
I10152 n1_m1_412800_432000 0 2.478340e-07
I10153 n1_m1_412800_436800 0 1.741669e-07
I10154 n1_m1_412800_441600 0 2.822736e-07
I10155 n1_m1_412800_446400 0 2.512388e-07
I10156 n1_m1_412800_451200 0 6.176560e-07
I10157 n1_m1_412800_456000 0 9.207673e-07
I10158 n1_m1_412800_460800 0 2.632238e-07
I10159 n1_m1_412800_465600 0 2.520301e-07
I10160 n1_m1_412800_470400 0 1.605537e-07
I10161 n1_m1_412800_475200 0 1.644205e-07
I10162 n1_m1_412800_480000 0 2.452711e-07
I10163 n1_m1_412800_484800 0 1.564906e-07
I10164 n1_m1_412800_489600 0 2.347450e-07
I10165 n1_m1_412800_494400 0 1.586561e-07
I10166 n1_m1_412800_499200 0 1.549651e-07
I10167 n1_m1_412800_504000 0 2.330176e-07
I10168 n1_m1_412800_508800 0 1.647685e-07
I10169 n1_m1_412800_513600 0 2.478693e-07
I10170 n1_m1_412800_518400 0 1.622186e-07
I10171 n1_m1_412800_523200 0 1.574865e-07
I10172 n1_m1_412800_528000 0 2.347409e-07
I10173 n1_m1_412800_532800 0 1.593668e-07
I10174 n1_m1_412800_537600 0 2.387939e-07
I10175 n1_m1_412800_542400 0 1.594871e-07
I10176 n1_m1_412800_547200 0 1.548461e-07
I10177 n1_m1_412800_552000 0 2.283219e-07
I10178 n1_m1_412800_556800 0 1.480127e-07
I10179 n1_m1_417600_0 0 2.337933e-07
I10180 n1_m1_417600_4800 0 2.354323e-07
I10181 n1_m1_417600_9600 0 3.546195e-07
I10182 n1_m1_417600_14400 0 2.365043e-07
I10183 n1_m1_417600_19200 0 2.365043e-07
I10184 n1_m1_417600_24000 0 3.577069e-07
I10185 n1_m1_417600_28800 0 2.455458e-07
I10186 n1_m1_417600_33600 0 3.702102e-07
I10187 n1_m1_417600_38400 0 2.356172e-07
I10188 n1_m1_417600_43200 0 2.310795e-07
I10189 n1_m1_417600_48000 0 3.526161e-07
I10190 n1_m1_417600_52800 0 2.328195e-07
I10191 n1_m1_417600_57600 0 3.490791e-07
I10192 n1_m1_417600_62400 0 2.510229e-07
I10193 n1_m1_417600_67200 0 3.009778e-07
I10194 n1_m1_417600_72000 0 7.697088e-07
I10195 n1_m1_417600_76800 0 9.836562e-07
I10196 n1_m1_417600_81600 0 2.398684e-06
I10197 n1_m1_417600_86400 0 1.964264e-06
I10198 n1_m1_417600_91200 0 1.991030e-06
I10199 n1_m1_417600_96000 0 2.629385e-06
I10200 n1_m1_417600_100800 0 1.486516e-06
I10201 n1_m1_417600_105600 0 1.612605e-06
I10202 n1_m1_417600_110400 0 5.741773e-07
I10203 n1_m1_417600_115200 0 3.423348e-07
I10204 n1_m1_417600_120000 0 4.264695e-07
I10205 n1_m1_417600_124800 0 2.576708e-07
I10206 n1_m1_417600_129600 0 3.796204e-07
I10207 n1_m1_417600_134400 0 2.631629e-07
I10208 n1_m1_417600_139200 0 2.849949e-07
I10209 n1_m1_417600_144000 0 4.187429e-07
I10210 n1_m1_417600_148800 0 2.588774e-07
I10211 n1_m1_417600_153600 0 4.147725e-07
I10212 n1_m1_417600_158400 0 2.755204e-07
I10213 n1_m1_417600_163200 0 2.588149e-07
I10214 n1_m1_417600_168000 0 3.828869e-07
I10215 n1_m1_417600_172800 0 2.651935e-07
I10216 n1_m1_417600_177600 0 4.105264e-07
I10217 n1_m1_417600_182400 0 2.655551e-07
I10218 n1_m1_417600_187200 0 2.615824e-07
I10219 n1_m1_417600_192000 0 3.896135e-07
I10220 n1_m1_417600_196800 0 2.572996e-07
I10221 n1_m1_417600_201600 0 3.752577e-07
I10222 n1_m1_417600_206400 0 2.439530e-07
I10223 n1_m1_417600_211200 0 2.560134e-07
I10224 n1_m1_417600_216000 0 3.751320e-07
I10225 n1_m1_417600_220800 0 2.553961e-07
I10226 n1_m1_417600_225600 0 3.904225e-07
I10227 n1_m1_417600_230400 0 2.689168e-07
I10228 n1_m1_417600_235200 0 3.125345e-07
I10229 n1_m1_417600_240000 0 5.692960e-07
I10230 n1_m1_417600_244800 0 5.344651e-07
I10231 n1_m1_417600_249600 0 9.948655e-07
I10232 n1_m1_417600_254400 0 5.178099e-07
I10233 n1_m1_417600_259200 0 5.550496e-07
I10234 n1_m1_417600_264000 0 1.355302e-06
I10235 n1_m1_417600_268800 0 7.297073e-07
I10236 n1_m1_417600_273600 0 4.928107e-07
I10237 n1_m1_417600_278400 0 2.655558e-07
I10238 n1_m1_417600_283200 0 2.560807e-07
I10239 n1_m1_417600_288000 0 3.765164e-07
I10240 n1_m1_417600_292800 0 2.451651e-07
I10241 n1_m1_417600_297600 0 3.813128e-07
I10242 n1_m1_417600_302400 0 2.699613e-07
I10243 n1_m1_417600_307200 0 2.708777e-07
I10244 n1_m1_417600_312000 0 3.913148e-07
I10245 n1_m1_417600_316800 0 2.684559e-07
I10246 n1_m1_417600_321600 0 3.847033e-07
I10247 n1_m1_417600_326400 0 2.520175e-07
I10248 n1_m1_417600_331200 0 2.535396e-07
I10249 n1_m1_417600_336000 0 3.792489e-07
I10250 n1_m1_417600_340800 0 2.614872e-07
I10251 n1_m1_417600_345600 0 4.705542e-07
I10252 n1_m1_417600_350400 0 5.665006e-07
I10253 n1_m1_417600_355200 0 4.892829e-07
I10254 n1_m1_417600_360000 0 5.155778e-07
I10255 n1_m1_417600_364800 0 2.978262e-07
I10256 n1_m1_417600_369600 0 4.121046e-07
I10257 n1_m1_417600_374400 0 2.884442e-07
I10258 n1_m1_417600_379200 0 3.362012e-07
I10259 n1_m1_417600_384000 0 7.347457e-07
I10260 n1_m1_417600_388800 0 4.780528e-07
I10261 n1_m1_417600_393600 0 6.115184e-07
I10262 n1_m1_417600_398400 0 4.806001e-07
I10263 n1_m1_417600_403200 0 4.676590e-07
I10264 n1_m1_417600_408000 0 5.733973e-07
I10265 n1_m1_417600_412800 0 2.662360e-07
I10266 n1_m1_417600_417600 0 3.562596e-07
I10267 n1_m1_417600_422400 0 2.495614e-07
I10268 n1_m1_417600_427200 0 2.518489e-07
I10269 n1_m1_417600_432000 0 3.772849e-07
I10270 n1_m1_417600_436800 0 2.542507e-07
I10271 n1_m1_417600_441600 0 3.790888e-07
I10272 n1_m1_417600_446400 0 2.543003e-07
I10273 n1_m1_417600_451200 0 3.655946e-07
I10274 n1_m1_417600_456000 0 7.679596e-07
I10275 n1_m1_417600_460800 0 3.151449e-07
I10276 n1_m1_417600_465600 0 3.825507e-07
I10277 n1_m1_417600_470400 0 2.429278e-07
I10278 n1_m1_417600_475200 0 2.447320e-07
I10279 n1_m1_417600_480000 0 3.635080e-07
I10280 n1_m1_417600_484800 0 2.354867e-07
I10281 n1_m1_417600_489600 0 3.575264e-07
I10282 n1_m1_417600_494400 0 2.366556e-07
I10283 n1_m1_417600_499200 0 2.313174e-07
I10284 n1_m1_417600_504000 0 3.461675e-07
I10285 n1_m1_417600_508800 0 2.365509e-07
I10286 n1_m1_417600_513600 0 3.530080e-07
I10287 n1_m1_417600_518400 0 2.308586e-07
I10288 n1_m1_417600_523200 0 2.302930e-07
I10289 n1_m1_417600_528000 0 3.451743e-07
I10290 n1_m1_417600_532800 0 2.304609e-07
I10291 n1_m1_417600_537600 0 3.461661e-07
I10292 n1_m1_417600_542400 0 2.351009e-07
I10293 n1_m1_417600_547200 0 2.314602e-07
I10294 n1_m1_417600_552000 0 3.396716e-07
I10295 n1_m1_417600_556800 0 2.213719e-07
I10296 n1_m1_422400_0 0 7.870652e-08
I10297 n1_m1_422400_4800 0 7.709844e-08
I10298 n1_m1_422400_9600 0 1.149211e-07
I10299 n1_m1_422400_14400 0 7.661408e-08
I10300 n1_m1_422400_19200 0 7.661408e-08
I10301 n1_m1_422400_24000 0 1.149211e-07
I10302 n1_m1_422400_28800 0 7.661408e-08
I10303 n1_m1_422400_33600 0 1.149211e-07
I10304 n1_m1_422400_38400 0 7.661408e-08
I10305 n1_m1_422400_43200 0 7.695874e-08
I10306 n1_m1_422400_48000 0 1.152481e-07
I10307 n1_m1_422400_52800 0 7.661408e-08
I10308 n1_m1_422400_57600 0 1.162593e-07
I10309 n1_m1_422400_62400 0 8.295021e-08
I10310 n1_m1_422400_67200 0 8.567929e-08
I10311 n1_m1_422400_72000 0 1.307178e-07
I10312 n1_m1_422400_76800 0 1.195866e-07
I10313 n1_m1_422400_81600 0 4.070247e-07
I10314 n1_m1_422400_86400 0 4.365337e-07
I10315 n1_m1_422400_91200 0 4.352502e-07
I10316 n1_m1_422400_96000 0 4.431917e-07
I10317 n1_m1_422400_100800 0 1.592033e-07
I10318 n1_m1_422400_105600 0 1.866199e-07
I10319 n1_m1_422400_110400 0 1.045867e-07
I10320 n1_m1_422400_115200 0 9.282642e-08
I10321 n1_m1_422400_120000 0 1.294397e-07
I10322 n1_m1_422400_124800 0 8.327618e-08
I10323 n1_m1_422400_129600 0 1.249143e-07
I10324 n1_m1_422400_134400 0 8.327618e-08
I10325 n1_m1_422400_139200 0 8.703550e-08
I10326 n1_m1_422400_144000 0 1.310968e-07
I10327 n1_m1_422400_148800 0 8.329691e-08
I10328 n1_m1_422400_153600 0 1.311386e-07
I10329 n1_m1_422400_158400 0 9.083765e-08
I10330 n1_m1_422400_163200 0 8.928328e-08
I10331 n1_m1_422400_168000 0 1.303564e-07
I10332 n1_m1_422400_172800 0 8.824759e-08
I10333 n1_m1_422400_177600 0 1.371028e-07
I10334 n1_m1_422400_182400 0 8.959361e-08
I10335 n1_m1_422400_187200 0 8.804093e-08
I10336 n1_m1_422400_192000 0 1.292439e-07
I10337 n1_m1_422400_196800 0 8.346652e-08
I10338 n1_m1_422400_201600 0 1.235020e-07
I10339 n1_m1_422400_206400 0 8.166946e-08
I10340 n1_m1_422400_211200 0 8.848723e-08
I10341 n1_m1_422400_216000 0 1.265434e-07
I10342 n1_m1_422400_220800 0 8.812047e-08
I10343 n1_m1_422400_225600 0 1.292222e-07
I10344 n1_m1_422400_230400 0 8.999809e-08
I10345 n1_m1_422400_235200 0 1.204473e-07
I10346 n1_m1_422400_240000 0 2.282546e-07
I10347 n1_m1_422400_244800 0 2.767781e-07
I10348 n1_m1_422400_249600 0 5.330715e-07
I10349 n1_m1_422400_254400 0 2.086979e-07
I10350 n1_m1_422400_259200 0 2.041956e-07
I10351 n1_m1_422400_264000 0 6.527948e-07
I10352 n1_m1_422400_268800 0 3.581875e-07
I10353 n1_m1_422400_273600 0 1.864037e-07
I10354 n1_m1_422400_278400 0 9.031896e-08
I10355 n1_m1_422400_283200 0 8.466706e-08
I10356 n1_m1_422400_288000 0 1.334540e-07
I10357 n1_m1_422400_292800 0 8.527480e-08
I10358 n1_m1_422400_297600 0 1.254455e-07
I10359 n1_m1_422400_302400 0 8.987301e-08
I10360 n1_m1_422400_307200 0 9.074894e-08
I10361 n1_m1_422400_312000 0 1.281767e-07
I10362 n1_m1_422400_316800 0 8.997396e-08
I10363 n1_m1_422400_321600 0 1.296100e-07
I10364 n1_m1_422400_326400 0 8.903413e-08
I10365 n1_m1_422400_331200 0 8.870238e-08
I10366 n1_m1_422400_336000 0 1.237538e-07
I10367 n1_m1_422400_340800 0 8.441825e-08
I10368 n1_m1_422400_345600 0 1.670258e-07
I10369 n1_m1_422400_350400 0 2.014196e-07
I10370 n1_m1_422400_355200 0 1.697954e-07
I10371 n1_m1_422400_360000 0 1.523465e-07
I10372 n1_m1_422400_364800 0 8.732408e-08
I10373 n1_m1_422400_369600 0 1.372877e-07
I10374 n1_m1_422400_374400 0 1.070666e-07
I10375 n1_m1_422400_379200 0 1.267395e-07
I10376 n1_m1_422400_384000 0 2.542541e-07
I10377 n1_m1_422400_388800 0 1.676944e-07
I10378 n1_m1_422400_393600 0 1.722226e-07
I10379 n1_m1_422400_398400 0 9.170271e-08
I10380 n1_m1_422400_403200 0 8.931999e-08
I10381 n1_m1_422400_408000 0 1.284537e-07
I10382 n1_m1_422400_412800 0 7.965247e-08
I10383 n1_m1_422400_417600 0 1.182522e-07
I10384 n1_m1_422400_422400 0 8.265755e-08
I10385 n1_m1_422400_427200 0 8.176633e-08
I10386 n1_m1_422400_432000 0 1.203551e-07
I10387 n1_m1_422400_436800 0 8.018374e-08
I10388 n1_m1_422400_441600 0 1.168484e-07
I10389 n1_m1_422400_446400 0 8.000053e-08
I10390 n1_m1_422400_451200 0 8.810687e-08
I10391 n1_m1_422400_456000 0 1.690384e-07
I10392 n1_m1_422400_460800 0 9.155043e-08
I10393 n1_m1_422400_465600 0 1.248582e-07
I10394 n1_m1_422400_470400 0 8.080372e-08
I10395 n1_m1_422400_475200 0 7.766574e-08
I10396 n1_m1_422400_480000 0 1.176747e-07
I10397 n1_m1_422400_484800 0 8.153383e-08
I10398 n1_m1_422400_489600 0 1.204034e-07
I10399 n1_m1_422400_494400 0 7.709844e-08
I10400 n1_m1_422400_499200 0 7.661408e-08
I10401 n1_m1_422400_504000 0 1.149211e-07
I10402 n1_m1_422400_508800 0 7.661408e-08
I10403 n1_m1_422400_513600 0 1.149211e-07
I10404 n1_m1_422400_518400 0 7.661408e-08
I10405 n1_m1_422400_523200 0 7.661408e-08
I10406 n1_m1_422400_528000 0 1.149211e-07
I10407 n1_m1_422400_532800 0 7.661408e-08
I10408 n1_m1_422400_537600 0 1.149211e-07
I10409 n1_m1_422400_542400 0 7.661408e-08
I10410 n1_m1_422400_547200 0 7.661408e-08
I10411 n1_m1_422400_552000 0 1.110190e-07
I10412 n1_m1_422400_556800 0 7.328303e-08
I10413 n1_m1_427200_0 0 1.515395e-07
I10414 n1_m1_427200_4800 0 1.528373e-07
I10415 n1_m1_427200_9600 0 2.298422e-07
I10416 n1_m1_427200_14400 0 1.532282e-07
I10417 n1_m1_427200_19200 0 1.535565e-07
I10418 n1_m1_427200_24000 0 2.328599e-07
I10419 n1_m1_427200_28800 0 1.554171e-07
I10420 n1_m1_427200_33600 0 2.331257e-07
I10421 n1_m1_427200_38400 0 1.554171e-07
I10422 n1_m1_427200_43200 0 1.579093e-07
I10423 n1_m1_427200_48000 0 2.353181e-07
I10424 n1_m1_427200_52800 0 1.536503e-07
I10425 n1_m1_427200_57600 0 2.313174e-07
I10426 n1_m1_427200_62400 0 1.603559e-07
I10427 n1_m1_427200_67200 0 1.645422e-07
I10428 n1_m1_427200_72000 0 2.479047e-07
I10429 n1_m1_427200_76800 0 1.576061e-07
I10430 n1_m1_427200_81600 0 2.458986e-07
I10431 n1_m1_427200_86400 0 1.751764e-07
I10432 n1_m1_427200_91200 0 1.754184e-07
I10433 n1_m1_427200_96000 0 2.579515e-07
I10434 n1_m1_427200_100800 0 1.727141e-07
I10435 n1_m1_427200_105600 0 2.571324e-07
I10436 n1_m1_427200_110400 0 1.710255e-07
I10437 n1_m1_427200_115200 0 1.712913e-07
I10438 n1_m1_427200_120000 0 2.569237e-07
I10439 n1_m1_427200_124800 0 1.665524e-07
I10440 n1_m1_427200_129600 0 2.498285e-07
I10441 n1_m1_427200_134400 0 1.678345e-07
I10442 n1_m1_427200_139200 0 1.643158e-07
I10443 n1_m1_427200_144000 0 2.418367e-07
I10444 n1_m1_427200_148800 0 1.620636e-07
I10445 n1_m1_427200_153600 0 2.421991e-07
I10446 n1_m1_427200_158400 0 1.726570e-07
I10447 n1_m1_427200_163200 0 1.978601e-07
I10448 n1_m1_427200_168000 0 3.185018e-07
I10449 n1_m1_427200_172800 0 1.935665e-07
I10450 n1_m1_427200_177600 0 2.669984e-07
I10451 n1_m1_427200_182400 0 1.751954e-07
I10452 n1_m1_427200_187200 0 1.721825e-07
I10453 n1_m1_427200_192000 0 2.504777e-07
I10454 n1_m1_427200_196800 0 1.609766e-07
I10455 n1_m1_427200_201600 0 2.398354e-07
I10456 n1_m1_427200_206400 0 1.610786e-07
I10457 n1_m1_427200_211200 0 1.685007e-07
I10458 n1_m1_427200_216000 0 2.832573e-07
I10459 n1_m1_427200_220800 0 2.143875e-07
I10460 n1_m1_427200_225600 0 2.836523e-07
I10461 n1_m1_427200_230400 0 2.325207e-07
I10462 n1_m1_427200_235200 0 2.622853e-07
I10463 n1_m1_427200_240000 0 3.788196e-07
I10464 n1_m1_427200_244800 0 3.078282e-07
I10465 n1_m1_427200_249600 0 6.765968e-07
I10466 n1_m1_427200_254400 0 8.334892e-07
I10467 n1_m1_427200_259200 0 9.408984e-07
I10468 n1_m1_427200_264000 0 1.153592e-06
I10469 n1_m1_427200_268800 0 7.035226e-07
I10470 n1_m1_427200_273600 0 7.905343e-07
I10471 n1_m1_427200_278400 0 2.449271e-07
I10472 n1_m1_427200_283200 0 1.949818e-07
I10473 n1_m1_427200_288000 0 2.694708e-07
I10474 n1_m1_427200_292800 0 1.714252e-07
I10475 n1_m1_427200_297600 0 2.530059e-07
I10476 n1_m1_427200_302400 0 1.702981e-07
I10477 n1_m1_427200_307200 0 1.822287e-07
I10478 n1_m1_427200_312000 0 2.848018e-07
I10479 n1_m1_427200_316800 0 1.766155e-07
I10480 n1_m1_427200_321600 0 2.641799e-07
I10481 n1_m1_427200_326400 0 1.676890e-07
I10482 n1_m1_427200_331200 0 1.625796e-07
I10483 n1_m1_427200_336000 0 2.398354e-07
I10484 n1_m1_427200_340800 0 1.658970e-07
I10485 n1_m1_427200_345600 0 2.578142e-07
I10486 n1_m1_427200_350400 0 1.712056e-07
I10487 n1_m1_427200_355200 0 1.693538e-07
I10488 n1_m1_427200_360000 0 2.560535e-07
I10489 n1_m1_427200_364800 0 1.718698e-07
I10490 n1_m1_427200_369600 0 2.721180e-07
I10491 n1_m1_427200_374400 0 2.086581e-07
I10492 n1_m1_427200_379200 0 2.416505e-07
I10493 n1_m1_427200_384000 0 4.793853e-07
I10494 n1_m1_427200_388800 0 3.076528e-07
I10495 n1_m1_427200_393600 0 3.203883e-07
I10496 n1_m1_427200_398400 0 1.791627e-07
I10497 n1_m1_427200_403200 0 1.720724e-07
I10498 n1_m1_427200_408000 0 2.471725e-07
I10499 n1_m1_427200_412800 0 1.589243e-07
I10500 n1_m1_427200_417600 0 2.326974e-07
I10501 n1_m1_427200_422400 0 1.595150e-07
I10502 n1_m1_427200_427200 0 1.627985e-07
I10503 n1_m1_427200_432000 0 2.449217e-07
I10504 n1_m1_427200_436800 0 1.594266e-07
I10505 n1_m1_427200_441600 0 2.324303e-07
I10506 n1_m1_427200_446400 0 1.575415e-07
I10507 n1_m1_427200_451200 0 1.646027e-07
I10508 n1_m1_427200_456000 0 2.394336e-07
I10509 n1_m1_427200_460800 0 1.597495e-07
I10510 n1_m1_427200_465600 0 2.398354e-07
I10511 n1_m1_427200_470400 0 1.616156e-07
I10512 n1_m1_427200_475200 0 1.636781e-07
I10513 n1_m1_427200_480000 0 2.416654e-07
I10514 n1_m1_427200_484800 0 1.586081e-07
I10515 n1_m1_427200_489600 0 2.320788e-07
I10516 n1_m1_427200_494400 0 1.532282e-07
I10517 n1_m1_427200_499200 0 1.532282e-07
I10518 n1_m1_427200_504000 0 2.298422e-07
I10519 n1_m1_427200_508800 0 1.532282e-07
I10520 n1_m1_427200_513600 0 2.298422e-07
I10521 n1_m1_427200_518400 0 1.532282e-07
I10522 n1_m1_427200_523200 0 1.532282e-07
I10523 n1_m1_427200_528000 0 2.298422e-07
I10524 n1_m1_427200_532800 0 1.532282e-07
I10525 n1_m1_427200_537600 0 2.296703e-07
I10526 n1_m1_427200_542400 0 1.514613e-07
I10527 n1_m1_427200_547200 0 1.510392e-07
I10528 n1_m1_427200_552000 0 2.213188e-07
I10529 n1_m1_427200_556800 0 1.465661e-07
I10530 n1_m1_432000_0 0 2.257675e-07
I10531 n1_m1_432000_4800 0 2.291346e-07
I10532 n1_m1_432000_9600 0 3.519309e-07
I10533 n1_m1_432000_14400 0 2.390961e-07
I10534 n1_m1_432000_19200 0 2.393500e-07
I10535 n1_m1_432000_24000 0 3.596837e-07
I10536 n1_m1_432000_28800 0 2.398354e-07
I10537 n1_m1_432000_33600 0 3.597531e-07
I10538 n1_m1_432000_38400 0 2.428639e-07
I10539 n1_m1_432000_43200 0 2.471712e-07
I10540 n1_m1_432000_48000 0 3.727309e-07
I10541 n1_m1_432000_52800 0 2.373891e-07
I10542 n1_m1_432000_57600 0 3.529996e-07
I10543 n1_m1_432000_62400 0 2.395713e-07
I10544 n1_m1_432000_67200 0 2.406297e-07
I10545 n1_m1_432000_72000 0 3.655501e-07
I10546 n1_m1_432000_76800 0 2.450502e-07
I10547 n1_m1_432000_81600 0 3.818094e-07
I10548 n1_m1_432000_86400 0 2.484009e-07
I10549 n1_m1_432000_91200 0 2.420563e-07
I10550 n1_m1_432000_96000 0 3.653758e-07
I10551 n1_m1_432000_100800 0 2.528265e-07
I10552 n1_m1_432000_105600 0 3.713645e-07
I10553 n1_m1_432000_110400 0 2.502996e-07
I10554 n1_m1_432000_115200 0 2.546762e-07
I10555 n1_m1_432000_120000 0 3.869028e-07
I10556 n1_m1_432000_124800 0 2.531263e-07
I10557 n1_m1_432000_129600 0 3.747764e-07
I10558 n1_m1_432000_134400 0 2.556817e-07
I10559 n1_m1_432000_139200 0 2.498285e-07
I10560 n1_m1_432000_144000 0 3.775042e-07
I10561 n1_m1_432000_148800 0 2.591456e-07
I10562 n1_m1_432000_153600 0 3.750854e-07
I10563 n1_m1_432000_158400 0 2.986165e-07
I10564 n1_m1_432000_163200 0 4.880477e-07
I10565 n1_m1_432000_168000 0 8.992297e-07
I10566 n1_m1_432000_172800 0 4.604574e-07
I10567 n1_m1_432000_177600 0 3.956336e-07
I10568 n1_m1_432000_182400 0 2.571969e-07
I10569 n1_m1_432000_187200 0 2.526205e-07
I10570 n1_m1_432000_192000 0 3.658917e-07
I10571 n1_m1_432000_196800 0 2.398354e-07
I10572 n1_m1_432000_201600 0 3.597531e-07
I10573 n1_m1_432000_206400 0 2.446209e-07
I10574 n1_m1_432000_211200 0 2.698209e-07
I10575 n1_m1_432000_216000 0 4.348882e-07
I10576 n1_m1_432000_220800 0 4.092334e-07
I10577 n1_m1_432000_225600 0 8.314436e-07
I10578 n1_m1_432000_230400 0 5.051594e-07
I10579 n1_m1_432000_235200 0 4.679747e-07
I10580 n1_m1_432000_240000 0 8.749281e-07
I10581 n1_m1_432000_244800 0 8.536916e-07
I10582 n1_m1_432000_249600 0 1.896998e-06
I10583 n1_m1_432000_254400 0 1.851409e-06
I10584 n1_m1_432000_259200 0 1.981155e-06
I10585 n1_m1_432000_264000 0 2.884320e-06
I10586 n1_m1_432000_268800 0 1.814705e-06
I10587 n1_m1_432000_273600 0 2.144368e-06
I10588 n1_m1_432000_278400 0 7.779660e-07
I10589 n1_m1_432000_283200 0 4.206501e-07
I10590 n1_m1_432000_288000 0 4.213975e-07
I10591 n1_m1_432000_292800 0 2.631194e-07
I10592 n1_m1_432000_297600 0 4.078639e-07
I10593 n1_m1_432000_302400 0 2.742923e-07
I10594 n1_m1_432000_307200 0 3.014971e-07
I10595 n1_m1_432000_312000 0 5.710774e-07
I10596 n1_m1_432000_316800 0 4.758560e-07
I10597 n1_m1_432000_321600 0 9.268567e-07
I10598 n1_m1_432000_326400 0 5.293897e-07
I10599 n1_m1_432000_331200 0 3.436417e-07
I10600 n1_m1_432000_336000 0 3.630845e-07
I10601 n1_m1_432000_340800 0 2.398354e-07
I10602 n1_m1_432000_345600 0 3.596756e-07
I10603 n1_m1_432000_350400 0 2.398323e-07
I10604 n1_m1_432000_355200 0 2.438673e-07
I10605 n1_m1_432000_360000 0 3.735732e-07
I10606 n1_m1_432000_364800 0 2.527745e-07
I10607 n1_m1_432000_369600 0 4.250542e-07
I10608 n1_m1_432000_374400 0 4.103755e-07
I10609 n1_m1_432000_379200 0 5.790617e-07
I10610 n1_m1_432000_384000 0 8.218645e-07
I10611 n1_m1_432000_388800 0 3.568877e-07
I10612 n1_m1_432000_393600 0 4.266103e-07
I10613 n1_m1_432000_398400 0 2.566167e-07
I10614 n1_m1_432000_403200 0 2.468561e-07
I10615 n1_m1_432000_408000 0 3.610359e-07
I10616 n1_m1_432000_412800 0 2.380509e-07
I10617 n1_m1_432000_417600 0 3.527579e-07
I10618 n1_m1_432000_422400 0 2.483520e-07
I10619 n1_m1_432000_427200 0 2.547272e-07
I10620 n1_m1_432000_432000 0 3.647976e-07
I10621 n1_m1_432000_436800 0 2.298422e-07
I10622 n1_m1_432000_441600 0 3.452681e-07
I10623 n1_m1_432000_446400 0 2.337793e-07
I10624 n1_m1_432000_451200 0 2.345533e-07
I10625 n1_m1_432000_456000 0 3.539000e-07
I10626 n1_m1_432000_460800 0 2.439040e-07
I10627 n1_m1_432000_465600 0 3.645987e-07
I10628 n1_m1_432000_470400 0 2.380183e-07
I10629 n1_m1_432000_475200 0 2.381223e-07
I10630 n1_m1_432000_480000 0 3.703846e-07
I10631 n1_m1_432000_484800 0 2.461637e-07
I10632 n1_m1_432000_489600 0 3.518299e-07
I10633 n1_m1_432000_494400 0 2.298422e-07
I10634 n1_m1_432000_499200 0 2.298422e-07
I10635 n1_m1_432000_504000 0 3.447634e-07
I10636 n1_m1_432000_508800 0 2.298422e-07
I10637 n1_m1_432000_513600 0 3.447634e-07
I10638 n1_m1_432000_518400 0 2.298422e-07
I10639 n1_m1_432000_523200 0 2.298422e-07
I10640 n1_m1_432000_528000 0 3.447634e-07
I10641 n1_m1_432000_532800 0 2.298422e-07
I10642 n1_m1_432000_537600 0 3.439782e-07
I10643 n1_m1_432000_542400 0 2.217764e-07
I10644 n1_m1_432000_547200 0 2.198491e-07
I10645 n1_m1_432000_552000 0 3.352923e-07
I10646 n1_m1_432000_556800 0 2.245602e-07
I10647 n1_m1_436800_0 0 1.541636e-07
I10648 n1_m1_436800_4800 0 1.569229e-07
I10649 n1_m1_436800_9600 0 2.461168e-07
I10650 n1_m1_436800_14400 0 1.704068e-07
I10651 n1_m1_436800_19200 0 1.696455e-07
I10652 n1_m1_436800_24000 0 2.449706e-07
I10653 n1_m1_436800_28800 0 1.598903e-07
I10654 n1_m1_436800_33600 0 2.398354e-07
I10655 n1_m1_436800_38400 0 1.641730e-07
I10656 n1_m1_436800_43200 0 1.702641e-07
I10657 n1_m1_436800_48000 0 2.590963e-07
I10658 n1_m1_436800_52800 0 1.656169e-07
I10659 n1_m1_436800_57600 0 2.408293e-07
I10660 n1_m1_436800_62400 0 1.598903e-07
I10661 n1_m1_436800_67200 0 1.595415e-07
I10662 n1_m1_436800_72000 0 2.346342e-07
I10663 n1_m1_436800_76800 0 1.557611e-07
I10664 n1_m1_436800_81600 0 2.414057e-07
I10665 n1_m1_436800_86400 0 1.593587e-07
I10666 n1_m1_436800_91200 0 1.570092e-07
I10667 n1_m1_436800_96000 0 2.379836e-07
I10668 n1_m1_436800_100800 0 1.650296e-07
I10669 n1_m1_436800_105600 0 2.421760e-07
I10670 n1_m1_436800_110400 0 1.633892e-07
I10671 n1_m1_436800_115200 0 1.689052e-07
I10672 n1_m1_436800_120000 0 2.576293e-07
I10673 n1_m1_436800_124800 0 1.671234e-07
I10674 n1_m1_436800_129600 0 2.437375e-07
I10675 n1_m1_436800_134400 0 1.639650e-07
I10676 n1_m1_436800_139200 0 1.624599e-07
I10677 n1_m1_436800_144000 0 2.543669e-07
I10678 n1_m1_436800_148800 0 1.756889e-07
I10679 n1_m1_436800_153600 0 2.494676e-07
I10680 n1_m1_436800_158400 0 1.987330e-07
I10681 n1_m1_436800_163200 0 3.470101e-07
I10682 n1_m1_436800_168000 0 6.647941e-07
I10683 n1_m1_436800_172800 0 3.338742e-07
I10684 n1_m1_436800_177600 0 2.585287e-07
I10685 n1_m1_436800_182400 0 1.676903e-07
I10686 n1_m1_436800_187200 0 1.665524e-07
I10687 n1_m1_436800_192000 0 2.476987e-07
I10688 n1_m1_436800_196800 0 1.670812e-07
I10689 n1_m1_436800_201600 0 2.521127e-07
I10690 n1_m1_436800_206400 0 1.685659e-07
I10691 n1_m1_436800_211200 0 1.715809e-07
I10692 n1_m1_436800_216000 0 2.932783e-07
I10693 n1_m1_436800_220800 0 3.694770e-07
I10694 n1_m1_436800_225600 0 1.058461e-06
I10695 n1_m1_436800_230400 0 6.015517e-07
I10696 n1_m1_436800_235200 0 4.773078e-07
I10697 n1_m1_436800_240000 0 1.104079e-06
I10698 n1_m1_436800_244800 0 1.151291e-06
I10699 n1_m1_436800_249600 0 1.968059e-06
I10700 n1_m1_436800_254400 0 1.382628e-06
I10701 n1_m1_436800_259200 0 1.331927e-06
I10702 n1_m1_436800_264000 0 1.722457e-06
I10703 n1_m1_436800_268800 0 1.155989e-06
I10704 n1_m1_436800_273600 0 1.701681e-06
I10705 n1_m1_436800_278400 0 7.589553e-07
I10706 n1_m1_436800_283200 0 4.449436e-07
I10707 n1_m1_436800_288000 0 3.710440e-07
I10708 n1_m1_436800_292800 0 2.012048e-07
I10709 n1_m1_436800_297600 0 3.604567e-07
I10710 n1_m1_436800_302400 0 3.068642e-07
I10711 n1_m1_436800_307200 0 4.181559e-07
I10712 n1_m1_436800_312000 0 8.946812e-07
I10713 n1_m1_436800_316800 0 6.166455e-07
I10714 n1_m1_436800_321600 0 1.022588e-06
I10715 n1_m1_436800_326400 0 4.925286e-07
I10716 n1_m1_436800_331200 0 2.638937e-07
I10717 n1_m1_436800_336000 0 2.474404e-07
I10718 n1_m1_436800_340800 0 1.626380e-07
I10719 n1_m1_436800_345600 0 2.418796e-07
I10720 n1_m1_436800_350400 0 1.624912e-07
I10721 n1_m1_436800_355200 0 1.656169e-07
I10722 n1_m1_436800_360000 0 2.445961e-07
I10723 n1_m1_436800_364800 0 1.629555e-07
I10724 n1_m1_436800_369600 0 2.611765e-07
I10725 n1_m1_436800_374400 0 2.411896e-07
I10726 n1_m1_436800_379200 0 3.476525e-07
I10727 n1_m1_436800_384000 0 4.629680e-07
I10728 n1_m1_436800_388800 0 1.829425e-07
I10729 n1_m1_436800_393600 0 2.612887e-07
I10730 n1_m1_436800_398400 0 1.670282e-07
I10731 n1_m1_436800_403200 0 1.611751e-07
I10732 n1_m1_436800_408000 0 2.407416e-07
I10733 n1_m1_436800_412800 0 1.625884e-07
I10734 n1_m1_436800_417600 0 2.425002e-07
I10735 n1_m1_436800_422400 0 1.691220e-07
I10736 n1_m1_436800_427200 0 1.655884e-07
I10737 n1_m1_436800_432000 0 2.339170e-07
I10738 n1_m1_436800_436800 0 1.557421e-07
I10739 n1_m1_436800_441600 0 2.446749e-07
I10740 n1_m1_436800_446400 0 1.676530e-07
I10741 n1_m1_436800_451200 0 1.681628e-07
I10742 n1_m1_436800_456000 0 2.576728e-07
I10743 n1_m1_436800_460800 0 1.738997e-07
I10744 n1_m1_436800_465600 0 2.513357e-07
I10745 n1_m1_436800_470400 0 1.573206e-07
I10746 n1_m1_436800_475200 0 1.539991e-07
I10747 n1_m1_436800_480000 0 2.453724e-07
I10748 n1_m1_436800_484800 0 1.732144e-07
I10749 n1_m1_436800_489600 0 2.435478e-07
I10750 n1_m1_436800_494400 0 1.539590e-07
I10751 n1_m1_436800_499200 0 1.532282e-07
I10752 n1_m1_436800_504000 0 2.298422e-07
I10753 n1_m1_436800_508800 0 1.532282e-07
I10754 n1_m1_436800_513600 0 2.298422e-07
I10755 n1_m1_436800_518400 0 1.532282e-07
I10756 n1_m1_436800_523200 0 1.532282e-07
I10757 n1_m1_436800_528000 0 2.298422e-07
I10758 n1_m1_436800_532800 0 1.532282e-07
I10759 n1_m1_436800_537600 0 2.293188e-07
I10760 n1_m1_436800_542400 0 1.478509e-07
I10761 n1_m1_436800_547200 0 1.465661e-07
I10762 n1_m1_436800_552000 0 2.276533e-07
I10763 n1_m1_436800_556800 0 1.532282e-07
I10764 n1_m1_441600_0 0 2.374126e-07
I10765 n1_m1_441600_4800 0 2.397385e-07
I10766 n1_m1_441600_9600 0 3.723801e-07
I10767 n1_m1_441600_14400 0 2.521433e-07
I10768 n1_m1_441600_19200 0 2.517843e-07
I10769 n1_m1_441600_24000 0 3.699440e-07
I10770 n1_m1_441600_28800 0 2.398354e-07
I10771 n1_m1_441600_33600 0 3.597531e-07
I10772 n1_m1_441600_38400 0 2.458007e-07
I10773 n1_m1_441600_43200 0 2.546823e-07
I10774 n1_m1_441600_48000 0 3.878766e-07
I10775 n1_m1_441600_52800 0 2.507106e-07
I10776 n1_m1_441600_57600 0 3.620066e-07
I10777 n1_m1_441600_62400 0 2.398354e-07
I10778 n1_m1_441600_67200 0 2.422378e-07
I10779 n1_m1_441600_72000 0 3.803553e-07
I10780 n1_m1_441600_76800 0 2.449380e-07
I10781 n1_m1_441600_81600 0 3.507011e-07
I10782 n1_m1_441600_86400 0 2.305560e-07
I10783 n1_m1_441600_91200 0 2.402902e-07
I10784 n1_m1_441600_96000 0 3.757860e-07
I10785 n1_m1_441600_100800 0 2.442507e-07
I10786 n1_m1_441600_105600 0 3.605597e-07
I10787 n1_m1_441600_110400 0 2.410193e-07
I10788 n1_m1_441600_115200 0 2.436481e-07
I10789 n1_m1_441600_120000 0 3.675997e-07
I10790 n1_m1_441600_124800 0 2.420339e-07
I10791 n1_m1_441600_129600 0 3.597755e-07
I10792 n1_m1_441600_134400 0 2.398354e-07
I10793 n1_m1_441600_139200 0 2.405492e-07
I10794 n1_m1_441600_144000 0 3.795507e-07
I10795 n1_m1_441600_148800 0 2.609535e-07
I10796 n1_m1_441600_153600 0 3.692150e-07
I10797 n1_m1_441600_158400 0 2.563118e-07
I10798 n1_m1_441600_163200 0 3.216466e-07
I10799 n1_m1_441600_168000 0 5.512023e-07
I10800 n1_m1_441600_172800 0 3.137031e-07
I10801 n1_m1_441600_177600 0 3.665443e-07
I10802 n1_m1_441600_182400 0 2.463962e-07
I10803 n1_m1_441600_187200 0 2.491147e-07
I10804 n1_m1_441600_192000 0 3.740035e-07
I10805 n1_m1_441600_196800 0 2.561405e-07
I10806 n1_m1_441600_201600 0 3.877186e-07
I10807 n1_m1_441600_206400 0 2.574916e-07
I10808 n1_m1_441600_211200 0 2.487864e-07
I10809 n1_m1_441600_216000 0 3.752017e-07
I10810 n1_m1_441600_220800 0 3.877298e-07
I10811 n1_m1_441600_225600 0 1.656257e-06
I10812 n1_m1_441600_230400 0 1.617347e-06
I10813 n1_m1_441600_235200 0 1.565891e-06
I10814 n1_m1_441600_240000 0 2.485511e-06
I10815 n1_m1_441600_244800 0 1.876123e-06
I10816 n1_m1_441600_249600 0 2.985599e-06
I10817 n1_m1_441600_254400 0 1.890872e-06
I10818 n1_m1_441600_259200 0 1.523224e-06
I10819 n1_m1_441600_264000 0 1.465440e-06
I10820 n1_m1_441600_268800 0 7.002480e-07
I10821 n1_m1_441600_273600 0 1.048282e-06
I10822 n1_m1_441600_278400 0 6.741087e-07
I10823 n1_m1_441600_283200 0 6.293517e-07
I10824 n1_m1_441600_288000 0 6.470284e-07
I10825 n1_m1_441600_292800 0 3.725586e-07
I10826 n1_m1_441600_297600 0 7.913772e-07
I10827 n1_m1_441600_302400 0 8.949235e-07
I10828 n1_m1_441600_307200 0 1.355641e-06
I10829 n1_m1_441600_312000 0 2.423132e-06
I10830 n1_m1_441600_316800 0 1.394930e-06
I10831 n1_m1_441600_321600 0 1.445663e-06
I10832 n1_m1_441600_326400 0 4.913709e-07
I10833 n1_m1_441600_331200 0 2.902518e-07
I10834 n1_m1_441600_336000 0 3.804114e-07
I10835 n1_m1_441600_340800 0 2.546905e-07
I10836 n1_m1_441600_345600 0 3.661405e-07
I10837 n1_m1_441600_350400 0 2.401270e-07
I10838 n1_m1_441600_355200 0 2.422939e-07
I10839 n1_m1_441600_360000 0 3.628520e-07
I10840 n1_m1_441600_364800 0 2.466062e-07
I10841 n1_m1_441600_369600 0 3.707445e-07
I10842 n1_m1_441600_374400 0 2.604233e-07
I10843 n1_m1_441600_379200 0 2.976630e-07
I10844 n1_m1_441600_384000 0 4.458369e-07
I10845 n1_m1_441600_388800 0 2.609943e-07
I10846 n1_m1_441600_393600 0 3.937563e-07
I10847 n1_m1_441600_398400 0 2.603621e-07
I10848 n1_m1_441600_403200 0 2.565372e-07
I10849 n1_m1_441600_408000 0 3.831625e-07
I10850 n1_m1_441600_412800 0 2.565851e-07
I10851 n1_m1_441600_417600 0 3.791693e-07
I10852 n1_m1_441600_422400 0 2.474077e-07
I10853 n1_m1_441600_427200 0 2.411467e-07
I10854 n1_m1_441600_432000 0 3.609584e-07
I10855 n1_m1_441600_436800 0 2.411039e-07
I10856 n1_m1_441600_441600 0 3.604812e-07
I10857 n1_m1_441600_446400 0 2.598054e-07
I10858 n1_m1_441600_451200 0 2.992375e-07
I10859 n1_m1_441600_456000 0 7.484067e-07
I10860 n1_m1_441600_460800 0 3.802084e-07
I10861 n1_m1_441600_465600 0 4.009962e-07
I10862 n1_m1_441600_470400 0 2.495226e-07
I10863 n1_m1_441600_475200 0 2.403636e-07
I10864 n1_m1_441600_480000 0 3.564870e-07
I10865 n1_m1_441600_484800 0 2.494166e-07
I10866 n1_m1_441600_489600 0 3.588190e-07
I10867 n1_m1_441600_494400 0 2.304031e-07
I10868 n1_m1_441600_499200 0 2.298422e-07
I10869 n1_m1_441600_504000 0 3.447634e-07
I10870 n1_m1_441600_508800 0 2.298422e-07
I10871 n1_m1_441600_513600 0 3.447634e-07
I10872 n1_m1_441600_518400 0 2.298422e-07
I10873 n1_m1_441600_523200 0 2.320897e-07
I10874 n1_m1_441600_528000 0 3.565471e-07
I10875 n1_m1_441600_532800 0 2.335907e-07
I10876 n1_m1_441600_537600 0 3.443555e-07
I10877 n1_m1_441600_542400 0 2.217764e-07
I10878 n1_m1_441600_547200 0 2.198491e-07
I10879 n1_m1_441600_552000 0 3.414799e-07
I10880 n1_m1_441600_556800 0 2.298422e-07
I10881 n1_m1_446400_0 0 1.597924e-07
I10882 n1_m1_446400_4800 0 1.595932e-07
I10883 n1_m1_446400_9600 0 2.405924e-07
I10884 n1_m1_446400_14400 0 1.605565e-07
I10885 n1_m1_446400_19200 0 1.606207e-07
I10886 n1_m1_446400_24000 0 2.409404e-07
I10887 n1_m1_446400_28800 0 1.598903e-07
I10888 n1_m1_446400_33600 0 2.395142e-07
I10889 n1_m1_446400_38400 0 1.601656e-07
I10890 n1_m1_446400_43200 0 1.642682e-07
I10891 n1_m1_446400_48000 0 2.499220e-07
I10892 n1_m1_446400_52800 0 1.617196e-07
I10893 n1_m1_446400_57600 0 2.395536e-07
I10894 n1_m1_446400_62400 0 1.597924e-07
I10895 n1_m1_446400_67200 0 1.593080e-07
I10896 n1_m1_446400_72000 0 2.390985e-07
I10897 n1_m1_446400_76800 0 1.617883e-07
I10898 n1_m1_446400_81600 0 2.390981e-07
I10899 n1_m1_446400_86400 0 1.583675e-07
I10900 n1_m1_446400_91200 0 1.603294e-07
I10901 n1_m1_446400_96000 0 2.434554e-07
I10902 n1_m1_446400_100800 0 1.572356e-07
I10903 n1_m1_446400_105600 0 2.407898e-07
I10904 n1_m1_446400_110400 0 1.655558e-07
I10905 n1_m1_446400_115200 0 1.652621e-07
I10906 n1_m1_446400_120000 0 2.417259e-07
I10907 n1_m1_446400_124800 0 1.603185e-07
I10908 n1_m1_446400_129600 0 2.407654e-07
I10909 n1_m1_446400_134400 0 1.609977e-07
I10910 n1_m1_446400_139200 0 1.658861e-07
I10911 n1_m1_446400_144000 0 2.632873e-07
I10912 n1_m1_446400_148800 0 1.829850e-07
I10913 n1_m1_446400_153600 0 2.688961e-07
I10914 n1_m1_446400_158400 0 1.718188e-07
I10915 n1_m1_446400_163200 0 1.682325e-07
I10916 n1_m1_446400_168000 0 2.502867e-07
I10917 n1_m1_446400_172800 0 1.617971e-07
I10918 n1_m1_446400_177600 0 2.398915e-07
I10919 n1_m1_446400_182400 0 1.605000e-07
I10920 n1_m1_446400_187200 0 1.609847e-07
I10921 n1_m1_446400_192000 0 2.415009e-07
I10922 n1_m1_446400_196800 0 1.614892e-07
I10923 n1_m1_446400_201600 0 2.433942e-07
I10924 n1_m1_446400_206400 0 1.640721e-07
I10925 n1_m1_446400_211200 0 1.552982e-07
I10926 n1_m1_446400_216000 0 2.628587e-07
I10927 n1_m1_446400_220800 0 1.863823e-07
I10928 n1_m1_446400_225600 0 5.832568e-07
I10929 n1_m1_446400_230400 0 6.714351e-07
I10930 n1_m1_446400_235200 0 7.165041e-07
I10931 n1_m1_446400_240000 0 1.284737e-06
I10932 n1_m1_446400_244800 0 1.125844e-06
I10933 n1_m1_446400_249600 0 1.744657e-06
I10934 n1_m1_446400_254400 0 7.722315e-07
I10935 n1_m1_446400_259200 0 3.956346e-07
I10936 n1_m1_446400_264000 0 4.491254e-07
I10937 n1_m1_446400_268800 0 1.819595e-07
I10938 n1_m1_446400_273600 0 3.097163e-07
I10939 n1_m1_446400_278400 0 2.925373e-07
I10940 n1_m1_446400_283200 0 3.436152e-07
I10941 n1_m1_446400_288000 0 5.774567e-07
I10942 n1_m1_446400_292800 0 3.116813e-07
I10943 n1_m1_446400_297600 0 4.123119e-07
I10944 n1_m1_446400_302400 0 3.978140e-07
I10945 n1_m1_446400_307200 0 5.934335e-07
I10946 n1_m1_446400_312000 0 1.178370e-06
I10947 n1_m1_446400_316800 0 8.469017e-07
I10948 n1_m1_446400_321600 0 6.889435e-07
I10949 n1_m1_446400_326400 0 2.086303e-07
I10950 n1_m1_446400_331200 0 1.730554e-07
I10951 n1_m1_446400_336000 0 2.583686e-07
I10952 n1_m1_446400_340800 0 1.654565e-07
I10953 n1_m1_446400_345600 0 2.421372e-07
I10954 n1_m1_446400_350400 0 1.611353e-07
I10955 n1_m1_446400_355200 0 1.610374e-07
I10956 n1_m1_446400_360000 0 2.468619e-07
I10957 n1_m1_446400_364800 0 1.670761e-07
I10958 n1_m1_446400_369600 0 2.534227e-07
I10959 n1_m1_446400_374400 0 1.633715e-07
I10960 n1_m1_446400_379200 0 1.611377e-07
I10961 n1_m1_446400_384000 0 2.561099e-07
I10962 n1_m1_446400_388800 0 1.848697e-07
I10963 n1_m1_446400_393600 0 3.012361e-07
I10964 n1_m1_446400_398400 0 2.059440e-07
I10965 n1_m1_446400_403200 0 1.967024e-07
I10966 n1_m1_446400_408000 0 2.791186e-07
I10967 n1_m1_446400_412800 0 1.782069e-07
I10968 n1_m1_446400_417600 0 2.601799e-07
I10969 n1_m1_446400_422400 0 1.668759e-07
I10970 n1_m1_446400_427200 0 1.615728e-07
I10971 n1_m1_446400_432000 0 2.535403e-07
I10972 n1_m1_446400_436800 0 1.613525e-07
I10973 n1_m1_446400_441600 0 2.379163e-07
I10974 n1_m1_446400_446400 0 2.578778e-07
I10975 n1_m1_446400_451200 0 4.958518e-07
I10976 n1_m1_446400_456000 0 1.254432e-06
I10977 n1_m1_446400_460800 0 4.986319e-07
I10978 n1_m1_446400_465600 0 3.004122e-07
I10979 n1_m1_446400_470400 0 1.691091e-07
I10980 n1_m1_446400_475200 0 1.697930e-07
I10981 n1_m1_446400_480000 0 2.398588e-07
I10982 n1_m1_446400_484800 0 1.582247e-07
I10983 n1_m1_446400_489600 0 2.337205e-07
I10984 n1_m1_446400_494400 0 1.532282e-07
I10985 n1_m1_446400_499200 0 1.532282e-07
I10986 n1_m1_446400_504000 0 2.298422e-07
I10987 n1_m1_446400_508800 0 1.532282e-07
I10988 n1_m1_446400_513600 0 2.298422e-07
I10989 n1_m1_446400_518400 0 1.532282e-07
I10990 n1_m1_446400_523200 0 1.581751e-07
I10991 n1_m1_446400_528000 0 2.532109e-07
I10992 n1_m1_446400_532800 0 1.619358e-07
I10993 n1_m1_446400_537600 0 2.322617e-07
I10994 n1_m1_446400_542400 0 1.478509e-07
I10995 n1_m1_446400_547200 0 1.465661e-07
I10996 n1_m1_446400_552000 0 2.276533e-07
I10997 n1_m1_446400_556800 0 1.532282e-07
I10998 n1_m1_451200_0 0 7.949918e-08
I10999 n1_m1_451200_4800 0 7.834249e-08
I11000 n1_m1_451200_9600 0 1.169911e-07
I11001 n1_m1_451200_14400 0 7.799409e-08
I11002 n1_m1_451200_19200 0 7.828674e-08
I11003 n1_m1_451200_24000 0 1.196808e-07
I11004 n1_m1_451200_28800 0 7.994513e-08
I11005 n1_m1_451200_33600 0 1.184544e-07
I11006 n1_m1_451200_38400 0 7.799409e-08
I11007 n1_m1_451200_43200 0 7.984996e-08
I11008 n1_m1_451200_48000 0 1.199840e-07
I11009 n1_m1_451200_52800 0 7.826023e-08
I11010 n1_m1_451200_57600 0 1.174231e-07
I11011 n1_m1_451200_62400 0 7.949918e-08
I11012 n1_m1_451200_67200 0 7.825275e-08
I11013 n1_m1_451200_72000 0 1.191502e-07
I11014 n1_m1_451200_76800 0 8.189617e-08
I11015 n1_m1_451200_81600 0 1.200849e-07
I11016 n1_m1_451200_86400 0 7.799409e-08
I11017 n1_m1_451200_91200 0 7.902535e-08
I11018 n1_m1_451200_96000 0 1.235081e-07
I11019 n1_m1_451200_100800 0 8.278264e-08
I11020 n1_m1_451200_105600 0 1.256821e-07
I11021 n1_m1_451200_110400 0 8.513850e-08
I11022 n1_m1_451200_115200 0 8.505965e-08
I11023 n1_m1_451200_120000 0 1.252253e-07
I11024 n1_m1_451200_124800 0 8.189617e-08
I11025 n1_m1_451200_129600 0 1.241542e-07
I11026 n1_m1_451200_134400 0 8.498997e-08
I11027 n1_m1_451200_139200 0 8.522722e-08
I11028 n1_m1_451200_144000 0 1.302939e-07
I11029 n1_m1_451200_148800 0 9.215953e-08
I11030 n1_m1_451200_153600 0 1.478067e-07
I11031 n1_m1_451200_158400 0 9.029925e-08
I11032 n1_m1_451200_163200 0 8.394544e-08
I11033 n1_m1_451200_168000 0 1.225122e-07
I11034 n1_m1_451200_172800 0 8.136660e-08
I11035 n1_m1_451200_177600 0 1.199595e-07
I11036 n1_m1_451200_182400 0 7.994513e-08
I11037 n1_m1_451200_187200 0 7.994513e-08
I11038 n1_m1_451200_192000 0 1.198480e-07
I11039 n1_m1_451200_196800 0 7.846791e-08
I11040 n1_m1_451200_201600 0 1.172376e-07
I11041 n1_m1_451200_206400 0 7.868409e-08
I11042 n1_m1_451200_211200 0 7.710830e-08
I11043 n1_m1_451200_216000 0 1.291505e-07
I11044 n1_m1_451200_220800 0 8.280439e-08
I11045 n1_m1_451200_225600 0 1.776672e-07
I11046 n1_m1_451200_230400 0 1.740989e-07
I11047 n1_m1_451200_235200 0 1.835033e-07
I11048 n1_m1_451200_240000 0 4.247258e-07
I11049 n1_m1_451200_244800 0 3.900568e-07
I11050 n1_m1_451200_249600 0 4.963175e-07
I11051 n1_m1_451200_254400 0 2.135606e-07
I11052 n1_m1_451200_259200 0 1.310740e-07
I11053 n1_m1_451200_264000 0 1.625782e-07
I11054 n1_m1_451200_268800 0 8.854399e-08
I11055 n1_m1_451200_273600 0 1.457252e-07
I11056 n1_m1_451200_278400 0 1.118518e-07
I11057 n1_m1_451200_283200 0 1.559222e-07
I11058 n1_m1_451200_288000 0 3.674957e-07
I11059 n1_m1_451200_292800 0 2.195398e-07
I11060 n1_m1_451200_297600 0 2.210473e-07
I11061 n1_m1_451200_302400 0 1.373408e-07
I11062 n1_m1_451200_307200 0 1.699657e-07
I11063 n1_m1_451200_312000 0 3.202299e-07
I11064 n1_m1_451200_316800 0 2.497571e-07
I11065 n1_m1_451200_321600 0 2.197879e-07
I11066 n1_m1_451200_326400 0 9.263302e-08
I11067 n1_m1_451200_331200 0 8.780572e-08
I11068 n1_m1_451200_336000 0 1.268170e-07
I11069 n1_m1_451200_340800 0 8.085199e-08
I11070 n1_m1_451200_345600 0 1.262725e-07
I11071 n1_m1_451200_350400 0 8.561709e-08
I11072 n1_m1_451200_355200 0 8.406951e-08
I11073 n1_m1_451200_360000 0 1.225462e-07
I11074 n1_m1_451200_364800 0 8.159128e-08
I11075 n1_m1_451200_369600 0 1.242511e-07
I11076 n1_m1_451200_374400 0 8.352906e-08
I11077 n1_m1_451200_379200 0 8.384721e-08
I11078 n1_m1_451200_384000 0 1.332657e-07
I11079 n1_m1_451200_388800 0 1.035072e-07
I11080 n1_m1_451200_393600 0 1.826046e-07
I11081 n1_m1_451200_398400 0 1.290084e-07
I11082 n1_m1_451200_403200 0 1.197991e-07
I11083 n1_m1_451200_408000 0 1.512496e-07
I11084 n1_m1_451200_412800 0 9.015105e-08
I11085 n1_m1_451200_417600 0 1.319900e-07
I11086 n1_m1_451200_422400 0 8.303892e-08
I11087 n1_m1_451200_427200 0 8.037069e-08
I11088 n1_m1_451200_432000 0 1.301964e-07
I11089 n1_m1_451200_436800 0 8.122112e-08
I11090 n1_m1_451200_441600 0 1.378972e-07
I11091 n1_m1_451200_446400 0 2.395468e-07
I11092 n1_m1_451200_451200 0 4.419963e-07
I11093 n1_m1_451200_456000 0 8.396108e-07
I11094 n1_m1_451200_460800 0 3.417831e-07
I11095 n1_m1_451200_465600 0 1.628739e-07
I11096 n1_m1_451200_470400 0 8.336251e-08
I11097 n1_m1_451200_475200 0 8.560791e-08
I11098 n1_m1_451200_480000 0 1.204649e-07
I11099 n1_m1_451200_484800 0 7.856512e-08
I11100 n1_m1_451200_489600 0 1.165866e-07
I11101 n1_m1_451200_494400 0 7.661408e-08
I11102 n1_m1_451200_499200 0 7.661408e-08
I11103 n1_m1_451200_504000 0 1.149211e-07
I11104 n1_m1_451200_508800 0 7.661408e-08
I11105 n1_m1_451200_513600 0 1.149211e-07
I11106 n1_m1_451200_518400 0 7.661408e-08
I11107 n1_m1_451200_523200 0 7.985607e-08
I11108 n1_m1_451200_528000 0 1.304401e-07
I11109 n1_m1_451200_532800 0 8.228434e-08
I11110 n1_m1_451200_537600 0 1.164201e-07
I11111 n1_m1_451200_542400 0 7.392545e-08
I11112 n1_m1_451200_547200 0 7.328303e-08
I11113 n1_m1_451200_552000 0 1.138266e-07
I11114 n1_m1_451200_556800 0 7.661408e-08
I11115 n1_m1_456000_0 0 1.533383e-07
I11116 n1_m1_456000_4800 0 1.535106e-07
I11117 n1_m1_456000_9600 0 2.351651e-07
I11118 n1_m1_456000_14400 0 1.534117e-07
I11119 n1_m1_456000_19200 0 1.540205e-07
I11120 n1_m1_456000_24000 0 2.377351e-07
I11121 n1_m1_456000_28800 0 1.598903e-07
I11122 n1_m1_456000_33600 0 2.446178e-07
I11123 n1_m1_456000_38400 0 1.653797e-07
I11124 n1_m1_456000_43200 0 1.621030e-07
I11125 n1_m1_456000_48000 0 2.333636e-07
I11126 n1_m1_456000_52800 0 1.532282e-07
I11127 n1_m1_456000_57600 0 2.298739e-07
I11128 n1_m1_456000_62400 0 1.535847e-07
I11129 n1_m1_456000_67200 0 1.552101e-07
I11130 n1_m1_456000_72000 0 2.391777e-07
I11131 n1_m1_456000_76800 0 1.604864e-07
I11132 n1_m1_456000_81600 0 2.409418e-07
I11133 n1_m1_456000_86400 0 1.597475e-07
I11134 n1_m1_456000_91200 0 1.598230e-07
I11135 n1_m1_456000_96000 0 2.466705e-07
I11136 n1_m1_456000_100800 0 1.728419e-07
I11137 n1_m1_456000_105600 0 3.102004e-07
I11138 n1_m1_456000_110400 0 1.910155e-07
I11139 n1_m1_456000_115200 0 1.781675e-07
I11140 n1_m1_456000_120000 0 2.498734e-07
I11141 n1_m1_456000_124800 0 1.706257e-07
I11142 n1_m1_456000_129600 0 3.977148e-07
I11143 n1_m1_456000_134400 0 4.591699e-07
I11144 n1_m1_456000_139200 0 3.580638e-07
I11145 n1_m1_456000_144000 0 2.854316e-07
I11146 n1_m1_456000_148800 0 1.851175e-07
I11147 n1_m1_456000_153600 0 2.663152e-07
I11148 n1_m1_456000_158400 0 1.655306e-07
I11149 n1_m1_456000_163200 0 1.594814e-07
I11150 n1_m1_456000_168000 0 2.378398e-07
I11151 n1_m1_456000_172800 0 1.589888e-07
I11152 n1_m1_456000_177600 0 2.389217e-07
I11153 n1_m1_456000_182400 0 1.585103e-07
I11154 n1_m1_456000_187200 0 1.560874e-07
I11155 n1_m1_456000_192000 0 2.300513e-07
I11156 n1_m1_456000_196800 0 1.532628e-07
I11157 n1_m1_456000_201600 0 2.363150e-07
I11158 n1_m1_456000_206400 0 1.538335e-07
I11159 n1_m1_456000_211200 0 1.532679e-07
I11160 n1_m1_456000_216000 0 2.324095e-07
I11161 n1_m1_456000_220800 0 1.613308e-07
I11162 n1_m1_456000_225600 0 2.505413e-07
I11163 n1_m1_456000_230400 0 1.682770e-07
I11164 n1_m1_456000_235200 0 1.680751e-07
I11165 n1_m1_456000_240000 0 2.635518e-07
I11166 n1_m1_456000_244800 0 1.833626e-07
I11167 n1_m1_456000_249600 0 2.694375e-07
I11168 n1_m1_456000_254400 0 1.898741e-07
I11169 n1_m1_456000_259200 0 2.028618e-07
I11170 n1_m1_456000_264000 0 3.352576e-07
I11171 n1_m1_456000_268800 0 2.389360e-07
I11172 n1_m1_456000_273600 0 3.622014e-07
I11173 n1_m1_456000_278400 0 2.206105e-07
I11174 n1_m1_456000_283200 0 2.954571e-07
I11175 n1_m1_456000_288000 0 7.886872e-07
I11176 n1_m1_456000_292800 0 5.151417e-07
I11177 n1_m1_456000_297600 0 4.310562e-07
I11178 n1_m1_456000_302400 0 1.846121e-07
I11179 n1_m1_456000_307200 0 1.737794e-07
I11180 n1_m1_456000_312000 0 2.553849e-07
I11181 n1_m1_456000_316800 0 1.656849e-07
I11182 n1_m1_456000_321600 0 2.491453e-07
I11183 n1_m1_456000_326400 0 1.697923e-07
I11184 n1_m1_456000_331200 0 1.710744e-07
I11185 n1_m1_456000_336000 0 2.608077e-07
I11186 n1_m1_456000_340800 0 2.270659e-07
I11187 n1_m1_456000_345600 0 5.647780e-07
I11188 n1_m1_456000_350400 0 4.356269e-07
I11189 n1_m1_456000_355200 0 2.508663e-07
I11190 n1_m1_456000_360000 0 2.587251e-07
I11191 n1_m1_456000_364800 0 1.799588e-07
I11192 n1_m1_456000_369600 0 2.509203e-07
I11193 n1_m1_456000_374400 0 1.607074e-07
I11194 n1_m1_456000_379200 0 1.638841e-07
I11195 n1_m1_456000_384000 0 2.513989e-07
I11196 n1_m1_456000_388800 0 2.556851e-07
I11197 n1_m1_456000_393600 0 7.220867e-07
I11198 n1_m1_456000_398400 0 5.263523e-07
I11199 n1_m1_456000_403200 0 3.855245e-07
I11200 n1_m1_456000_408000 0 3.600665e-07
I11201 n1_m1_456000_412800 0 1.942245e-07
I11202 n1_m1_456000_417600 0 2.796237e-07
I11203 n1_m1_456000_422400 0 1.679446e-07
I11204 n1_m1_456000_427200 0 1.597951e-07
I11205 n1_m1_456000_432000 0 2.516783e-07
I11206 n1_m1_456000_436800 0 1.590385e-07
I11207 n1_m1_456000_441600 0 2.675490e-07
I11208 n1_m1_456000_446400 0 4.021223e-07
I11209 n1_m1_456000_451200 0 1.168237e-06
I11210 n1_m1_456000_456000 0 2.037874e-06
I11211 n1_m1_456000_460800 0 9.923179e-07
I11212 n1_m1_456000_465600 0 4.534765e-07
I11213 n1_m1_456000_470400 0 1.748161e-07
I11214 n1_m1_456000_475200 0 1.698358e-07
I11215 n1_m1_456000_480000 0 2.407130e-07
I11216 n1_m1_456000_484800 0 1.585103e-07
I11217 n1_m1_456000_489600 0 2.338633e-07
I11218 n1_m1_456000_494400 0 1.532282e-07
I11219 n1_m1_456000_499200 0 1.532282e-07
I11220 n1_m1_456000_504000 0 2.298422e-07
I11221 n1_m1_456000_508800 0 1.532282e-07
I11222 n1_m1_456000_513600 0 2.298422e-07
I11223 n1_m1_456000_518400 0 1.532282e-07
I11224 n1_m1_456000_523200 0 1.597121e-07
I11225 n1_m1_456000_528000 0 2.617673e-07
I11226 n1_m1_456000_532800 0 1.680432e-07
I11227 n1_m1_456000_537600 0 2.406576e-07
I11228 n1_m1_456000_542400 0 1.538713e-07
I11229 n1_m1_456000_547200 0 1.481493e-07
I11230 n1_m1_456000_552000 0 2.190986e-07
I11231 n1_m1_456000_556800 0 1.427442e-07
I11232 n1_m1_460800_0 0 1.532282e-07
I11233 n1_m1_460800_4800 0 1.531949e-07
I11234 n1_m1_460800_9600 0 2.288864e-07
I11235 n1_m1_460800_14400 0 1.523601e-07
I11236 n1_m1_460800_19200 0 1.532064e-07
I11237 n1_m1_460800_24000 0 2.327086e-07
I11238 n1_m1_460800_28800 0 1.591867e-07
I11239 n1_m1_460800_33600 0 2.448320e-07
I11240 n1_m1_460800_38400 0 1.625449e-07
I11241 n1_m1_460800_43200 0 1.600799e-07
I11242 n1_m1_460800_48000 0 2.333636e-07
I11243 n1_m1_460800_52800 0 1.532282e-07
I11244 n1_m1_460800_57600 0 2.300846e-07
I11245 n1_m1_460800_62400 0 1.551857e-07
I11246 n1_m1_460800_67200 0 1.590429e-07
I11247 n1_m1_460800_72000 0 2.402307e-07
I11248 n1_m1_460800_76800 0 1.630330e-07
I11249 n1_m1_460800_81600 0 2.479676e-07
I11250 n1_m1_460800_86400 0 1.631737e-07
I11251 n1_m1_460800_91200 0 1.631737e-07
I11252 n1_m1_460800_96000 0 2.503680e-07
I11253 n1_m1_460800_100800 0 1.745302e-07
I11254 n1_m1_460800_105600 0 3.307400e-07
I11255 n1_m1_460800_110400 0 1.923095e-07
I11256 n1_m1_460800_115200 0 1.740387e-07
I11257 n1_m1_460800_120000 0 2.424764e-07
I11258 n1_m1_460800_124800 0 1.644443e-07
I11259 n1_m1_460800_129600 0 3.293192e-07
I11260 n1_m1_460800_134400 0 3.371570e-07
I11261 n1_m1_460800_139200 0 2.837576e-07
I11262 n1_m1_460800_144000 0 2.733624e-07
I11263 n1_m1_460800_148800 0 1.735520e-07
I11264 n1_m1_460800_153600 0 2.486722e-07
I11265 n1_m1_460800_158400 0 1.588600e-07
I11266 n1_m1_460800_163200 0 1.543325e-07
I11267 n1_m1_460800_168000 0 2.304847e-07
I11268 n1_m1_460800_172800 0 1.550514e-07
I11269 n1_m1_460800_177600 0 2.347797e-07
I11270 n1_m1_460800_182400 0 1.536564e-07
I11271 n1_m1_460800_187200 0 1.534545e-07
I11272 n1_m1_460800_192000 0 2.298422e-07
I11273 n1_m1_460800_196800 0 1.532282e-07
I11274 n1_m1_460800_201600 0 2.353701e-07
I11275 n1_m1_460800_206400 0 1.537452e-07
I11276 n1_m1_460800_211200 0 1.532282e-07
I11277 n1_m1_460800_216000 0 2.320312e-07
I11278 n1_m1_460800_220800 0 1.612424e-07
I11279 n1_m1_460800_225600 0 2.518173e-07
I11280 n1_m1_460800_230400 0 1.716917e-07
I11281 n1_m1_460800_235200 0 1.716917e-07
I11282 n1_m1_460800_240000 0 2.578037e-07
I11283 n1_m1_460800_244800 0 1.686876e-07
I11284 n1_m1_460800_249600 0 2.470692e-07
I11285 n1_m1_460800_254400 0 1.736968e-07
I11286 n1_m1_460800_259200 0 1.870978e-07
I11287 n1_m1_460800_264000 0 3.509306e-07
I11288 n1_m1_460800_268800 0 2.995216e-07
I11289 n1_m1_460800_273600 0 5.436962e-07
I11290 n1_m1_460800_278400 0 2.855421e-07
I11291 n1_m1_460800_283200 0 2.152713e-07
I11292 n1_m1_460800_288000 0 4.578969e-07
I11293 n1_m1_460800_292800 0 2.894918e-07
I11294 n1_m1_460800_297600 0 3.045889e-07
I11295 n1_m1_460800_302400 0 1.738881e-07
I11296 n1_m1_460800_307200 0 1.677447e-07
I11297 n1_m1_460800_312000 0 2.423153e-07
I11298 n1_m1_460800_316800 0 1.563930e-07
I11299 n1_m1_460800_321600 0 2.346492e-07
I11300 n1_m1_460800_326400 0 1.580929e-07
I11301 n1_m1_460800_331200 0 1.616346e-07
I11302 n1_m1_460800_336000 0 2.611473e-07
I11303 n1_m1_460800_340800 0 3.721228e-07
I11304 n1_m1_460800_345600 0 1.059907e-06
I11305 n1_m1_460800_350400 0 8.373114e-07
I11306 n1_m1_460800_355200 0 4.596814e-07
I11307 n1_m1_460800_360000 0 3.048663e-07
I11308 n1_m1_460800_364800 0 1.706349e-07
I11309 n1_m1_460800_369600 0 2.416284e-07
I11310 n1_m1_460800_374400 0 1.626509e-07
I11311 n1_m1_460800_379200 0 1.681125e-07
I11312 n1_m1_460800_384000 0 2.536830e-07
I11313 n1_m1_460800_388800 0 1.939621e-07
I11314 n1_m1_460800_393600 0 4.796718e-07
I11315 n1_m1_460800_398400 0 3.825442e-07
I11316 n1_m1_460800_403200 0 3.521355e-07
I11317 n1_m1_460800_408000 0 4.432278e-07
I11318 n1_m1_460800_412800 0 2.210721e-07
I11319 n1_m1_460800_417600 0 2.722465e-07
I11320 n1_m1_460800_422400 0 1.658263e-07
I11321 n1_m1_460800_427200 0 1.594355e-07
I11322 n1_m1_460800_432000 0 2.531660e-07
I11323 n1_m1_460800_436800 0 1.692682e-07
I11324 n1_m1_460800_441600 0 2.583278e-07
I11325 n1_m1_460800_446400 0 2.656796e-07
I11326 n1_m1_460800_451200 0 9.606940e-07
I11327 n1_m1_460800_456000 0 1.855280e-06
I11328 n1_m1_460800_460800 0 7.258528e-07
I11329 n1_m1_460800_465600 0 3.327757e-07
I11330 n1_m1_460800_470400 0 1.661492e-07
I11331 n1_m1_460800_475200 0 1.638875e-07
I11332 n1_m1_460800_480000 0 2.397783e-07
I11333 n1_m1_460800_484800 0 1.644586e-07
I11334 n1_m1_460800_489600 0 2.368374e-07
I11335 n1_m1_460800_494400 0 1.532282e-07
I11336 n1_m1_460800_499200 0 1.532282e-07
I11337 n1_m1_460800_504000 0 2.298422e-07
I11338 n1_m1_460800_508800 0 1.532282e-07
I11339 n1_m1_460800_513600 0 2.298422e-07
I11340 n1_m1_460800_518400 0 1.532282e-07
I11341 n1_m1_460800_523200 0 1.567801e-07
I11342 n1_m1_460800_528000 0 2.482123e-07
I11343 n1_m1_460800_532800 0 1.616897e-07
I11344 n1_m1_460800_537600 0 2.333079e-07
I11345 n1_m1_460800_542400 0 1.522285e-07
I11346 n1_m1_460800_547200 0 1.479182e-07
I11347 n1_m1_460800_552000 0 2.210547e-07
I11348 n1_m1_460800_556800 0 1.473302e-07
I11349 n1_m1_465600_0 0 2.298422e-07
I11350 n1_m1_465600_4800 0 2.293783e-07
I11351 n1_m1_465600_9600 0 3.328991e-07
I11352 n1_m1_465600_14400 0 2.223525e-07
I11353 n1_m1_465600_19200 0 2.291132e-07
I11354 n1_m1_465600_24000 0 3.450795e-07
I11355 n1_m1_465600_28800 0 2.338701e-07
I11356 n1_m1_465600_33600 0 3.648924e-07
I11357 n1_m1_465600_38400 0 2.422827e-07
I11358 n1_m1_465600_43200 0 2.398354e-07
I11359 n1_m1_465600_48000 0 3.500455e-07
I11360 n1_m1_465600_52800 0 2.298422e-07
I11361 n1_m1_465600_57600 0 3.468181e-07
I11362 n1_m1_465600_62400 0 2.387851e-07
I11363 n1_m1_465600_67200 0 2.397691e-07
I11364 n1_m1_465600_72000 0 3.648985e-07
I11365 n1_m1_465600_76800 0 2.565708e-07
I11366 n1_m1_465600_81600 0 4.241293e-07
I11367 n1_m1_465600_86400 0 3.195847e-07
I11368 n1_m1_465600_91200 0 3.304875e-07
I11369 n1_m1_465600_96000 0 4.964501e-07
I11370 n1_m1_465600_100800 0 3.363130e-07
I11371 n1_m1_465600_105600 0 7.224837e-07
I11372 n1_m1_465600_110400 0 3.642551e-07
I11373 n1_m1_465600_115200 0 2.744453e-07
I11374 n1_m1_465600_120000 0 3.679332e-07
I11375 n1_m1_465600_124800 0 2.470876e-07
I11376 n1_m1_465600_129600 0 3.971927e-07
I11377 n1_m1_465600_134400 0 2.860751e-07
I11378 n1_m1_465600_139200 0 2.868745e-07
I11379 n1_m1_465600_144000 0 4.011277e-07
I11380 n1_m1_465600_148800 0 2.454591e-07
I11381 n1_m1_465600_153600 0 3.503707e-07
I11382 n1_m1_465600_158400 0 2.333990e-07
I11383 n1_m1_465600_163200 0 2.327331e-07
I11384 n1_m1_465600_168000 0 3.452793e-07
I11385 n1_m1_465600_172800 0 2.300360e-07
I11386 n1_m1_465600_177600 0 3.453599e-07
I11387 n1_m1_465600_182400 0 2.298422e-07
I11388 n1_m1_465600_187200 0 2.298422e-07
I11389 n1_m1_465600_192000 0 3.447634e-07
I11390 n1_m1_465600_196800 0 2.298422e-07
I11391 n1_m1_465600_201600 0 3.491512e-07
I11392 n1_m1_465600_206400 0 2.330492e-07
I11393 n1_m1_465600_211200 0 2.329829e-07
I11394 n1_m1_465600_216000 0 3.517259e-07
I11395 n1_m1_465600_220800 0 2.407715e-07
I11396 n1_m1_465600_225600 0 3.696065e-07
I11397 n1_m1_465600_230400 0 2.505423e-07
I11398 n1_m1_465600_235200 0 2.505423e-07
I11399 n1_m1_465600_240000 0 3.785575e-07
I11400 n1_m1_465600_244800 0 2.554512e-07
I11401 n1_m1_465600_249600 0 3.794783e-07
I11402 n1_m1_465600_254400 0 2.516446e-07
I11403 n1_m1_465600_259200 0 2.571755e-07
I11404 n1_m1_465600_264000 0 3.965605e-07
I11405 n1_m1_465600_268800 0 2.965322e-07
I11406 n1_m1_465600_273600 0 5.532203e-07
I11407 n1_m1_465600_278400 0 3.304875e-07
I11408 n1_m1_465600_283200 0 2.643798e-07
I11409 n1_m1_465600_288000 0 4.091559e-07
I11410 n1_m1_465600_292800 0 2.692438e-07
I11411 n1_m1_465600_297600 0 3.871445e-07
I11412 n1_m1_465600_302400 0 2.580922e-07
I11413 n1_m1_465600_307200 0 2.512225e-07
I11414 n1_m1_465600_312000 0 3.712707e-07
I11415 n1_m1_465600_316800 0 2.514223e-07
I11416 n1_m1_465600_321600 0 3.773125e-07
I11417 n1_m1_465600_326400 0 2.446097e-07
I11418 n1_m1_465600_331200 0 2.346899e-07
I11419 n1_m1_465600_336000 0 3.583367e-07
I11420 n1_m1_465600_340800 0 4.069125e-07
I11421 n1_m1_465600_345600 0 1.257947e-06
I11422 n1_m1_465600_350400 0 1.385164e-06
I11423 n1_m1_465600_355200 0 8.209376e-07
I11424 n1_m1_465600_360000 0 4.891163e-07
I11425 n1_m1_465600_364800 0 2.514509e-07
I11426 n1_m1_465600_369600 0 3.608411e-07
I11427 n1_m1_465600_374400 0 2.428700e-07
I11428 n1_m1_465600_379200 0 2.469428e-07
I11429 n1_m1_465600_384000 0 3.729226e-07
I11430 n1_m1_465600_388800 0 2.565280e-07
I11431 n1_m1_465600_393600 0 4.329845e-07
I11432 n1_m1_465600_398400 0 3.512620e-07
I11433 n1_m1_465600_403200 0 4.576114e-07
I11434 n1_m1_465600_408000 0 8.060580e-07
I11435 n1_m1_465600_412800 0 3.942702e-07
I11436 n1_m1_465600_417600 0 4.218421e-07
I11437 n1_m1_465600_422400 0 2.572785e-07
I11438 n1_m1_465600_427200 0 2.398293e-07
I11439 n1_m1_465600_432000 0 3.640359e-07
I11440 n1_m1_465600_436800 0 2.492473e-07
I11441 n1_m1_465600_441600 0 3.898763e-07
I11442 n1_m1_465600_446400 0 3.019224e-07
I11443 n1_m1_465600_451200 0 8.402029e-07
I11444 n1_m1_465600_456000 0 1.998562e-06
I11445 n1_m1_465600_460800 0 5.883034e-07
I11446 n1_m1_465600_465600 0 3.999316e-07
I11447 n1_m1_465600_470400 0 2.424785e-07
I11448 n1_m1_465600_475200 0 2.375512e-07
I11449 n1_m1_465600_480000 0 3.583663e-07
I11450 n1_m1_465600_484800 0 2.531283e-07
I11451 n1_m1_465600_489600 0 3.578258e-07
I11452 n1_m1_465600_494400 0 2.298422e-07
I11453 n1_m1_465600_499200 0 2.298422e-07
I11454 n1_m1_465600_504000 0 3.447634e-07
I11455 n1_m1_465600_508800 0 2.298422e-07
I11456 n1_m1_465600_513600 0 3.447634e-07
I11457 n1_m1_465600_518400 0 2.298422e-07
I11458 n1_m1_465600_523200 0 2.327484e-07
I11459 n1_m1_465600_528000 0 3.566481e-07
I11460 n1_m1_465600_532800 0 2.340129e-07
I11461 n1_m1_465600_537600 0 3.460717e-07
I11462 n1_m1_465600_542400 0 2.223270e-07
I11463 n1_m1_465600_547200 0 2.200225e-07
I11464 n1_m1_465600_552000 0 3.412046e-07
I11465 n1_m1_465600_556800 0 2.315513e-07
I11466 n1_m1_470400_0 0 1.532282e-07
I11467 n1_m1_470400_4800 0 1.528951e-07
I11468 n1_m1_470400_9600 0 2.213243e-07
I11469 n1_m1_470400_14400 0 1.478509e-07
I11470 n1_m1_470400_19200 0 1.527047e-07
I11471 n1_m1_470400_24000 0 2.298422e-07
I11472 n1_m1_470400_28800 0 1.546897e-07
I11473 n1_m1_470400_33600 0 2.379081e-07
I11474 n1_m1_470400_38400 0 1.598903e-07
I11475 n1_m1_470400_43200 0 1.584586e-07
I11476 n1_m1_470400_48000 0 2.320054e-07
I11477 n1_m1_470400_52800 0 1.533199e-07
I11478 n1_m1_470400_57600 0 2.339789e-07
I11479 n1_m1_470400_62400 0 1.596856e-07
I11480 n1_m1_470400_67200 0 1.598903e-07
I11481 n1_m1_470400_72000 0 2.442908e-07
I11482 n1_m1_470400_76800 0 1.750227e-07
I11483 n1_m1_470400_81600 0 3.157955e-07
I11484 n1_m1_470400_86400 0 2.818786e-07
I11485 n1_m1_470400_91200 0 3.106956e-07
I11486 n1_m1_470400_96000 0 4.640060e-07
I11487 n1_m1_470400_100800 0 3.006800e-07
I11488 n1_m1_470400_105600 0 5.819455e-07
I11489 n1_m1_470400_110400 0 2.914789e-07
I11490 n1_m1_470400_115200 0 1.945903e-07
I11491 n1_m1_470400_120000 0 2.524410e-07
I11492 n1_m1_470400_124800 0 1.665524e-07
I11493 n1_m1_470400_129600 0 2.481032e-07
I11494 n1_m1_470400_134400 0 1.624776e-07
I11495 n1_m1_470400_139200 0 1.714062e-07
I11496 n1_m1_470400_144000 0 2.593791e-07
I11497 n1_m1_470400_148800 0 1.596911e-07
I11498 n1_m1_470400_153600 0 2.354384e-07
I11499 n1_m1_470400_158400 0 1.619365e-07
I11500 n1_m1_470400_163200 0 1.614708e-07
I11501 n1_m1_470400_168000 0 2.313589e-07
I11502 n1_m1_470400_172800 0 1.532282e-07
I11503 n1_m1_470400_177600 0 2.298422e-07
I11504 n1_m1_470400_182400 0 1.532282e-07
I11505 n1_m1_470400_187200 0 1.532282e-07
I11506 n1_m1_470400_192000 0 2.298422e-07
I11507 n1_m1_470400_196800 0 1.532282e-07
I11508 n1_m1_470400_201600 0 2.376464e-07
I11509 n1_m1_470400_206400 0 1.602390e-07
I11510 n1_m1_470400_211200 0 1.623498e-07
I11511 n1_m1_470400_216000 0 2.470855e-07
I11512 n1_m1_470400_220800 0 1.660235e-07
I11513 n1_m1_470400_225600 0 2.535369e-07
I11514 n1_m1_470400_230400 0 1.677638e-07
I11515 n1_m1_470400_235200 0 1.665524e-07
I11516 n1_m1_470400_240000 0 2.533690e-07
I11517 n1_m1_470400_244800 0 1.717542e-07
I11518 n1_m1_470400_249600 0 2.533241e-07
I11519 n1_m1_470400_254400 0 1.667155e-07
I11520 n1_m1_470400_259200 0 1.664327e-07
I11521 n1_m1_470400_264000 0 2.478381e-07
I11522 n1_m1_470400_268800 0 1.659358e-07
I11523 n1_m1_470400_273600 0 2.534784e-07
I11524 n1_m1_470400_278400 0 1.698834e-07
I11525 n1_m1_470400_283200 0 1.717094e-07
I11526 n1_m1_470400_288000 0 2.564675e-07
I11527 n1_m1_470400_292800 0 1.727195e-07
I11528 n1_m1_470400_297600 0 2.651813e-07
I11529 n1_m1_470400_302400 0 1.731247e-07
I11530 n1_m1_470400_307200 0 1.672186e-07
I11531 n1_m1_470400_312000 0 2.441345e-07
I11532 n1_m1_470400_316800 0 1.698820e-07
I11533 n1_m1_470400_321600 0 2.537095e-07
I11534 n1_m1_470400_326400 0 1.699269e-07
I11535 n1_m1_470400_331200 0 1.649738e-07
I11536 n1_m1_470400_336000 0 2.375512e-07
I11537 n1_m1_470400_340800 0 1.683362e-07
I11538 n1_m1_470400_345600 0 3.747122e-07
I11539 n1_m1_470400_350400 0 5.500558e-07
I11540 n1_m1_470400_355200 0 3.341978e-07
I11541 n1_m1_470400_360000 0 2.794776e-07
I11542 n1_m1_470400_364800 0 1.705530e-07
I11543 n1_m1_470400_369600 0 2.408823e-07
I11544 n1_m1_470400_374400 0 1.598903e-07
I11545 n1_m1_470400_379200 0 1.589725e-07
I11546 n1_m1_470400_384000 0 2.409775e-07
I11547 n1_m1_470400_388800 0 1.639827e-07
I11548 n1_m1_470400_393600 0 2.535138e-07
I11549 n1_m1_470400_398400 0 1.796719e-07
I11550 n1_m1_470400_403200 0 2.350842e-07
I11551 n1_m1_470400_408000 0 4.703527e-07
I11552 n1_m1_470400_412800 0 2.572887e-07
I11553 n1_m1_470400_417600 0 2.825605e-07
I11554 n1_m1_470400_422400 0 1.763130e-07
I11555 n1_m1_470400_427200 0 1.669330e-07
I11556 n1_m1_470400_432000 0 2.371617e-07
I11557 n1_m1_470400_436800 0 1.582560e-07
I11558 n1_m1_470400_441600 0 2.573152e-07
I11559 n1_m1_470400_446400 0 1.815835e-07
I11560 n1_m1_470400_451200 0 3.343148e-07
I11561 n1_m1_470400_456000 0 7.203777e-07
I11562 n1_m1_470400_460800 0 2.101700e-07
I11563 n1_m1_470400_465600 0 2.475321e-07
I11564 n1_m1_470400_470400 0 1.655612e-07
I11565 n1_m1_470400_475200 0 1.578916e-07
I11566 n1_m1_470400_480000 0 2.388361e-07
I11567 n1_m1_470400_484800 0 1.665524e-07
I11568 n1_m1_470400_489600 0 2.365043e-07
I11569 n1_m1_470400_494400 0 1.532282e-07
I11570 n1_m1_470400_499200 0 1.532282e-07
I11571 n1_m1_470400_504000 0 2.298422e-07
I11572 n1_m1_470400_508800 0 1.532282e-07
I11573 n1_m1_470400_513600 0 2.298422e-07
I11574 n1_m1_470400_518400 0 1.532282e-07
I11575 n1_m1_470400_523200 0 1.557339e-07
I11576 n1_m1_470400_528000 0 2.434921e-07
I11577 n1_m1_470400_532800 0 1.624599e-07
I11578 n1_m1_470400_537600 0 2.364928e-07
I11579 n1_m1_470400_542400 0 1.483465e-07
I11580 n1_m1_470400_547200 0 1.465661e-07
I11581 n1_m1_470400_552000 0 2.258328e-07
I11582 n1_m1_470400_556800 0 1.557978e-07
I11583 n1_m1_475200_0 0 1.516864e-07
I11584 n1_m1_475200_4800 0 1.526381e-07
I11585 n1_m1_475200_9600 0 2.238797e-07
I11586 n1_m1_475200_14400 0 1.494641e-07
I11587 n1_m1_475200_19200 0 1.528617e-07
I11588 n1_m1_475200_24000 0 2.307274e-07
I11589 n1_m1_475200_28800 0 1.545130e-07
I11590 n1_m1_475200_33600 0 2.348388e-07
I11591 n1_m1_475200_38400 0 1.598903e-07
I11592 n1_m1_475200_43200 0 1.561785e-07
I11593 n1_m1_475200_48000 0 2.298422e-07
I11594 n1_m1_475200_52800 0 1.534661e-07
I11595 n1_m1_475200_57600 0 2.382174e-07
I11596 n1_m1_475200_62400 0 1.602472e-07
I11597 n1_m1_475200_67200 0 1.614321e-07
I11598 n1_m1_475200_72000 0 2.420386e-07
I11599 n1_m1_475200_76800 0 1.682750e-07
I11600 n1_m1_475200_81600 0 2.850187e-07
I11601 n1_m1_475200_86400 0 2.414628e-07
I11602 n1_m1_475200_91200 0 2.687489e-07
I11603 n1_m1_475200_96000 0 3.975414e-07
I11604 n1_m1_475200_100800 0 2.452745e-07
I11605 n1_m1_475200_105600 0 4.531985e-07
I11606 n1_m1_475200_110400 0 2.448320e-07
I11607 n1_m1_475200_115200 0 1.827127e-07
I11608 n1_m1_475200_120000 0 2.485294e-07
I11609 n1_m1_475200_124800 0 1.645537e-07
I11610 n1_m1_475200_129600 0 2.436994e-07
I11611 n1_m1_475200_134400 0 1.571588e-07
I11612 n1_m1_475200_139200 0 1.622220e-07
I11613 n1_m1_475200_144000 0 2.432378e-07
I11614 n1_m1_475200_148800 0 1.543084e-07
I11615 n1_m1_475200_153600 0 2.391216e-07
I11616 n1_m1_475200_158400 0 1.660289e-07
I11617 n1_m1_475200_163200 0 1.651248e-07
I11618 n1_m1_475200_168000 0 2.320312e-07
I11619 n1_m1_475200_172800 0 1.532282e-07
I11620 n1_m1_475200_177600 0 2.298422e-07
I11621 n1_m1_475200_182400 0 1.532282e-07
I11622 n1_m1_475200_187200 0 1.532282e-07
I11623 n1_m1_475200_192000 0 2.298422e-07
I11624 n1_m1_475200_196800 0 1.532282e-07
I11625 n1_m1_475200_201600 0 2.376464e-07
I11626 n1_m1_475200_206400 0 1.607944e-07
I11627 n1_m1_475200_211200 0 1.660812e-07
I11628 n1_m1_475200_216000 0 2.566477e-07
I11629 n1_m1_475200_220800 0 1.727291e-07
I11630 n1_m1_475200_225600 0 2.568951e-07
I11631 n1_m1_475200_230400 0 1.687508e-07
I11632 n1_m1_475200_235200 0 1.665524e-07
I11633 n1_m1_475200_240000 0 2.479727e-07
I11634 n1_m1_475200_244800 0 1.596999e-07
I11635 n1_m1_475200_249600 0 2.402161e-07
I11636 n1_m1_475200_254400 0 1.658386e-07
I11637 n1_m1_475200_259200 0 1.669188e-07
I11638 n1_m1_475200_264000 0 2.559243e-07
I11639 n1_m1_475200_268800 0 1.712158e-07
I11640 n1_m1_475200_273600 0 2.568237e-07
I11641 n1_m1_475200_278400 0 1.678848e-07
I11642 n1_m1_475200_283200 0 1.664857e-07
I11643 n1_m1_475200_288000 0 2.572758e-07
I11644 n1_m1_475200_292800 0 1.867385e-07
I11645 n1_m1_475200_297600 0 2.820493e-07
I11646 n1_m1_475200_302400 0 1.741471e-07
I11647 n1_m1_475200_307200 0 1.656768e-07
I11648 n1_m1_475200_312000 0 2.431522e-07
I11649 n1_m1_475200_316800 0 1.665714e-07
I11650 n1_m1_475200_321600 0 2.418768e-07
I11651 n1_m1_475200_326400 0 1.656958e-07
I11652 n1_m1_475200_331200 0 1.681893e-07
I11653 n1_m1_475200_336000 0 2.498285e-07
I11654 n1_m1_475200_340800 0 1.710255e-07
I11655 n1_m1_475200_345600 0 2.882117e-07
I11656 n1_m1_475200_350400 0 2.646945e-07
I11657 n1_m1_475200_355200 0 1.956372e-07
I11658 n1_m1_475200_360000 0 2.535117e-07
I11659 n1_m1_475200_364800 0 1.700214e-07
I11660 n1_m1_475200_369600 0 2.380414e-07
I11661 n1_m1_475200_374400 0 1.596618e-07
I11662 n1_m1_475200_379200 0 1.602234e-07
I11663 n1_m1_475200_384000 0 2.363378e-07
I11664 n1_m1_475200_388800 0 1.578916e-07
I11665 n1_m1_475200_393600 0 2.438802e-07
I11666 n1_m1_475200_398400 0 1.652866e-07
I11667 n1_m1_475200_403200 0 1.739853e-07
I11668 n1_m1_475200_408000 0 3.231020e-07
I11669 n1_m1_475200_412800 0 2.015712e-07
I11670 n1_m1_475200_417600 0 2.622724e-07
I11671 n1_m1_475200_422400 0 1.688746e-07
I11672 n1_m1_475200_427200 0 1.703402e-07
I11673 n1_m1_475200_432000 0 2.434044e-07
I11674 n1_m1_475200_436800 0 1.539991e-07
I11675 n1_m1_475200_441600 0 2.439469e-07
I11676 n1_m1_475200_446400 0 1.694884e-07
I11677 n1_m1_475200_451200 0 2.213005e-07
I11678 n1_m1_475200_456000 0 3.985122e-07
I11679 n1_m1_475200_460800 0 1.721390e-07
I11680 n1_m1_475200_465600 0 2.466164e-07
I11681 n1_m1_475200_470400 0 1.673042e-07
I11682 n1_m1_475200_475200 0 1.564926e-07
I11683 n1_m1_475200_480000 0 2.388218e-07
I11684 n1_m1_475200_484800 0 1.653817e-07
I11685 n1_m1_475200_489600 0 2.355050e-07
I11686 n1_m1_475200_494400 0 1.532282e-07
I11687 n1_m1_475200_499200 0 1.532282e-07
I11688 n1_m1_475200_504000 0 2.298422e-07
I11689 n1_m1_475200_508800 0 1.532282e-07
I11690 n1_m1_475200_513600 0 2.298422e-07
I11691 n1_m1_475200_518400 0 1.532282e-07
I11692 n1_m1_475200_523200 0 1.568447e-07
I11693 n1_m1_475200_528000 0 2.508278e-07
I11694 n1_m1_475200_532800 0 1.685510e-07
I11695 n1_m1_475200_537600 0 2.451508e-07
I11696 n1_m1_475200_542400 0 1.495212e-07
I11697 n1_m1_475200_547200 0 1.465661e-07
I11698 n1_m1_475200_552000 0 2.210388e-07
I11699 n1_m1_475200_556800 0 1.517054e-07
I11700 n1_m1_480000_0 0 2.221700e-07
I11701 n1_m1_480000_4800 0 2.280639e-07
I11702 n1_m1_480000_9600 0 3.457889e-07
I11703 n1_m1_480000_14400 0 2.341172e-07
I11704 n1_m1_480000_19200 0 2.343116e-07
I11705 n1_m1_480000_24000 0 3.538966e-07
I11706 n1_m1_480000_28800 0 2.378334e-07
I11707 n1_m1_480000_33600 0 3.556131e-07
I11708 n1_m1_480000_38400 0 2.369598e-07
I11709 n1_m1_480000_43200 0 2.322868e-07
I11710 n1_m1_480000_48000 0 3.447634e-07
I11711 n1_m1_480000_52800 0 2.301991e-07
I11712 n1_m1_480000_57600 0 3.573262e-07
I11713 n1_m1_480000_62400 0 2.416114e-07
I11714 n1_m1_480000_67200 0 2.481147e-07
I11715 n1_m1_480000_72000 0 3.653720e-07
I11716 n1_m1_480000_76800 0 2.417123e-07
I11717 n1_m1_480000_81600 0 3.722476e-07
I11718 n1_m1_480000_86400 0 2.549210e-07
I11719 n1_m1_480000_91200 0 2.596667e-07
I11720 n1_m1_480000_96000 0 3.832482e-07
I11721 n1_m1_480000_100800 0 2.517276e-07
I11722 n1_m1_480000_105600 0 3.838552e-07
I11723 n1_m1_480000_110400 0 2.510610e-07
I11724 n1_m1_480000_115200 0 2.454424e-07
I11725 n1_m1_480000_120000 0 3.589343e-07
I11726 n1_m1_480000_124800 0 2.354099e-07
I11727 n1_m1_480000_129600 0 3.560862e-07
I11728 n1_m1_480000_134400 0 2.424275e-07
I11729 n1_m1_480000_139200 0 2.420957e-07
I11730 n1_m1_480000_144000 0 3.548031e-07
I11731 n1_m1_480000_148800 0 2.343653e-07
I11732 n1_m1_480000_153600 0 3.591616e-07
I11733 n1_m1_480000_158400 0 2.455927e-07
I11734 n1_m1_480000_163200 0 2.476232e-07
I11735 n1_m1_480000_168000 0 3.540216e-07
I11736 n1_m1_480000_172800 0 2.343154e-07
I11737 n1_m1_480000_177600 0 3.514730e-07
I11738 n1_m1_480000_182400 0 2.343154e-07
I11739 n1_m1_480000_187200 0 2.322066e-07
I11740 n1_m1_480000_192000 0 3.447634e-07
I11741 n1_m1_480000_196800 0 2.298422e-07
I11742 n1_m1_480000_201600 0 3.556708e-07
I11743 n1_m1_480000_206400 0 2.365268e-07
I11744 n1_m1_480000_211200 0 2.405529e-07
I11745 n1_m1_480000_216000 0 3.690953e-07
I11746 n1_m1_480000_220800 0 2.484601e-07
I11747 n1_m1_480000_225600 0 3.617500e-07
I11748 n1_m1_480000_230400 0 2.432691e-07
I11749 n1_m1_480000_235200 0 2.453554e-07
I11750 n1_m1_480000_240000 0 3.595818e-07
I11751 n1_m1_480000_244800 0 2.379061e-07
I11752 n1_m1_480000_249600 0 3.646803e-07
I11753 n1_m1_480000_254400 0 2.452432e-07
I11754 n1_m1_480000_259200 0 2.450077e-07
I11755 n1_m1_480000_264000 0 3.635902e-07
I11756 n1_m1_480000_268800 0 2.453710e-07
I11757 n1_m1_480000_273600 0 3.681045e-07
I11758 n1_m1_480000_278400 0 2.448795e-07
I11759 n1_m1_480000_283200 0 2.443758e-07
I11760 n1_m1_480000_288000 0 3.759661e-07
I11761 n1_m1_480000_292800 0 2.839622e-07
I11762 n1_m1_480000_297600 0 4.326367e-07
I11763 n1_m1_480000_302400 0 2.617992e-07
I11764 n1_m1_480000_307200 0 2.468938e-07
I11765 n1_m1_480000_312000 0 3.706704e-07
I11766 n1_m1_480000_316800 0 2.562391e-07
I11767 n1_m1_480000_321600 0 3.644346e-07
I11768 n1_m1_480000_326400 0 2.414860e-07
I11769 n1_m1_480000_331200 0 2.447708e-07
I11770 n1_m1_480000_336000 0 3.644866e-07
I11771 n1_m1_480000_340800 0 2.475920e-07
I11772 n1_m1_480000_345600 0 3.981546e-07
I11773 n1_m1_480000_350400 0 2.697251e-07
I11774 n1_m1_480000_355200 0 2.538448e-07
I11775 n1_m1_480000_360000 0 3.761044e-07
I11776 n1_m1_480000_364800 0 2.502415e-07
I11777 n1_m1_480000_369600 0 3.468351e-07
I11778 n1_m1_480000_374400 0 2.386988e-07
I11779 n1_m1_480000_379200 0 2.497639e-07
I11780 n1_m1_480000_384000 0 3.597174e-07
I11781 n1_m1_480000_388800 0 2.327654e-07
I11782 n1_m1_480000_393600 0 3.568367e-07
I11783 n1_m1_480000_398400 0 2.360883e-07
I11784 n1_m1_480000_403200 0 2.357008e-07
I11785 n1_m1_480000_408000 0 3.629448e-07
I11786 n1_m1_480000_412800 0 2.496949e-07
I11787 n1_m1_480000_417600 0 3.632143e-07
I11788 n1_m1_480000_422400 0 2.408456e-07
I11789 n1_m1_480000_427200 0 2.501888e-07
I11790 n1_m1_480000_432000 0 3.747611e-07
I11791 n1_m1_480000_436800 0 2.371291e-07
I11792 n1_m1_480000_441600 0 3.464500e-07
I11793 n1_m1_480000_446400 0 2.414659e-07
I11794 n1_m1_480000_451200 0 2.381716e-07
I11795 n1_m1_480000_456000 0 3.712958e-07
I11796 n1_m1_480000_460800 0 2.406614e-07
I11797 n1_m1_480000_465600 0 3.670715e-07
I11798 n1_m1_480000_470400 0 2.455288e-07
I11799 n1_m1_480000_475200 0 2.312175e-07
I11800 n1_m1_480000_480000 0 3.618574e-07
I11801 n1_m1_480000_484800 0 2.440033e-07
I11802 n1_m1_480000_489600 0 3.497837e-07
I11803 n1_m1_480000_494400 0 2.298422e-07
I11804 n1_m1_480000_499200 0 2.298422e-07
I11805 n1_m1_480000_504000 0 3.447634e-07
I11806 n1_m1_480000_508800 0 2.298422e-07
I11807 n1_m1_480000_513600 0 3.447634e-07
I11808 n1_m1_480000_518400 0 2.314398e-07
I11809 n1_m1_480000_523200 0 2.373119e-07
I11810 n1_m1_480000_528000 0 3.770657e-07
I11811 n1_m1_480000_532800 0 2.597741e-07
I11812 n1_m1_480000_537600 0 3.736079e-07
I11813 n1_m1_480000_542400 0 2.247590e-07
I11814 n1_m1_480000_547200 0 2.198491e-07
I11815 n1_m1_480000_552000 0 3.315581e-07
I11816 n1_m1_480000_556800 0 2.275581e-07
I11817 n1_m1_484800_0 0 1.480888e-07
I11818 n1_m1_484800_4800 0 1.522336e-07
I11819 n1_m1_484800_9600 0 2.364493e-07
I11820 n1_m1_484800_14400 0 1.635544e-07
I11821 n1_m1_484800_19200 0 1.632070e-07
I11822 n1_m1_484800_24000 0 2.403092e-07
I11823 n1_m1_484800_28800 0 1.598903e-07
I11824 n1_m1_484800_33600 0 2.398354e-07
I11825 n1_m1_484800_38400 0 1.581160e-07
I11826 n1_m1_484800_43200 0 1.571302e-07
I11827 n1_m1_484800_48000 0 2.356954e-07
I11828 n1_m1_484800_52800 0 1.572288e-07
I11829 n1_m1_484800_57600 0 2.400291e-07
I11830 n1_m1_484800_62400 0 1.640901e-07
I11831 n1_m1_484800_67200 0 1.668256e-07
I11832 n1_m1_484800_72000 0 2.523921e-07
I11833 n1_m1_484800_76800 0 1.625102e-07
I11834 n1_m1_484800_81600 0 2.398354e-07
I11835 n1_m1_484800_86400 0 1.598903e-07
I11836 n1_m1_484800_91200 0 1.634117e-07
I11837 n1_m1_484800_96000 0 2.472262e-07
I11838 n1_m1_484800_100800 0 1.636251e-07
I11839 n1_m1_484800_105600 0 2.369088e-07
I11840 n1_m1_484800_110400 0 1.602805e-07
I11841 n1_m1_484800_115200 0 1.633743e-07
I11842 n1_m1_484800_120000 0 2.416138e-07
I11843 n1_m1_484800_124800 0 1.532282e-07
I11844 n1_m1_484800_129600 0 2.316954e-07
I11845 n1_m1_484800_134400 0 1.598903e-07
I11846 n1_m1_484800_139200 0 1.612703e-07
I11847 n1_m1_484800_144000 0 2.434030e-07
I11848 n1_m1_484800_148800 0 1.637923e-07
I11849 n1_m1_484800_153600 0 2.456885e-07
I11850 n1_m1_484800_158400 0 1.642063e-07
I11851 n1_m1_484800_163200 0 1.663396e-07
I11852 n1_m1_484800_168000 0 2.527476e-07
I11853 n1_m1_484800_172800 0 1.684191e-07
I11854 n1_m1_484800_177600 0 2.400862e-07
I11855 n1_m1_484800_182400 0 1.598903e-07
I11856 n1_m1_484800_187200 0 1.567496e-07
I11857 n1_m1_484800_192000 0 2.298422e-07
I11858 n1_m1_484800_196800 0 1.532282e-07
I11859 n1_m1_484800_201600 0 2.325825e-07
I11860 n1_m1_484800_206400 0 1.540140e-07
I11861 n1_m1_484800_211200 0 1.572193e-07
I11862 n1_m1_484800_216000 0 2.432167e-07
I11863 n1_m1_484800_220800 0 1.592200e-07
I11864 n1_m1_484800_225600 0 2.357939e-07
I11865 n1_m1_484800_230400 0 1.585891e-07
I11866 n1_m1_484800_235200 0 1.581622e-07
I11867 n1_m1_484800_240000 0 2.319857e-07
I11868 n1_m1_484800_244800 0 1.657787e-07
I11869 n1_m1_484800_249600 0 2.507687e-07
I11870 n1_m1_484800_254400 0 1.640881e-07
I11871 n1_m1_484800_259200 0 1.635755e-07
I11872 n1_m1_484800_264000 0 2.452500e-07
I11873 n1_m1_484800_268800 0 1.723851e-07
I11874 n1_m1_484800_273600 0 2.699093e-07
I11875 n1_m1_484800_278400 0 1.788296e-07
I11876 n1_m1_484800_283200 0 1.688379e-07
I11877 n1_m1_484800_288000 0 2.499434e-07
I11878 n1_m1_484800_292800 0 1.778113e-07
I11879 n1_m1_484800_297600 0 2.827284e-07
I11880 n1_m1_484800_302400 0 1.749276e-07
I11881 n1_m1_484800_307200 0 1.673960e-07
I11882 n1_m1_484800_312000 0 2.455328e-07
I11883 n1_m1_484800_316800 0 1.655877e-07
I11884 n1_m1_484800_321600 0 2.541031e-07
I11885 n1_m1_484800_326400 0 1.743565e-07
I11886 n1_m1_484800_331200 0 1.702818e-07
I11887 n1_m1_484800_336000 0 2.373126e-07
I11888 n1_m1_484800_340800 0 1.550813e-07
I11889 n1_m1_484800_345600 0 2.516259e-07
I11890 n1_m1_484800_350400 0 1.658508e-07
I11891 n1_m1_484800_355200 0 1.601329e-07
I11892 n1_m1_484800_360000 0 2.450067e-07
I11893 n1_m1_484800_364800 0 1.676061e-07
I11894 n1_m1_484800_369600 0 2.367423e-07
I11895 n1_m1_484800_374400 0 1.613029e-07
I11896 n1_m1_484800_379200 0 1.651588e-07
I11897 n1_m1_484800_384000 0 2.398354e-07
I11898 n1_m1_484800_388800 0 1.589045e-07
I11899 n1_m1_484800_393600 0 2.390264e-07
I11900 n1_m1_484800_398400 0 1.542275e-07
I11901 n1_m1_484800_403200 0 1.533675e-07
I11902 n1_m1_484800_408000 0 2.362229e-07
I11903 n1_m1_484800_412800 0 1.627624e-07
I11904 n1_m1_484800_417600 0 2.440998e-07
I11905 n1_m1_484800_422400 0 1.672213e-07
I11906 n1_m1_484800_427200 0 1.630813e-07
I11907 n1_m1_484800_432000 0 2.406450e-07
I11908 n1_m1_484800_436800 0 1.579270e-07
I11909 n1_m1_484800_441600 0 2.325241e-07
I11910 n1_m1_484800_446400 0 1.732899e-07
I11911 n1_m1_484800_451200 0 1.676700e-07
I11912 n1_m1_484800_456000 0 2.451902e-07
I11913 n1_m1_484800_460800 0 1.607822e-07
I11914 n1_m1_484800_465600 0 2.465716e-07
I11915 n1_m1_484800_470400 0 1.614130e-07
I11916 n1_m1_484800_475200 0 1.552268e-07
I11917 n1_m1_484800_480000 0 2.442609e-07
I11918 n1_m1_484800_484800 0 1.626503e-07
I11919 n1_m1_484800_489600 0 2.331733e-07
I11920 n1_m1_484800_494400 0 1.532282e-07
I11921 n1_m1_484800_499200 0 1.532282e-07
I11922 n1_m1_484800_504000 0 2.298422e-07
I11923 n1_m1_484800_508800 0 1.532282e-07
I11924 n1_m1_484800_513600 0 2.298422e-07
I11925 n1_m1_484800_518400 0 1.542139e-07
I11926 n1_m1_484800_523200 0 1.570473e-07
I11927 n1_m1_484800_528000 0 2.433004e-07
I11928 n1_m1_484800_532800 0 1.675843e-07
I11929 n1_m1_484800_537600 0 2.437687e-07
I11930 n1_m1_484800_542400 0 1.491357e-07
I11931 n1_m1_484800_547200 0 1.465661e-07
I11932 n1_m1_484800_552000 0 2.210388e-07
I11933 n1_m1_484800_556800 0 1.517054e-07
I11934 n1_m1_489600_0 0 2.339347e-07
I11935 n1_m1_489600_4800 0 2.363782e-07
I11936 n1_m1_489600_9600 0 3.675515e-07
I11937 n1_m1_489600_14400 0 2.492102e-07
I11938 n1_m1_489600_19200 0 2.492803e-07
I11939 n1_m1_489600_24000 0 3.701507e-07
I11940 n1_m1_489600_28800 0 2.464975e-07
I11941 n1_m1_489600_33600 0 3.711381e-07
I11942 n1_m1_489600_38400 0 2.483534e-07
I11943 n1_m1_489600_43200 0 2.446416e-07
I11944 n1_m1_489600_48000 0 3.619359e-07
I11945 n1_m1_489600_52800 0 2.410505e-07
I11946 n1_m1_489600_57600 0 3.630440e-07
I11947 n1_m1_489600_62400 0 2.510267e-07
I11948 n1_m1_489600_67200 0 2.547411e-07
I11949 n1_m1_489600_72000 0 3.711541e-07
I11950 n1_m1_489600_76800 0 2.424873e-07
I11951 n1_m1_489600_81600 0 3.597531e-07
I11952 n1_m1_489600_86400 0 2.398354e-07
I11953 n1_m1_489600_91200 0 2.415961e-07
I11954 n1_m1_489600_96000 0 3.647497e-07
I11955 n1_m1_489600_100800 0 2.430237e-07
I11956 n1_m1_489600_105600 0 3.572548e-07
I11957 n1_m1_489600_110400 0 2.401685e-07
I11958 n1_m1_489600_115200 0 2.428095e-07
I11959 n1_m1_489600_120000 0 3.619414e-07
I11960 n1_m1_489600_124800 0 2.340727e-07
I11961 n1_m1_489600_129600 0 3.448065e-07
I11962 n1_m1_489600_134400 0 2.317933e-07
I11963 n1_m1_489600_139200 0 2.361950e-07
I11964 n1_m1_489600_144000 0 3.747190e-07
I11965 n1_m1_489600_148800 0 2.662414e-07
I11966 n1_m1_489600_153600 0 4.006016e-07
I11967 n1_m1_489600_158400 0 2.548717e-07
I11968 n1_m1_489600_163200 0 2.445226e-07
I11969 n1_m1_489600_168000 0 3.739984e-07
I11970 n1_m1_489600_172800 0 2.559223e-07
I11971 n1_m1_489600_177600 0 3.559435e-07
I11972 n1_m1_489600_182400 0 2.331733e-07
I11973 n1_m1_489600_187200 0 2.347436e-07
I11974 n1_m1_489600_192000 0 3.716007e-07
I11975 n1_m1_489600_196800 0 2.602975e-07
I11976 n1_m1_489600_201600 0 3.763349e-07
I11977 n1_m1_489600_206400 0 2.381097e-07
I11978 n1_m1_489600_211200 0 2.391580e-07
I11979 n1_m1_489600_216000 0 3.621324e-07
I11980 n1_m1_489600_220800 0 2.392168e-07
I11981 n1_m1_489600_225600 0 3.588251e-07
I11982 n1_m1_489600_230400 0 2.392168e-07
I11983 n1_m1_489600_235200 0 2.350652e-07
I11984 n1_m1_489600_240000 0 3.455220e-07
I11985 n1_m1_489600_244800 0 2.556368e-07
I11986 n1_m1_489600_249600 0 4.126566e-07
I11987 n1_m1_489600_254400 0 2.930128e-07
I11988 n1_m1_489600_259200 0 2.716812e-07
I11989 n1_m1_489600_264000 0 3.777356e-07
I11990 n1_m1_489600_268800 0 2.518999e-07
I11991 n1_m1_489600_273600 0 3.980911e-07
I11992 n1_m1_489600_278400 0 2.641996e-07
I11993 n1_m1_489600_283200 0 2.489135e-07
I11994 n1_m1_489600_288000 0 3.657683e-07
I11995 n1_m1_489600_292800 0 2.526790e-07
I11996 n1_m1_489600_297600 0 3.957987e-07
I11997 n1_m1_489600_302400 0 2.534838e-07
I11998 n1_m1_489600_307200 0 2.444924e-07
I11999 n1_m1_489600_312000 0 3.622514e-07
I12000 n1_m1_489600_316800 0 2.482966e-07
I12001 n1_m1_489600_321600 0 3.869171e-07
I12002 n1_m1_489600_326400 0 2.625341e-07
I12003 n1_m1_489600_331200 0 2.550637e-07
I12004 n1_m1_489600_336000 0 3.541855e-07
I12005 n1_m1_489600_340800 0 2.298422e-07
I12006 n1_m1_489600_345600 0 3.613544e-07
I12007 n1_m1_489600_350400 0 2.415835e-07
I12008 n1_m1_489600_355200 0 2.482415e-07
I12009 n1_m1_489600_360000 0 3.812604e-07
I12010 n1_m1_489600_364800 0 2.545858e-07
I12011 n1_m1_489600_369600 0 3.524061e-07
I12012 n1_m1_489600_374400 0 2.346485e-07
I12013 n1_m1_489600_379200 0 2.400733e-07
I12014 n1_m1_489600_384000 0 3.602170e-07
I12015 n1_m1_489600_388800 0 2.337919e-07
I12016 n1_m1_489600_393600 0 3.560182e-07
I12017 n1_m1_489600_398400 0 2.363854e-07
I12018 n1_m1_489600_403200 0 2.360047e-07
I12019 n1_m1_489600_408000 0 3.587538e-07
I12020 n1_m1_489600_412800 0 2.417864e-07
I12021 n1_m1_489600_417600 0 3.591345e-07
I12022 n1_m1_489600_422400 0 2.378368e-07
I12023 n1_m1_489600_427200 0 2.339000e-07
I12024 n1_m1_489600_432000 0 3.513925e-07
I12025 n1_m1_489600_436800 0 2.371705e-07
I12026 n1_m1_489600_441600 0 3.549655e-07
I12027 n1_m1_489600_446400 0 2.443258e-07
I12028 n1_m1_489600_451200 0 2.411573e-07
I12029 n1_m1_489600_456000 0 3.556025e-07
I12030 n1_m1_489600_460800 0 2.339744e-07
I12031 n1_m1_489600_465600 0 3.543996e-07
I12032 n1_m1_489600_470400 0 2.339347e-07
I12033 n1_m1_489600_475200 0 2.326546e-07
I12034 n1_m1_489600_480000 0 3.609947e-07
I12035 n1_m1_489600_484800 0 2.405968e-07
I12036 n1_m1_489600_489600 0 3.494506e-07
I12037 n1_m1_489600_494400 0 2.298422e-07
I12038 n1_m1_489600_499200 0 2.298422e-07
I12039 n1_m1_489600_504000 0 3.447634e-07
I12040 n1_m1_489600_508800 0 2.307488e-07
I12041 n1_m1_489600_513600 0 3.530947e-07
I12042 n1_m1_489600_518400 0 2.361067e-07
I12043 n1_m1_489600_523200 0 2.374085e-07
I12044 n1_m1_489600_528000 0 3.966359e-07
I12045 n1_m1_489600_532800 0 3.433718e-07
I12046 n1_m1_489600_537600 0 4.441543e-07
I12047 n1_m1_489600_542400 0 2.262954e-07
I12048 n1_m1_489600_547200 0 2.203175e-07
I12049 n1_m1_489600_552000 0 3.319106e-07
I12050 n1_m1_489600_556800 0 2.231788e-07
I12051 n1_m1_494400_0 0 1.595572e-07
I12052 n1_m1_494400_4800 0 1.596166e-07
I12053 n1_m1_494400_9600 0 2.408568e-07
I12054 n1_m1_494400_14400 0 1.618022e-07
I12055 n1_m1_494400_19200 0 1.657893e-07
I12056 n1_m1_494400_24000 0 2.493289e-07
I12057 n1_m1_494400_28800 0 1.662192e-07
I12058 n1_m1_494400_33600 0 2.616418e-07
I12059 n1_m1_494400_38400 0 1.824224e-07
I12060 n1_m1_494400_43200 0 1.787773e-07
I12061 n1_m1_494400_48000 0 2.589692e-07
I12062 n1_m1_494400_52800 0 1.706516e-07
I12063 n1_m1_494400_57600 0 2.511932e-07
I12064 n1_m1_494400_62400 0 1.718613e-07
I12065 n1_m1_494400_67200 0 1.725241e-07
I12066 n1_m1_494400_72000 0 2.544012e-07
I12067 n1_m1_494400_76800 0 1.637883e-07
I12068 n1_m1_494400_81600 0 2.398354e-07
I12069 n1_m1_494400_86400 0 1.598903e-07
I12070 n1_m1_494400_91200 0 1.598903e-07
I12071 n1_m1_494400_96000 0 2.398354e-07
I12072 n1_m1_494400_100800 0 1.598974e-07
I12073 n1_m1_494400_105600 0 2.402446e-07
I12074 n1_m1_494400_110400 0 1.601686e-07
I12075 n1_m1_494400_115200 0 1.599259e-07
I12076 n1_m1_494400_120000 0 2.377246e-07
I12077 n1_m1_494400_124800 0 1.540609e-07
I12078 n1_m1_494400_129600 0 2.298507e-07
I12079 n1_m1_494400_134400 0 1.532282e-07
I12080 n1_m1_494400_139200 0 1.538230e-07
I12081 n1_m1_494400_144000 0 2.441539e-07
I12082 n1_m1_494400_148800 0 1.774867e-07
I12083 n1_m1_494400_153600 0 2.628543e-07
I12084 n1_m1_494400_158400 0 1.658202e-07
I12085 n1_m1_494400_163200 0 1.559549e-07
I12086 n1_m1_494400_168000 0 2.343120e-07
I12087 n1_m1_494400_172800 0 1.613811e-07
I12088 n1_m1_494400_177600 0 2.358106e-07
I12089 n1_m1_494400_182400 0 1.535613e-07
I12090 n1_m1_494400_187200 0 1.565449e-07
I12091 n1_m1_494400_192000 0 2.477864e-07
I12092 n1_m1_494400_196800 0 1.736427e-07
I12093 n1_m1_494400_201600 0 2.578434e-07
I12094 n1_m1_494400_206400 0 1.606109e-07
I12095 n1_m1_494400_211200 0 1.552057e-07
I12096 n1_m1_494400_216000 0 2.316267e-07
I12097 n1_m1_494400_220800 0 1.544178e-07
I12098 n1_m1_494400_225600 0 2.316267e-07
I12099 n1_m1_494400_230400 0 1.544178e-07
I12100 n1_m1_494400_235200 0 1.540385e-07
I12101 n1_m1_494400_240000 0 2.306570e-07
I12102 n1_m1_494400_244800 0 1.642743e-07
I12103 n1_m1_494400_249600 0 2.630524e-07
I12104 n1_m1_494400_254400 0 1.838653e-07
I12105 n1_m1_494400_259200 0 1.755265e-07
I12106 n1_m1_494400_264000 0 2.434982e-07
I12107 n1_m1_494400_268800 0 1.598291e-07
I12108 n1_m1_494400_273600 0 2.449628e-07
I12109 n1_m1_494400_278400 0 1.644110e-07
I12110 n1_m1_494400_283200 0 1.634633e-07
I12111 n1_m1_494400_288000 0 2.509149e-07
I12112 n1_m1_494400_292800 0 1.672281e-07
I12113 n1_m1_494400_297600 0 2.450563e-07
I12114 n1_m1_494400_302400 0 1.614253e-07
I12115 n1_m1_494400_307200 0 1.606972e-07
I12116 n1_m1_494400_312000 0 2.426430e-07
I12117 n1_m1_494400_316800 0 1.672532e-07
I12118 n1_m1_494400_321600 0 2.516864e-07
I12119 n1_m1_494400_326400 0 1.674089e-07
I12120 n1_m1_494400_331200 0 1.643804e-07
I12121 n1_m1_494400_336000 0 2.343177e-07
I12122 n1_m1_494400_340800 0 1.532282e-07
I12123 n1_m1_494400_345600 0 2.319218e-07
I12124 n1_m1_494400_350400 0 1.606418e-07
I12125 n1_m1_494400_355200 0 1.711516e-07
I12126 n1_m1_494400_360000 0 2.651445e-07
I12127 n1_m1_494400_364800 0 1.705989e-07
I12128 n1_m1_494400_369600 0 2.362987e-07
I12129 n1_m1_494400_374400 0 1.533757e-07
I12130 n1_m1_494400_379200 0 1.582009e-07
I12131 n1_m1_494400_384000 0 2.446892e-07
I12132 n1_m1_494400_388800 0 1.594858e-07
I12133 n1_m1_494400_393600 0 2.344418e-07
I12134 n1_m1_494400_398400 0 1.545178e-07
I12135 n1_m1_494400_403200 0 1.544178e-07
I12136 n1_m1_494400_408000 0 2.316267e-07
I12137 n1_m1_494400_412800 0 1.544773e-07
I12138 n1_m1_494400_417600 0 2.285979e-07
I12139 n1_m1_494400_422400 0 1.477557e-07
I12140 n1_m1_494400_427200 0 1.495538e-07
I12141 n1_m1_494400_432000 0 2.306835e-07
I12142 n1_m1_494400_436800 0 1.544178e-07
I12143 n1_m1_494400_441600 0 2.314993e-07
I12144 n1_m1_494400_446400 0 1.534236e-07
I12145 n1_m1_494400_451200 0 1.533383e-07
I12146 n1_m1_494400_456000 0 2.350917e-07
I12147 n1_m1_494400_460800 0 1.535585e-07
I12148 n1_m1_494400_465600 0 2.298422e-07
I12149 n1_m1_494400_470400 0 1.532282e-07
I12150 n1_m1_494400_475200 0 1.535851e-07
I12151 n1_m1_494400_480000 0 2.316182e-07
I12152 n1_m1_494400_484800 0 1.544178e-07
I12153 n1_m1_494400_489600 0 2.304371e-07
I12154 n1_m1_494400_494400 0 1.532282e-07
I12155 n1_m1_494400_499200 0 1.532258e-07
I12156 n1_m1_494400_504000 0 2.294425e-07
I12157 n1_m1_494400_508800 0 1.531235e-07
I12158 n1_m1_494400_513600 0 2.314418e-07
I12159 n1_m1_494400_518400 0 1.562533e-07
I12160 n1_m1_494400_523200 0 1.596476e-07
I12161 n1_m1_494400_528000 0 2.638730e-07
I12162 n1_m1_494400_532800 0 2.371148e-07
I12163 n1_m1_494400_537600 0 3.079635e-07
I12164 n1_m1_494400_542400 0 1.520817e-07
I12165 n1_m1_494400_547200 0 1.505382e-07
I12166 n1_m1_494400_552000 0 2.333817e-07
I12167 n1_m1_494400_556800 0 1.532893e-07
I12168 n1_m1_499200_0 0 1.546666e-07
I12169 n1_m1_499200_4800 0 1.546948e-07
I12170 n1_m1_499200_9600 0 2.320435e-07
I12171 n1_m1_499200_14400 0 1.559423e-07
I12172 n1_m1_499200_19200 0 1.607944e-07
I12173 n1_m1_499200_24000 0 2.419768e-07
I12174 n1_m1_499200_28800 0 1.613178e-07
I12175 n1_m1_499200_33600 0 2.568594e-07
I12176 n1_m1_499200_38400 0 1.778881e-07
I12177 n1_m1_499200_43200 0 1.752477e-07
I12178 n1_m1_499200_48000 0 2.605086e-07
I12179 n1_m1_499200_52800 0 1.731543e-07
I12180 n1_m1_499200_57600 0 2.583536e-07
I12181 n1_m1_499200_62400 0 1.722705e-07
I12182 n1_m1_499200_67200 0 1.692974e-07
I12183 n1_m1_499200_72000 0 2.585647e-07
I12184 n1_m1_499200_76800 0 1.678460e-07
I12185 n1_m1_499200_81600 0 2.398354e-07
I12186 n1_m1_499200_86400 0 1.598903e-07
I12187 n1_m1_499200_91200 0 1.598903e-07
I12188 n1_m1_499200_96000 0 2.399251e-07
I12189 n1_m1_499200_100800 0 1.600945e-07
I12190 n1_m1_499200_105600 0 2.462337e-07
I12191 n1_m1_499200_110400 0 1.642250e-07
I12192 n1_m1_499200_115200 0 1.604402e-07
I12193 n1_m1_499200_120000 0 2.372198e-07
I12194 n1_m1_499200_124800 0 1.532282e-07
I12195 n1_m1_499200_129600 0 2.298422e-07
I12196 n1_m1_499200_134400 0 1.532560e-07
I12197 n1_m1_499200_139200 0 1.532520e-07
I12198 n1_m1_499200_144000 0 2.376454e-07
I12199 n1_m1_499200_148800 0 1.676428e-07
I12200 n1_m1_499200_153600 0 2.501365e-07
I12201 n1_m1_499200_158400 0 1.566632e-07
I12202 n1_m1_499200_163200 0 1.535864e-07
I12203 n1_m1_499200_168000 0 2.303691e-07
I12204 n1_m1_499200_172800 0 1.560983e-07
I12205 n1_m1_499200_177600 0 2.387361e-07
I12206 n1_m1_499200_182400 0 1.584681e-07
I12207 n1_m1_499200_187200 0 1.592057e-07
I12208 n1_m1_499200_192000 0 2.414771e-07
I12209 n1_m1_499200_196800 0 1.663851e-07
I12210 n1_m1_499200_201600 0 2.514431e-07
I12211 n1_m1_499200_206400 0 1.637019e-07
I12212 n1_m1_499200_211200 0 1.548298e-07
I12213 n1_m1_499200_216000 0 2.298266e-07
I12214 n1_m1_499200_220800 0 1.531806e-07
I12215 n1_m1_499200_225600 0 2.297709e-07
I12216 n1_m1_499200_230400 0 1.532057e-07
I12217 n1_m1_499200_235200 0 1.555463e-07
I12218 n1_m1_499200_240000 0 2.376451e-07
I12219 n1_m1_499200_244800 0 1.567985e-07
I12220 n1_m1_499200_249600 0 2.429139e-07
I12221 n1_m1_499200_254400 0 1.678956e-07
I12222 n1_m1_499200_259200 0 1.631496e-07
I12223 n1_m1_499200_264000 0 2.336152e-07
I12224 n1_m1_499200_268800 0 1.547033e-07
I12225 n1_m1_499200_273600 0 2.359571e-07
I12226 n1_m1_499200_278400 0 1.632213e-07
I12227 n1_m1_499200_283200 0 1.726081e-07
I12228 n1_m1_499200_288000 0 2.963792e-07
I12229 n1_m1_499200_292800 0 1.832409e-07
I12230 n1_m1_499200_297600 0 2.453959e-07
I12231 n1_m1_499200_302400 0 1.652685e-07
I12232 n1_m1_499200_307200 0 1.702875e-07
I12233 n1_m1_499200_312000 0 2.585909e-07
I12234 n1_m1_499200_316800 0 1.757702e-07
I12235 n1_m1_499200_321600 0 2.521657e-07
I12236 n1_m1_499200_326400 0 1.613430e-07
I12237 n1_m1_499200_331200 0 1.587665e-07
I12238 n1_m1_499200_336000 0 2.309231e-07
I12239 n1_m1_499200_340800 0 1.532438e-07
I12240 n1_m1_499200_345600 0 2.314439e-07
I12241 n1_m1_499200_350400 0 1.641836e-07
I12242 n1_m1_499200_355200 0 1.717899e-07
I12243 n1_m1_499200_360000 0 2.613274e-07
I12244 n1_m1_499200_364800 0 1.706608e-07
I12245 n1_m1_499200_369600 0 2.373572e-07
I12246 n1_m1_499200_374400 0 1.555252e-07
I12247 n1_m1_499200_379200 0 1.613043e-07
I12248 n1_m1_499200_384000 0 2.565382e-07
I12249 n1_m1_499200_388800 0 1.722117e-07
I12250 n1_m1_499200_393600 0 2.472422e-07
I12251 n1_m1_499200_398400 0 1.549161e-07
I12252 n1_m1_499200_403200 0 1.533308e-07
I12253 n1_m1_499200_408000 0 2.299252e-07
I12254 n1_m1_499200_412800 0 1.541935e-07
I12255 n1_m1_499200_417600 0 2.312209e-07
I12256 n1_m1_499200_422400 0 1.465661e-07
I12257 n1_m1_499200_427200 0 1.487550e-07
I12258 n1_m1_499200_432000 0 2.298422e-07
I12259 n1_m1_499200_436800 0 1.532282e-07
I12260 n1_m1_499200_441600 0 2.298422e-07
I12261 n1_m1_499200_446400 0 1.532282e-07
I12262 n1_m1_499200_451200 0 1.532598e-07
I12263 n1_m1_499200_456000 0 2.313490e-07
I12264 n1_m1_499200_460800 0 1.533230e-07
I12265 n1_m1_499200_465600 0 2.298198e-07
I12266 n1_m1_499200_470400 0 1.531806e-07
I12267 n1_m1_499200_475200 0 1.531949e-07
I12268 n1_m1_499200_480000 0 2.298419e-07
I12269 n1_m1_499200_484800 0 1.532282e-07
I12270 n1_m1_499200_489600 0 2.298422e-07
I12271 n1_m1_499200_494400 0 1.532282e-07
I12272 n1_m1_499200_499200 0 1.531915e-07
I12273 n1_m1_499200_504000 0 2.236751e-07
I12274 n1_m1_499200_508800 0 1.488597e-07
I12275 n1_m1_499200_513600 0 2.292182e-07
I12276 n1_m1_499200_518400 0 1.537720e-07
I12277 n1_m1_499200_523200 0 1.561459e-07
I12278 n1_m1_499200_528000 0 2.544396e-07
I12279 n1_m1_499200_532800 0 1.975467e-07
I12280 n1_m1_499200_537600 0 2.725238e-07
I12281 n1_m1_499200_542400 0 1.547132e-07
I12282 n1_m1_499200_547200 0 1.489311e-07
I12283 n1_m1_499200_552000 0 2.346495e-07
I12284 n1_m1_499200_556800 0 1.546925e-07
I12285 n1_m1_504000_0 0 2.233814e-07
I12286 n1_m1_504000_4800 0 2.273593e-07
I12287 n1_m1_504000_9600 0 3.412066e-07
I12288 n1_m1_504000_14400 0 2.237668e-07
I12289 n1_m1_504000_19200 0 2.298718e-07
I12290 n1_m1_504000_24000 0 3.464031e-07
I12291 n1_m1_504000_28800 0 2.318409e-07
I12292 n1_m1_504000_33600 0 3.522582e-07
I12293 n1_m1_504000_38400 0 2.408653e-07
I12294 n1_m1_504000_43200 0 2.432636e-07
I12295 n1_m1_504000_48000 0 3.759970e-07
I12296 n1_m1_504000_52800 0 2.668067e-07
I12297 n1_m1_504000_57600 0 4.411085e-07
I12298 n1_m1_504000_62400 0 3.060134e-07
I12299 n1_m1_504000_67200 0 3.019193e-07
I12300 n1_m1_504000_72000 0 4.066943e-07
I12301 n1_m1_504000_76800 0 2.549617e-07
I12302 n1_m1_504000_81600 0 3.617905e-07
I12303 n1_m1_504000_86400 0 2.398354e-07
I12304 n1_m1_504000_91200 0 2.398354e-07
I12305 n1_m1_504000_96000 0 3.736996e-07
I12306 n1_m1_504000_100800 0 2.554298e-07
I12307 n1_m1_504000_105600 0 3.763702e-07
I12308 n1_m1_504000_110400 0 2.481868e-07
I12309 n1_m1_504000_115200 0 2.400913e-07
I12310 n1_m1_504000_120000 0 3.494285e-07
I12311 n1_m1_504000_124800 0 2.298422e-07
I12312 n1_m1_504000_129600 0 3.447634e-07
I12313 n1_m1_504000_134400 0 2.345247e-07
I12314 n1_m1_504000_139200 0 2.331971e-07
I12315 n1_m1_504000_144000 0 3.462736e-07
I12316 n1_m1_504000_148800 0 2.386209e-07
I12317 n1_m1_504000_153600 0 3.587589e-07
I12318 n1_m1_504000_158400 0 2.306835e-07
I12319 n1_m1_504000_163200 0 2.298422e-07
I12320 n1_m1_504000_168000 0 3.452222e-07
I12321 n1_m1_504000_172800 0 2.309721e-07
I12322 n1_m1_504000_177600 0 3.526376e-07
I12323 n1_m1_504000_182400 0 2.507442e-07
I12324 n1_m1_504000_187200 0 2.583941e-07
I12325 n1_m1_504000_192000 0 3.802043e-07
I12326 n1_m1_504000_196800 0 2.439142e-07
I12327 n1_m1_504000_201600 0 3.612459e-07
I12328 n1_m1_504000_206400 0 2.392705e-07
I12329 n1_m1_504000_211200 0 2.322865e-07
I12330 n1_m1_504000_216000 0 3.427882e-07
I12331 n1_m1_504000_220800 0 2.231326e-07
I12332 n1_m1_504000_225600 0 3.346988e-07
I12333 n1_m1_504000_230400 0 2.273582e-07
I12334 n1_m1_504000_235200 0 2.385240e-07
I12335 n1_m1_504000_240000 0 3.724056e-07
I12336 n1_m1_504000_244800 0 2.341373e-07
I12337 n1_m1_504000_249600 0 3.469170e-07
I12338 n1_m1_504000_254400 0 2.333827e-07
I12339 n1_m1_504000_259200 0 2.319836e-07
I12340 n1_m1_504000_264000 0 3.451488e-07
I12341 n1_m1_504000_268800 0 2.298422e-07
I12342 n1_m1_504000_273600 0 3.506165e-07
I12343 n1_m1_504000_278400 0 2.448320e-07
I12344 n1_m1_504000_283200 0 3.406723e-07
I12345 n1_m1_504000_288000 0 7.915914e-07
I12346 n1_m1_504000_292800 0 3.849358e-07
I12347 n1_m1_504000_297600 0 4.069340e-07
I12348 n1_m1_504000_302400 0 3.025984e-07
I12349 n1_m1_504000_307200 0 4.174115e-07
I12350 n1_m1_504000_312000 0 6.394948e-07
I12351 n1_m1_504000_316800 0 2.767998e-07
I12352 n1_m1_504000_321600 0 3.778264e-07
I12353 n1_m1_504000_326400 0 2.347817e-07
I12354 n1_m1_504000_331200 0 2.302807e-07
I12355 n1_m1_504000_336000 0 3.511019e-07
I12356 n1_m1_504000_340800 0 2.324690e-07
I12357 n1_m1_504000_345600 0 3.462165e-07
I12358 n1_m1_504000_350400 0 2.400240e-07
I12359 n1_m1_504000_355200 0 2.490933e-07
I12360 n1_m1_504000_360000 0 3.827628e-07
I12361 n1_m1_504000_364800 0 2.484693e-07
I12362 n1_m1_504000_369600 0 3.541651e-07
I12363 n1_m1_504000_374400 0 2.336988e-07
I12364 n1_m1_504000_379200 0 2.392644e-07
I12365 n1_m1_504000_384000 0 3.928375e-07
I12366 n1_m1_504000_388800 0 2.776360e-07
I12367 n1_m1_504000_393600 0 4.012827e-07
I12368 n1_m1_504000_398400 0 2.560885e-07
I12369 n1_m1_504000_403200 0 2.483724e-07
I12370 n1_m1_504000_408000 0 3.600549e-07
I12371 n1_m1_504000_412800 0 2.370373e-07
I12372 n1_m1_504000_417600 0 3.489319e-07
I12373 n1_m1_504000_422400 0 2.211339e-07
I12374 n1_m1_504000_427200 0 2.239952e-07
I12375 n1_m1_504000_432000 0 3.447634e-07
I12376 n1_m1_504000_436800 0 2.298422e-07
I12377 n1_m1_504000_441600 0 3.449010e-07
I12378 n1_m1_504000_446400 0 2.309160e-07
I12379 n1_m1_504000_451200 0 2.310995e-07
I12380 n1_m1_504000_456000 0 3.451121e-07
I12381 n1_m1_504000_460800 0 2.298422e-07
I12382 n1_m1_504000_465600 0 3.409945e-07
I12383 n1_m1_504000_470400 0 2.218477e-07
I12384 n1_m1_504000_475200 0 2.242461e-07
I12385 n1_m1_504000_480000 0 3.447063e-07
I12386 n1_m1_504000_484800 0 2.298422e-07
I12387 n1_m1_504000_489600 0 3.434785e-07
I12388 n1_m1_504000_494400 0 2.286217e-07
I12389 n1_m1_504000_499200 0 2.295435e-07
I12390 n1_m1_504000_504000 0 3.426128e-07
I12391 n1_m1_504000_508800 0 2.295200e-07
I12392 n1_m1_504000_513600 0 3.482192e-07
I12393 n1_m1_504000_518400 0 2.352671e-07
I12394 n1_m1_504000_523200 0 2.406002e-07
I12395 n1_m1_504000_528000 0 3.749722e-07
I12396 n1_m1_504000_532800 0 2.640473e-07
I12397 n1_m1_504000_537600 0 3.739586e-07
I12398 n1_m1_504000_542400 0 2.266220e-07
I12399 n1_m1_504000_547200 0 2.206465e-07
I12400 n1_m1_504000_552000 0 3.340993e-07
I12401 n1_m1_504000_556800 0 2.223046e-07
I12402 n1_m1_508800_0 0 7.328303e-08
I12403 n1_m1_508800_4800 0 7.323307e-08
I12404 n1_m1_508800_9600 0 1.086469e-07
I12405 n1_m1_508800_14400 0 7.247645e-08
I12406 n1_m1_508800_19200 0 7.320452e-08
I12407 n1_m1_508800_24000 0 1.109572e-07
I12408 n1_m1_508800_28800 0 7.597167e-08
I12409 n1_m1_508800_33600 0 1.149211e-07
I12410 n1_m1_508800_38400 0 7.661408e-08
I12411 n1_m1_508800_43200 0 7.791319e-08
I12412 n1_m1_508800_48000 0 1.279289e-07
I12413 n1_m1_508800_52800 0 1.100126e-07
I12414 n1_m1_508800_57600 0 2.516463e-07
I12415 n1_m1_508800_62400 0 2.008645e-07
I12416 n1_m1_508800_67200 0 1.931650e-07
I12417 n1_m1_508800_72000 0 1.619555e-07
I12418 n1_m1_508800_76800 0 9.051407e-08
I12419 n1_m1_508800_81600 0 1.266988e-07
I12420 n1_m1_508800_86400 0 7.971671e-08
I12421 n1_m1_508800_91200 0 7.894581e-08
I12422 n1_m1_508800_96000 0 1.207671e-07
I12423 n1_m1_508800_100800 0 8.311914e-08
I12424 n1_m1_508800_105600 0 1.250047e-07
I12425 n1_m1_508800_110400 0 8.272893e-08
I12426 n1_m1_508800_115200 0 8.030203e-08
I12427 n1_m1_508800_120000 0 1.186329e-07
I12428 n1_m1_508800_124800 0 7.661408e-08
I12429 n1_m1_508800_129600 0 1.149211e-07
I12430 n1_m1_508800_134400 0 7.797981e-08
I12431 n1_m1_508800_139200 0 7.661408e-08
I12432 n1_m1_508800_144000 0 1.135554e-07
I12433 n1_m1_508800_148800 0 7.661408e-08
I12434 n1_m1_508800_153600 0 1.149211e-07
I12435 n1_m1_508800_158400 0 7.661408e-08
I12436 n1_m1_508800_163200 0 7.661408e-08
I12437 n1_m1_508800_168000 0 1.157539e-07
I12438 n1_m1_508800_172800 0 7.740877e-08
I12439 n1_m1_508800_177600 0 1.158276e-07
I12440 n1_m1_508800_182400 0 8.784447e-08
I12441 n1_m1_508800_187200 0 9.274111e-08
I12442 n1_m1_508800_192000 0 1.366324e-07
I12443 n1_m1_508800_196800 0 8.312866e-08
I12444 n1_m1_508800_201600 0 1.163440e-07
I12445 n1_m1_508800_206400 0 7.706615e-08
I12446 n1_m1_508800_211200 0 7.918375e-08
I12447 n1_m1_508800_216000 0 1.155160e-07
I12448 n1_m1_508800_220800 0 7.661408e-08
I12449 n1_m1_508800_225600 0 1.155350e-07
I12450 n1_m1_508800_230400 0 7.884588e-08
I12451 n1_m1_508800_235200 0 8.142031e-08
I12452 n1_m1_508800_240000 0 1.266702e-07
I12453 n1_m1_508800_244800 0 7.735643e-08
I12454 n1_m1_508800_249600 0 1.140884e-07
I12455 n1_m1_508800_254400 0 7.661408e-08
I12456 n1_m1_508800_259200 0 7.661408e-08
I12457 n1_m1_508800_264000 0 1.149211e-07
I12458 n1_m1_508800_268800 0 7.661408e-08
I12459 n1_m1_508800_273600 0 1.168722e-07
I12460 n1_m1_508800_278400 0 8.061134e-08
I12461 n1_m1_508800_283200 0 1.070836e-07
I12462 n1_m1_508800_288000 0 2.451603e-07
I12463 n1_m1_508800_292800 0 1.261134e-07
I12464 n1_m1_508800_297600 0 1.388904e-07
I12465 n1_m1_508800_302400 0 1.137386e-07
I12466 n1_m1_508800_307200 0 1.573491e-07
I12467 n1_m1_508800_312000 0 2.357691e-07
I12468 n1_m1_508800_316800 0 8.937199e-08
I12469 n1_m1_508800_321600 0 1.212454e-07
I12470 n1_m1_508800_326400 0 7.604305e-08
I12471 n1_m1_508800_331200 0 7.518173e-08
I12472 n1_m1_508800_336000 0 1.167699e-07
I12473 n1_m1_508800_340800 0 7.738022e-08
I12474 n1_m1_508800_345600 0 1.149211e-07
I12475 n1_m1_508800_350400 0 7.683060e-08
I12476 n1_m1_508800_355200 0 7.852943e-08
I12477 n1_m1_508800_360000 0 1.184187e-07
I12478 n1_m1_508800_364800 0 7.849612e-08
I12479 n1_m1_508800_369600 0 1.151043e-07
I12480 n1_m1_508800_374400 0 7.661408e-08
I12481 n1_m1_508800_379200 0 7.661408e-08
I12482 n1_m1_508800_384000 0 1.226658e-07
I12483 n1_m1_508800_388800 0 8.758274e-08
I12484 n1_m1_508800_393600 0 1.329659e-07
I12485 n1_m1_508800_398400 0 8.875575e-08
I12486 n1_m1_508800_403200 0 8.690226e-08
I12487 n1_m1_508800_408000 0 1.229918e-07
I12488 n1_m1_508800_412800 0 7.594787e-08
I12489 n1_m1_508800_417600 0 1.139218e-07
I12490 n1_m1_508800_422400 0 7.661408e-08
I12491 n1_m1_508800_427200 0 7.661408e-08
I12492 n1_m1_508800_432000 0 1.149211e-07
I12493 n1_m1_508800_436800 0 7.661408e-08
I12494 n1_m1_508800_441600 0 1.152780e-07
I12495 n1_m1_508800_446400 0 7.939789e-08
I12496 n1_m1_508800_451200 0 7.987375e-08
I12497 n1_m1_508800_456000 0 1.158253e-07
I12498 n1_m1_508800_460800 0 7.661408e-08
I12499 n1_m1_508800_465600 0 1.133508e-07
I12500 n1_m1_508800_470400 0 7.328303e-08
I12501 n1_m1_508800_475200 0 7.428235e-08
I12502 n1_m1_508800_480000 0 1.148973e-07
I12503 n1_m1_508800_484800 0 7.661408e-08
I12504 n1_m1_508800_489600 0 1.115901e-07
I12505 n1_m1_508800_494400 0 7.344959e-08
I12506 n1_m1_508800_499200 0 7.588363e-08
I12507 n1_m1_508800_504000 0 1.167627e-07
I12508 n1_m1_508800_508800 0 8.118238e-08
I12509 n1_m1_508800_513600 0 1.260088e-07
I12510 n1_m1_508800_518400 0 8.510825e-08
I12511 n1_m1_508800_523200 0 8.624557e-08
I12512 n1_m1_508800_528000 0 1.287973e-07
I12513 n1_m1_508800_532800 0 8.660722e-08
I12514 n1_m1_508800_537600 0 1.231774e-07
I12515 n1_m1_508800_542400 0 7.717322e-08
I12516 n1_m1_508800_547200 0 7.484863e-08
I12517 n1_m1_508800_552000 0 1.112451e-07
I12518 n1_m1_508800_556800 0 7.351145e-08
I12519 n1_m1_513600_0 0 2.198491e-07
I12520 n1_m1_513600_4800 0 2.193899e-07
I12521 n1_m1_513600_9600 0 3.180310e-07
I12522 n1_m1_513600_14400 0 2.118672e-07
I12523 n1_m1_513600_19200 0 2.168515e-07
I12524 n1_m1_513600_24000 0 3.310802e-07
I12525 n1_m1_513600_28800 0 2.258348e-07
I12526 n1_m1_513600_33600 0 3.491889e-07
I12527 n1_m1_513600_38400 0 2.319496e-07
I12528 n1_m1_513600_43200 0 2.286492e-07
I12529 n1_m1_513600_48000 0 3.728288e-07
I12530 n1_m1_513600_52800 0 3.194743e-07
I12531 n1_m1_513600_57600 0 7.225293e-07
I12532 n1_m1_513600_62400 0 5.963713e-07
I12533 n1_m1_513600_67200 0 5.780118e-07
I12534 n1_m1_513600_72000 0 4.936802e-07
I12535 n1_m1_513600_76800 0 2.740004e-07
I12536 n1_m1_513600_81600 0 3.826109e-07
I12537 n1_m1_513600_86400 0 2.365982e-07
I12538 n1_m1_513600_91200 0 2.306512e-07
I12539 n1_m1_513600_96000 0 3.467916e-07
I12540 n1_m1_513600_100800 0 2.324779e-07
I12541 n1_m1_513600_105600 0 3.699767e-07
I12542 n1_m1_513600_110400 0 2.486715e-07
I12543 n1_m1_513600_115200 0 2.435403e-07
I12544 n1_m1_513600_120000 0 3.603241e-07
I12545 n1_m1_513600_124800 0 2.327926e-07
I12546 n1_m1_513600_129600 0 3.472079e-07
I12547 n1_m1_513600_134400 0 2.303161e-07
I12548 n1_m1_513600_139200 0 2.298422e-07
I12549 n1_m1_513600_144000 0 3.415921e-07
I12550 n1_m1_513600_148800 0 2.268919e-07
I12551 n1_m1_513600_153600 0 3.409068e-07
I12552 n1_m1_513600_158400 0 2.296104e-07
I12553 n1_m1_513600_163200 0 2.298422e-07
I12554 n1_m1_513600_168000 0 3.450523e-07
I12555 n1_m1_513600_172800 0 2.277192e-07
I12556 n1_m1_513600_177600 0 3.414768e-07
I12557 n1_m1_513600_182400 0 2.527531e-07
I12558 n1_m1_513600_187200 0 2.690527e-07
I12559 n1_m1_513600_192000 0 4.013725e-07
I12560 n1_m1_513600_196800 0 2.504030e-07
I12561 n1_m1_513600_201600 0 3.500951e-07
I12562 n1_m1_513600_206400 0 2.311985e-07
I12563 n1_m1_513600_211200 0 2.378252e-07
I12564 n1_m1_513600_216000 0 3.504465e-07
I12565 n1_m1_513600_220800 0 2.320761e-07
I12566 n1_m1_513600_225600 0 3.486981e-07
I12567 n1_m1_513600_230400 0 2.365037e-07
I12568 n1_m1_513600_235200 0 2.413106e-07
I12569 n1_m1_513600_240000 0 3.706742e-07
I12570 n1_m1_513600_244800 0 2.362460e-07
I12571 n1_m1_513600_249600 0 3.455281e-07
I12572 n1_m1_513600_254400 0 2.298422e-07
I12573 n1_m1_513600_259200 0 2.298422e-07
I12574 n1_m1_513600_264000 0 3.447634e-07
I12575 n1_m1_513600_268800 0 2.298422e-07
I12576 n1_m1_513600_273600 0 3.488884e-07
I12577 n1_m1_513600_278400 0 2.341726e-07
I12578 n1_m1_513600_283200 0 2.513914e-07
I12579 n1_m1_513600_288000 0 4.489979e-07
I12580 n1_m1_513600_292800 0 2.764579e-07
I12581 n1_m1_513600_297600 0 3.792030e-07
I12582 n1_m1_513600_302400 0 2.715758e-07
I12583 n1_m1_513600_307200 0 3.150062e-07
I12584 n1_m1_513600_312000 0 4.862768e-07
I12585 n1_m1_513600_316800 0 2.537027e-07
I12586 n1_m1_513600_321600 0 3.609706e-07
I12587 n1_m1_513600_326400 0 2.357062e-07
I12588 n1_m1_513600_331200 0 2.311577e-07
I12589 n1_m1_513600_336000 0 3.454048e-07
I12590 n1_m1_513600_340800 0 2.320890e-07
I12591 n1_m1_513600_345600 0 3.487885e-07
I12592 n1_m1_513600_350400 0 2.303178e-07
I12593 n1_m1_513600_355200 0 2.305068e-07
I12594 n1_m1_513600_360000 0 3.459768e-07
I12595 n1_m1_513600_364800 0 2.304952e-07
I12596 n1_m1_513600_369600 0 3.448269e-07
I12597 n1_m1_513600_374400 0 2.298422e-07
I12598 n1_m1_513600_379200 0 2.298422e-07
I12599 n1_m1_513600_384000 0 3.518656e-07
I12600 n1_m1_513600_388800 0 2.433194e-07
I12601 n1_m1_513600_393600 0 3.783859e-07
I12602 n1_m1_513600_398400 0 2.569424e-07
I12603 n1_m1_513600_403200 0 2.541718e-07
I12604 n1_m1_513600_408000 0 3.604186e-07
I12605 n1_m1_513600_412800 0 2.239334e-07
I12606 n1_m1_513600_417600 0 3.358532e-07
I12607 n1_m1_513600_422400 0 2.298422e-07
I12608 n1_m1_513600_427200 0 2.288728e-07
I12609 n1_m1_513600_432000 0 3.403378e-07
I12610 n1_m1_513600_436800 0 2.268919e-07
I12611 n1_m1_513600_441600 0 3.444432e-07
I12612 n1_m1_513600_446400 0 2.381937e-07
I12613 n1_m1_513600_451200 0 2.396212e-07
I12614 n1_m1_513600_456000 0 3.474758e-07
I12615 n1_m1_513600_460800 0 2.298422e-07
I12616 n1_m1_513600_465600 0 3.400523e-07
I12617 n1_m1_513600_470400 0 2.198491e-07
I12618 n1_m1_513600_475200 0 2.228470e-07
I12619 n1_m1_513600_480000 0 3.446920e-07
I12620 n1_m1_513600_484800 0 2.298422e-07
I12621 n1_m1_513600_489600 0 3.350442e-07
I12622 n1_m1_513600_494400 0 2.226248e-07
I12623 n1_m1_513600_499200 0 2.283484e-07
I12624 n1_m1_513600_504000 0 3.577116e-07
I12625 n1_m1_513600_508800 0 2.492908e-07
I12626 n1_m1_513600_513600 0 3.832383e-07
I12627 n1_m1_513600_518400 0 2.574050e-07
I12628 n1_m1_513600_523200 0 2.612941e-07
I12629 n1_m1_513600_528000 0 3.923695e-07
I12630 n1_m1_513600_532800 0 2.535838e-07
I12631 n1_m1_513600_537600 0 3.622194e-07
I12632 n1_m1_513600_542400 0 2.311716e-07
I12633 n1_m1_513600_547200 0 2.292297e-07
I12634 n1_m1_513600_552000 0 3.389806e-07
I12635 n1_m1_513600_556800 0 2.212740e-07
I12636 n1_m1_518400_0 0 1.465661e-07
I12637 n1_m1_518400_4800 0 1.462330e-07
I12638 n1_m1_518400_9600 0 2.113311e-07
I12639 n1_m1_518400_14400 0 1.399040e-07
I12640 n1_m1_518400_19200 0 1.409033e-07
I12641 n1_m1_518400_24000 0 2.219905e-07
I12642 n1_m1_518400_28800 0 1.532282e-07
I12643 n1_m1_518400_33600 0 2.451889e-07
I12644 n1_m1_518400_38400 0 1.635952e-07
I12645 n1_m1_518400_43200 0 1.516238e-07
I12646 n1_m1_518400_48000 0 2.315282e-07
I12647 n1_m1_518400_52800 0 1.695061e-07
I12648 n1_m1_518400_57600 0 3.099335e-07
I12649 n1_m1_518400_62400 0 2.500495e-07
I12650 n1_m1_518400_67200 0 2.467966e-07
I12651 n1_m1_518400_72000 0 2.690874e-07
I12652 n1_m1_518400_76800 0 1.662668e-07
I12653 n1_m1_518400_81600 0 2.396620e-07
I12654 n1_m1_518400_86400 0 1.548801e-07
I12655 n1_m1_518400_91200 0 1.532282e-07
I12656 n1_m1_518400_96000 0 2.299952e-07
I12657 n1_m1_518400_100800 0 1.552982e-07
I12658 n1_m1_518400_105600 0 2.444275e-07
I12659 n1_m1_518400_110400 0 1.663994e-07
I12660 n1_m1_518400_115200 0 1.665524e-07
I12661 n1_m1_518400_120000 0 2.481766e-07
I12662 n1_m1_518400_124800 0 1.615558e-07
I12663 n1_m1_518400_129600 0 2.353793e-07
I12664 n1_m1_518400_134400 0 1.532282e-07
I12665 n1_m1_518400_139200 0 1.520385e-07
I12666 n1_m1_518400_144000 0 2.223576e-07
I12667 n1_m1_518400_148800 0 1.465661e-07
I12668 n1_m1_518400_153600 0 2.206751e-07
I12669 n1_m1_518400_158400 0 1.508692e-07
I12670 n1_m1_518400_163200 0 1.529392e-07
I12671 n1_m1_518400_168000 0 2.298422e-07
I12672 n1_m1_518400_172800 0 1.520657e-07
I12673 n1_m1_518400_177600 0 2.262631e-07
I12674 n1_m1_518400_182400 0 1.580004e-07
I12675 n1_m1_518400_187200 0 1.638127e-07
I12676 n1_m1_518400_192000 0 2.451685e-07
I12677 n1_m1_518400_196800 0 1.585510e-07
I12678 n1_m1_518400_201600 0 2.312494e-07
I12679 n1_m1_518400_206400 0 1.538094e-07
I12680 n1_m1_518400_211200 0 1.569297e-07
I12681 n1_m1_518400_216000 0 2.362664e-07
I12682 n1_m1_518400_220800 0 1.564708e-07
I12683 n1_m1_518400_225600 0 2.299952e-07
I12684 n1_m1_518400_230400 0 1.532282e-07
I12685 n1_m1_518400_235200 0 1.551248e-07
I12686 n1_m1_518400_240000 0 2.363174e-07
I12687 n1_m1_518400_244800 0 1.592444e-07
I12688 n1_m1_518400_249600 0 2.322216e-07
I12689 n1_m1_518400_254400 0 1.532282e-07
I12690 n1_m1_518400_259200 0 1.532282e-07
I12691 n1_m1_518400_264000 0 2.298422e-07
I12692 n1_m1_518400_268800 0 1.532282e-07
I12693 n1_m1_518400_273600 0 2.298422e-07
I12694 n1_m1_518400_278400 0 1.544178e-07
I12695 n1_m1_518400_283200 0 1.563961e-07
I12696 n1_m1_518400_288000 0 2.362834e-07
I12697 n1_m1_518400_292800 0 1.591765e-07
I12698 n1_m1_518400_297600 0 2.417728e-07
I12699 n1_m1_518400_302400 0 1.580888e-07
I12700 n1_m1_518400_307200 0 1.575109e-07
I12701 n1_m1_518400_312000 0 2.362664e-07
I12702 n1_m1_518400_316800 0 1.575109e-07
I12703 n1_m1_518400_321600 0 2.389176e-07
I12704 n1_m1_518400_326400 0 1.611479e-07
I12705 n1_m1_518400_331200 0 1.582383e-07
I12706 n1_m1_518400_336000 0 2.315248e-07
I12707 n1_m1_518400_340800 0 1.577013e-07
I12708 n1_m1_518400_345600 0 2.389312e-07
I12709 n1_m1_518400_350400 0 1.541323e-07
I12710 n1_m1_518400_355200 0 1.532282e-07
I12711 n1_m1_518400_360000 0 2.298422e-07
I12712 n1_m1_518400_364800 0 1.536870e-07
I12713 n1_m1_518400_369600 0 2.332243e-07
I12714 n1_m1_518400_374400 0 1.545538e-07
I12715 n1_m1_518400_379200 0 1.532282e-07
I12716 n1_m1_518400_384000 0 2.298422e-07
I12717 n1_m1_518400_388800 0 1.532282e-07
I12718 n1_m1_518400_393600 0 2.351787e-07
I12719 n1_m1_518400_398400 0 1.628372e-07
I12720 n1_m1_518400_403200 0 1.607162e-07
I12721 n1_m1_518400_408000 0 2.388871e-07
I12722 n1_m1_518400_412800 0 1.550568e-07
I12723 n1_m1_518400_417600 0 2.283365e-07
I12724 n1_m1_518400_422400 0 1.522424e-07
I12725 n1_m1_518400_427200 0 1.494416e-07
I12726 n1_m1_518400_432000 0 2.198491e-07
I12727 n1_m1_518400_436800 0 1.465661e-07
I12728 n1_m1_518400_441600 0 2.249680e-07
I12729 n1_m1_518400_446400 0 1.565694e-07
I12730 n1_m1_518400_451200 0 1.592546e-07
I12731 n1_m1_518400_456000 0 2.316505e-07
I12732 n1_m1_518400_460800 0 1.532282e-07
I12733 n1_m1_518400_465600 0 2.278232e-07
I12734 n1_m1_518400_470400 0 1.489454e-07
I12735 n1_m1_518400_475200 0 1.502302e-07
I12736 n1_m1_518400_480000 0 2.298117e-07
I12737 n1_m1_518400_484800 0 1.532282e-07
I12738 n1_m1_518400_489600 0 2.259572e-07
I12739 n1_m1_518400_494400 0 1.525823e-07
I12740 n1_m1_518400_499200 0 1.551112e-07
I12741 n1_m1_518400_504000 0 2.398354e-07
I12742 n1_m1_518400_508800 0 1.660289e-07
I12743 n1_m1_518400_513600 0 2.498285e-07
I12744 n1_m1_518400_518400 0 1.672322e-07
I12745 n1_m1_518400_523200 0 1.684558e-07
I12746 n1_m1_518400_528000 0 2.468714e-07
I12747 n1_m1_518400_532800 0 1.533165e-07
I12748 n1_m1_518400_537600 0 2.250156e-07
I12749 n1_m1_518400_542400 0 1.508488e-07
I12750 n1_m1_518400_547200 0 1.508488e-07
I12751 n1_m1_518400_552000 0 2.212563e-07
I12752 n1_m1_518400_556800 0 1.465661e-07
I12753 n1_m1_523200_0 0 1.479610e-07
I12754 n1_m1_523200_4800 0 1.465559e-07
I12755 n1_m1_523200_9600 0 2.113311e-07
I12756 n1_m1_523200_14400 0 1.402527e-07
I12757 n1_m1_523200_19200 0 1.422983e-07
I12758 n1_m1_523200_24000 0 2.214093e-07
I12759 n1_m1_523200_28800 0 1.514199e-07
I12760 n1_m1_523200_33600 0 2.453316e-07
I12761 n1_m1_523200_38400 0 1.674905e-07
I12762 n1_m1_523200_43200 0 1.558305e-07
I12763 n1_m1_523200_48000 0 2.326505e-07
I12764 n1_m1_523200_52800 0 1.666156e-07
I12765 n1_m1_523200_57600 0 2.707665e-07
I12766 n1_m1_523200_62400 0 1.886596e-07
I12767 n1_m1_523200_67200 0 1.877657e-07
I12768 n1_m1_523200_72000 0 2.483731e-07
I12769 n1_m1_523200_76800 0 1.595096e-07
I12770 n1_m1_523200_81600 0 2.312760e-07
I12771 n1_m1_523200_86400 0 1.532282e-07
I12772 n1_m1_523200_91200 0 1.532282e-07
I12773 n1_m1_523200_96000 0 2.319755e-07
I12774 n1_m1_523200_100800 0 1.603573e-07
I12775 n1_m1_523200_105600 0 2.454003e-07
I12776 n1_m1_523200_110400 0 1.675449e-07
I12777 n1_m1_523200_115200 0 1.725714e-07
I12778 n1_m1_523200_120000 0 2.550984e-07
I12779 n1_m1_523200_124800 0 1.658195e-07
I12780 n1_m1_523200_129600 0 2.342086e-07
I12781 n1_m1_523200_134400 0 1.545973e-07
I12782 n1_m1_523200_139200 0 1.535137e-07
I12783 n1_m1_523200_144000 0 2.251835e-07
I12784 n1_m1_523200_148800 0 1.487748e-07
I12785 n1_m1_523200_153600 0 2.225615e-07
I12786 n1_m1_523200_158400 0 1.491024e-07
I12787 n1_m1_523200_163200 0 1.526388e-07
I12788 n1_m1_523200_168000 0 2.298422e-07
I12789 n1_m1_523200_172800 0 1.532282e-07
I12790 n1_m1_523200_177600 0 2.298422e-07
I12791 n1_m1_523200_182400 0 1.532282e-07
I12792 n1_m1_523200_187200 0 1.532282e-07
I12793 n1_m1_523200_192000 0 2.314439e-07
I12794 n1_m1_523200_196800 0 1.550364e-07
I12795 n1_m1_523200_201600 0 2.304364e-07
I12796 n1_m1_523200_206400 0 1.532282e-07
I12797 n1_m1_523200_211200 0 1.533961e-07
I12798 n1_m1_523200_216000 0 2.328259e-07
I12799 n1_m1_523200_220800 0 1.564056e-07
I12800 n1_m1_523200_225600 0 2.315084e-07
I12801 n1_m1_523200_230400 0 1.522724e-07
I12802 n1_m1_523200_235200 0 1.522207e-07
I12803 n1_m1_523200_240000 0 2.330462e-07
I12804 n1_m1_523200_244800 0 1.603811e-07
I12805 n1_m1_523200_249600 0 2.328674e-07
I12806 n1_m1_523200_254400 0 1.532282e-07
I12807 n1_m1_523200_259200 0 1.532282e-07
I12808 n1_m1_523200_264000 0 2.303847e-07
I12809 n1_m1_523200_268800 0 1.550235e-07
I12810 n1_m1_523200_273600 0 2.314955e-07
I12811 n1_m1_523200_278400 0 1.556551e-07
I12812 n1_m1_523200_283200 0 1.568203e-07
I12813 n1_m1_523200_288000 0 2.326023e-07
I12814 n1_m1_523200_292800 0 1.596999e-07
I12815 n1_m1_523200_297600 0 2.444853e-07
I12816 n1_m1_523200_302400 0 1.560215e-07
I12817 n1_m1_523200_307200 0 1.535252e-07
I12818 n1_m1_523200_312000 0 2.303331e-07
I12819 n1_m1_523200_316800 0 1.546231e-07
I12820 n1_m1_523200_321600 0 2.353670e-07
I12821 n1_m1_523200_326400 0 1.606476e-07
I12822 n1_m1_523200_331200 0 1.587795e-07
I12823 n1_m1_523200_336000 0 2.388544e-07
I12824 n1_m1_523200_340800 0 1.619120e-07
I12825 n1_m1_523200_345600 0 2.421474e-07
I12826 n1_m1_523200_350400 0 1.543777e-07
I12827 n1_m1_523200_355200 0 1.532282e-07
I12828 n1_m1_523200_360000 0 2.298422e-07
I12829 n1_m1_523200_364800 0 1.541643e-07
I12830 n1_m1_523200_369600 0 2.357858e-07
I12831 n1_m1_523200_374400 0 1.541241e-07
I12832 n1_m1_523200_379200 0 1.514199e-07
I12833 n1_m1_523200_384000 0 2.284860e-07
I12834 n1_m1_523200_388800 0 1.532282e-07
I12835 n1_m1_523200_393600 0 2.306512e-07
I12836 n1_m1_523200_398400 0 1.587489e-07
I12837 n1_m1_523200_403200 0 1.584307e-07
I12838 n1_m1_523200_408000 0 2.367226e-07
I12839 n1_m1_523200_412800 0 1.563641e-07
I12840 n1_m1_523200_417600 0 2.319836e-07
I12841 n1_m1_523200_422400 0 1.501582e-07
I12842 n1_m1_523200_427200 0 1.483744e-07
I12843 n1_m1_523200_432000 0 2.212828e-07
I12844 n1_m1_523200_436800 0 1.465661e-07
I12845 n1_m1_523200_441600 0 2.207566e-07
I12846 n1_m1_523200_446400 0 1.540732e-07
I12847 n1_m1_523200_451200 0 1.601758e-07
I12848 n1_m1_523200_456000 0 2.339884e-07
I12849 n1_m1_523200_460800 0 1.533444e-07
I12850 n1_m1_523200_465600 0 2.298422e-07
I12851 n1_m1_523200_470400 0 1.532282e-07
I12852 n1_m1_523200_475200 0 1.537706e-07
I12853 n1_m1_523200_480000 0 2.325418e-07
I12854 n1_m1_523200_484800 0 1.560956e-07
I12855 n1_m1_523200_489600 0 2.365716e-07
I12856 n1_m1_523200_494400 0 1.545300e-07
I12857 n1_m1_523200_499200 0 1.584409e-07
I12858 n1_m1_523200_504000 0 2.461576e-07
I12859 n1_m1_523200_508800 0 1.721641e-07
I12860 n1_m1_523200_513600 0 2.515981e-07
I12861 n1_m1_523200_518400 0 1.630106e-07
I12862 n1_m1_523200_523200 0 1.593994e-07
I12863 n1_m1_523200_528000 0 2.297586e-07
I12864 n1_m1_523200_532800 0 1.438618e-07
I12865 n1_m1_523200_537600 0 2.172835e-07
I12866 n1_m1_523200_542400 0 1.465661e-07
I12867 n1_m1_523200_547200 0 1.465661e-07
I12868 n1_m1_523200_552000 0 2.198491e-07
I12869 n1_m1_523200_556800 0 1.465661e-07
I12870 n1_m1_528000_0 0 2.360135e-07
I12871 n1_m1_528000_4800 0 2.294599e-07
I12872 n1_m1_528000_9600 0 3.243692e-07
I12873 n1_m1_528000_14400 0 2.152125e-07
I12874 n1_m1_528000_19200 0 2.192903e-07
I12875 n1_m1_528000_24000 0 3.298195e-07
I12876 n1_m1_528000_28800 0 2.199919e-07
I12877 n1_m1_528000_33600 0 3.305231e-07
I12878 n1_m1_528000_38400 0 2.240095e-07
I12879 n1_m1_528000_43200 0 2.310944e-07
I12880 n1_m1_528000_48000 0 3.637412e-07
I12881 n1_m1_528000_52800 0 2.573060e-07
I12882 n1_m1_528000_57600 0 4.060886e-07
I12883 n1_m1_528000_62400 0 2.833463e-07
I12884 n1_m1_528000_67200 0 2.900611e-07
I12885 n1_m1_528000_72000 0 3.902413e-07
I12886 n1_m1_528000_76800 0 2.449951e-07
I12887 n1_m1_528000_81600 0 3.491777e-07
I12888 n1_m1_528000_86400 0 2.272114e-07
I12889 n1_m1_528000_91200 0 2.278232e-07
I12890 n1_m1_528000_96000 0 3.546933e-07
I12891 n1_m1_528000_100800 0 2.477351e-07
I12892 n1_m1_528000_105600 0 3.935523e-07
I12893 n1_m1_528000_110400 0 3.420917e-07
I12894 n1_m1_528000_115200 0 4.611162e-07
I12895 n1_m1_528000_120000 0 4.576879e-07
I12896 n1_m1_528000_124800 0 2.490148e-07
I12897 n1_m1_528000_129600 0 3.529037e-07
I12898 n1_m1_528000_134400 0 2.365662e-07
I12899 n1_m1_528000_139200 0 2.424051e-07
I12900 n1_m1_528000_144000 0 3.551307e-07
I12901 n1_m1_528000_148800 0 2.309323e-07
I12902 n1_m1_528000_153600 0 3.445492e-07
I12903 n1_m1_528000_158400 0 2.297209e-07
I12904 n1_m1_528000_163200 0 2.298249e-07
I12905 n1_m1_528000_168000 0 3.462929e-07
I12906 n1_m1_528000_172800 0 2.329626e-07
I12907 n1_m1_528000_177600 0 3.448551e-07
I12908 n1_m1_528000_182400 0 2.298422e-07
I12909 n1_m1_528000_187200 0 2.298422e-07
I12910 n1_m1_528000_192000 0 3.496947e-07
I12911 n1_m1_528000_196800 0 2.354099e-07
I12912 n1_m1_528000_201600 0 3.465927e-07
I12913 n1_m1_528000_206400 0 2.304235e-07
I12914 n1_m1_528000_211200 0 2.344585e-07
I12915 n1_m1_528000_216000 0 3.674407e-07
I12916 n1_m1_528000_220800 0 2.503934e-07
I12917 n1_m1_528000_225600 0 3.539927e-07
I12918 n1_m1_528000_230400 0 2.268994e-07
I12919 n1_m1_528000_235200 0 2.267403e-07
I12920 n1_m1_528000_240000 0 3.617446e-07
I12921 n1_m1_528000_244800 0 2.527673e-07
I12922 n1_m1_528000_249600 0 3.575709e-07
I12923 n1_m1_528000_254400 0 2.303011e-07
I12924 n1_m1_528000_259200 0 2.298422e-07
I12925 n1_m1_528000_264000 0 3.477185e-07
I12926 n1_m1_528000_268800 0 2.386739e-07
I12927 n1_m1_528000_273600 0 3.500679e-07
I12928 n1_m1_528000_278400 0 2.299136e-07
I12929 n1_m1_528000_283200 0 2.322324e-07
I12930 n1_m1_528000_288000 0 3.567347e-07
I12931 n1_m1_528000_292800 0 2.466878e-07
I12932 n1_m1_528000_297600 0 3.690834e-07
I12933 n1_m1_528000_302400 0 2.467174e-07
I12934 n1_m1_528000_307200 0 2.400261e-07
I12935 n1_m1_528000_312000 0 3.591229e-07
I12936 n1_m1_528000_316800 0 2.427028e-07
I12937 n1_m1_528000_321600 0 3.581287e-07
I12938 n1_m1_528000_326400 0 2.386260e-07
I12939 n1_m1_528000_331200 0 2.406981e-07
I12940 n1_m1_528000_336000 0 3.748927e-07
I12941 n1_m1_528000_340800 0 2.552065e-07
I12942 n1_m1_528000_345600 0 3.782108e-07
I12943 n1_m1_528000_350400 0 2.331165e-07
I12944 n1_m1_528000_355200 0 2.298422e-07
I12945 n1_m1_528000_360000 0 3.447634e-07
I12946 n1_m1_528000_364800 0 2.298698e-07
I12947 n1_m1_528000_369600 0 3.420234e-07
I12948 n1_m1_528000_374400 0 2.262508e-07
I12949 n1_m1_528000_379200 0 2.270279e-07
I12950 n1_m1_528000_384000 0 3.405877e-07
I12951 n1_m1_528000_388800 0 2.298422e-07
I12952 n1_m1_528000_393600 0 3.499843e-07
I12953 n1_m1_528000_398400 0 2.385414e-07
I12954 n1_m1_528000_403200 0 2.351886e-07
I12955 n1_m1_528000_408000 0 3.447848e-07
I12956 n1_m1_528000_412800 0 2.239310e-07
I12957 n1_m1_528000_417600 0 3.305282e-07
I12958 n1_m1_528000_422400 0 2.240136e-07
I12959 n1_m1_528000_427200 0 2.296995e-07
I12960 n1_m1_528000_432000 0 3.375836e-07
I12961 n1_m1_528000_436800 0 2.198491e-07
I12962 n1_m1_528000_441600 0 3.314409e-07
I12963 n1_m1_528000_446400 0 2.337712e-07
I12964 n1_m1_528000_451200 0 2.466062e-07
I12965 n1_m1_528000_456000 0 3.654726e-07
I12966 n1_m1_528000_460800 0 2.347583e-07
I12967 n1_m1_528000_465600 0 3.511875e-07
I12968 n1_m1_528000_470400 0 2.341250e-07
I12969 n1_m1_528000_475200 0 2.357953e-07
I12970 n1_m1_528000_480000 0 3.623748e-07
I12971 n1_m1_528000_484800 0 2.497449e-07
I12972 n1_m1_528000_489600 0 3.757921e-07
I12973 n1_m1_528000_494400 0 2.340893e-07
I12974 n1_m1_528000_499200 0 2.378245e-07
I12975 n1_m1_528000_504000 0 4.035292e-07
I12976 n1_m1_528000_508800 0 3.062643e-07
I12977 n1_m1_528000_513600 0 3.880225e-07
I12978 n1_m1_528000_518400 0 2.383976e-07
I12979 n1_m1_528000_523200 0 2.328789e-07
I12980 n1_m1_528000_528000 0 3.350017e-07
I12981 n1_m1_528000_532800 0 2.197696e-07
I12982 n1_m1_528000_537600 0 3.258743e-07
I12983 n1_m1_528000_542400 0 2.190231e-07
I12984 n1_m1_528000_547200 0 2.198491e-07
I12985 n1_m1_528000_552000 0 3.297737e-07
I12986 n1_m1_528000_556800 0 2.198491e-07
I12987 n1_m1_532800_0 0 1.687413e-07
I12988 n1_m1_532800_4800 0 1.641254e-07
I12989 n1_m1_532800_9600 0 2.274656e-07
I12990 n1_m1_532800_14400 0 1.466986e-07
I12991 n1_m1_532800_19200 0 1.465661e-07
I12992 n1_m1_532800_24000 0 2.198491e-07
I12993 n1_m1_532800_28800 0 1.452404e-07
I12994 n1_m1_532800_33600 0 2.170653e-07
I12995 n1_m1_532800_38400 0 1.465661e-07
I12996 n1_m1_532800_43200 0 1.502778e-07
I12997 n1_m1_532800_48000 0 2.334636e-07
I12998 n1_m1_532800_52800 0 1.640697e-07
I12999 n1_m1_532800_57600 0 2.540059e-07
I13000 n1_m1_532800_62400 0 1.734952e-07
I13001 n1_m1_532800_67200 0 1.771920e-07
I13002 n1_m1_532800_72000 0 2.527986e-07
I13003 n1_m1_532800_76800 0 1.596822e-07
I13004 n1_m1_532800_81600 0 2.272175e-07
I13005 n1_m1_532800_86400 0 1.477041e-07
I13006 n1_m1_532800_91200 0 1.481255e-07
I13007 n1_m1_532800_96000 0 2.309843e-07
I13008 n1_m1_532800_100800 0 1.614606e-07
I13009 n1_m1_532800_105600 0 2.934088e-07
I13010 n1_m1_532800_110400 0 4.341211e-07
I13011 n1_m1_532800_115200 0 6.149697e-07
I13012 n1_m1_532800_120000 0 4.201871e-07
I13013 n1_m1_532800_124800 0 1.604042e-07
I13014 n1_m1_532800_129600 0 2.463493e-07
I13015 n1_m1_532800_134400 0 1.564939e-07
I13016 n1_m1_532800_139200 0 1.561785e-07
I13017 n1_m1_532800_144000 0 2.315703e-07
I13018 n1_m1_532800_148800 0 1.532282e-07
I13019 n1_m1_532800_153600 0 2.298422e-07
I13020 n1_m1_532800_158400 0 1.537849e-07
I13021 n1_m1_532800_163200 0 1.564892e-07
I13022 n1_m1_532800_168000 0 2.377892e-07
I13023 n1_m1_532800_172800 0 1.617937e-07
I13024 n1_m1_532800_177600 0 2.331665e-07
I13025 n1_m1_532800_182400 0 1.532282e-07
I13026 n1_m1_532800_187200 0 1.532282e-07
I13027 n1_m1_532800_192000 0 2.299748e-07
I13028 n1_m1_532800_196800 0 1.560385e-07
I13029 n1_m1_532800_201600 0 2.347470e-07
I13030 n1_m1_532800_206400 0 1.544770e-07
I13031 n1_m1_532800_211200 0 1.596047e-07
I13032 n1_m1_532800_216000 0 2.508278e-07
I13033 n1_m1_532800_220800 0 1.708800e-07
I13034 n1_m1_532800_225600 0 2.393738e-07
I13035 n1_m1_532800_230400 0 1.532282e-07
I13036 n1_m1_532800_235200 0 1.548719e-07
I13037 n1_m1_532800_240000 0 2.437123e-07
I13038 n1_m1_532800_244800 0 1.687019e-07
I13039 n1_m1_532800_249600 0 2.421739e-07
I13040 n1_m1_532800_254400 0 1.539420e-07
I13041 n1_m1_532800_259200 0 1.535198e-07
I13042 n1_m1_532800_264000 0 2.366926e-07
I13043 n1_m1_532800_268800 0 1.620792e-07
I13044 n1_m1_532800_273600 0 2.357430e-07
I13045 n1_m1_532800_278400 0 1.550840e-07
I13046 n1_m1_532800_283200 0 1.532282e-07
I13047 n1_m1_532800_288000 0 2.323344e-07
I13048 n1_m1_532800_292800 0 1.608420e-07
I13049 n1_m1_532800_297600 0 2.493962e-07
I13050 n1_m1_532800_302400 0 1.720894e-07
I13051 n1_m1_532800_307200 0 1.707488e-07
I13052 n1_m1_532800_312000 0 2.553961e-07
I13053 n1_m1_532800_316800 0 1.718018e-07
I13054 n1_m1_532800_321600 0 2.867338e-07
I13055 n1_m1_532800_326400 0 2.060559e-07
I13056 n1_m1_532800_331200 0 1.862246e-07
I13057 n1_m1_532800_336000 0 2.524533e-07
I13058 n1_m1_532800_340800 0 1.665524e-07
I13059 n1_m1_532800_345600 0 2.583791e-07
I13060 n1_m1_532800_350400 0 1.596523e-07
I13061 n1_m1_532800_355200 0 1.567543e-07
I13062 n1_m1_532800_360000 0 2.306641e-07
I13063 n1_m1_532800_364800 0 1.532282e-07
I13064 n1_m1_532800_369600 0 2.318042e-07
I13065 n1_m1_532800_374400 0 1.598903e-07
I13066 n1_m1_532800_379200 0 1.638739e-07
I13067 n1_m1_532800_384000 0 2.381937e-07
I13068 n1_m1_532800_388800 0 1.556143e-07
I13069 n1_m1_532800_393600 0 2.389795e-07
I13070 n1_m1_532800_398400 0 1.627536e-07
I13071 n1_m1_532800_403200 0 1.605007e-07
I13072 n1_m1_532800_408000 0 2.353045e-07
I13073 n1_m1_532800_412800 0 1.528869e-07
I13074 n1_m1_532800_417600 0 2.238348e-07
I13075 n1_m1_532800_422400 0 1.493261e-07
I13076 n1_m1_532800_427200 0 1.532282e-07
I13077 n1_m1_532800_432000 0 2.277559e-07
I13078 n1_m1_532800_436800 0 1.479977e-07
I13079 n1_m1_532800_441600 0 2.205629e-07
I13080 n1_m1_532800_446400 0 1.527516e-07
I13081 n1_m1_532800_451200 0 1.609290e-07
I13082 n1_m1_532800_456000 0 2.474411e-07
I13083 n1_m1_532800_460800 0 1.603185e-07
I13084 n1_m1_532800_465600 0 2.398354e-07
I13085 n1_m1_532800_470400 0 1.598903e-07
I13086 n1_m1_532800_475200 0 1.610038e-07
I13087 n1_m1_532800_480000 0 2.498496e-07
I13088 n1_m1_532800_484800 0 1.763402e-07
I13089 n1_m1_532800_489600 0 2.536470e-07
I13090 n1_m1_532800_494400 0 1.616972e-07
I13091 n1_m1_532800_499200 0 1.692369e-07
I13092 n1_m1_532800_504000 0 3.443698e-07
I13093 n1_m1_532800_508800 0 2.414826e-07
I13094 n1_m1_532800_513600 0 2.638135e-07
I13095 n1_m1_532800_518400 0 1.575109e-07
I13096 n1_m1_532800_523200 0 1.514199e-07
I13097 n1_m1_532800_528000 0 2.199919e-07
I13098 n1_m1_532800_532800 0 1.465661e-07
I13099 n1_m1_532800_537600 0 2.172149e-07
I13100 n1_m1_532800_542400 0 1.459971e-07
I13101 n1_m1_532800_547200 0 1.465661e-07
I13102 n1_m1_532800_552000 0 2.198491e-07
I13103 n1_m1_532800_556800 0 1.465661e-07
I13104 n1_m1_537600_0 0 1.693504e-07
I13105 n1_m1_537600_4800 0 1.614297e-07
I13106 n1_m1_537600_9600 0 2.236968e-07
I13107 n1_m1_537600_14400 0 1.460970e-07
I13108 n1_m1_537600_19200 0 1.461211e-07
I13109 n1_m1_537600_24000 0 2.197855e-07
I13110 n1_m1_537600_28800 0 1.462092e-07
I13111 n1_m1_537600_33600 0 2.190996e-07
I13112 n1_m1_537600_38400 0 1.462296e-07
I13113 n1_m1_537600_43200 0 1.468910e-07
I13114 n1_m1_537600_48000 0 2.218304e-07
I13115 n1_m1_537600_52800 0 1.527394e-07
I13116 n1_m1_537600_57600 0 2.382732e-07
I13117 n1_m1_537600_62400 0 1.601146e-07
I13118 n1_m1_537600_67200 0 1.610884e-07
I13119 n1_m1_537600_72000 0 2.402708e-07
I13120 n1_m1_537600_76800 0 1.571778e-07
I13121 n1_m1_537600_81600 0 2.247162e-07
I13122 n1_m1_537600_86400 0 1.465661e-07
I13123 n1_m1_537600_91200 0 1.465661e-07
I13124 n1_m1_537600_96000 0 2.257349e-07
I13125 n1_m1_537600_100800 0 1.539233e-07
I13126 n1_m1_537600_105600 0 2.889588e-07
I13127 n1_m1_537600_110400 0 4.642004e-07
I13128 n1_m1_537600_115200 0 6.529964e-07
I13129 n1_m1_537600_120000 0 4.157300e-07
I13130 n1_m1_537600_124800 0 1.585436e-07
I13131 n1_m1_537600_129600 0 2.495175e-07
I13132 n1_m1_537600_134400 0 1.597013e-07
I13133 n1_m1_537600_139200 0 1.565830e-07
I13134 n1_m1_537600_144000 0 2.298422e-07
I13135 n1_m1_537600_148800 0 1.532282e-07
I13136 n1_m1_537600_153600 0 2.309344e-07
I13137 n1_m1_537600_158400 0 1.585959e-07
I13138 n1_m1_537600_163200 0 1.603756e-07
I13139 n1_m1_537600_168000 0 2.497786e-07
I13140 n1_m1_537600_172800 0 1.719439e-07
I13141 n1_m1_537600_177600 0 2.525624e-07
I13142 n1_m1_537600_182400 0 1.613987e-07
I13143 n1_m1_537600_187200 0 1.562213e-07
I13144 n1_m1_537600_192000 0 2.350958e-07
I13145 n1_m1_537600_196800 0 1.639351e-07
I13146 n1_m1_537600_201600 0 2.487643e-07
I13147 n1_m1_537600_206400 0 1.643950e-07
I13148 n1_m1_537600_211200 0 1.607604e-07
I13149 n1_m1_537600_216000 0 2.481820e-07
I13150 n1_m1_537600_220800 0 1.667855e-07
I13151 n1_m1_537600_225600 0 2.412157e-07
I13152 n1_m1_537600_230400 0 1.532282e-07
I13153 n1_m1_537600_235200 0 1.559467e-07
I13154 n1_m1_537600_240000 0 2.441029e-07
I13155 n1_m1_537600_244800 0 1.583981e-07
I13156 n1_m1_537600_249600 0 2.323191e-07
I13157 n1_m1_537600_254400 0 1.545463e-07
I13158 n1_m1_537600_259200 0 1.590062e-07
I13159 n1_m1_537600_264000 0 2.467612e-07
I13160 n1_m1_537600_268800 0 1.670544e-07
I13161 n1_m1_537600_273600 0 2.558054e-07
I13162 n1_m1_537600_278400 0 1.619603e-07
I13163 n1_m1_537600_283200 0 1.532282e-07
I13164 n1_m1_537600_288000 0 2.341039e-07
I13165 n1_m1_537600_292800 0 1.587006e-07
I13166 n1_m1_537600_297600 0 2.401117e-07
I13167 n1_m1_537600_302400 0 1.612441e-07
I13168 n1_m1_537600_307200 0 1.613654e-07
I13169 n1_m1_537600_312000 0 2.448381e-07
I13170 n1_m1_537600_316800 0 1.876093e-07
I13171 n1_m1_537600_321600 0 4.526852e-07
I13172 n1_m1_537600_326400 0 3.850922e-07
I13173 n1_m1_537600_331200 0 3.098071e-07
I13174 n1_m1_537600_336000 0 2.836808e-07
I13175 n1_m1_537600_340800 0 1.662009e-07
I13176 n1_m1_537600_345600 0 2.557598e-07
I13177 n1_m1_537600_350400 0 1.660605e-07
I13178 n1_m1_537600_355200 0 1.605684e-07
I13179 n1_m1_537600_360000 0 2.313174e-07
I13180 n1_m1_537600_364800 0 1.532282e-07
I13181 n1_m1_537600_369600 0 2.333636e-07
I13182 n1_m1_537600_374400 0 1.653484e-07
I13183 n1_m1_537600_379200 0 1.745945e-07
I13184 n1_m1_537600_384000 0 2.490790e-07
I13185 n1_m1_537600_388800 0 1.571744e-07
I13186 n1_m1_537600_393600 0 2.391716e-07
I13187 n1_m1_537600_398400 0 1.601788e-07
I13188 n1_m1_537600_403200 0 1.597798e-07
I13189 n1_m1_537600_408000 0 2.324952e-07
I13190 n1_m1_537600_412800 0 1.532781e-07
I13191 n1_m1_537600_417600 0 2.265112e-07
I13192 n1_m1_537600_422400 0 1.493261e-07
I13193 n1_m1_537600_427200 0 1.534002e-07
I13194 n1_m1_537600_432000 0 2.302573e-07
I13195 n1_m1_537600_436800 0 1.491357e-07
I13196 n1_m1_537600_441600 0 2.205068e-07
I13197 n1_m1_537600_446400 0 1.521245e-07
I13198 n1_m1_537600_451200 0 1.581183e-07
I13199 n1_m1_537600_456000 0 2.452120e-07
I13200 n1_m1_537600_460800 0 1.584273e-07
I13201 n1_m1_537600_465600 0 2.313535e-07
I13202 n1_m1_537600_470400 0 1.562098e-07
I13203 n1_m1_537600_475200 0 1.613654e-07
I13204 n1_m1_537600_480000 0 2.538203e-07
I13205 n1_m1_537600_484800 0 1.807120e-07
I13206 n1_m1_537600_489600 0 2.770741e-07
I13207 n1_m1_537600_494400 0 1.913020e-07
I13208 n1_m1_537600_499200 0 2.380971e-07
I13209 n1_m1_537600_504000 0 4.409117e-07
I13210 n1_m1_537600_508800 0 2.339608e-07
I13211 n1_m1_537600_513600 0 2.528424e-07
I13212 n1_m1_537600_518400 0 1.515117e-07
I13213 n1_m1_537600_523200 0 1.488312e-07
I13214 n1_m1_537600_528000 0 2.282433e-07
I13215 n1_m1_537600_532800 0 1.493655e-07
I13216 n1_m1_537600_537600 0 2.201258e-07
I13217 n1_m1_537600_542400 0 1.465661e-07
I13218 n1_m1_537600_547200 0 1.465661e-07
I13219 n1_m1_537600_552000 0 2.198491e-07
I13220 n1_m1_537600_556800 0 1.465661e-07
I13221 n1_m1_542400_0 0 1.592308e-07
I13222 n1_m1_542400_4800 0 1.513441e-07
I13223 n1_m1_542400_9600 0 2.191122e-07
I13224 n1_m1_542400_14400 0 1.413809e-07
I13225 n1_m1_542400_19200 0 1.419954e-07
I13226 n1_m1_542400_24000 0 2.191962e-07
I13227 n1_m1_542400_28800 0 1.465661e-07
I13228 n1_m1_542400_33600 0 2.196707e-07
I13229 n1_m1_542400_38400 0 1.431772e-07
I13230 n1_m1_542400_43200 0 1.442901e-07
I13231 n1_m1_542400_48000 0 2.199501e-07
I13232 n1_m1_542400_52800 0 1.476490e-07
I13233 n1_m1_542400_57600 0 2.233916e-07
I13234 n1_m1_542400_62400 0 1.500960e-07
I13235 n1_m1_542400_67200 0 1.540137e-07
I13236 n1_m1_542400_72000 0 2.317695e-07
I13237 n1_m1_542400_76800 0 1.523240e-07
I13238 n1_m1_542400_81600 0 2.208678e-07
I13239 n1_m1_542400_86400 0 1.465661e-07
I13240 n1_m1_542400_91200 0 1.465661e-07
I13241 n1_m1_542400_96000 0 2.213909e-07
I13242 n1_m1_542400_100800 0 1.520460e-07
I13243 n1_m1_542400_105600 0 2.519879e-07
I13244 n1_m1_542400_110400 0 2.657652e-07
I13245 n1_m1_542400_115200 0 4.005802e-07
I13246 n1_m1_542400_120000 0 3.071310e-07
I13247 n1_m1_542400_124800 0 1.524002e-07
I13248 n1_m1_542400_129600 0 2.380917e-07
I13249 n1_m1_542400_134400 0 1.638630e-07
I13250 n1_m1_542400_139200 0 1.619365e-07
I13251 n1_m1_542400_144000 0 2.298422e-07
I13252 n1_m1_542400_148800 0 1.532282e-07
I13253 n1_m1_542400_153600 0 2.310812e-07
I13254 n1_m1_542400_158400 0 1.591833e-07
I13255 n1_m1_542400_163200 0 1.605497e-07
I13256 n1_m1_542400_168000 0 2.507956e-07
I13257 n1_m1_542400_172800 0 1.729765e-07
I13258 n1_m1_542400_177600 0 2.551820e-07
I13259 n1_m1_542400_182400 0 1.626027e-07
I13260 n1_m1_542400_187200 0 1.566238e-07
I13261 n1_m1_542400_192000 0 2.357701e-07
I13262 n1_m1_542400_196800 0 1.646965e-07
I13263 n1_m1_542400_201600 0 2.554920e-07
I13264 n1_m1_542400_206400 0 1.691546e-07
I13265 n1_m1_542400_211200 0 1.574086e-07
I13266 n1_m1_542400_216000 0 2.403367e-07
I13267 n1_m1_542400_220800 0 1.611751e-07
I13268 n1_m1_542400_225600 0 2.368810e-07
I13269 n1_m1_542400_230400 0 1.532282e-07
I13270 n1_m1_542400_235200 0 1.537972e-07
I13271 n1_m1_542400_240000 0 2.329360e-07
I13272 n1_m1_542400_244800 0 1.580167e-07
I13273 n1_m1_542400_249600 0 2.385370e-07
I13274 n1_m1_542400_254400 0 1.598325e-07
I13275 n1_m1_542400_259200 0 1.640180e-07
I13276 n1_m1_542400_264000 0 2.424805e-07
I13277 n1_m1_542400_268800 0 1.623087e-07
I13278 n1_m1_542400_273600 0 2.503758e-07
I13279 n1_m1_542400_278400 0 1.600568e-07
I13280 n1_m1_542400_283200 0 1.529902e-07
I13281 n1_m1_542400_288000 0 2.305132e-07
I13282 n1_m1_542400_292800 0 1.506775e-07
I13283 n1_m1_542400_297600 0 2.294660e-07
I13284 n1_m1_542400_302400 0 1.544841e-07
I13285 n1_m1_542400_307200 0 1.545283e-07
I13286 n1_m1_542400_312000 0 2.326454e-07
I13287 n1_m1_542400_316800 0 1.691903e-07
I13288 n1_m1_542400_321600 0 4.252867e-07
I13289 n1_m1_542400_326400 0 4.083809e-07
I13290 n1_m1_542400_331200 0 3.443643e-07
I13291 n1_m1_542400_336000 0 2.972215e-07
I13292 n1_m1_542400_340800 0 1.627040e-07
I13293 n1_m1_542400_345600 0 2.431301e-07
I13294 n1_m1_542400_350400 0 1.651081e-07
I13295 n1_m1_542400_355200 0 1.605208e-07
I13296 n1_m1_542400_360000 0 2.312647e-07
I13297 n1_m1_542400_364800 0 1.532282e-07
I13298 n1_m1_542400_369600 0 2.333636e-07
I13299 n1_m1_542400_374400 0 1.656856e-07
I13300 n1_m1_542400_379200 0 1.753558e-07
I13301 n1_m1_542400_384000 0 2.496501e-07
I13302 n1_m1_542400_388800 0 1.540541e-07
I13303 n1_m1_542400_393600 0 2.317695e-07
I13304 n1_m1_542400_398400 0 1.549168e-07
I13305 n1_m1_542400_403200 0 1.584317e-07
I13306 n1_m1_542400_408000 0 2.314024e-07
I13307 n1_m1_542400_412800 0 1.532282e-07
I13308 n1_m1_542400_417600 0 2.265112e-07
I13309 n1_m1_542400_422400 0 1.493261e-07
I13310 n1_m1_542400_427200 0 1.549950e-07
I13311 n1_m1_542400_432000 0 2.342739e-07
I13312 n1_m1_542400_436800 0 1.493737e-07
I13313 n1_m1_542400_441600 0 2.200989e-07
I13314 n1_m1_542400_446400 0 1.480528e-07
I13315 n1_m1_542400_451200 0 1.529719e-07
I13316 n1_m1_542400_456000 0 2.316604e-07
I13317 n1_m1_542400_460800 0 1.493376e-07
I13318 n1_m1_542400_465600 0 2.243368e-07
I13319 n1_m1_542400_470400 0 1.534858e-07
I13320 n1_m1_542400_475200 0 1.562737e-07
I13321 n1_m1_542400_480000 0 2.492820e-07
I13322 n1_m1_542400_484800 0 1.773932e-07
I13323 n1_m1_542400_489600 0 2.767862e-07
I13324 n1_m1_542400_494400 0 1.938027e-07
I13325 n1_m1_542400_499200 0 2.314799e-07
I13326 n1_m1_542400_504000 0 3.500251e-07
I13327 n1_m1_542400_508800 0 1.851579e-07
I13328 n1_m1_542400_513600 0 2.336485e-07
I13329 n1_m1_542400_518400 0 1.477149e-07
I13330 n1_m1_542400_523200 0 1.487856e-07
I13331 n1_m1_542400_528000 0 2.300615e-07
I13332 n1_m1_542400_532800 0 1.526177e-07
I13333 n1_m1_542400_537600 0 2.226914e-07
I13334 n1_m1_542400_542400 0 1.465661e-07
I13335 n1_m1_542400_547200 0 1.465661e-07
I13336 n1_m1_542400_552000 0 2.198491e-07
I13337 n1_m1_542400_556800 0 1.465661e-07
I13338 n1_m1_547200_0 0 1.529535e-07
I13339 n1_m1_547200_4800 0 1.480446e-07
I13340 n1_m1_547200_9600 0 2.182312e-07
I13341 n1_m1_547200_14400 0 1.401419e-07
I13342 n1_m1_547200_19200 0 1.409033e-07
I13343 n1_m1_547200_24000 0 2.190401e-07
I13344 n1_m1_547200_28800 0 1.465661e-07
I13345 n1_m1_547200_33600 0 2.160660e-07
I13346 n1_m1_547200_38400 0 1.437245e-07
I13347 n1_m1_547200_43200 0 1.458496e-07
I13348 n1_m1_547200_48000 0 2.198491e-07
I13349 n1_m1_547200_52800 0 1.465661e-07
I13350 n1_m1_547200_57600 0 2.198491e-07
I13351 n1_m1_547200_62400 0 1.477557e-07
I13352 n1_m1_547200_67200 0 1.526095e-07
I13353 n1_m1_547200_72000 0 2.298422e-07
I13354 n1_m1_547200_76800 0 1.510392e-07
I13355 n1_m1_547200_81600 0 2.198491e-07
I13356 n1_m1_547200_86400 0 1.465661e-07
I13357 n1_m1_547200_91200 0 1.465661e-07
I13358 n1_m1_547200_96000 0 2.199531e-07
I13359 n1_m1_547200_100800 0 1.480997e-07
I13360 n1_m1_547200_105600 0 2.359088e-07
I13361 n1_m1_547200_110400 0 1.680608e-07
I13362 n1_m1_547200_115200 0 2.113624e-07
I13363 n1_m1_547200_120000 0 2.497694e-07
I13364 n1_m1_547200_124800 0 1.540942e-07
I13365 n1_m1_547200_129600 0 2.319163e-07
I13366 n1_m1_547200_134400 0 1.628447e-07
I13367 n1_m1_547200_139200 0 1.632213e-07
I13368 n1_m1_547200_144000 0 2.298422e-07
I13369 n1_m1_547200_148800 0 1.532282e-07
I13370 n1_m1_547200_153600 0 2.301543e-07
I13371 n1_m1_547200_158400 0 1.554756e-07
I13372 n1_m1_547200_163200 0 1.594511e-07
I13373 n1_m1_547200_168000 0 2.443758e-07
I13374 n1_m1_547200_172800 0 1.681703e-07
I13375 n1_m1_547200_177600 0 2.479727e-07
I13376 n1_m1_547200_182400 0 1.577965e-07
I13377 n1_m1_547200_187200 0 1.540834e-07
I13378 n1_m1_547200_192000 0 2.315132e-07
I13379 n1_m1_547200_196800 0 1.598903e-07
I13380 n1_m1_547200_201600 0 2.441576e-07
I13381 n1_m1_547200_206400 0 1.617828e-07
I13382 n1_m1_547200_211200 0 1.547217e-07
I13383 n1_m1_547200_216000 0 2.336376e-07
I13384 n1_m1_547200_220800 0 1.598903e-07
I13385 n1_m1_547200_225600 0 2.357430e-07
I13386 n1_m1_547200_230400 0 1.532282e-07
I13387 n1_m1_547200_235200 0 1.532282e-07
I13388 n1_m1_547200_240000 0 2.300931e-07
I13389 n1_m1_547200_244800 0 1.617570e-07
I13390 n1_m1_547200_249600 0 2.531664e-07
I13391 n1_m1_547200_254400 0 1.695625e-07
I13392 n1_m1_547200_259200 0 1.665428e-07
I13393 n1_m1_547200_264000 0 2.396070e-07
I13394 n1_m1_547200_268800 0 1.541235e-07
I13395 n1_m1_547200_273600 0 2.273011e-07
I13396 n1_m1_547200_278400 0 1.498019e-07
I13397 n1_m1_547200_283200 0 1.481840e-07
I13398 n1_m1_547200_288000 0 2.222645e-07
I13399 n1_m1_547200_292800 0 1.470515e-07
I13400 n1_m1_547200_297600 0 2.224086e-07
I13401 n1_m1_547200_302400 0 1.526157e-07
I13402 n1_m1_547200_307200 0 1.535524e-07
I13403 n1_m1_547200_312000 0 2.336254e-07
I13404 n1_m1_547200_316800 0 1.542159e-07
I13405 n1_m1_547200_321600 0 3.121103e-07
I13406 n1_m1_547200_326400 0 2.793294e-07
I13407 n1_m1_547200_331200 0 2.563506e-07
I13408 n1_m1_547200_336000 0 2.655484e-07
I13409 n1_m1_547200_340800 0 1.570351e-07
I13410 n1_m1_547200_345600 0 2.283813e-07
I13411 n1_m1_547200_350400 0 1.593009e-07
I13412 n1_m1_547200_355200 0 1.559549e-07
I13413 n1_m1_547200_360000 0 2.302005e-07
I13414 n1_m1_547200_364800 0 1.532282e-07
I13415 n1_m1_547200_369600 0 2.333636e-07
I13416 n1_m1_547200_374400 0 1.635571e-07
I13417 n1_m1_547200_379200 0 1.705496e-07
I13418 n1_m1_547200_384000 0 2.460454e-07
I13419 n1_m1_547200_388800 0 1.532282e-07
I13420 n1_m1_547200_393600 0 2.298422e-07
I13421 n1_m1_547200_398400 0 1.533553e-07
I13422 n1_m1_547200_403200 0 1.544763e-07
I13423 n1_m1_547200_408000 0 2.302352e-07
I13424 n1_m1_547200_412800 0 1.532282e-07
I13425 n1_m1_547200_417600 0 2.265112e-07
I13426 n1_m1_547200_422400 0 1.493261e-07
I13427 n1_m1_547200_427200 0 1.554171e-07
I13428 n1_m1_547200_432000 0 2.386913e-07
I13429 n1_m1_547200_436800 0 1.541799e-07
I13430 n1_m1_547200_441600 0 2.222271e-07
I13431 n1_m1_547200_446400 0 1.466701e-07
I13432 n1_m1_547200_451200 0 1.478489e-07
I13433 n1_m1_547200_456000 0 2.219409e-07
I13434 n1_m1_547200_460800 0 1.466701e-07
I13435 n1_m1_547200_465600 0 2.206118e-07
I13436 n1_m1_547200_470400 0 1.481840e-07
I13437 n1_m1_547200_475200 0 1.501826e-07
I13438 n1_m1_547200_480000 0 2.377810e-07
I13439 n1_m1_547200_484800 0 1.670282e-07
I13440 n1_m1_547200_489600 0 2.569189e-07
I13441 n1_m1_547200_494400 0 1.774449e-07
I13442 n1_m1_547200_499200 0 1.868153e-07
I13443 n1_m1_547200_504000 0 2.680833e-07
I13444 n1_m1_547200_508800 0 1.582798e-07
I13445 n1_m1_547200_513600 0 2.249952e-07
I13446 n1_m1_547200_518400 0 1.534117e-07
I13447 n1_m1_547200_523200 0 1.570935e-07
I13448 n1_m1_547200_528000 0 2.373738e-07
I13449 n1_m1_547200_532800 0 1.554620e-07
I13450 n1_m1_547200_537600 0 2.233705e-07
I13451 n1_m1_547200_542400 0 1.465661e-07
I13452 n1_m1_547200_547200 0 1.465661e-07
I13453 n1_m1_547200_552000 0 2.198491e-07
I13454 n1_m1_547200_556800 0 1.465661e-07
I13455 n1_m1_552000_0 0 2.377416e-07
I13456 n1_m1_552000_4800 0 2.313674e-07
I13457 n1_m1_552000_9600 0 3.327291e-07
I13458 n1_m1_552000_14400 0 2.177808e-07
I13459 n1_m1_552000_19200 0 2.179885e-07
I13460 n1_m1_552000_24000 0 3.295079e-07
I13461 n1_m1_552000_28800 0 2.194242e-07
I13462 n1_m1_552000_33600 0 3.272397e-07
I13463 n1_m1_552000_38400 0 2.190673e-07
I13464 n1_m1_552000_43200 0 2.198491e-07
I13465 n1_m1_552000_48000 0 3.314490e-07
I13466 n1_m1_552000_52800 0 2.263776e-07
I13467 n1_m1_552000_57600 0 3.417433e-07
I13468 n1_m1_552000_62400 0 2.291743e-07
I13469 n1_m1_552000_67200 0 2.306672e-07
I13470 n1_m1_552000_72000 0 3.449248e-07
I13471 n1_m1_552000_76800 0 2.291230e-07
I13472 n1_m1_552000_81600 0 3.414799e-07
I13473 n1_m1_552000_86400 0 2.276533e-07
I13474 n1_m1_552000_91200 0 2.276533e-07
I13475 n1_m1_552000_96000 0 3.351669e-07
I13476 n1_m1_552000_100800 0 2.203311e-07
I13477 n1_m1_552000_105600 0 3.410017e-07
I13478 n1_m1_552000_110400 0 2.260360e-07
I13479 n1_m1_552000_115200 0 2.472062e-07
I13480 n1_m1_552000_120000 0 3.545363e-07
I13481 n1_m1_552000_124800 0 2.410013e-07
I13482 n1_m1_552000_129600 0 3.537059e-07
I13483 n1_m1_552000_134400 0 2.327260e-07
I13484 n1_m1_552000_139200 0 2.391454e-07
I13485 n1_m1_552000_144000 0 3.496658e-07
I13486 n1_m1_552000_148800 0 2.301057e-07
I13487 n1_m1_552000_153600 0 3.447634e-07
I13488 n1_m1_552000_158400 0 2.301706e-07
I13489 n1_m1_552000_163200 0 2.317654e-07
I13490 n1_m1_552000_168000 0 3.511909e-07
I13491 n1_m1_552000_172800 0 2.411576e-07
I13492 n1_m1_552000_177600 0 3.573517e-07
I13493 n1_m1_552000_182400 0 2.320013e-07
I13494 n1_m1_552000_187200 0 2.310319e-07
I13495 n1_m1_552000_192000 0 3.535383e-07
I13496 n1_m1_552000_196800 0 2.404934e-07
I13497 n1_m1_552000_201600 0 3.587504e-07
I13498 n1_m1_552000_206400 0 2.335180e-07
I13499 n1_m1_552000_211200 0 2.368844e-07
I13500 n1_m1_552000_216000 0 3.571889e-07
I13501 n1_m1_552000_220800 0 2.401243e-07
I13502 n1_m1_552000_225600 0 3.601504e-07
I13503 n1_m1_552000_230400 0 2.388361e-07
I13504 n1_m1_552000_235200 0 2.353799e-07
I13505 n1_m1_552000_240000 0 3.455965e-07
I13506 n1_m1_552000_244800 0 2.321651e-07
I13507 n1_m1_552000_249600 0 3.610845e-07
I13508 n1_m1_552000_254400 0 2.495984e-07
I13509 n1_m1_552000_259200 0 2.477558e-07
I13510 n1_m1_552000_264000 0 3.521481e-07
I13511 n1_m1_552000_268800 0 2.305628e-07
I13512 n1_m1_552000_273600 0 3.440706e-07
I13513 n1_m1_552000_278400 0 2.267253e-07
I13514 n1_m1_552000_283200 0 2.234181e-07
I13515 n1_m1_552000_288000 0 3.330999e-07
I13516 n1_m1_552000_292800 0 2.155758e-07
I13517 n1_m1_552000_297600 0 3.273722e-07
I13518 n1_m1_552000_302400 0 2.215632e-07
I13519 n1_m1_552000_307200 0 2.275112e-07
I13520 n1_m1_552000_312000 0 3.431482e-07
I13521 n1_m1_552000_316800 0 2.237328e-07
I13522 n1_m1_552000_321600 0 3.622167e-07
I13523 n1_m1_552000_326400 0 2.654348e-07
I13524 n1_m1_552000_331200 0 2.633363e-07
I13525 n1_m1_552000_336000 0 3.644988e-07
I13526 n1_m1_552000_340800 0 2.351141e-07
I13527 n1_m1_552000_345600 0 3.462270e-07
I13528 n1_m1_552000_350400 0 2.315567e-07
I13529 n1_m1_552000_355200 0 2.302331e-07
I13530 n1_m1_552000_360000 0 3.447634e-07
I13531 n1_m1_552000_364800 0 2.298422e-07
I13532 n1_m1_552000_369600 0 3.452916e-07
I13533 n1_m1_552000_374400 0 2.318110e-07
I13534 n1_m1_552000_379200 0 2.361746e-07
I13535 n1_m1_552000_384000 0 3.605026e-07
I13536 n1_m1_552000_388800 0 2.388361e-07
I13537 n1_m1_552000_393600 0 3.561933e-07
I13538 n1_m1_552000_398400 0 2.320241e-07
I13539 n1_m1_552000_403200 0 2.310319e-07
I13540 n1_m1_552000_408000 0 3.465479e-07
I13541 n1_m1_552000_412800 0 2.310319e-07
I13542 n1_m1_552000_417600 0 3.409565e-07
I13543 n1_m1_552000_422400 0 2.239891e-07
I13544 n1_m1_552000_427200 0 2.331257e-07
I13545 n1_m1_552000_432000 0 3.597531e-07
I13546 n1_m1_552000_436800 0 2.336967e-07
I13547 n1_m1_552000_441600 0 3.344847e-07
I13548 n1_m1_552000_446400 0 2.198491e-07
I13549 n1_m1_552000_451200 0 2.198491e-07
I13550 n1_m1_552000_456000 0 3.297737e-07
I13551 n1_m1_552000_460800 0 2.198491e-07
I13552 n1_m1_552000_465600 0 3.303345e-07
I13553 n1_m1_552000_470400 0 2.210388e-07
I13554 n1_m1_552000_475200 0 2.216955e-07
I13555 n1_m1_552000_480000 0 3.399381e-07
I13556 n1_m1_552000_484800 0 2.321237e-07
I13557 n1_m1_552000_489600 0 3.516634e-07
I13558 n1_m1_552000_494400 0 2.424288e-07
I13559 n1_m1_552000_499200 0 2.441420e-07
I13560 n1_m1_552000_504000 0 3.522083e-07
I13561 n1_m1_552000_508800 0 2.247553e-07
I13562 n1_m1_552000_513600 0 3.419119e-07
I13563 n1_m1_552000_518400 0 2.301991e-07
I13564 n1_m1_552000_523200 0 2.332827e-07
I13565 n1_m1_552000_528000 0 3.595604e-07
I13566 n1_m1_552000_532800 0 2.342678e-07
I13567 n1_m1_552000_537600 0 3.420238e-07
I13568 n1_m1_552000_542400 0 2.213542e-07
I13569 n1_m1_552000_547200 0 2.198491e-07
I13570 n1_m1_552000_552000 0 3.297737e-07
I13571 n1_m1_552000_556800 0 2.198491e-07
I13572 n1_m1_556800_0 0 1.686462e-07
I13573 n1_m1_556800_4800 0 1.641064e-07
I13574 n1_m1_556800_9600 0 2.289231e-07
I13575 n1_m1_556800_14400 0 1.467496e-07
I13576 n1_m1_556800_19200 0 1.465661e-07
I13577 n1_m1_556800_24000 0 2.198491e-07
I13578 n1_m1_556800_28800 0 1.447306e-07
I13579 n1_m1_556800_33600 0 2.159946e-07
I13580 n1_m1_556800_38400 0 1.465661e-07
I13581 n1_m1_556800_43200 0 1.465661e-07
I13582 n1_m1_556800_48000 0 2.249612e-07
I13583 n1_m1_556800_52800 0 1.529345e-07
I13584 n1_m1_556800_57600 0 2.309802e-07
I13585 n1_m1_556800_62400 0 1.581105e-07
I13586 n1_m1_556800_67200 0 1.576700e-07
I13587 n1_m1_556800_72000 0 2.305397e-07
I13588 n1_m1_556800_76800 0 1.532282e-07
I13589 n1_m1_556800_81600 0 2.298422e-07
I13590 n1_m1_556800_86400 0 1.532282e-07
I13591 n1_m1_556800_91200 0 1.532282e-07
I13592 n1_m1_556800_96000 0 2.280761e-07
I13593 n1_m1_556800_100800 0 1.476633e-07
I13594 n1_m1_556800_105600 0 2.214045e-07
I13595 n1_m1_556800_110400 0 1.507917e-07
I13596 n1_m1_556800_115200 0 1.673817e-07
I13597 n1_m1_556800_120000 0 2.401372e-07
I13598 n1_m1_556800_124800 0 1.634307e-07
I13599 n1_m1_556800_129600 0 2.405832e-07
I13600 n1_m1_556800_134400 0 1.483499e-07
I13601 n1_m1_556800_139200 0 1.521813e-07
I13602 n1_m1_556800_144000 0 2.351760e-07
I13603 n1_m1_556800_148800 0 1.543662e-07
I13604 n1_m1_556800_153600 0 2.298422e-07
I13605 n1_m1_556800_158400 0 1.532282e-07
I13606 n1_m1_556800_163200 0 1.532282e-07
I13607 n1_m1_556800_168000 0 2.303861e-07
I13608 n1_m1_556800_172800 0 1.561459e-07
I13609 n1_m1_556800_177600 0 2.387463e-07
I13610 n1_m1_556800_182400 0 1.583675e-07
I13611 n1_m1_556800_187200 0 1.583675e-07
I13612 n1_m1_556800_192000 0 2.434520e-07
I13613 n1_m1_556800_196800 0 1.650296e-07
I13614 n1_m1_556800_201600 0 2.403344e-07
I13615 n1_m1_556800_206400 0 1.547509e-07
I13616 n1_m1_556800_211200 0 1.589861e-07
I13617 n1_m1_556800_216000 0 2.398354e-07
I13618 n1_m1_556800_220800 0 1.611384e-07
I13619 n1_m1_556800_225600 0 2.473608e-07
I13620 n1_m1_556800_230400 0 1.650296e-07
I13621 n1_m1_556800_235200 0 1.620792e-07
I13622 n1_m1_556800_240000 0 2.330360e-07
I13623 n1_m1_556800_244800 0 1.494838e-07
I13624 n1_m1_556800_249600 0 2.258124e-07
I13625 n1_m1_556800_254400 0 1.601486e-07
I13626 n1_m1_556800_259200 0 1.611737e-07
I13627 n1_m1_556800_264000 0 2.381386e-07
I13628 n1_m1_556800_268800 0 1.583675e-07
I13629 n1_m1_556800_273600 0 2.405614e-07
I13630 n1_m1_556800_278400 0 1.627454e-07
I13631 n1_m1_556800_283200 0 1.619841e-07
I13632 n1_m1_556800_288000 0 2.344119e-07
I13633 n1_m1_556800_292800 0 1.470419e-07
I13634 n1_m1_556800_297600 0 2.184909e-07
I13635 n1_m1_556800_302400 0 1.427646e-07
I13636 n1_m1_556800_307200 0 1.469943e-07
I13637 n1_m1_556800_312000 0 2.231149e-07
I13638 n1_m1_556800_316800 0 1.508788e-07
I13639 n1_m1_556800_321600 0 2.232141e-07
I13640 n1_m1_556800_326400 0 1.503295e-07
I13641 n1_m1_556800_331200 0 1.525293e-07
I13642 n1_m1_556800_336000 0 2.402759e-07
I13643 n1_m1_556800_340800 0 1.640072e-07
I13644 n1_m1_556800_345600 0 2.438653e-07
I13645 n1_m1_556800_350400 0 1.546231e-07
I13646 n1_m1_556800_355200 0 1.532282e-07
I13647 n1_m1_556800_360000 0 2.298422e-07
I13648 n1_m1_556800_364800 0 1.532282e-07
I13649 n1_m1_556800_369600 0 2.271257e-07
I13650 n1_m1_556800_374400 0 1.480888e-07
I13651 n1_m1_556800_379200 0 1.486327e-07
I13652 n1_m1_556800_384000 0 2.359809e-07
I13653 n1_m1_556800_388800 0 1.650296e-07
I13654 n1_m1_556800_393600 0 2.419265e-07
I13655 n1_m1_556800_398400 0 1.585959e-07
I13656 n1_m1_556800_403200 0 1.583675e-07
I13657 n1_m1_556800_408000 0 2.375512e-07
I13658 n1_m1_556800_412800 0 1.583675e-07
I13659 n1_m1_556800_417600 0 2.316505e-07
I13660 n1_m1_556800_422400 0 1.493261e-07
I13661 n1_m1_556800_427200 0 1.554171e-07
I13662 n1_m1_556800_432000 0 2.398354e-07
I13663 n1_m1_556800_436800 0 1.557978e-07
I13664 n1_m1_556800_441600 0 2.229898e-07
I13665 n1_m1_556800_446400 0 1.465661e-07
I13666 n1_m1_556800_451200 0 1.465661e-07
I13667 n1_m1_556800_456000 0 2.198491e-07
I13668 n1_m1_556800_460800 0 1.465661e-07
I13669 n1_m1_556800_465600 0 2.222719e-07
I13670 n1_m1_556800_470400 0 1.517054e-07
I13671 n1_m1_556800_475200 0 1.517054e-07
I13672 n1_m1_556800_480000 0 2.251298e-07
I13673 n1_m1_556800_484800 0 1.480888e-07
I13674 n1_m1_556800_489600 0 2.278912e-07
I13675 n1_m1_556800_494400 0 1.587006e-07
I13676 n1_m1_556800_499200 0 1.598427e-07
I13677 n1_m1_556800_504000 0 2.315472e-07
I13678 n1_m1_556800_508800 0 1.520535e-07
I13679 n1_m1_556800_513600 0 2.296573e-07
I13680 n1_m1_556800_518400 0 1.513927e-07
I13681 n1_m1_556800_523200 0 1.512921e-07
I13682 n1_m1_556800_528000 0 2.395825e-07
I13683 n1_m1_556800_532800 0 1.561785e-07
I13684 n1_m1_556800_537600 0 2.293188e-07
I13685 n1_m1_556800_542400 0 1.478509e-07
I13686 n1_m1_556800_547200 0 1.465661e-07
I13687 n1_m1_556800_552000 0 2.198491e-07
I13688 n1_m1_556800_556800 0 1.465661e-07
I13689 n1_m1_4000_0 0 8.113479e-08
I13690 n1_m1_4000_4800 0 8.096824e-08
I13691 n1_m1_4000_9600 0 1.166342e-07
I13692 n1_m1_4000_14400 0 7.436223e-08
I13693 n1_m1_4000_19200 0 7.305530e-08
I13694 n1_m1_4000_24000 0 1.069725e-07
I13695 n1_m1_4000_28800 0 7.071677e-08
I13696 n1_m1_4000_33600 0 1.065340e-07
I13697 n1_m1_4000_38400 0 7.209338e-08
I13698 n1_m1_4000_43200 0 7.275619e-08
I13699 n1_m1_4000_48000 0 1.099246e-07
I13700 n1_m1_4000_52800 0 7.328303e-08
I13701 n1_m1_4000_57600 0 1.099246e-07
I13702 n1_m1_4000_62400 0 7.328303e-08
I13703 n1_m1_4000_67200 0 7.328303e-08
I13704 n1_m1_4000_72000 0 1.099246e-07
I13705 n1_m1_4000_76800 0 7.328303e-08
I13706 n1_m1_4000_81600 0 1.099246e-07
I13707 n1_m1_4000_86400 0 7.328303e-08
I13708 n1_m1_4000_91200 0 7.328303e-08
I13709 n1_m1_4000_96000 0 1.099246e-07
I13710 n1_m1_4000_100800 0 7.325754e-08
I13711 n1_m1_4000_105600 0 1.084630e-07
I13712 n1_m1_4000_110400 0 7.228882e-08
I13713 n1_m1_4000_115200 0 7.315557e-08
I13714 n1_m1_4000_120000 0 1.099246e-07
I13715 n1_m1_4000_124800 0 7.292614e-08
I13716 n1_m1_4000_129600 0 1.081486e-07
I13717 n1_m1_4000_134400 0 7.279018e-08
I13718 n1_m1_4000_139200 0 7.161751e-08
I13719 n1_m1_4000_144000 0 1.059562e-07
I13720 n1_m1_4000_148800 0 7.023921e-08
I13721 n1_m1_4000_153600 0 1.089252e-07
I13722 n1_m1_4000_158400 0 7.296183e-08
I13723 n1_m1_4000_163200 0 7.140167e-08
I13724 n1_m1_4000_168000 0 1.062876e-07
I13725 n1_m1_4000_172800 0 7.027490e-08
I13726 n1_m1_4000_177600 0 1.066870e-07
I13727 n1_m1_4000_182400 0 7.047884e-08
I13728 n1_m1_4000_187200 0 7.051283e-08
I13729 n1_m1_4000_192000 0 1.057013e-07
I13730 n1_m1_4000_196800 0 7.085273e-08
I13731 n1_m1_4000_201600 0 1.070949e-07
I13732 n1_m1_4000_206400 0 7.308419e-08
I13733 n1_m1_4000_211200 0 7.328303e-08
I13734 n1_m1_4000_216000 0 1.099246e-07
I13735 n1_m1_4000_220800 0 7.328303e-08
I13736 n1_m1_4000_225600 0 1.099246e-07
I13737 n1_m1_4000_230400 0 7.328303e-08
I13738 n1_m1_4000_235200 0 7.328303e-08
I13739 n1_m1_4000_240000 0 1.098532e-07
I13740 n1_m1_4000_244800 0 7.085613e-08
I13741 n1_m1_4000_249600 0 1.052798e-07
I13742 n1_m1_4000_254400 0 7.200840e-08
I13743 n1_m1_4000_259200 0 7.310459e-08
I13744 n1_m1_4000_264000 0 1.099246e-07
I13745 n1_m1_4000_268800 0 7.328303e-08
I13746 n1_m1_4000_273600 0 1.099246e-07
I13747 n1_m1_4000_278400 0 7.435373e-08
I13748 n1_m1_4000_283200 0 7.542442e-08
I13749 n1_m1_4000_288000 0 1.131213e-07
I13750 n1_m1_4000_292800 0 7.392545e-08
I13751 n1_m1_4000_297600 0 1.099246e-07
I13752 n1_m1_4000_302400 0 7.328303e-08
I13753 n1_m1_4000_307200 0 7.328303e-08
I13754 n1_m1_4000_312000 0 1.105058e-07
I13755 n1_m1_4000_316800 0 7.537854e-08
I13756 n1_m1_4000_321600 0 1.131366e-07
I13757 n1_m1_4000_326400 0 7.598526e-08
I13758 n1_m1_4000_331200 0 7.744005e-08
I13759 n1_m1_4000_336000 0 1.181332e-07
I13760 n1_m1_4000_340800 0 7.875547e-08
I13761 n1_m1_4000_345600 0 1.146781e-07
I13762 n1_m1_4000_350400 0 7.634216e-08
I13763 n1_m1_4000_355200 0 7.552979e-08
I13764 n1_m1_4000_360000 0 1.103987e-07
I13765 n1_m1_4000_364800 0 7.328303e-08
I13766 n1_m1_4000_369600 0 1.099246e-07
I13767 n1_m1_4000_374400 0 7.328303e-08
I13768 n1_m1_4000_379200 0 7.328303e-08
I13769 n1_m1_4000_384000 0 1.115306e-07
I13770 n1_m1_4000_388800 0 7.542442e-08
I13771 n1_m1_4000_393600 0 1.131366e-07
I13772 n1_m1_4000_398400 0 7.542442e-08
I13773 n1_m1_4000_403200 0 7.542442e-08
I13774 n1_m1_4000_408000 0 1.131366e-07
I13775 n1_m1_4000_412800 0 7.542442e-08
I13776 n1_m1_4000_417600 0 1.120659e-07
I13777 n1_m1_4000_422400 0 7.279018e-08
I13778 n1_m1_4000_427200 0 7.248426e-08
I13779 n1_m1_4000_432000 0 1.099246e-07
I13780 n1_m1_4000_436800 0 7.328303e-08
I13781 n1_m1_4000_441600 0 1.112502e-07
I13782 n1_m1_4000_446400 0 7.526807e-08
I13783 n1_m1_4000_451200 0 7.542442e-08
I13784 n1_m1_4000_456000 0 1.131366e-07
I13785 n1_m1_4000_460800 0 7.507262e-08
I13786 n1_m1_4000_465600 0 1.101540e-07
I13787 n1_m1_4000_470400 0 7.328303e-08
I13788 n1_m1_4000_475200 0 7.292614e-08
I13789 n1_m1_4000_480000 0 1.067108e-07
I13790 n1_m1_4000_484800 0 6.995199e-08
I13791 n1_m1_4000_489600 0 1.049280e-07
I13792 n1_m1_4000_494400 0 6.995199e-08
I13793 n1_m1_4000_499200 0 6.995199e-08
I13794 n1_m1_4000_504000 0 1.049280e-07
I13795 n1_m1_4000_508800 0 6.995199e-08
I13796 n1_m1_4000_513600 0 1.049280e-07
I13797 n1_m1_4000_518400 0 7.114165e-08
I13798 n1_m1_4000_523200 0 7.237889e-08
I13799 n1_m1_4000_528000 0 1.049994e-07
I13800 n1_m1_4000_532800 0 6.995199e-08
I13801 n1_m1_4000_537600 0 1.047597e-07
I13802 n1_m1_4000_542400 0 6.838504e-08
I13803 n1_m1_4000_547200 0 7.123342e-08
I13804 n1_m1_4000_552000 0 1.188844e-07
I13805 n1_m1_4000_556800 0 8.532239e-08
I13806 n1_m1_32000_0 0 7.574257e-08
I13807 n1_m1_32000_4800 0 7.384523e-08
I13808 n1_m1_32000_9600 0 1.097420e-07
I13809 n1_m1_32000_14400 0 7.252539e-08
I13810 n1_m1_32000_19200 0 7.020250e-08
I13811 n1_m1_32000_24000 0 1.049280e-07
I13812 n1_m1_32000_28800 0 7.114165e-08
I13813 n1_m1_32000_33600 0 1.100316e-07
I13814 n1_m1_32000_38400 0 7.342579e-08
I13815 n1_m1_32000_43200 0 7.350533e-08
I13816 n1_m1_32000_48000 0 1.107420e-07
I13817 n1_m1_32000_52800 0 7.627962e-08
I13818 n1_m1_32000_57600 0 1.144323e-07
I13819 n1_m1_32000_62400 0 7.359235e-08
I13820 n1_m1_32000_67200 0 7.342579e-08
I13821 n1_m1_32000_72000 0 1.101387e-07
I13822 n1_m1_32000_76800 0 7.342579e-08
I13823 n1_m1_32000_81600 0 1.100377e-07
I13824 n1_m1_32000_86400 0 7.328303e-08
I13825 n1_m1_32000_91200 0 7.328303e-08
I13826 n1_m1_32000_96000 0 1.099246e-07
I13827 n1_m1_32000_100800 0 7.328303e-08
I13828 n1_m1_32000_105600 0 1.099246e-07
I13829 n1_m1_32000_110400 0 7.328303e-08
I13830 n1_m1_32000_115200 0 7.328303e-08
I13831 n1_m1_32000_120000 0 1.099246e-07
I13832 n1_m1_32000_124800 0 7.332586e-08
I13833 n1_m1_32000_129600 0 1.100418e-07
I13834 n1_m1_32000_134400 0 7.328303e-08
I13835 n1_m1_32000_139200 0 7.328303e-08
I13836 n1_m1_32000_144000 0 1.099317e-07
I13837 n1_m1_32000_148800 0 7.341696e-08
I13838 n1_m1_32000_153600 0 1.139371e-07
I13839 n1_m1_32000_158400 0 7.650395e-08
I13840 n1_m1_32000_163200 0 7.659675e-08
I13841 n1_m1_32000_168000 0 1.149211e-07
I13842 n1_m1_32000_172800 0 7.747947e-08
I13843 n1_m1_32000_177600 0 1.196352e-07
I13844 n1_m1_32000_182400 0 7.980237e-08
I13845 n1_m1_32000_187200 0 7.980237e-08
I13846 n1_m1_32000_192000 0 1.195771e-07
I13847 n1_m1_32000_196800 0 7.965961e-08
I13848 n1_m1_32000_201600 0 1.194894e-07
I13849 n1_m1_32000_206400 0 7.881359e-08
I13850 n1_m1_32000_211200 0 7.427181e-08
I13851 n1_m1_32000_216000 0 1.101387e-07
I13852 n1_m1_32000_220800 0 7.339112e-08
I13853 n1_m1_32000_225600 0 1.099297e-07
I13854 n1_m1_32000_230400 0 7.328303e-08
I13855 n1_m1_32000_235200 0 7.328303e-08
I13856 n1_m1_32000_240000 0 1.101122e-07
I13857 n1_m1_32000_244800 0 7.564468e-08
I13858 n1_m1_32000_249600 0 1.150802e-07
I13859 n1_m1_32000_254400 0 7.701177e-08
I13860 n1_m1_32000_259200 0 7.700871e-08
I13861 n1_m1_32000_264000 0 1.159174e-07
I13862 n1_m1_32000_268800 0 7.966947e-08
I13863 n1_m1_32000_273600 0 1.197800e-07
I13864 n1_m1_32000_278400 0 8.327618e-08
I13865 n1_m1_32000_283200 0 8.654808e-08
I13866 n1_m1_32000_288000 0 1.296739e-07
I13867 n1_m1_32000_292800 0 8.423266e-08
I13868 n1_m1_32000_297600 0 1.211811e-07
I13869 n1_m1_32000_302400 0 7.981970e-08
I13870 n1_m1_32000_307200 0 7.980237e-08
I13871 n1_m1_32000_312000 0 1.205689e-07
I13872 n1_m1_32000_316800 0 8.226191e-08
I13873 n1_m1_32000_321600 0 1.181322e-07
I13874 n1_m1_32000_326400 0 7.661408e-08
I13875 n1_m1_32000_331200 0 7.661408e-08
I13876 n1_m1_32000_336000 0 1.150343e-07
I13877 n1_m1_32000_340800 0 7.889755e-08
I13878 n1_m1_32000_345600 0 1.194850e-07
I13879 n1_m1_32000_350400 0 7.718954e-08
I13880 n1_m1_32000_355200 0 7.674970e-08
I13881 n1_m1_32000_360000 0 1.149874e-07
I13882 n1_m1_32000_364800 0 7.675174e-08
I13883 n1_m1_32000_369600 0 1.151353e-07
I13884 n1_m1_32000_374400 0 7.669362e-08
I13885 n1_m1_32000_379200 0 7.661408e-08
I13886 n1_m1_32000_384000 0 1.149211e-07
I13887 n1_m1_32000_388800 0 7.670586e-08
I13888 n1_m1_32000_393600 0 1.149670e-07
I13889 n1_m1_32000_398400 0 7.624223e-08
I13890 n1_m1_32000_403200 0 7.389792e-08
I13891 n1_m1_32000_408000 0 1.099246e-07
I13892 n1_m1_32000_412800 0 7.328303e-08
I13893 n1_m1_32000_417600 0 1.131842e-07
I13894 n1_m1_32000_422400 0 7.848151e-08
I13895 n1_m1_32000_427200 0 7.556650e-08
I13896 n1_m1_32000_432000 0 1.101387e-07
I13897 n1_m1_32000_436800 0 7.342579e-08
I13898 n1_m1_32000_441600 0 1.136281e-07
I13899 n1_m1_32000_446400 0 7.946927e-08
I13900 n1_m1_32000_451200 0 8.230066e-08
I13901 n1_m1_32000_456000 0 1.171757e-07
I13902 n1_m1_32000_460800 0 7.893086e-08
I13903 n1_m1_32000_465600 0 1.150486e-07
I13904 n1_m1_32000_470400 0 7.647132e-08
I13905 n1_m1_32000_475200 0 7.551484e-08
I13906 n1_m1_32000_480000 0 1.100432e-07
I13907 n1_m1_32000_484800 0 7.342579e-08
I13908 n1_m1_32000_489600 0 1.166448e-07
I13909 n1_m1_32000_494400 0 7.998728e-08
I13910 n1_m1_32000_499200 0 8.228468e-08
I13911 n1_m1_32000_504000 0 1.244585e-07
I13912 n1_m1_32000_508800 0 8.238087e-08
I13913 n1_m1_32000_513600 0 1.170527e-07
I13914 n1_m1_32000_518400 0 7.214436e-08
I13915 n1_m1_32000_523200 0 7.009475e-08
I13916 n1_m1_32000_528000 0 1.051421e-07
I13917 n1_m1_32000_532800 0 7.001521e-08
I13918 n1_m1_32000_537600 0 1.049280e-07
I13919 n1_m1_32000_542400 0 6.995709e-08
I13920 n1_m1_32000_547200 0 7.006008e-08
I13921 n1_m1_32000_552000 0 1.059042e-07
I13922 n1_m1_32000_556800 0 7.280717e-08
I13923 n1_m1_60000_0 0 6.961480e-08
I13924 n1_m1_60000_4800 0 6.881399e-08
I13925 n1_m1_60000_9600 0 1.046013e-07
I13926 n1_m1_60000_14400 0 6.995199e-08
I13927 n1_m1_60000_19200 0 7.045164e-08
I13928 n1_m1_60000_24000 0 1.095201e-07
I13929 n1_m1_60000_28800 0 7.447269e-08
I13930 n1_m1_60000_33600 0 1.124228e-07
I13931 n1_m1_60000_38400 0 7.328303e-08
I13932 n1_m1_60000_43200 0 7.328303e-08
I13933 n1_m1_60000_48000 0 1.099246e-07
I13934 n1_m1_60000_52800 0 7.328303e-08
I13935 n1_m1_60000_57600 0 1.099246e-07
I13936 n1_m1_60000_62400 0 7.354646e-08
I13937 n1_m1_60000_67200 0 7.442103e-08
I13938 n1_m1_60000_72000 0 1.101248e-07
I13939 n1_m1_60000_76800 0 7.389282e-08
I13940 n1_m1_60000_81600 0 1.137515e-07
I13941 n1_m1_60000_86400 0 7.661408e-08
I13942 n1_m1_60000_91200 0 7.661408e-08
I13943 n1_m1_60000_96000 0 1.149211e-07
I13944 n1_m1_60000_100800 0 7.654270e-08
I13945 n1_m1_60000_105600 0 1.119031e-07
I13946 n1_m1_60000_110400 0 7.850394e-08
I13947 n1_m1_60000_115200 0 7.979081e-08
I13948 n1_m1_60000_120000 0 1.128277e-07
I13949 n1_m1_60000_124800 0 7.328303e-08
I13950 n1_m1_60000_129600 0 1.109150e-07
I13951 n1_m1_60000_134400 0 7.584522e-08
I13952 n1_m1_60000_139200 0 7.827961e-08
I13953 n1_m1_60000_144000 0 1.212664e-07
I13954 n1_m1_60000_148800 0 8.139651e-08
I13955 n1_m1_60000_153600 0 1.178487e-07
I13956 n1_m1_60000_158400 0 7.672999e-08
I13957 n1_m1_60000_163200 0 7.661408e-08
I13958 n1_m1_60000_168000 0 1.155839e-07
I13959 n1_m1_60000_172800 0 7.796622e-08
I13960 n1_m1_60000_177600 0 1.149609e-07
I13961 n1_m1_60000_182400 0 7.743597e-08
I13962 n1_m1_60000_187200 0 7.878470e-08
I13963 n1_m1_60000_192000 0 1.193467e-07
I13964 n1_m1_60000_196800 0 7.956444e-08
I13965 n1_m1_60000_201600 0 1.190832e-07
I13966 n1_m1_60000_206400 0 7.827791e-08
I13967 n1_m1_60000_211200 0 7.824596e-08
I13968 n1_m1_60000_216000 0 1.152525e-07
I13969 n1_m1_60000_220800 0 7.661408e-08
I13970 n1_m1_60000_225600 0 1.149211e-07
I13971 n1_m1_60000_230400 0 7.817356e-08
I13972 n1_m1_60000_235200 0 8.021773e-08
I13973 n1_m1_60000_240000 0 1.243912e-07
I13974 n1_m1_60000_244800 0 8.357325e-08
I13975 n1_m1_60000_249600 0 1.211074e-07
I13976 n1_m1_60000_254400 0 7.994513e-08
I13977 n1_m1_60000_259200 0 7.994513e-08
I13978 n1_m1_60000_264000 0 1.193609e-07
I13979 n1_m1_60000_268800 0 7.810252e-08
I13980 n1_m1_60000_273600 0 1.182209e-07
I13981 n1_m1_60000_278400 0 8.215790e-08
I13982 n1_m1_60000_283200 0 8.513952e-08
I13983 n1_m1_60000_288000 0 1.265798e-07
I13984 n1_m1_60000_292800 0 8.289548e-08
I13985 n1_m1_60000_297600 0 1.211311e-07
I13986 n1_m1_60000_302400 0 8.249100e-08
I13987 n1_m1_60000_307200 0 8.310962e-08
I13988 n1_m1_60000_312000 0 1.269448e-07
I13989 n1_m1_60000_316800 0 8.007973e-08
I13990 n1_m1_60000_321600 0 1.188837e-07
I13991 n1_m1_60000_326400 0 7.739382e-08
I13992 n1_m1_60000_331200 0 7.661408e-08
I13993 n1_m1_60000_336000 0 1.149211e-07
I13994 n1_m1_60000_340800 0 7.661408e-08
I13995 n1_m1_60000_345600 0 1.153732e-07
I13996 n1_m1_60000_350400 0 7.918375e-08
I13997 n1_m1_60000_355200 0 7.720891e-08
I13998 n1_m1_60000_360000 0 1.152794e-07
I13999 n1_m1_60000_364800 0 7.832107e-08
I14000 n1_m1_60000_369600 0 1.229534e-07
I14001 n1_m1_60000_374400 0 1.035296e-07
I14002 n1_m1_60000_379200 0 1.392650e-07
I14003 n1_m1_60000_384000 0 2.164586e-07
I14004 n1_m1_60000_388800 0 9.997220e-08
I14005 n1_m1_60000_393600 0 1.214309e-07
I14006 n1_m1_60000_398400 0 7.803046e-08
I14007 n1_m1_60000_403200 0 7.684590e-08
I14008 n1_m1_60000_408000 0 1.126557e-07
I14009 n1_m1_60000_412800 0 7.363925e-08
I14010 n1_m1_60000_417600 0 1.112627e-07
I14011 n1_m1_60000_422400 0 7.466304e-08
I14012 n1_m1_60000_427200 0 7.551960e-08
I14013 n1_m1_60000_432000 0 1.099246e-07
I14014 n1_m1_60000_436800 0 7.714161e-08
I14015 n1_m1_60000_441600 0 1.552016e-07
I14016 n1_m1_60000_446400 0 1.187692e-07
I14017 n1_m1_60000_451200 0 9.893244e-08
I14018 n1_m1_60000_456000 0 1.253337e-07
I14019 n1_m1_60000_460800 0 8.087306e-08
I14020 n1_m1_60000_465600 0 1.167953e-07
I14021 n1_m1_60000_470400 0 7.661408e-08
I14022 n1_m1_60000_475200 0 7.661408e-08
I14023 n1_m1_60000_480000 0 1.149211e-07
I14024 n1_m1_60000_484800 0 7.661408e-08
I14025 n1_m1_60000_489600 0 1.149211e-07
I14026 n1_m1_60000_494400 0 7.661408e-08
I14027 n1_m1_60000_499200 0 7.660083e-08
I14028 n1_m1_60000_504000 0 1.126941e-07
I14029 n1_m1_60000_508800 0 7.475821e-08
I14030 n1_m1_60000_513600 0 1.129592e-07
I14031 n1_m1_60000_518400 0 7.595127e-08
I14032 n1_m1_60000_523200 0 7.515862e-08
I14033 n1_m1_60000_528000 0 1.143185e-07
I14034 n1_m1_60000_532800 0 7.541151e-08
I14035 n1_m1_60000_537600 0 1.108501e-07
I14036 n1_m1_60000_542400 0 7.478099e-08
I14037 n1_m1_60000_547200 0 7.513890e-08
I14038 n1_m1_60000_552000 0 1.133032e-07
I14039 n1_m1_60000_556800 0 7.770857e-08
I14040 n1_m1_88000_0 0 7.328303e-08
I14041 n1_m1_88000_4800 0 7.344959e-08
I14042 n1_m1_88000_9600 0 1.141835e-07
I14043 n1_m1_88000_14400 0 7.715555e-08
I14044 n1_m1_88000_19200 0 7.927960e-08
I14045 n1_m1_88000_24000 0 1.198541e-07
I14046 n1_m1_88000_28800 0 7.994513e-08
I14047 n1_m1_88000_33600 0 1.174194e-07
I14048 n1_m1_88000_38400 0 7.661408e-08
I14049 n1_m1_88000_43200 0 7.475821e-08
I14050 n1_m1_88000_48000 0 1.099246e-07
I14051 n1_m1_88000_52800 0 7.328303e-08
I14052 n1_m1_88000_57600 0 1.099246e-07
I14053 n1_m1_88000_62400 0 7.328303e-08
I14054 n1_m1_88000_67200 0 7.411614e-08
I14055 n1_m1_88000_72000 0 1.182994e-07
I14056 n1_m1_88000_76800 0 7.959367e-08
I14057 n1_m1_88000_81600 0 1.199177e-07
I14058 n1_m1_88000_86400 0 7.994513e-08
I14059 n1_m1_88000_91200 0 7.818443e-08
I14060 n1_m1_88000_96000 0 1.149211e-07
I14061 n1_m1_88000_100800 0 7.661408e-08
I14062 n1_m1_88000_105600 0 1.149211e-07
I14063 n1_m1_88000_110400 0 7.661408e-08
I14064 n1_m1_88000_115200 0 7.661408e-08
I14065 n1_m1_88000_120000 0 1.149211e-07
I14066 n1_m1_88000_124800 0 7.661408e-08
I14067 n1_m1_88000_129600 0 1.149211e-07
I14068 n1_m1_88000_134400 0 7.661408e-08
I14069 n1_m1_88000_139200 0 7.661408e-08
I14070 n1_m1_88000_144000 0 1.150877e-07
I14071 n1_m1_88000_148800 0 7.920754e-08
I14072 n1_m1_88000_153600 0 1.199177e-07
I14073 n1_m1_88000_158400 0 7.986661e-08
I14074 n1_m1_88000_163200 0 7.948524e-08
I14075 n1_m1_88000_168000 0 1.181298e-07
I14076 n1_m1_88000_172800 0 7.675616e-08
I14077 n1_m1_88000_177600 0 1.153586e-07
I14078 n1_m1_88000_182400 0 7.661408e-08
I14079 n1_m1_88000_187200 0 7.661408e-08
I14080 n1_m1_88000_192000 0 1.153848e-07
I14081 n1_m1_88000_196800 0 7.713753e-08
I14082 n1_m1_88000_201600 0 1.150931e-07
I14083 n1_m1_88000_206400 0 7.661408e-08
I14084 n1_m1_88000_211200 0 7.687479e-08
I14085 n1_m1_88000_216000 0 1.188032e-07
I14086 n1_m1_88000_220800 0 7.994513e-08
I14087 n1_m1_88000_225600 0 1.181930e-07
I14088 n1_m1_88000_230400 0 7.862155e-08
I14089 n1_m1_88000_235200 0 8.118849e-08
I14090 n1_m1_88000_240000 0 1.268639e-07
I14091 n1_m1_88000_244800 0 8.199270e-08
I14092 n1_m1_88000_249600 0 1.201046e-07
I14093 n1_m1_88000_254400 0 7.960421e-08
I14094 n1_m1_88000_259200 0 7.751754e-08
I14095 n1_m1_88000_264000 0 1.150221e-07
I14096 n1_m1_88000_268800 0 7.661408e-08
I14097 n1_m1_88000_273600 0 1.168722e-07
I14098 n1_m1_88000_278400 0 7.932651e-08
I14099 n1_m1_88000_283200 0 8.314361e-08
I14100 n1_m1_88000_288000 0 1.308683e-07
I14101 n1_m1_88000_292800 0 7.966437e-08
I14102 n1_m1_88000_297600 0 1.209221e-07
I14103 n1_m1_88000_302400 0 8.602837e-08
I14104 n1_m1_88000_307200 0 8.395224e-08
I14105 n1_m1_88000_312000 0 1.194293e-07
I14106 n1_m1_88000_316800 0 8.355965e-08
I14107 n1_m1_88000_321600 0 1.230920e-07
I14108 n1_m1_88000_326400 0 7.969836e-08
I14109 n1_m1_88000_331200 0 7.833875e-08
I14110 n1_m1_88000_336000 0 1.175622e-07
I14111 n1_m1_88000_340800 0 8.218169e-08
I14112 n1_m1_88000_345600 0 1.272457e-07
I14113 n1_m1_88000_350400 0 7.873202e-08
I14114 n1_m1_88000_355200 0 7.987375e-08
I14115 n1_m1_88000_360000 0 1.200210e-07
I14116 n1_m1_88000_364800 0 7.820177e-08
I14117 n1_m1_88000_369600 0 1.197382e-07
I14118 n1_m1_88000_374400 0 7.846995e-08
I14119 n1_m1_88000_379200 0 7.661408e-08
I14120 n1_m1_88000_384000 0 1.149211e-07
I14121 n1_m1_88000_388800 0 7.661408e-08
I14122 n1_m1_88000_393600 0 1.149847e-07
I14123 n1_m1_88000_398400 0 7.727961e-08
I14124 n1_m1_88000_403200 0 7.942236e-08
I14125 n1_m1_88000_408000 0 1.211974e-07
I14126 n1_m1_88000_412800 0 8.313580e-08
I14127 n1_m1_88000_417600 0 1.306008e-07
I14128 n1_m1_88000_422400 0 9.240189e-08
I14129 n1_m1_88000_427200 0 8.853651e-08
I14130 n1_m1_88000_432000 0 1.259850e-07
I14131 n1_m1_88000_436800 0 7.842236e-08
I14132 n1_m1_88000_441600 0 1.151679e-07
I14133 n1_m1_88000_446400 0 7.661408e-08
I14134 n1_m1_88000_451200 0 7.661408e-08
I14135 n1_m1_88000_456000 0 1.149211e-07
I14136 n1_m1_88000_460800 0 7.661408e-08
I14137 n1_m1_88000_465600 0 1.149211e-07
I14138 n1_m1_88000_470400 0 7.769701e-08
I14139 n1_m1_88000_475200 0 7.957871e-08
I14140 n1_m1_88000_480000 0 1.217991e-07
I14141 n1_m1_88000_484800 0 8.305932e-08
I14142 n1_m1_88000_489600 0 1.215832e-07
I14143 n1_m1_88000_494400 0 7.994513e-08
I14144 n1_m1_88000_499200 0 7.994513e-08
I14145 n1_m1_88000_504000 0 1.199177e-07
I14146 n1_m1_88000_508800 0 8.036627e-08
I14147 n1_m1_88000_513600 0 1.240200e-07
I14148 n1_m1_88000_518400 0 8.327618e-08
I14149 n1_m1_88000_523200 0 9.022515e-08
I14150 n1_m1_88000_528000 0 1.545388e-07
I14151 n1_m1_88000_532800 0 9.080094e-08
I14152 n1_m1_88000_537600 0 1.236859e-07
I14153 n1_m1_88000_542400 0 7.766098e-08
I14154 n1_m1_88000_547200 0 7.461545e-08
I14155 n1_m1_88000_552000 0 1.106914e-07
I14156 n1_m1_88000_556800 0 7.585270e-08
I14157 n1_m1_116000_0 0 1.414267e-07
I14158 n1_m1_116000_4800 0 1.453764e-07
I14159 n1_m1_116000_9600 0 2.198491e-07
I14160 n1_m1_116000_14400 0 1.472452e-07
I14161 n1_m1_116000_19200 0 1.492826e-07
I14162 n1_m1_116000_24000 0 2.202767e-07
I14163 n1_m1_116000_28800 0 1.465661e-07
I14164 n1_m1_116000_33600 0 2.198491e-07
I14165 n1_m1_116000_38400 0 1.465661e-07
I14166 n1_m1_116000_43200 0 1.465661e-07
I14167 n1_m1_116000_48000 0 2.198491e-07
I14168 n1_m1_116000_52800 0 1.465661e-07
I14169 n1_m1_116000_57600 0 2.198491e-07
I14170 n1_m1_116000_62400 0 1.471949e-07
I14171 n1_m1_116000_67200 0 1.501867e-07
I14172 n1_m1_116000_72000 0 2.294160e-07
I14173 n1_m1_116000_76800 0 1.532282e-07
I14174 n1_m1_116000_81600 0 2.251312e-07
I14175 n1_m1_116000_86400 0 1.465661e-07
I14176 n1_m1_116000_91200 0 1.465661e-07
I14177 n1_m1_116000_96000 0 2.198491e-07
I14178 n1_m1_116000_100800 0 1.467088e-07
I14179 n1_m1_116000_105600 0 2.280340e-07
I14180 n1_m1_116000_110400 0 1.532282e-07
I14181 n1_m1_116000_115200 0 1.532282e-07
I14182 n1_m1_116000_120000 0 2.298422e-07
I14183 n1_m1_116000_124800 0 1.532282e-07
I14184 n1_m1_116000_129600 0 2.298422e-07
I14185 n1_m1_116000_134400 0 1.532282e-07
I14186 n1_m1_116000_139200 0 1.532282e-07
I14187 n1_m1_116000_144000 0 2.332188e-07
I14188 n1_m1_116000_148800 0 1.591472e-07
I14189 n1_m1_116000_153600 0 2.318409e-07
I14190 n1_m1_116000_158400 0 1.542275e-07
I14191 n1_m1_116000_163200 0 1.583675e-07
I14192 n1_m1_116000_168000 0 2.309367e-07
I14193 n1_m1_116000_172800 0 1.558889e-07
I14194 n1_m1_116000_177600 0 2.443364e-07
I14195 n1_m1_116000_182400 0 1.667427e-07
I14196 n1_m1_116000_187200 0 1.682124e-07
I14197 n1_m1_116000_192000 0 2.440536e-07
I14198 n1_m1_116000_196800 0 1.625565e-07
I14199 n1_m1_116000_201600 0 2.542262e-07
I14200 n1_m1_116000_206400 0 1.785856e-07
I14201 n1_m1_116000_211200 0 1.785856e-07
I14202 n1_m1_116000_216000 0 2.574471e-07
I14203 n1_m1_116000_220800 0 1.813041e-07
I14204 n1_m1_116000_225600 0 3.560699e-07
I14205 n1_m1_116000_230400 0 2.703736e-07
I14206 n1_m1_116000_235200 0 2.540528e-07
I14207 n1_m1_116000_240000 0 3.847053e-07
I14208 n1_m1_116000_244800 0 1.977622e-07
I14209 n1_m1_116000_249600 0 2.545668e-07
I14210 n1_m1_116000_254400 0 1.633634e-07
I14211 n1_m1_116000_259200 0 1.603614e-07
I14212 n1_m1_116000_264000 0 2.398354e-07
I14213 n1_m1_116000_268800 0 1.613654e-07
I14214 n1_m1_116000_273600 0 2.474329e-07
I14215 n1_m1_116000_278400 0 1.630310e-07
I14216 n1_m1_116000_283200 0 1.672498e-07
I14217 n1_m1_116000_288000 0 2.550590e-07
I14218 n1_m1_116000_292800 0 2.102367e-07
I14219 n1_m1_116000_297600 0 4.596233e-07
I14220 n1_m1_116000_302400 0 3.353032e-07
I14221 n1_m1_116000_307200 0 4.132647e-07
I14222 n1_m1_116000_312000 0 5.503692e-07
I14223 n1_m1_116000_316800 0 2.062224e-07
I14224 n1_m1_116000_321600 0 2.715096e-07
I14225 n1_m1_116000_326400 0 1.950185e-07
I14226 n1_m1_116000_331200 0 2.062829e-07
I14227 n1_m1_116000_336000 0 2.722723e-07
I14228 n1_m1_116000_340800 0 1.622043e-07
I14229 n1_m1_116000_345600 0 2.437232e-07
I14230 n1_m1_116000_350400 0 1.663661e-07
I14231 n1_m1_116000_355200 0 1.689561e-07
I14232 n1_m1_116000_360000 0 2.491820e-07
I14233 n1_m1_116000_364800 0 1.627760e-07
I14234 n1_m1_116000_369600 0 2.406552e-07
I14235 n1_m1_116000_374400 0 1.565375e-07
I14236 n1_m1_116000_379200 0 1.567496e-07
I14237 n1_m1_116000_384000 0 2.401209e-07
I14238 n1_m1_116000_388800 0 1.634117e-07
I14239 n1_m1_116000_393600 0 2.405859e-07
I14240 n1_m1_116000_398400 0 1.542275e-07
I14241 n1_m1_116000_403200 0 1.532282e-07
I14242 n1_m1_116000_408000 0 2.298422e-07
I14243 n1_m1_116000_412800 0 1.532282e-07
I14244 n1_m1_116000_417600 0 2.298422e-07
I14245 n1_m1_116000_422400 0 1.532282e-07
I14246 n1_m1_116000_427200 0 1.532282e-07
I14247 n1_m1_116000_432000 0 2.298422e-07
I14248 n1_m1_116000_436800 0 1.532282e-07
I14249 n1_m1_116000_441600 0 2.298422e-07
I14250 n1_m1_116000_446400 0 1.532282e-07
I14251 n1_m1_116000_451200 0 1.533709e-07
I14252 n1_m1_116000_456000 0 2.380271e-07
I14253 n1_m1_116000_460800 0 1.598903e-07
I14254 n1_m1_116000_465600 0 2.398354e-07
I14255 n1_m1_116000_470400 0 1.598903e-07
I14256 n1_m1_116000_475200 0 1.598903e-07
I14257 n1_m1_116000_480000 0 2.398354e-07
I14258 n1_m1_116000_484800 0 1.598903e-07
I14259 n1_m1_116000_489600 0 2.331733e-07
I14260 n1_m1_116000_494400 0 1.534042e-07
I14261 n1_m1_116000_499200 0 1.560398e-07
I14262 n1_m1_116000_504000 0 2.468877e-07
I14263 n1_m1_116000_508800 0 1.660812e-07
I14264 n1_m1_116000_513600 0 2.454988e-07
I14265 n1_m1_116000_518400 0 1.646693e-07
I14266 n1_m1_116000_523200 0 1.686380e-07
I14267 n1_m1_116000_528000 0 2.596871e-07
I14268 n1_m1_116000_532800 0 1.695027e-07
I14269 n1_m1_116000_537600 0 2.459774e-07
I14270 n1_m1_116000_542400 0 1.550664e-07
I14271 n1_m1_116000_547200 0 1.505620e-07
I14272 n1_m1_116000_552000 0 2.286852e-07
I14273 n1_m1_116000_556800 0 1.532282e-07
I14274 n1_m1_172000_0 0 7.415455e-08
I14275 n1_m1_172000_4800 0 7.604474e-08
I14276 n1_m1_172000_9600 0 1.149211e-07
I14277 n1_m1_172000_14400 0 7.599920e-08
I14278 n1_m1_172000_19200 0 7.367630e-08
I14279 n1_m1_172000_24000 0 1.100755e-07
I14280 n1_m1_172000_28800 0 7.328303e-08
I14281 n1_m1_172000_33600 0 1.148141e-07
I14282 n1_m1_172000_38400 0 7.980237e-08
I14283 n1_m1_172000_43200 0 7.980237e-08
I14284 n1_m1_172000_48000 0 1.166064e-07
I14285 n1_m1_172000_52800 0 7.650021e-08
I14286 n1_m1_172000_57600 0 1.109130e-07
I14287 n1_m1_172000_62400 0 7.342579e-08
I14288 n1_m1_172000_67200 0 7.385849e-08
I14289 n1_m1_172000_72000 0 1.144884e-07
I14290 n1_m1_172000_76800 0 7.661408e-08
I14291 n1_m1_172000_81600 0 1.149211e-07
I14292 n1_m1_172000_86400 0 7.661408e-08
I14293 n1_m1_172000_91200 0 7.661408e-08
I14294 n1_m1_172000_96000 0 1.149211e-07
I14295 n1_m1_172000_100800 0 7.661408e-08
I14296 n1_m1_172000_105600 0 1.149211e-07
I14297 n1_m1_172000_110400 0 7.663754e-08
I14298 n1_m1_172000_115200 0 7.674155e-08
I14299 n1_m1_172000_120000 0 1.163650e-07
I14300 n1_m1_172000_124800 0 7.994513e-08
I14301 n1_m1_172000_129600 0 1.199177e-07
I14302 n1_m1_172000_134400 0 8.376360e-08
I14303 n1_m1_172000_139200 0 8.479894e-08
I14304 n1_m1_172000_144000 0 1.250988e-07
I14305 n1_m1_172000_148800 0 8.367080e-08
I14306 n1_m1_172000_153600 0 1.258289e-07
I14307 n1_m1_172000_158400 0 8.637813e-08
I14308 n1_m1_172000_163200 0 8.637575e-08
I14309 n1_m1_172000_168000 0 1.243840e-07
I14310 n1_m1_172000_172800 0 8.074526e-08
I14311 n1_m1_172000_177600 0 1.226984e-07
I14312 n1_m1_172000_182400 0 7.986559e-08
I14313 n1_m1_172000_187200 0 7.980237e-08
I14314 n1_m1_172000_192000 0 1.197036e-07
I14315 n1_m1_172000_196800 0 7.980237e-08
I14316 n1_m1_172000_201600 0 1.191342e-07
I14317 n1_m1_172000_206400 0 7.694889e-08
I14318 n1_m1_172000_211200 0 7.715691e-08
I14319 n1_m1_172000_216000 0 1.196094e-07
I14320 n1_m1_172000_220800 0 8.177924e-08
I14321 n1_m1_172000_225600 0 1.317293e-07
I14322 n1_m1_172000_230400 0 9.024010e-08
I14323 n1_m1_172000_235200 0 9.095186e-08
I14324 n1_m1_172000_240000 0 1.376831e-07
I14325 n1_m1_172000_244800 0 8.570444e-08
I14326 n1_m1_172000_249600 0 1.280577e-07
I14327 n1_m1_172000_254400 0 8.374524e-08
I14328 n1_m1_172000_259200 0 8.366944e-08
I14329 n1_m1_172000_264000 0 1.283395e-07
I14330 n1_m1_172000_268800 0 8.270412e-08
I14331 n1_m1_172000_273600 0 1.240332e-07
I14332 n1_m1_172000_278400 0 8.487032e-08
I14333 n1_m1_172000_283200 0 1.070517e-07
I14334 n1_m1_172000_288000 0 2.662010e-07
I14335 n1_m1_172000_292800 0 1.808378e-07
I14336 n1_m1_172000_297600 0 2.139582e-07
I14337 n1_m1_172000_302400 0 1.445657e-07
I14338 n1_m1_172000_307200 0 1.387813e-07
I14339 n1_m1_172000_312000 0 1.580748e-07
I14340 n1_m1_172000_316800 0 1.169697e-07
I14341 n1_m1_172000_321600 0 1.312181e-07
I14342 n1_m1_172000_326400 0 8.007973e-08
I14343 n1_m1_172000_331200 0 8.140535e-08
I14344 n1_m1_172000_336000 0 1.272157e-07
I14345 n1_m1_172000_340800 0 8.617895e-08
I14346 n1_m1_172000_345600 0 1.252514e-07
I14347 n1_m1_172000_350400 0 7.806105e-08
I14348 n1_m1_172000_355200 0 7.967083e-08
I14349 n1_m1_172000_360000 0 1.240258e-07
I14350 n1_m1_172000_364800 0 8.251853e-08
I14351 n1_m1_172000_369600 0 1.184830e-07
I14352 n1_m1_172000_374400 0 7.675684e-08
I14353 n1_m1_172000_379200 0 7.675684e-08
I14354 n1_m1_172000_384000 0 1.175265e-07
I14355 n1_m1_172000_388800 0 8.003690e-08
I14356 n1_m1_172000_393600 0 1.201145e-07
I14357 n1_m1_172000_398400 0 7.996654e-08
I14358 n1_m1_172000_403200 0 7.995533e-08
I14359 n1_m1_172000_408000 0 1.209826e-07
I14360 n1_m1_172000_412800 0 8.380337e-08
I14361 n1_m1_172000_417600 0 1.824489e-07
I14362 n1_m1_172000_422400 0 2.638611e-07
I14363 n1_m1_172000_427200 0 3.793682e-07
I14364 n1_m1_172000_432000 0 5.542104e-07
I14365 n1_m1_172000_436800 0 3.477532e-07
I14366 n1_m1_172000_441600 0 6.578658e-07
I14367 n1_m1_172000_446400 0 3.879218e-07
I14368 n1_m1_172000_451200 0 1.979485e-07
I14369 n1_m1_172000_456000 0 1.464770e-07
I14370 n1_m1_172000_460800 0 8.296652e-08
I14371 n1_m1_172000_465600 0 1.204734e-07
I14372 n1_m1_172000_470400 0 8.003282e-08
I14373 n1_m1_172000_475200 0 7.994513e-08
I14374 n1_m1_172000_480000 0 1.199177e-07
I14375 n1_m1_172000_484800 0 7.994513e-08
I14376 n1_m1_172000_489600 0 1.199177e-07
I14377 n1_m1_172000_494400 0 7.993799e-08
I14378 n1_m1_172000_499200 0 7.981121e-08
I14379 n1_m1_172000_504000 0 1.165200e-07
I14380 n1_m1_172000_508800 0 7.968340e-08
I14381 n1_m1_172000_513600 0 1.213929e-07
I14382 n1_m1_172000_518400 0 8.446584e-08
I14383 n1_m1_172000_523200 0 8.578058e-08
I14384 n1_m1_172000_528000 0 1.252243e-07
I14385 n1_m1_172000_532800 0 8.134077e-08
I14386 n1_m1_172000_537600 0 1.166064e-07
I14387 n1_m1_172000_542400 0 7.661918e-08
I14388 n1_m1_172000_547200 0 7.672217e-08
I14389 n1_m1_172000_552000 0 1.151098e-07
I14390 n1_m1_172000_556800 0 7.664671e-08
I14391 n1_m1_200000_0 0 7.661408e-08
I14392 n1_m1_200000_4800 0 7.661408e-08
I14393 n1_m1_200000_9600 0 1.149211e-07
I14394 n1_m1_200000_14400 0 7.661408e-08
I14395 n1_m1_200000_19200 0 7.661408e-08
I14396 n1_m1_200000_24000 0 1.134459e-07
I14397 n1_m1_200000_28800 0 7.328303e-08
I14398 n1_m1_200000_33600 0 1.099246e-07
I14399 n1_m1_200000_38400 0 7.328303e-08
I14400 n1_m1_200000_43200 0 7.328303e-08
I14401 n1_m1_200000_48000 0 1.099246e-07
I14402 n1_m1_200000_52800 0 7.328303e-08
I14403 n1_m1_200000_57600 0 1.099246e-07
I14404 n1_m1_200000_62400 0 7.328303e-08
I14405 n1_m1_200000_67200 0 7.373511e-08
I14406 n1_m1_200000_72000 0 1.144691e-07
I14407 n1_m1_200000_76800 0 7.661408e-08
I14408 n1_m1_200000_81600 0 1.149211e-07
I14409 n1_m1_200000_86400 0 7.661408e-08
I14410 n1_m1_200000_91200 0 7.661408e-08
I14411 n1_m1_200000_96000 0 1.149211e-07
I14412 n1_m1_200000_100800 0 7.661408e-08
I14413 n1_m1_200000_105600 0 1.153056e-07
I14414 n1_m1_200000_110400 0 7.859300e-08
I14415 n1_m1_200000_115200 0 7.978707e-08
I14416 n1_m1_200000_120000 0 1.199177e-07
I14417 n1_m1_200000_124800 0 8.038768e-08
I14418 n1_m1_200000_129600 0 1.241009e-07
I14419 n1_m1_200000_134400 0 8.740871e-08
I14420 n1_m1_200000_139200 0 1.020966e-07
I14421 n1_m1_200000_144000 0 1.552523e-07
I14422 n1_m1_200000_148800 0 8.889647e-08
I14423 n1_m1_200000_153600 0 1.302942e-07
I14424 n1_m1_200000_158400 0 8.707969e-08
I14425 n1_m1_200000_163200 0 8.884242e-08
I14426 n1_m1_200000_168000 0 1.294962e-07
I14427 n1_m1_200000_172800 0 8.462831e-08
I14428 n1_m1_200000_177600 0 1.228126e-07
I14429 n1_m1_200000_182400 0 7.994513e-08
I14430 n1_m1_200000_187200 0 7.837478e-08
I14431 n1_m1_200000_192000 0 1.149211e-07
I14432 n1_m1_200000_196800 0 7.661408e-08
I14433 n1_m1_200000_201600 0 1.149211e-07
I14434 n1_m1_200000_206400 0 7.686595e-08
I14435 n1_m1_200000_211200 0 7.821808e-08
I14436 n1_m1_200000_216000 0 1.181896e-07
I14437 n1_m1_200000_220800 0 7.994513e-08
I14438 n1_m1_200000_225600 0 1.208239e-07
I14439 n1_m1_200000_230400 0 8.240127e-08
I14440 n1_m1_200000_235200 0 8.245429e-08
I14441 n1_m1_200000_240000 0 1.221702e-07
I14442 n1_m1_200000_244800 0 8.277244e-08
I14443 n1_m1_200000_249600 0 1.243670e-07
I14444 n1_m1_200000_254400 0 8.030203e-08
I14445 n1_m1_200000_259200 0 7.982922e-08
I14446 n1_m1_200000_264000 0 1.179894e-07
I14447 n1_m1_200000_268800 0 7.879660e-08
I14448 n1_m1_200000_273600 0 1.198439e-07
I14449 n1_m1_200000_278400 0 8.327618e-08
I14450 n1_m1_200000_283200 0 8.660722e-08
I14451 n1_m1_200000_288000 0 1.299108e-07
I14452 n1_m1_200000_292800 0 8.660722e-08
I14453 n1_m1_200000_297600 0 1.317759e-07
I14454 n1_m1_200000_302400 0 8.985261e-08
I14455 n1_m1_200000_307200 0 9.373023e-08
I14456 n1_m1_200000_312000 0 1.538172e-07
I14457 n1_m1_200000_316800 0 1.251185e-07
I14458 n1_m1_200000_321600 0 2.540083e-07
I14459 n1_m1_200000_326400 0 1.374798e-07
I14460 n1_m1_200000_331200 0 9.181249e-08
I14461 n1_m1_200000_336000 0 1.240139e-07
I14462 n1_m1_200000_340800 0 8.154539e-08
I14463 n1_m1_200000_345600 0 1.240550e-07
I14464 n1_m1_200000_350400 0 8.044886e-08
I14465 n1_m1_200000_355200 0 7.994513e-08
I14466 n1_m1_200000_360000 0 1.199177e-07
I14467 n1_m1_200000_364800 0 7.994513e-08
I14468 n1_m1_200000_369600 0 1.206974e-07
I14469 n1_m1_200000_374400 0 8.207360e-08
I14470 n1_m1_200000_379200 0 8.342233e-08
I14471 n1_m1_200000_384000 0 1.232368e-07
I14472 n1_m1_200000_388800 0 8.208652e-08
I14473 n1_m1_200000_393600 0 1.249143e-07
I14474 n1_m1_200000_398400 0 8.353790e-08
I14475 n1_m1_200000_403200 0 8.613646e-08
I14476 n1_m1_200000_408000 0 1.356263e-07
I14477 n1_m1_200000_412800 0 8.968062e-08
I14478 n1_m1_200000_417600 0 1.321056e-07
I14479 n1_m1_200000_422400 0 1.193433e-07
I14480 n1_m1_200000_427200 0 2.104685e-07
I14481 n1_m1_200000_432000 0 5.788394e-07
I14482 n1_m1_200000_436800 0 5.125394e-07
I14483 n1_m1_200000_441600 0 5.891762e-07
I14484 n1_m1_200000_446400 0 1.868486e-07
I14485 n1_m1_200000_451200 0 1.167831e-07
I14486 n1_m1_200000_456000 0 1.326467e-07
I14487 n1_m1_200000_460800 0 8.391825e-08
I14488 n1_m1_200000_465600 0 1.295539e-07
I14489 n1_m1_200000_470400 0 8.589139e-08
I14490 n1_m1_200000_475200 0 8.419459e-08
I14491 n1_m1_200000_480000 0 1.246121e-07
I14492 n1_m1_200000_484800 0 8.327618e-08
I14493 n1_m1_200000_489600 0 1.247419e-07
I14494 n1_m1_200000_494400 0 8.177075e-08
I14495 n1_m1_200000_499200 0 8.171670e-08
I14496 n1_m1_200000_504000 0 1.227015e-07
I14497 n1_m1_200000_508800 0 8.152262e-08
I14498 n1_m1_200000_513600 0 1.201430e-07
I14499 n1_m1_200000_518400 0 7.994513e-08
I14500 n1_m1_200000_523200 0 7.994513e-08
I14501 n1_m1_200000_528000 0 1.199177e-07
I14502 n1_m1_200000_532800 0 8.158890e-08
I14503 n1_m1_200000_537600 0 1.226485e-07
I14504 n1_m1_200000_542400 0 7.867899e-08
I14505 n1_m1_200000_547200 0 7.697234e-08
I14506 n1_m1_200000_552000 0 1.149211e-07
I14507 n1_m1_200000_556800 0 7.661408e-08
I14508 n1_m1_228000_0 0 7.404442e-08
I14509 n1_m1_228000_4800 0 7.601925e-08
I14510 n1_m1_228000_9600 0 1.149211e-07
I14511 n1_m1_228000_14400 0 7.661408e-08
I14512 n1_m1_228000_19200 0 7.661408e-08
I14513 n1_m1_228000_24000 0 1.149211e-07
I14514 n1_m1_228000_28800 0 7.542442e-08
I14515 n1_m1_228000_33600 0 1.124228e-07
I14516 n1_m1_228000_38400 0 7.661408e-08
I14517 n1_m1_228000_43200 0 7.661408e-08
I14518 n1_m1_228000_48000 0 1.149211e-07
I14519 n1_m1_228000_52800 0 7.661408e-08
I14520 n1_m1_228000_57600 0 1.149211e-07
I14521 n1_m1_228000_62400 0 7.661408e-08
I14522 n1_m1_228000_67200 0 7.661408e-08
I14523 n1_m1_228000_72000 0 1.149211e-07
I14524 n1_m1_228000_76800 0 7.661408e-08
I14525 n1_m1_228000_81600 0 1.149211e-07
I14526 n1_m1_228000_86400 0 7.661408e-08
I14527 n1_m1_228000_91200 0 7.837478e-08
I14528 n1_m1_228000_96000 0 1.194242e-07
I14529 n1_m1_228000_100800 0 7.950428e-08
I14530 n1_m1_228000_105600 0 1.243412e-07
I14531 n1_m1_228000_110400 0 8.642198e-08
I14532 n1_m1_228000_115200 0 9.110482e-08
I14533 n1_m1_228000_120000 0 1.360892e-07
I14534 n1_m1_228000_124800 0 8.560791e-08
I14535 n1_m1_228000_129600 0 1.275261e-07
I14536 n1_m1_228000_134400 0 1.054147e-07
I14537 n1_m1_228000_139200 0 1.024773e-07
I14538 n1_m1_228000_144000 0 1.732144e-07
I14539 n1_m1_228000_148800 0 1.937568e-07
I14540 n1_m1_228000_153600 0 6.156897e-07
I14541 n1_m1_228000_158400 0 5.291691e-07
I14542 n1_m1_228000_163200 0 3.659553e-07
I14543 n1_m1_228000_168000 0 2.575960e-07
I14544 n1_m1_228000_172800 0 9.222650e-08
I14545 n1_m1_228000_177600 0 1.328333e-07
I14546 n1_m1_228000_182400 0 8.631559e-08
I14547 n1_m1_228000_187200 0 8.740735e-08
I14548 n1_m1_228000_192000 0 1.353602e-07
I14549 n1_m1_228000_196800 0 9.117552e-08
I14550 n1_m1_228000_201600 0 1.558101e-07
I14551 n1_m1_228000_206400 0 1.332422e-07
I14552 n1_m1_228000_211200 0 9.510411e-08
I14553 n1_m1_228000_216000 0 1.263877e-07
I14554 n1_m1_228000_220800 0 8.694305e-08
I14555 n1_m1_228000_225600 0 1.844659e-07
I14556 n1_m1_228000_230400 0 1.782321e-07
I14557 n1_m1_228000_235200 0 1.817888e-07
I14558 n1_m1_228000_240000 0 2.222209e-07
I14559 n1_m1_228000_244800 0 9.931007e-08
I14560 n1_m1_228000_249600 0 1.248575e-07
I14561 n1_m1_228000_254400 0 8.024594e-08
I14562 n1_m1_228000_259200 0 7.994513e-08
I14563 n1_m1_228000_264000 0 1.199177e-07
I14564 n1_m1_228000_268800 0 8.006104e-08
I14565 n1_m1_228000_273600 0 1.206767e-07
I14566 n1_m1_228000_278400 0 8.301445e-08
I14567 n1_m1_228000_283200 0 8.556032e-08
I14568 n1_m1_228000_288000 0 1.287579e-07
I14569 n1_m1_228000_292800 0 8.448487e-08
I14570 n1_m1_228000_297600 0 1.257780e-07
I14571 n1_m1_228000_302400 0 8.450424e-08
I14572 n1_m1_228000_307200 0 8.623197e-08
I14573 n1_m1_228000_312000 0 1.299108e-07
I14574 n1_m1_228000_316800 0 8.602565e-08
I14575 n1_m1_228000_321600 0 1.255883e-07
I14576 n1_m1_228000_326400 0 8.484653e-08
I14577 n1_m1_228000_331200 0 8.789206e-08
I14578 n1_m1_228000_336000 0 1.375484e-07
I14579 n1_m1_228000_340800 0 9.103276e-08
I14580 n1_m1_228000_345600 0 1.312198e-07
I14581 n1_m1_228000_350400 0 8.615481e-08
I14582 n1_m1_228000_355200 0 8.610995e-08
I14583 n1_m1_228000_360000 0 1.299221e-07
I14584 n1_m1_228000_364800 0 8.711198e-08
I14585 n1_m1_228000_369600 0 1.306960e-07
I14586 n1_m1_228000_374400 0 8.689886e-08
I14587 n1_m1_228000_379200 0 8.642028e-08
I14588 n1_m1_228000_384000 0 1.316239e-07
I14589 n1_m1_228000_388800 0 8.941482e-08
I14590 n1_m1_228000_393600 0 1.337177e-07
I14591 n1_m1_228000_398400 0 8.658343e-08
I14592 n1_m1_228000_403200 0 8.598350e-08
I14593 n1_m1_228000_408000 0 1.263337e-07
I14594 n1_m1_228000_412800 0 8.703550e-08
I14595 n1_m1_228000_417600 0 1.326708e-07
I14596 n1_m1_228000_422400 0 8.513748e-08
I14597 n1_m1_228000_427200 0 8.712999e-08
I14598 n1_m1_228000_432000 0 1.433934e-07
I14599 n1_m1_228000_436800 0 9.111365e-08
I14600 n1_m1_228000_441600 0 1.782797e-07
I14601 n1_m1_228000_446400 0 2.243946e-07
I14602 n1_m1_228000_451200 0 2.739674e-07
I14603 n1_m1_228000_456000 0 3.365367e-07
I14604 n1_m1_228000_460800 0 1.059667e-07
I14605 n1_m1_228000_465600 0 1.264877e-07
I14606 n1_m1_228000_470400 0 8.692877e-08
I14607 n1_m1_228000_475200 0 8.660722e-08
I14608 n1_m1_228000_480000 0 1.299108e-07
I14609 n1_m1_228000_484800 0 8.434959e-08
I14610 n1_m1_228000_489600 0 1.335988e-07
I14611 n1_m1_228000_494400 0 9.205586e-08
I14612 n1_m1_228000_499200 0 8.960890e-08
I14613 n1_m1_228000_504000 0 1.293255e-07
I14614 n1_m1_228000_508800 0 8.301445e-08
I14615 n1_m1_228000_513600 0 1.241291e-07
I14616 n1_m1_228000_518400 0 8.275273e-08
I14617 n1_m1_228000_523200 0 8.275273e-08
I14618 n1_m1_228000_528000 0 1.241291e-07
I14619 n1_m1_228000_532800 0 8.275273e-08
I14620 n1_m1_228000_537600 0 1.241291e-07
I14621 n1_m1_228000_542400 0 8.265245e-08
I14622 n1_m1_228000_547200 0 8.062697e-08
I14623 n1_m1_228000_552000 0 1.166288e-07
I14624 n1_m1_228000_556800 0 7.713753e-08
I14625 n1_m1_256000_0 0 7.346794e-08
I14626 n1_m1_256000_4800 0 7.411410e-08
I14627 n1_m1_256000_9600 0 1.152005e-07
I14628 n1_m1_256000_14400 0 7.664297e-08
I14629 n1_m1_256000_19200 0 7.661408e-08
I14630 n1_m1_256000_24000 0 1.149211e-07
I14631 n1_m1_256000_28800 0 7.661408e-08
I14632 n1_m1_256000_33600 0 1.174194e-07
I14633 n1_m1_256000_38400 0 7.780374e-08
I14634 n1_m1_256000_43200 0 7.661408e-08
I14635 n1_m1_256000_48000 0 1.149211e-07
I14636 n1_m1_256000_52800 0 7.673305e-08
I14637 n1_m1_256000_57600 0 1.204048e-07
I14638 n1_m1_256000_62400 0 8.565006e-08
I14639 n1_m1_256000_67200 0 8.642232e-08
I14640 n1_m1_256000_72000 0 1.277623e-07
I14641 n1_m1_256000_76800 0 8.327618e-08
I14642 n1_m1_256000_81600 0 1.225587e-07
I14643 n1_m1_256000_86400 0 8.044207e-08
I14644 n1_m1_256000_91200 0 9.763163e-08
I14645 n1_m1_256000_96000 0 1.968129e-07
I14646 n1_m1_256000_100800 0 1.033634e-07
I14647 n1_m1_256000_105600 0 1.407976e-07
I14648 n1_m1_256000_110400 0 1.052686e-07
I14649 n1_m1_256000_115200 0 1.188069e-07
I14650 n1_m1_256000_120000 0 1.658505e-07
I14651 n1_m1_256000_124800 0 9.196069e-08
I14652 n1_m1_256000_129600 0 1.342660e-07
I14653 n1_m1_256000_134400 0 9.367312e-08
I14654 n1_m1_256000_139200 0 1.009069e-07
I14655 n1_m1_256000_144000 0 1.401960e-07
I14656 n1_m1_256000_148800 0 8.519799e-08
I14657 n1_m1_256000_153600 0 1.356824e-07
I14658 n1_m1_256000_158400 0 1.780275e-07
I14659 n1_m1_256000_163200 0 5.515911e-07
I14660 n1_m1_256000_168000 0 9.993974e-07
I14661 n1_m1_256000_172800 0 4.635689e-07
I14662 n1_m1_256000_177600 0 4.816633e-07
I14663 n1_m1_256000_182400 0 1.977004e-07
I14664 n1_m1_256000_187200 0 1.294513e-07
I14665 n1_m1_256000_192000 0 1.347358e-07
I14666 n1_m1_256000_196800 0 8.388868e-08
I14667 n1_m1_256000_201600 0 1.264945e-07
I14668 n1_m1_256000_206400 0 7.837104e-08
I14669 n1_m1_256000_211200 0 8.213784e-08
I14670 n1_m1_256000_216000 0 1.218473e-07
I14671 n1_m1_256000_220800 0 8.318100e-08
I14672 n1_m1_256000_225600 0 1.325967e-07
I14673 n1_m1_256000_230400 0 8.860653e-08
I14674 n1_m1_256000_235200 0 8.750865e-08
I14675 n1_m1_256000_240000 0 1.285220e-07
I14676 n1_m1_256000_244800 0 8.491995e-08
I14677 n1_m1_256000_249600 0 1.243259e-07
I14678 n1_m1_256000_254400 0 8.195599e-08
I14679 n1_m1_256000_259200 0 8.396856e-08
I14680 n1_m1_256000_264000 0 1.334227e-07
I14681 n1_m1_256000_268800 0 1.009107e-07
I14682 n1_m1_256000_273600 0 1.765655e-07
I14683 n1_m1_256000_278400 0 1.138028e-07
I14684 n1_m1_256000_283200 0 9.824549e-08
I14685 n1_m1_256000_288000 0 1.332099e-07
I14686 n1_m1_256000_292800 0 8.427549e-08
I14687 n1_m1_256000_297600 0 1.245360e-07
I14688 n1_m1_256000_302400 0 8.097367e-08
I14689 n1_m1_256000_307200 0 8.007803e-08
I14690 n1_m1_256000_312000 0 1.199177e-07
I14691 n1_m1_256000_316800 0 8.132513e-08
I14692 n1_m1_256000_321600 0 1.331943e-07
I14693 n1_m1_256000_326400 0 9.246171e-08
I14694 n1_m1_256000_331200 0 8.995934e-08
I14695 n1_m1_256000_336000 0 1.304829e-07
I14696 n1_m1_256000_340800 0 8.999401e-08
I14697 n1_m1_256000_345600 0 1.498703e-07
I14698 n1_m1_256000_350400 0 9.643687e-08
I14699 n1_m1_256000_355200 0 9.893414e-08
I14700 n1_m1_256000_360000 0 1.532574e-07
I14701 n1_m1_256000_364800 0 8.887913e-08
I14702 n1_m1_256000_369600 0 1.870295e-07
I14703 n1_m1_256000_374400 0 2.466858e-07
I14704 n1_m1_256000_379200 0 3.072653e-07
I14705 n1_m1_256000_384000 0 3.112150e-07
I14706 n1_m1_256000_388800 0 1.316409e-07
I14707 n1_m1_256000_393600 0 1.649545e-07
I14708 n1_m1_256000_398400 0 8.734889e-08
I14709 n1_m1_256000_403200 0 8.578160e-08
I14710 n1_m1_256000_408000 0 1.370315e-07
I14711 n1_m1_256000_412800 0 9.248006e-08
I14712 n1_m1_256000_417600 0 1.315563e-07
I14713 n1_m1_256000_422400 0 1.919818e-07
I14714 n1_m1_256000_427200 0 4.064421e-07
I14715 n1_m1_256000_432000 0 6.621914e-07
I14716 n1_m1_256000_436800 0 1.986093e-07
I14717 n1_m1_256000_441600 0 1.433893e-07
I14718 n1_m1_256000_446400 0 9.177680e-08
I14719 n1_m1_256000_451200 0 8.602191e-08
I14720 n1_m1_256000_456000 0 1.295614e-07
I14721 n1_m1_256000_460800 0 8.812115e-08
I14722 n1_m1_256000_465600 0 1.315750e-07
I14723 n1_m1_256000_470400 0 8.886486e-08
I14724 n1_m1_256000_475200 0 9.521560e-08
I14725 n1_m1_256000_480000 0 1.445413e-07
I14726 n1_m1_256000_484800 0 8.798723e-08
I14727 n1_m1_256000_489600 0 1.619654e-07
I14728 n1_m1_256000_494400 0 1.324105e-07
I14729 n1_m1_256000_499200 0 1.313116e-07
I14730 n1_m1_256000_504000 0 1.474539e-07
I14731 n1_m1_256000_508800 0 8.393423e-08
I14732 n1_m1_256000_513600 0 1.249143e-07
I14733 n1_m1_256000_518400 0 8.327618e-08
I14734 n1_m1_256000_523200 0 8.418032e-08
I14735 n1_m1_256000_528000 0 1.298395e-07
I14736 n1_m1_256000_532800 0 8.660722e-08
I14737 n1_m1_256000_537600 0 1.296491e-07
I14738 n1_m1_256000_542400 0 8.379963e-08
I14739 n1_m1_256000_547200 0 8.075410e-08
I14740 n1_m1_256000_552000 0 1.146176e-07
I14741 n1_m1_256000_556800 0 7.385951e-08
I14742 n1_m1_284000_0 0 1.532282e-07
I14743 n1_m1_284000_4800 0 1.532282e-07
I14744 n1_m1_284000_9600 0 2.298422e-07
I14745 n1_m1_284000_14400 0 1.532282e-07
I14746 n1_m1_284000_19200 0 1.540490e-07
I14747 n1_m1_284000_24000 0 2.373864e-07
I14748 n1_m1_284000_28800 0 1.587006e-07
I14749 n1_m1_284000_33600 0 2.357311e-07
I14750 n1_m1_284000_38400 0 1.556075e-07
I14751 n1_m1_284000_43200 0 1.549447e-07
I14752 n1_m1_284000_48000 0 2.312246e-07
I14753 n1_m1_284000_52800 0 1.580208e-07
I14754 n1_m1_284000_57600 0 2.399724e-07
I14755 n1_m1_284000_62400 0 1.601194e-07
I14756 n1_m1_284000_67200 0 1.610147e-07
I14757 n1_m1_284000_72000 0 2.417195e-07
I14758 n1_m1_284000_76800 0 1.605565e-07
I14759 n1_m1_284000_81600 0 2.408347e-07
I14760 n1_m1_284000_86400 0 1.610826e-07
I14761 n1_m1_284000_91200 0 1.649344e-07
I14762 n1_m1_284000_96000 0 2.588611e-07
I14763 n1_m1_284000_100800 0 1.934720e-07
I14764 n1_m1_284000_105600 0 6.860621e-07
I14765 n1_m1_284000_110400 0 4.202666e-07
I14766 n1_m1_284000_115200 0 3.491532e-07
I14767 n1_m1_284000_120000 0 4.007821e-07
I14768 n1_m1_284000_124800 0 1.838548e-07
I14769 n1_m1_284000_129600 0 2.607448e-07
I14770 n1_m1_284000_134400 0 2.220857e-07
I14771 n1_m1_284000_139200 0 2.241319e-07
I14772 n1_m1_284000_144000 0 2.844398e-07
I14773 n1_m1_284000_148800 0 1.884900e-07
I14774 n1_m1_284000_153600 0 2.973592e-07
I14775 n1_m1_284000_158400 0 2.805010e-07
I14776 n1_m1_284000_163200 0 3.510788e-07
I14777 n1_m1_284000_168000 0 4.559099e-07
I14778 n1_m1_284000_172800 0 2.194507e-07
I14779 n1_m1_284000_177600 0 2.616714e-07
I14780 n1_m1_284000_182400 0 1.733620e-07
I14781 n1_m1_284000_187200 0 1.737753e-07
I14782 n1_m1_284000_192000 0 2.616486e-07
I14783 n1_m1_284000_196800 0 1.753048e-07
I14784 n1_m1_284000_201600 0 2.718590e-07
I14785 n1_m1_284000_206400 0 1.749463e-07
I14786 n1_m1_284000_211200 0 1.623947e-07
I14787 n1_m1_284000_216000 0 2.398949e-07
I14788 n1_m1_284000_220800 0 1.601792e-07
I14789 n1_m1_284000_225600 0 2.415774e-07
I14790 n1_m1_284000_230400 0 1.610799e-07
I14791 n1_m1_284000_235200 0 1.607006e-07
I14792 n1_m1_284000_240000 0 2.414465e-07
I14793 n1_m1_284000_244800 0 1.645333e-07
I14794 n1_m1_284000_249600 0 2.485437e-07
I14795 n1_m1_284000_254400 0 1.656553e-07
I14796 n1_m1_284000_259200 0 1.655061e-07
I14797 n1_m1_284000_264000 0 2.495991e-07
I14798 n1_m1_284000_268800 0 1.680275e-07
I14799 n1_m1_284000_273600 0 2.594886e-07
I14800 n1_m1_284000_278400 0 1.698834e-07
I14801 n1_m1_284000_283200 0 1.669072e-07
I14802 n1_m1_284000_288000 0 2.501276e-07
I14803 n1_m1_284000_292800 0 1.662192e-07
I14804 n1_m1_284000_297600 0 2.436022e-07
I14805 n1_m1_284000_302400 0 1.609525e-07
I14806 n1_m1_284000_307200 0 1.600857e-07
I14807 n1_m1_284000_312000 0 2.398354e-07
I14808 n1_m1_284000_316800 0 1.601367e-07
I14809 n1_m1_284000_321600 0 2.450695e-07
I14810 n1_m1_284000_326400 0 1.644252e-07
I14811 n1_m1_284000_331200 0 1.612084e-07
I14812 n1_m1_284000_336000 0 2.512123e-07
I14813 n1_m1_284000_340800 0 2.136506e-07
I14814 n1_m1_284000_345600 0 4.734624e-07
I14815 n1_m1_284000_350400 0 3.641229e-07
I14816 n1_m1_284000_355200 0 2.326685e-07
I14817 n1_m1_284000_360000 0 2.710928e-07
I14818 n1_m1_284000_364800 0 2.343140e-07
I14819 n1_m1_284000_369600 0 8.086722e-07
I14820 n1_m1_284000_374400 0 6.985206e-07
I14821 n1_m1_284000_379200 0 5.394631e-07
I14822 n1_m1_284000_384000 0 4.359508e-07
I14823 n1_m1_284000_388800 0 2.882783e-07
I14824 n1_m1_284000_393600 0 5.580799e-07
I14825 n1_m1_284000_398400 0 3.795616e-07
I14826 n1_m1_284000_403200 0 3.280956e-07
I14827 n1_m1_284000_408000 0 3.563085e-07
I14828 n1_m1_284000_412800 0 2.404000e-07
I14829 n1_m1_284000_417600 0 3.490642e-07
I14830 n1_m1_284000_422400 0 2.502711e-07
I14831 n1_m1_284000_427200 0 4.170043e-07
I14832 n1_m1_284000_432000 0 5.862884e-07
I14833 n1_m1_284000_436800 0 1.972925e-07
I14834 n1_m1_284000_441600 0 2.570399e-07
I14835 n1_m1_284000_446400 0 1.895522e-07
I14836 n1_m1_284000_451200 0 1.984505e-07
I14837 n1_m1_284000_456000 0 2.970471e-07
I14838 n1_m1_284000_460800 0 1.856675e-07
I14839 n1_m1_284000_465600 0 2.678294e-07
I14840 n1_m1_284000_470400 0 1.797759e-07
I14841 n1_m1_284000_475200 0 1.764931e-07
I14842 n1_m1_284000_480000 0 2.620749e-07
I14843 n1_m1_284000_484800 0 1.765033e-07
I14844 n1_m1_284000_489600 0 2.615810e-07
I14845 n1_m1_284000_494400 0 1.728307e-07
I14846 n1_m1_284000_499200 0 1.666156e-07
I14847 n1_m1_284000_504000 0 2.468775e-07
I14848 n1_m1_284000_508800 0 1.659477e-07
I14849 n1_m1_284000_513600 0 2.437868e-07
I14850 n1_m1_284000_518400 0 1.616578e-07
I14851 n1_m1_284000_523200 0 1.680350e-07
I14852 n1_m1_284000_528000 0 2.780551e-07
I14853 n1_m1_284000_532800 0 1.802504e-07
I14854 n1_m1_284000_537600 0 2.668033e-07
I14855 n1_m1_284000_542400 0 1.736465e-07
I14856 n1_m1_284000_547200 0 1.680894e-07
I14857 n1_m1_284000_552000 0 2.352046e-07
I14858 n1_m1_284000_556800 0 1.499447e-07
I14859 n1_m1_340000_0 0 7.994513e-08
I14860 n1_m1_340000_4800 0 7.994513e-08
I14861 n1_m1_340000_9600 0 1.199177e-07
I14862 n1_m1_340000_14400 0 8.022963e-08
I14863 n1_m1_340000_19200 0 8.196823e-08
I14864 n1_m1_340000_24000 0 1.393374e-07
I14865 n1_m1_340000_28800 0 1.200163e-07
I14866 n1_m1_340000_33600 0 1.647441e-07
I14867 n1_m1_340000_38400 0 8.327618e-08
I14868 n1_m1_340000_43200 0 8.327618e-08
I14869 n1_m1_340000_48000 0 1.233354e-07
I14870 n1_m1_340000_52800 0 8.030305e-08
I14871 n1_m1_340000_57600 0 1.206553e-07
I14872 n1_m1_340000_62400 0 8.370445e-08
I14873 n1_m1_340000_67200 0 8.855181e-08
I14874 n1_m1_340000_72000 0 1.618933e-07
I14875 n1_m1_340000_76800 0 1.260828e-07
I14876 n1_m1_340000_81600 0 1.836984e-07
I14877 n1_m1_340000_86400 0 1.094303e-07
I14878 n1_m1_340000_91200 0 9.983216e-08
I14879 n1_m1_340000_96000 0 1.375270e-07
I14880 n1_m1_340000_100800 0 8.574693e-08
I14881 n1_m1_340000_105600 0 1.271270e-07
I14882 n1_m1_340000_110400 0 8.450900e-08
I14883 n1_m1_340000_115200 0 8.365959e-08
I14884 n1_m1_340000_120000 0 1.287045e-07
I14885 n1_m1_340000_124800 0 8.934820e-08
I14886 n1_m1_340000_129600 0 1.358530e-07
I14887 n1_m1_340000_134400 0 8.869355e-08
I14888 n1_m1_340000_139200 0 9.103276e-08
I14889 n1_m1_340000_144000 0 1.743178e-07
I14890 n1_m1_340000_148800 0 1.683260e-07
I14891 n1_m1_340000_153600 0 2.361073e-07
I14892 n1_m1_340000_158400 0 1.183035e-07
I14893 n1_m1_340000_163200 0 1.033090e-07
I14894 n1_m1_340000_168000 0 1.397041e-07
I14895 n1_m1_340000_172800 0 1.114670e-07
I14896 n1_m1_340000_177600 0 2.323089e-07
I14897 n1_m1_340000_182400 0 1.109715e-07
I14898 n1_m1_340000_187200 0 9.169897e-08
I14899 n1_m1_340000_192000 0 1.319570e-07
I14900 n1_m1_340000_196800 0 8.660722e-08
I14901 n1_m1_340000_201600 0 1.299108e-07
I14902 n1_m1_340000_206400 0 8.595495e-08
I14903 n1_m1_340000_211200 0 8.276258e-08
I14904 n1_m1_340000_216000 0 1.271032e-07
I14905 n1_m1_340000_220800 0 8.594101e-08
I14906 n1_m1_340000_225600 0 1.314356e-07
I14907 n1_m1_340000_230400 0 8.660722e-08
I14908 n1_m1_340000_235200 0 8.660722e-08
I14909 n1_m1_340000_240000 0 1.313986e-07
I14910 n1_m1_340000_244800 0 8.496141e-08
I14911 n1_m1_340000_249600 0 1.251804e-07
I14912 n1_m1_340000_254400 0 8.177449e-08
I14913 n1_m1_340000_259200 0 8.022351e-08
I14914 n1_m1_340000_264000 0 1.199177e-07
I14915 n1_m1_340000_268800 0 8.027178e-08
I14916 n1_m1_340000_273600 0 1.231437e-07
I14917 n1_m1_340000_278400 0 8.234824e-08
I14918 n1_m1_340000_283200 0 8.142031e-08
I14919 n1_m1_340000_288000 0 1.209082e-07
I14920 n1_m1_340000_292800 0 7.994513e-08
I14921 n1_m1_340000_297600 0 1.201961e-07
I14922 n1_m1_340000_302400 0 8.173370e-08
I14923 n1_m1_340000_307200 0 8.303383e-08
I14924 n1_m1_340000_312000 0 1.258184e-07
I14925 n1_m1_340000_316800 0 8.653584e-08
I14926 n1_m1_340000_321600 0 1.290889e-07
I14927 n1_m1_340000_326400 0 8.513205e-08
I14928 n1_m1_340000_331200 0 8.441621e-08
I14929 n1_m1_340000_336000 0 1.249143e-07
I14930 n1_m1_340000_340800 0 8.103962e-08
I14931 n1_m1_340000_345600 0 1.221845e-07
I14932 n1_m1_340000_350400 0 8.354198e-08
I14933 n1_m1_340000_355200 0 8.468303e-08
I14934 n1_m1_340000_360000 0 1.234031e-07
I14935 n1_m1_340000_364800 0 8.356781e-08
I14936 n1_m1_340000_369600 0 1.275522e-07
I14937 n1_m1_340000_374400 0 8.578534e-08
I14938 n1_m1_340000_379200 0 8.727003e-08
I14939 n1_m1_340000_384000 0 1.288045e-07
I14940 n1_m1_340000_388800 0 8.994507e-08
I14941 n1_m1_340000_393600 0 1.765621e-07
I14942 n1_m1_340000_398400 0 1.167767e-07
I14943 n1_m1_340000_403200 0 1.164830e-07
I14944 n1_m1_340000_408000 0 1.918483e-07
I14945 n1_m1_340000_412800 0 1.127135e-07
I14946 n1_m1_340000_417600 0 1.349652e-07
I14947 n1_m1_340000_422400 0 1.043603e-07
I14948 n1_m1_340000_427200 0 1.245193e-07
I14949 n1_m1_340000_432000 0 1.722063e-07
I14950 n1_m1_340000_436800 0 1.302766e-07
I14951 n1_m1_340000_441600 0 2.292977e-07
I14952 n1_m1_340000_446400 0 1.395182e-07
I14953 n1_m1_340000_451200 0 1.256216e-07
I14954 n1_m1_340000_456000 0 1.374387e-07
I14955 n1_m1_340000_460800 0 8.367590e-08
I14956 n1_m1_340000_465600 0 1.299445e-07
I14957 n1_m1_340000_470400 0 8.888729e-08
I14958 n1_m1_340000_475200 0 8.505115e-08
I14959 n1_m1_340000_480000 0 1.221675e-07
I14960 n1_m1_340000_484800 0 8.250732e-08
I14961 n1_m1_340000_489600 0 1.262885e-07
I14962 n1_m1_340000_494400 0 8.087136e-08
I14963 n1_m1_340000_499200 0 7.998490e-08
I14964 n1_m1_340000_504000 0 1.269567e-07
I14965 n1_m1_340000_508800 0 8.716568e-08
I14966 n1_m1_340000_513600 0 1.334785e-07
I14967 n1_m1_340000_518400 0 1.050368e-07
I14968 n1_m1_340000_523200 0 1.152644e-07
I14969 n1_m1_340000_528000 0 1.316596e-07
I14970 n1_m1_340000_532800 0 8.496345e-08
I14971 n1_m1_340000_537600 0 1.240523e-07
I14972 n1_m1_340000_542400 0 8.216809e-08
I14973 n1_m1_340000_547200 0 8.189345e-08
I14974 n1_m1_340000_552000 0 1.201961e-07
I14975 n1_m1_340000_556800 0 7.851346e-08
I14976 n1_m1_368000_0 0 7.444822e-08
I14977 n1_m1_368000_4800 0 7.613890e-08
I14978 n1_m1_368000_9600 0 1.157175e-07
I14979 n1_m1_368000_14400 0 7.764229e-08
I14980 n1_m1_368000_19200 0 7.808212e-08
I14981 n1_m1_368000_24000 0 1.201301e-07
I14982 n1_m1_368000_28800 0 7.894242e-08
I14983 n1_m1_368000_33600 0 1.178120e-07
I14984 n1_m1_368000_38400 0 8.208652e-08
I14985 n1_m1_368000_43200 0 8.327618e-08
I14986 n1_m1_368000_48000 0 1.249143e-07
I14987 n1_m1_368000_52800 0 8.327618e-08
I14988 n1_m1_368000_57600 0 1.249143e-07
I14989 n1_m1_368000_62400 0 8.336965e-08
I14990 n1_m1_368000_67200 0 8.336999e-08
I14991 n1_m1_368000_72000 0 1.230322e-07
I14992 n1_m1_368000_76800 0 8.362764e-08
I14993 n1_m1_368000_81600 0 1.249143e-07
I14994 n1_m1_368000_86400 0 8.155151e-08
I14995 n1_m1_368000_91200 0 8.222928e-08
I14996 n1_m1_368000_96000 0 1.285271e-07
I14997 n1_m1_368000_100800 0 8.885568e-08
I14998 n1_m1_368000_105600 0 1.342847e-07
I14999 n1_m1_368000_110400 0 1.105510e-07
I15000 n1_m1_368000_115200 0 2.301145e-07
I15001 n1_m1_368000_120000 0 3.931914e-07
I15002 n1_m1_368000_124800 0 1.543893e-07
I15003 n1_m1_368000_129600 0 2.116343e-07
I15004 n1_m1_368000_134400 0 1.528162e-07
I15005 n1_m1_368000_139200 0 1.238912e-07
I15006 n1_m1_368000_144000 0 1.273177e-07
I15007 n1_m1_368000_148800 0 8.339208e-08
I15008 n1_m1_368000_153600 0 1.249143e-07
I15009 n1_m1_368000_158400 0 8.369732e-08
I15010 n1_m1_368000_163200 0 8.579893e-08
I15011 n1_m1_368000_168000 0 1.298248e-07
I15012 n1_m1_368000_172800 0 8.598724e-08
I15013 n1_m1_368000_177600 0 1.286749e-07
I15014 n1_m1_368000_182400 0 9.428223e-08
I15015 n1_m1_368000_187200 0 1.131006e-07
I15016 n1_m1_368000_192000 0 2.041724e-07
I15017 n1_m1_368000_196800 0 1.308632e-07
I15018 n1_m1_368000_201600 0 1.600578e-07
I15019 n1_m1_368000_206400 0 9.672409e-08
I15020 n1_m1_368000_211200 0 1.206148e-07
I15021 n1_m1_368000_216000 0 3.293535e-07
I15022 n1_m1_368000_220800 0 2.677543e-07
I15023 n1_m1_368000_225600 0 2.996131e-07
I15024 n1_m1_368000_230400 0 1.196546e-07
I15025 n1_m1_368000_235200 0 1.020408e-07
I15026 n1_m1_368000_240000 0 2.164290e-07
I15027 n1_m1_368000_244800 0 2.180857e-07
I15028 n1_m1_368000_249600 0 2.681809e-07
I15029 n1_m1_368000_254400 0 1.000419e-07
I15030 n1_m1_368000_259200 0 8.403110e-08
I15031 n1_m1_368000_264000 0 1.213014e-07
I15032 n1_m1_368000_268800 0 8.420785e-08
I15033 n1_m1_368000_273600 0 1.370780e-07
I15034 n1_m1_368000_278400 0 9.055689e-08
I15035 n1_m1_368000_283200 0 8.354062e-08
I15036 n1_m1_368000_288000 0 1.199214e-07
I15037 n1_m1_368000_292800 0 8.031154e-08
I15038 n1_m1_368000_297600 0 1.279642e-07
I15039 n1_m1_368000_302400 0 8.877308e-08
I15040 n1_m1_368000_307200 0 8.685433e-08
I15041 n1_m1_368000_312000 0 1.551697e-07
I15042 n1_m1_368000_316800 0 1.709021e-07
I15043 n1_m1_368000_321600 0 1.468849e-07
I15044 n1_m1_368000_326400 0 8.299950e-08
I15045 n1_m1_368000_331200 0 8.456101e-08
I15046 n1_m1_368000_336000 0 1.290808e-07
I15047 n1_m1_368000_340800 0 8.556032e-08
I15048 n1_m1_368000_345600 0 1.254085e-07
I15049 n1_m1_368000_350400 0 8.101582e-08
I15050 n1_m1_368000_355200 0 8.555794e-08
I15051 n1_m1_368000_360000 0 1.320097e-07
I15052 n1_m1_368000_364800 0 8.295395e-08
I15053 n1_m1_368000_369600 0 1.224075e-07
I15054 n1_m1_368000_374400 0 8.475135e-08
I15055 n1_m1_368000_379200 0 8.541756e-08
I15056 n1_m1_368000_384000 0 1.299108e-07
I15057 n1_m1_368000_388800 0 8.565550e-08
I15058 n1_m1_368000_393600 0 1.253823e-07
I15059 n1_m1_368000_398400 0 8.651137e-08
I15060 n1_m1_368000_403200 0 8.700899e-08
I15061 n1_m1_368000_408000 0 1.418588e-07
I15062 n1_m1_368000_412800 0 9.826147e-08
I15063 n1_m1_368000_417600 0 1.295974e-07
I15064 n1_m1_368000_422400 0 9.301507e-08
I15065 n1_m1_368000_427200 0 1.012489e-07
I15066 n1_m1_368000_432000 0 1.329220e-07
I15067 n1_m1_368000_436800 0 9.347394e-08
I15068 n1_m1_368000_441600 0 1.409329e-07
I15069 n1_m1_368000_446400 0 8.748077e-08
I15070 n1_m1_368000_451200 0 9.296884e-08
I15071 n1_m1_368000_456000 0 3.184780e-07
I15072 n1_m1_368000_460800 0 1.056425e-07
I15073 n1_m1_368000_465600 0 1.355050e-07
I15074 n1_m1_368000_470400 0 8.532239e-08
I15075 n1_m1_368000_475200 0 8.427549e-08
I15076 n1_m1_368000_480000 0 1.250625e-07
I15077 n1_m1_368000_484800 0 8.435503e-08
I15078 n1_m1_368000_489600 0 1.242253e-07
I15079 n1_m1_368000_494400 0 8.322553e-08
I15080 n1_m1_368000_499200 0 8.553041e-08
I15081 n1_m1_368000_504000 0 1.205897e-07
I15082 n1_m1_368000_508800 0 7.833365e-08
I15083 n1_m1_368000_513600 0 1.286974e-07
I15084 n1_m1_368000_518400 0 8.404096e-08
I15085 n1_m1_368000_523200 0 7.865962e-08
I15086 n1_m1_368000_528000 0 1.149813e-07
I15087 n1_m1_368000_532800 0 7.661408e-08
I15088 n1_m1_368000_537600 0 1.178953e-07
I15089 n1_m1_368000_542400 0 7.725650e-08
I15090 n1_m1_368000_547200 0 7.661408e-08
I15091 n1_m1_368000_552000 0 1.110190e-07
I15092 n1_m1_368000_556800 0 7.328303e-08
I15093 n1_m1_396000_0 0 7.404442e-08
I15094 n1_m1_396000_4800 0 7.631191e-08
I15095 n1_m1_396000_9600 0 1.224048e-07
I15096 n1_m1_396000_14400 0 8.182479e-08
I15097 n1_m1_396000_19200 0 7.951923e-08
I15098 n1_m1_396000_24000 0 1.198195e-07
I15099 n1_m1_396000_28800 0 7.994513e-08
I15100 n1_m1_396000_33600 0 1.230227e-07
I15101 n1_m1_396000_38400 0 8.194376e-08
I15102 n1_m1_396000_43200 0 8.356441e-08
I15103 n1_m1_396000_48000 0 1.368401e-07
I15104 n1_m1_396000_52800 0 1.008767e-07
I15105 n1_m1_396000_57600 0 1.324265e-07
I15106 n1_m1_396000_62400 0 8.325782e-08
I15107 n1_m1_396000_67200 0 8.287169e-08
I15108 n1_m1_396000_72000 0 1.270118e-07
I15109 n1_m1_396000_76800 0 8.353382e-08
I15110 n1_m1_396000_81600 0 1.205591e-07
I15111 n1_m1_396000_86400 0 8.093900e-08
I15112 n1_m1_396000_91200 0 8.332376e-08
I15113 n1_m1_396000_96000 0 1.288524e-07
I15114 n1_m1_396000_100800 0 8.539581e-08
I15115 n1_m1_396000_105600 0 1.310539e-07
I15116 n1_m1_396000_110400 0 8.609329e-08
I15117 n1_m1_396000_115200 0 8.611606e-08
I15118 n1_m1_396000_120000 0 1.260380e-07
I15119 n1_m1_396000_124800 0 1.028389e-07
I15120 n1_m1_396000_129600 0 2.745650e-07
I15121 n1_m1_396000_134400 0 2.067635e-07
I15122 n1_m1_396000_139200 0 1.454954e-07
I15123 n1_m1_396000_144000 0 1.423363e-07
I15124 n1_m1_396000_148800 0 9.077545e-08
I15125 n1_m1_396000_153600 0 1.414845e-07
I15126 n1_m1_396000_158400 0 9.596543e-08
I15127 n1_m1_396000_163200 0 8.763883e-08
I15128 n1_m1_396000_168000 0 1.262375e-07
I15129 n1_m1_396000_172800 0 8.259161e-08
I15130 n1_m1_396000_177600 0 1.238466e-07
I15131 n1_m1_396000_182400 0 8.579554e-08
I15132 n1_m1_396000_187200 0 8.613068e-08
I15133 n1_m1_396000_192000 0 1.248300e-07
I15134 n1_m1_396000_196800 0 8.033806e-08
I15135 n1_m1_396000_201600 0 1.242701e-07
I15136 n1_m1_396000_206400 0 8.686861e-08
I15137 n1_m1_396000_211200 0 9.343009e-08
I15138 n1_m1_396000_216000 0 1.332606e-07
I15139 n1_m1_396000_220800 0 8.702326e-08
I15140 n1_m1_396000_225600 0 1.287552e-07
I15141 n1_m1_396000_230400 0 8.622585e-08
I15142 n1_m1_396000_235200 0 9.023195e-08
I15143 n1_m1_396000_240000 0 1.535854e-07
I15144 n1_m1_396000_244800 0 9.258747e-08
I15145 n1_m1_396000_249600 0 1.266141e-07
I15146 n1_m1_396000_254400 0 8.213954e-08
I15147 n1_m1_396000_259200 0 8.416672e-08
I15148 n1_m1_396000_264000 0 1.337786e-07
I15149 n1_m1_396000_268800 0 8.864222e-08
I15150 n1_m1_396000_273600 0 1.239955e-07
I15151 n1_m1_396000_278400 0 7.994513e-08
I15152 n1_m1_396000_283200 0 8.061542e-08
I15153 n1_m1_396000_288000 0 1.250988e-07
I15154 n1_m1_396000_292800 0 8.432784e-08
I15155 n1_m1_396000_297600 0 1.219163e-07
I15156 n1_m1_396000_302400 0 7.809776e-08
I15157 n1_m1_396000_307200 0 7.958279e-08
I15158 n1_m1_396000_312000 0 1.225523e-07
I15159 n1_m1_396000_316800 0 8.526937e-08
I15160 n1_m1_396000_321600 0 1.210567e-07
I15161 n1_m1_396000_326400 0 7.994513e-08
I15162 n1_m1_396000_331200 0 8.122996e-08
I15163 n1_m1_396000_336000 0 1.281967e-07
I15164 n1_m1_396000_340800 0 8.572280e-08
I15165 n1_m1_396000_345600 0 1.266695e-07
I15166 n1_m1_396000_350400 0 8.092609e-08
I15167 n1_m1_396000_355200 0 8.284790e-08
I15168 n1_m1_396000_360000 0 1.283643e-07
I15169 n1_m1_396000_364800 0 8.339514e-08
I15170 n1_m1_396000_369600 0 1.249143e-07
I15171 n1_m1_396000_374400 0 8.439310e-08
I15172 n1_m1_396000_379200 0 8.489751e-08
I15173 n1_m1_396000_384000 0 1.255210e-07
I15174 n1_m1_396000_388800 0 8.356509e-08
I15175 n1_m1_396000_393600 0 1.331555e-07
I15176 n1_m1_396000_398400 0 8.690396e-08
I15177 n1_m1_396000_403200 0 8.212085e-08
I15178 n1_m1_396000_408000 0 1.313609e-07
I15179 n1_m1_396000_412800 0 9.344369e-08
I15180 n1_m1_396000_417600 0 1.263694e-07
I15181 n1_m1_396000_422400 0 8.526869e-08
I15182 n1_m1_396000_427200 0 8.999401e-08
I15183 n1_m1_396000_432000 0 2.208005e-07
I15184 n1_m1_396000_436800 0 4.673486e-07
I15185 n1_m1_396000_441600 0 9.458967e-07
I15186 n1_m1_396000_446400 0 5.272198e-07
I15187 n1_m1_396000_451200 0 4.940079e-07
I15188 n1_m1_396000_456000 0 3.487559e-07
I15189 n1_m1_396000_460800 0 1.328782e-07
I15190 n1_m1_396000_465600 0 1.740112e-07
I15191 n1_m1_396000_470400 0 8.563442e-08
I15192 n1_m1_396000_475200 0 8.862489e-08
I15193 n1_m1_396000_480000 0 1.369285e-07
I15194 n1_m1_396000_484800 0 8.112867e-08
I15195 n1_m1_396000_489600 0 1.211311e-07
I15196 n1_m1_396000_494400 0 8.071365e-08
I15197 n1_m1_396000_499200 0 8.013004e-08
I15198 n1_m1_396000_504000 0 1.204021e-07
I15199 n1_m1_396000_508800 0 7.830884e-08
I15200 n1_m1_396000_513600 0 1.158746e-07
I15201 n1_m1_396000_518400 0 7.661408e-08
I15202 n1_m1_396000_523200 0 7.705324e-08
I15203 n1_m1_396000_528000 0 1.173134e-07
I15204 n1_m1_396000_532800 0 7.778131e-08
I15205 n1_m1_396000_537600 0 1.153487e-07
I15206 n1_m1_396000_542400 0 7.661408e-08
I15207 n1_m1_396000_547200 0 7.661408e-08
I15208 n1_m1_396000_552000 0 1.149211e-07
I15209 n1_m1_396000_556800 0 7.661408e-08
I15210 n1_m1_424000_0 0 7.753182e-08
I15211 n1_m1_424000_4800 0 7.682652e-08
I15212 n1_m1_424000_9600 0 1.149211e-07
I15213 n1_m1_424000_14400 0 7.661408e-08
I15214 n1_m1_424000_19200 0 7.661408e-08
I15215 n1_m1_424000_24000 0 1.149211e-07
I15216 n1_m1_424000_28800 0 7.661408e-08
I15217 n1_m1_424000_33600 0 1.149211e-07
I15218 n1_m1_424000_38400 0 7.661408e-08
I15219 n1_m1_424000_43200 0 7.780714e-08
I15220 n1_m1_424000_48000 0 1.160530e-07
I15221 n1_m1_424000_52800 0 7.661408e-08
I15222 n1_m1_424000_57600 0 1.159221e-07
I15223 n1_m1_424000_62400 0 8.150358e-08
I15224 n1_m1_424000_67200 0 8.415652e-08
I15225 n1_m1_424000_72000 0 1.259102e-07
I15226 n1_m1_424000_76800 0 9.546169e-08
I15227 n1_m1_424000_81600 0 2.470039e-07
I15228 n1_m1_424000_86400 0 2.423813e-07
I15229 n1_m1_424000_91200 0 2.422725e-07
I15230 n1_m1_424000_96000 0 2.683566e-07
I15231 n1_m1_424000_100800 0 1.184476e-07
I15232 n1_m1_424000_105600 0 1.547832e-07
I15233 n1_m1_424000_110400 0 9.449297e-08
I15234 n1_m1_424000_115200 0 8.933494e-08
I15235 n1_m1_424000_120000 0 1.289829e-07
I15236 n1_m1_424000_124800 0 8.327618e-08
I15237 n1_m1_424000_129600 0 1.249143e-07
I15238 n1_m1_424000_134400 0 8.327618e-08
I15239 n1_m1_424000_139200 0 8.398997e-08
I15240 n1_m1_424000_144000 0 1.248208e-07
I15241 n1_m1_424000_148800 0 8.141521e-08
I15242 n1_m1_424000_153600 0 1.251998e-07
I15243 n1_m1_424000_158400 0 8.672619e-08
I15244 n1_m1_424000_163200 0 8.755385e-08
I15245 n1_m1_424000_168000 0 1.301063e-07
I15246 n1_m1_424000_172800 0 8.783427e-08
I15247 n1_m1_424000_177600 0 1.358302e-07
I15248 n1_m1_424000_182400 0 8.874521e-08
I15249 n1_m1_424000_187200 0 8.723604e-08
I15250 n1_m1_424000_192000 0 1.278952e-07
I15251 n1_m1_424000_196800 0 8.194376e-08
I15252 n1_m1_424000_201600 0 1.214897e-07
I15253 n1_m1_424000_206400 0 8.070141e-08
I15254 n1_m1_424000_211200 0 8.421261e-08
I15255 n1_m1_424000_216000 0 1.369961e-07
I15256 n1_m1_424000_220800 0 1.042618e-07
I15257 n1_m1_424000_225600 0 1.281127e-07
I15258 n1_m1_424000_230400 0 8.534278e-08
I15259 n1_m1_424000_235200 0 1.028920e-07
I15260 n1_m1_424000_240000 0 1.858673e-07
I15261 n1_m1_424000_244800 0 2.202400e-07
I15262 n1_m1_424000_249600 0 4.150791e-07
I15263 n1_m1_424000_254400 0 2.839769e-07
I15264 n1_m1_424000_259200 0 3.067537e-07
I15265 n1_m1_424000_264000 0 5.198575e-07
I15266 n1_m1_424000_268800 0 3.021498e-07
I15267 n1_m1_424000_273600 0 2.624440e-07
I15268 n1_m1_424000_278400 0 9.945555e-08
I15269 n1_m1_424000_283200 0 8.949640e-08
I15270 n1_m1_424000_288000 0 1.354988e-07
I15271 n1_m1_424000_292800 0 8.527480e-08
I15272 n1_m1_424000_297600 0 1.230635e-07
I15273 n1_m1_424000_302400 0 8.449983e-08
I15274 n1_m1_424000_307200 0 8.612626e-08
I15275 n1_m1_424000_312000 0 1.244350e-07
I15276 n1_m1_424000_316800 0 8.578636e-08
I15277 n1_m1_424000_321600 0 1.232470e-07
I15278 n1_m1_424000_326400 0 8.294307e-08
I15279 n1_m1_424000_331200 0 8.378603e-08
I15280 n1_m1_424000_336000 0 1.216002e-07
I15281 n1_m1_424000_340800 0 8.441825e-08
I15282 n1_m1_424000_345600 0 1.482197e-07
I15283 n1_m1_424000_350400 0 1.386599e-07
I15284 n1_m1_424000_355200 0 1.234272e-07
I15285 n1_m1_424000_360000 0 1.397510e-07
I15286 n1_m1_424000_364800 0 8.692163e-08
I15287 n1_m1_424000_369600 0 1.351232e-07
I15288 n1_m1_424000_374400 0 1.001489e-07
I15289 n1_m1_424000_379200 0 1.124908e-07
I15290 n1_m1_424000_384000 0 2.405492e-07
I15291 n1_m1_424000_388800 0 1.646489e-07
I15292 n1_m1_424000_393600 0 1.680241e-07
I15293 n1_m1_424000_398400 0 9.112623e-08
I15294 n1_m1_424000_403200 0 8.809090e-08
I15295 n1_m1_424000_408000 0 1.265067e-07
I15296 n1_m1_424000_412800 0 7.957633e-08
I15297 n1_m1_424000_417600 0 1.174908e-07
I15298 n1_m1_424000_422400 0 8.113479e-08
I15299 n1_m1_424000_427200 0 8.074390e-08
I15300 n1_m1_424000_432000 0 1.214320e-07
I15301 n1_m1_424000_436800 0 8.077109e-08
I15302 n1_m1_424000_441600 0 1.168484e-07
I15303 n1_m1_424000_446400 0 7.990264e-08
I15304 n1_m1_424000_451200 0 8.641008e-08
I15305 n1_m1_424000_456000 0 1.424770e-07
I15306 n1_m1_424000_460800 0 8.503517e-08
I15307 n1_m1_424000_465600 0 1.220846e-07
I15308 n1_m1_424000_470400 0 8.104301e-08
I15309 n1_m1_424000_475200 0 8.025444e-08
I15310 n1_m1_424000_480000 0 1.189473e-07
I15311 n1_m1_424000_484800 0 8.064193e-08
I15312 n1_m1_424000_489600 0 1.182607e-07
I15313 n1_m1_424000_494400 0 7.682652e-08
I15314 n1_m1_424000_499200 0 7.661408e-08
I15315 n1_m1_424000_504000 0 1.149211e-07
I15316 n1_m1_424000_508800 0 7.661408e-08
I15317 n1_m1_424000_513600 0 1.149211e-07
I15318 n1_m1_424000_518400 0 7.661408e-08
I15319 n1_m1_424000_523200 0 7.661408e-08
I15320 n1_m1_424000_528000 0 1.149211e-07
I15321 n1_m1_424000_532800 0 7.661408e-08
I15322 n1_m1_424000_537600 0 1.149211e-07
I15323 n1_m1_424000_542400 0 7.661408e-08
I15324 n1_m1_424000_547200 0 7.661408e-08
I15325 n1_m1_424000_552000 0 1.110190e-07
I15326 n1_m1_424000_556800 0 7.328303e-08
I15327 n1_m1_452000_0 0 1.569725e-07
I15328 n1_m1_452000_4800 0 1.541853e-07
I15329 n1_m1_452000_9600 0 2.317151e-07
I15330 n1_m1_452000_14400 0 1.532927e-07
I15331 n1_m1_452000_19200 0 1.542275e-07
I15332 n1_m1_452000_24000 0 2.390264e-07
I15333 n1_m1_452000_28800 0 1.598903e-07
I15334 n1_m1_452000_33600 0 2.375512e-07
I15335 n1_m1_452000_38400 0 1.568447e-07
I15336 n1_m1_452000_43200 0 1.585415e-07
I15337 n1_m1_452000_48000 0 2.333636e-07
I15338 n1_m1_452000_52800 0 1.532282e-07
I15339 n1_m1_452000_57600 0 2.309170e-07
I15340 n1_m1_452000_62400 0 1.569725e-07
I15341 n1_m1_452000_67200 0 1.545830e-07
I15342 n1_m1_452000_72000 0 2.409421e-07
I15343 n1_m1_452000_76800 0 1.647441e-07
I15344 n1_m1_452000_81600 0 2.402514e-07
I15345 n1_m1_452000_86400 0 1.550364e-07
I15346 n1_m1_452000_91200 0 1.576020e-07
I15347 n1_m1_452000_96000 0 2.508095e-07
I15348 n1_m1_452000_100800 0 1.731111e-07
I15349 n1_m1_452000_105600 0 2.738746e-07
I15350 n1_m1_452000_110400 0 1.785101e-07
I15351 n1_m1_452000_115200 0 1.749711e-07
I15352 n1_m1_452000_120000 0 2.557795e-07
I15353 n1_m1_452000_124800 0 1.681798e-07
I15354 n1_m1_452000_129600 0 2.988242e-07
I15355 n1_m1_452000_134400 0 2.632683e-07
I15356 n1_m1_452000_139200 0 2.292712e-07
I15357 n1_m1_452000_144000 0 2.655110e-07
I15358 n1_m1_452000_148800 0 1.849499e-07
I15359 n1_m1_452000_153600 0 3.013829e-07
I15360 n1_m1_452000_158400 0 1.808493e-07
I15361 n1_m1_452000_163200 0 1.662118e-07
I15362 n1_m1_452000_168000 0 2.423663e-07
I15363 n1_m1_452000_172800 0 1.634266e-07
I15364 n1_m1_452000_177600 0 2.399394e-07
I15365 n1_m1_452000_182400 0 1.598903e-07
I15366 n1_m1_452000_187200 0 1.590378e-07
I15367 n1_m1_452000_192000 0 2.369496e-07
I15368 n1_m1_452000_196800 0 1.544069e-07
I15369 n1_m1_452000_201600 0 2.316376e-07
I15370 n1_m1_452000_206400 0 1.533961e-07
I15371 n1_m1_452000_211200 0 1.545803e-07
I15372 n1_m1_452000_216000 0 2.448938e-07
I15373 n1_m1_452000_220800 0 1.554756e-07
I15374 n1_m1_452000_225600 0 2.530923e-07
I15375 n1_m1_452000_230400 0 1.782708e-07
I15376 n1_m1_452000_235200 0 1.714062e-07
I15377 n1_m1_452000_240000 0 4.951132e-07
I15378 n1_m1_452000_244800 0 4.264447e-07
I15379 n1_m1_452000_249600 0 3.791343e-07
I15380 n1_m1_452000_254400 0 2.145745e-07
I15381 n1_m1_452000_259200 0 2.320265e-07
I15382 n1_m1_452000_264000 0 2.893443e-07
I15383 n1_m1_452000_268800 0 1.882959e-07
I15384 n1_m1_452000_273600 0 2.783457e-07
I15385 n1_m1_452000_278400 0 1.780207e-07
I15386 n1_m1_452000_283200 0 2.995210e-07
I15387 n1_m1_452000_288000 0 8.481464e-07
I15388 n1_m1_452000_292800 0 5.453305e-07
I15389 n1_m1_452000_297600 0 4.878509e-07
I15390 n1_m1_452000_302400 0 2.166758e-07
I15391 n1_m1_452000_307200 0 2.062401e-07
I15392 n1_m1_452000_312000 0 2.996868e-07
I15393 n1_m1_452000_316800 0 2.261890e-07
I15394 n1_m1_452000_321600 0 2.710140e-07
I15395 n1_m1_452000_326400 0 1.755027e-07
I15396 n1_m1_452000_331200 0 1.761961e-07
I15397 n1_m1_452000_336000 0 2.521249e-07
I15398 n1_m1_452000_340800 0 1.659351e-07
I15399 n1_m1_452000_345600 0 3.055148e-07
I15400 n1_m1_452000_350400 0 2.216621e-07
I15401 n1_m1_452000_355200 0 1.810614e-07
I15402 n1_m1_452000_360000 0 2.441420e-07
I15403 n1_m1_452000_364800 0 1.661676e-07
I15404 n1_m1_452000_369600 0 2.461984e-07
I15405 n1_m1_452000_374400 0 1.668936e-07
I15406 n1_m1_452000_379200 0 1.702437e-07
I15407 n1_m1_452000_384000 0 2.680303e-07
I15408 n1_m1_452000_388800 0 2.368714e-07
I15409 n1_m1_452000_393600 0 5.140139e-07
I15410 n1_m1_452000_398400 0 3.690467e-07
I15411 n1_m1_452000_403200 0 3.049431e-07
I15412 n1_m1_452000_408000 0 3.249967e-07
I15413 n1_m1_452000_412800 0 1.832497e-07
I15414 n1_m1_452000_417600 0 2.708366e-07
I15415 n1_m1_452000_422400 0 1.659936e-07
I15416 n1_m1_452000_427200 0 1.597951e-07
I15417 n1_m1_452000_432000 0 2.606966e-07
I15418 n1_m1_452000_436800 0 1.614144e-07
I15419 n1_m1_452000_441600 0 2.960784e-07
I15420 n1_m1_452000_446400 0 5.867130e-07
I15421 n1_m1_452000_451200 0 1.165300e-06
I15422 n1_m1_452000_456000 0 1.952637e-06
I15423 n1_m1_452000_460800 0 8.676371e-07
I15424 n1_m1_452000_465600 0 3.814688e-07
I15425 n1_m1_452000_470400 0 1.683620e-07
I15426 n1_m1_452000_475200 0 1.712158e-07
I15427 n1_m1_452000_480000 0 2.409299e-07
I15428 n1_m1_452000_484800 0 1.571302e-07
I15429 n1_m1_452000_489600 0 2.331733e-07
I15430 n1_m1_452000_494400 0 1.532282e-07
I15431 n1_m1_452000_499200 0 1.532282e-07
I15432 n1_m1_452000_504000 0 2.298422e-07
I15433 n1_m1_452000_508800 0 1.532282e-07
I15434 n1_m1_452000_513600 0 2.298422e-07
I15435 n1_m1_452000_518400 0 1.532282e-07
I15436 n1_m1_452000_523200 0 1.604613e-07
I15437 n1_m1_452000_528000 0 2.649610e-07
I15438 n1_m1_452000_532800 0 1.667984e-07
I15439 n1_m1_452000_537600 0 2.355526e-07
I15440 n1_m1_452000_542400 0 1.495946e-07
I15441 n1_m1_452000_547200 0 1.470052e-07
I15442 n1_m1_452000_552000 0 2.252121e-07
I15443 n1_m1_452000_556800 0 1.500249e-07
I15444 n1_m1_508000_0 0 7.340268e-08
I15445 n1_m1_508000_4800 0 7.371301e-08
I15446 n1_m1_508000_9600 0 1.105826e-07
I15447 n1_m1_508000_14400 0 7.340268e-08
I15448 n1_m1_508000_19200 0 7.376536e-08
I15449 n1_m1_508000_24000 0 1.119531e-07
I15450 n1_m1_508000_28800 0 7.661408e-08
I15451 n1_m1_508000_33600 0 1.149211e-07
I15452 n1_m1_508000_38400 0 7.695059e-08
I15453 n1_m1_508000_43200 0 7.870176e-08
I15454 n1_m1_508000_48000 0 1.274663e-07
I15455 n1_m1_508000_52800 0 1.040925e-07
I15456 n1_m1_508000_57600 0 2.244028e-07
I15457 n1_m1_508000_62400 0 1.741862e-07
I15458 n1_m1_508000_67200 0 1.678290e-07
I15459 n1_m1_508000_72000 0 1.522180e-07
I15460 n1_m1_508000_76800 0 8.814834e-08
I15461 n1_m1_508000_81600 0 1.243697e-07
I15462 n1_m1_508000_86400 0 7.994513e-08
I15463 n1_m1_508000_91200 0 7.994513e-08
I15464 n1_m1_508000_96000 0 1.237324e-07
I15465 n1_m1_508000_100800 0 8.595427e-08
I15466 n1_m1_508000_105600 0 1.258184e-07
I15467 n1_m1_508000_110400 0 8.272893e-08
I15468 n1_m1_508000_115200 0 8.023847e-08
I15469 n1_m1_508000_120000 0 1.181281e-07
I15470 n1_m1_508000_124800 0 7.661408e-08
I15471 n1_m1_508000_129600 0 1.149211e-07
I15472 n1_m1_508000_134400 0 7.856512e-08
I15473 n1_m1_508000_139200 0 7.687581e-08
I15474 n1_m1_508000_144000 0 1.133028e-07
I15475 n1_m1_508000_148800 0 7.702163e-08
I15476 n1_m1_508000_153600 0 1.156053e-07
I15477 n1_m1_508000_158400 0 7.665521e-08
I15478 n1_m1_508000_163200 0 7.661408e-08
I15479 n1_m1_508000_168000 0 1.159238e-07
I15480 n1_m1_508000_172800 0 7.789755e-08
I15481 n1_m1_508000_177600 0 1.165812e-07
I15482 n1_m1_508000_182400 0 8.802870e-08
I15483 n1_m1_508000_187200 0 9.222242e-08
I15484 n1_m1_508000_192000 0 1.350638e-07
I15485 n1_m1_508000_196800 0 8.211779e-08
I15486 n1_m1_508000_201600 0 1.166288e-07
I15487 n1_m1_508000_206400 0 7.744752e-08
I15488 n1_m1_508000_211200 0 7.885098e-08
I15489 n1_m1_508000_216000 0 1.152505e-07
I15490 n1_m1_508000_220800 0 7.609063e-08
I15491 n1_m1_508000_225600 0 1.141359e-07
I15492 n1_m1_508000_230400 0 7.785133e-08
I15493 n1_m1_508000_235200 0 8.112867e-08
I15494 n1_m1_508000_240000 0 1.270577e-07
I15495 n1_m1_508000_244800 0 7.713889e-08
I15496 n1_m1_508000_249600 0 1.139184e-07
I15497 n1_m1_508000_254400 0 7.661408e-08
I15498 n1_m1_508000_259200 0 7.661408e-08
I15499 n1_m1_508000_264000 0 1.149211e-07
I15500 n1_m1_508000_268800 0 7.661408e-08
I15501 n1_m1_508000_273600 0 1.168722e-07
I15502 n1_m1_508000_278400 0 8.161065e-08
I15503 n1_m1_508000_283200 0 1.182100e-07
I15504 n1_m1_508000_288000 0 2.884265e-07
I15505 n1_m1_508000_292800 0 1.401705e-07
I15506 n1_m1_508000_297600 0 1.429478e-07
I15507 n1_m1_508000_302400 0 1.199802e-07
I15508 n1_m1_508000_307200 0 1.738630e-07
I15509 n1_m1_508000_312000 0 2.587309e-07
I15510 n1_m1_508000_316800 0 9.125369e-08
I15511 n1_m1_508000_321600 0 1.224160e-07
I15512 n1_m1_508000_326400 0 7.556718e-08
I15513 n1_m1_508000_331200 0 7.488942e-08
I15514 n1_m1_508000_336000 0 1.175622e-07
I15515 n1_m1_508000_340800 0 7.770857e-08
I15516 n1_m1_508000_345600 0 1.149922e-07
I15517 n1_m1_508000_350400 0 7.737580e-08
I15518 n1_m1_508000_355200 0 7.989992e-08
I15519 n1_m1_508000_360000 0 1.212450e-07
I15520 n1_m1_508000_364800 0 7.984486e-08
I15521 n1_m1_508000_369600 0 1.156913e-07
I15522 n1_m1_508000_374400 0 7.684590e-08
I15523 n1_m1_508000_379200 0 7.713753e-08
I15524 n1_m1_508000_384000 0 1.260920e-07
I15525 n1_m1_508000_388800 0 9.064867e-08
I15526 n1_m1_508000_393600 0 1.350757e-07
I15527 n1_m1_508000_398400 0 8.923161e-08
I15528 n1_m1_508000_403200 0 8.660722e-08
I15529 n1_m1_508000_408000 0 1.236947e-07
I15530 n1_m1_508000_412800 0 7.741829e-08
I15531 n1_m1_508000_417600 0 1.151828e-07
I15532 n1_m1_508000_422400 0 7.609063e-08
I15533 n1_m1_508000_427200 0 7.626262e-08
I15534 n1_m1_508000_432000 0 1.149211e-07
I15535 n1_m1_508000_436800 0 7.661408e-08
I15536 n1_m1_508000_441600 0 1.152219e-07
I15537 n1_m1_508000_446400 0 7.896043e-08
I15538 n1_m1_508000_451200 0 7.936152e-08
I15539 n1_m1_508000_456000 0 1.156832e-07
I15540 n1_m1_508000_460800 0 7.661408e-08
I15541 n1_m1_508000_465600 0 1.133508e-07
I15542 n1_m1_508000_470400 0 7.328303e-08
I15543 n1_m1_508000_475200 0 7.428235e-08
I15544 n1_m1_508000_480000 0 1.148973e-07
I15545 n1_m1_508000_484800 0 7.661408e-08
I15546 n1_m1_508000_489600 0 1.121135e-07
I15547 n1_m1_508000_494400 0 7.394686e-08
I15548 n1_m1_508000_499200 0 7.599240e-08
I15549 n1_m1_508000_504000 0 1.154626e-07
I15550 n1_m1_508000_508800 0 7.962222e-08
I15551 n1_m1_508000_513600 0 1.230030e-07
I15552 n1_m1_508000_518400 0 8.341894e-08
I15553 n1_m1_508000_523200 0 8.479826e-08
I15554 n1_m1_508000_528000 0 1.266671e-07
I15555 n1_m1_508000_532800 0 8.660722e-08
I15556 n1_m1_508000_537600 0 1.231362e-07
I15557 n1_m1_508000_542400 0 7.673373e-08
I15558 n1_m1_508000_547200 0 7.396488e-08
I15559 n1_m1_508000_552000 0 1.099246e-07
I15560 n1_m1_508000_556800 0 7.328303e-08
I15561 n1_m1_536000_0 0 8.566093e-08
I15562 n1_m1_536000_4800 0 8.287339e-08
I15563 n1_m1_536000_9600 0 1.145703e-07
I15564 n1_m1_536000_14400 0 7.337311e-08
I15565 n1_m1_536000_19200 0 7.328303e-08
I15566 n1_m1_536000_24000 0 1.099246e-07
I15567 n1_m1_536000_28800 0 7.238229e-08
I15568 n1_m1_536000_33600 0 1.080330e-07
I15569 n1_m1_536000_38400 0 7.328303e-08
I15570 n1_m1_536000_43200 0 7.468819e-08
I15571 n1_m1_536000_48000 0 1.139694e-07
I15572 n1_m1_536000_52800 0 7.861271e-08
I15573 n1_m1_536000_57600 0 1.228918e-07
I15574 n1_m1_536000_62400 0 8.291758e-08
I15575 n1_m1_536000_67200 0 8.441281e-08
I15576 n1_m1_536000_72000 0 1.229982e-07
I15577 n1_m1_536000_76800 0 7.885064e-08
I15578 n1_m1_536000_81600 0 1.125656e-07
I15579 n1_m1_536000_86400 0 7.328303e-08
I15580 n1_m1_536000_91200 0 7.328303e-08
I15581 n1_m1_536000_96000 0 1.132274e-07
I15582 n1_m1_536000_100800 0 7.861373e-08
I15583 n1_m1_536000_105600 0 1.530762e-07
I15584 n1_m1_536000_110400 0 2.612176e-07
I15585 n1_m1_536000_115200 0 3.587392e-07
I15586 n1_m1_536000_120000 0 2.298779e-07
I15587 n1_m1_536000_124800 0 7.961202e-08
I15588 n1_m1_536000_129600 0 1.253663e-07
I15589 n1_m1_536000_134400 0 7.846791e-08
I15590 n1_m1_536000_139200 0 7.701857e-08
I15591 n1_m1_536000_144000 0 1.149211e-07
I15592 n1_m1_536000_148800 0 7.661408e-08
I15593 n1_m1_536000_153600 0 1.150771e-07
I15594 n1_m1_536000_158400 0 7.773780e-08
I15595 n1_m1_536000_163200 0 7.972555e-08
I15596 n1_m1_536000_168000 0 1.221879e-07
I15597 n1_m1_536000_172800 0 8.340058e-08
I15598 n1_m1_536000_177600 0 1.202573e-07
I15599 n1_m1_536000_182400 0 7.778131e-08
I15600 n1_m1_536000_187200 0 7.704168e-08
I15601 n1_m1_536000_192000 0 1.157566e-07
I15602 n1_m1_536000_196800 0 7.994513e-08
I15603 n1_m1_536000_201600 0 1.206808e-07
I15604 n1_m1_536000_206400 0 7.869871e-08
I15605 n1_m1_536000_211200 0 8.002195e-08
I15606 n1_m1_536000_216000 0 1.251481e-07
I15607 n1_m1_536000_220800 0 8.518575e-08
I15608 n1_m1_536000_225600 0 1.209119e-07
I15609 n1_m1_536000_230400 0 7.661408e-08
I15610 n1_m1_536000_235200 0 7.808926e-08
I15611 n1_m1_536000_240000 0 1.227382e-07
I15612 n1_m1_536000_244800 0 8.209739e-08
I15613 n1_m1_536000_249600 0 1.191906e-07
I15614 n1_m1_536000_254400 0 7.698254e-08
I15615 n1_m1_536000_259200 0 7.756343e-08
I15616 n1_m1_536000_264000 0 1.212454e-07
I15617 n1_m1_536000_268800 0 8.287883e-08
I15618 n1_m1_536000_273600 0 1.224303e-07
I15619 n1_m1_536000_278400 0 7.908857e-08
I15620 n1_m1_536000_283200 0 7.661408e-08
I15621 n1_m1_536000_288000 0 1.156094e-07
I15622 n1_m1_536000_292800 0 7.918851e-08
I15623 n1_m1_536000_297600 0 1.231063e-07
I15624 n1_m1_536000_302400 0 8.468303e-08
I15625 n1_m1_536000_307200 0 8.498929e-08
I15626 n1_m1_536000_312000 0 1.279231e-07
I15627 n1_m1_536000_316800 0 8.996342e-08
I15628 n1_m1_536000_321600 0 1.782817e-07
I15629 n1_m1_536000_326400 0 1.397612e-07
I15630 n1_m1_536000_331200 0 1.160353e-07
I15631 n1_m1_536000_336000 0 1.312742e-07
I15632 n1_m1_536000_340800 0 8.327618e-08
I15633 n1_m1_536000_345600 0 1.301325e-07
I15634 n1_m1_536000_350400 0 8.181561e-08
I15635 n1_m1_536000_355200 0 7.992304e-08
I15636 n1_m1_536000_360000 0 1.156587e-07
I15637 n1_m1_536000_364800 0 7.661408e-08
I15638 n1_m1_536000_369600 0 1.166818e-07
I15639 n1_m1_536000_374400 0 8.177856e-08
I15640 n1_m1_536000_379200 0 8.527480e-08
I15641 n1_m1_536000_384000 0 1.230227e-07
I15642 n1_m1_536000_388800 0 7.875547e-08
I15643 n1_m1_536000_393600 0 1.202239e-07
I15644 n1_m1_536000_398400 0 8.189073e-08
I15645 n1_m1_536000_403200 0 8.040264e-08
I15646 n1_m1_536000_408000 0 1.183422e-07
I15647 n1_m1_536000_412800 0 7.674019e-08
I15648 n1_m1_536000_417600 0 1.132556e-07
I15649 n1_m1_536000_422400 0 7.466304e-08
I15650 n1_m1_536000_427200 0 7.661408e-08
I15651 n1_m1_536000_432000 0 1.149211e-07
I15652 n1_m1_536000_436800 0 7.456787e-08
I15653 n1_m1_536000_441600 0 1.102815e-07
I15654 n1_m1_536000_446400 0 7.628098e-08
I15655 n1_m1_536000_451200 0 7.932651e-08
I15656 n1_m1_536000_456000 0 1.233201e-07
I15657 n1_m1_536000_460800 0 8.002637e-08
I15658 n1_m1_536000_465600 0 1.187909e-07
I15659 n1_m1_536000_470400 0 7.944819e-08
I15660 n1_m1_536000_475200 0 8.094444e-08
I15661 n1_m1_536000_480000 0 1.271270e-07
I15662 n1_m1_536000_484800 0 9.050931e-08
I15663 n1_m1_536000_489600 0 1.324129e-07
I15664 n1_m1_536000_494400 0 8.706473e-08
I15665 n1_m1_536000_499200 0 9.771355e-08
I15666 n1_m1_536000_504000 0 2.051704e-07
I15667 n1_m1_536000_508800 0 1.248592e-07
I15668 n1_m1_536000_513600 0 1.311151e-07
I15669 n1_m1_536000_518400 0 7.794650e-08
I15670 n1_m1_536000_523200 0 7.534013e-08
I15671 n1_m1_536000_528000 0 1.111747e-07
I15672 n1_m1_536000_532800 0 7.364129e-08
I15673 n1_m1_536000_537600 0 1.099246e-07
I15674 n1_m1_536000_542400 0 7.328303e-08
I15675 n1_m1_536000_547200 0 7.328303e-08
I15676 n1_m1_536000_552000 0 1.099246e-07
I15677 n1_m1_536000_556800 0 7.328303e-08
.op
.end
