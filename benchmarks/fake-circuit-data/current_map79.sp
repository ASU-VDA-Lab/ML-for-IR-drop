R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_470400_0 n1_m1_475200_0 5.356235
R114 n1_m1_475200_0 n1_m1_480000_0 5.356235
R115 n1_m1_480000_0 n1_m1_484800_0 5.356235
R116 n1_m1_484800_0 n1_m1_489600_0 5.356235
R117 n1_m1_489600_0 n1_m1_494400_0 5.356235
R118 n1_m1_494400_0 n1_m1_499200_0 5.356235
R119 n1_m1_499200_0 n1_m1_504000_0 5.356235
R120 n1_m1_504000_0 n1_m1_508000_0 4.463529
R121 n1_m1_508800_0 n1_m1_508000_0 0.892706
R122 n1_m1_508800_0 n1_m1_513600_0 5.356235
R123 n1_m1_513600_0 n1_m1_518400_0 5.356235
R124 n1_m1_518400_0 n1_m1_523200_0 5.356235
R125 n1_m1_523200_0 n1_m1_528000_0 5.356235
R126 n1_m1_528000_0 n1_m1_532800_0 5.356235
R127 n1_m1_532800_0 n1_m1_536000_0 3.570824
R128 n1_m1_537600_0 n1_m1_536000_0 1.785412
R129 n1_m1_537600_0 n1_m1_542400_0 5.356235
R130 n1_m1_542400_0 n1_m1_547200_0 5.356235
R131 n1_m1_547200_0 n1_m1_552000_0 5.356235
R132 n1_m1_552000_0 n1_m1_556800_0 5.356235
R133 n1_m1_556800_0 n1_m1_561600_0 5.356235
R134 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R135 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R136 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R137 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R138 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R139 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R140 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R141 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R142 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R143 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R144 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R145 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R146 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R147 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R148 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R149 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R150 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R151 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R152 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R153 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R154 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R155 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R156 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R157 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R158 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R159 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R160 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R161 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R162 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R163 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R164 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R165 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R166 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R167 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R168 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R169 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R170 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R171 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R172 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R173 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R174 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R175 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R176 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R177 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R178 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R179 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R180 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R181 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R182 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R183 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R184 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R185 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R186 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R187 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R188 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R189 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R190 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R191 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R192 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R193 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R194 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R195 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R196 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R197 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R198 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R199 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R200 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R201 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R202 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R203 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R204 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R205 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R206 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R207 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R208 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R209 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R210 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R211 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R212 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R213 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R214 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R215 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R216 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R217 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R218 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R219 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R220 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R221 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R222 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R223 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R224 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R225 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R226 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R227 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R228 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R229 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R230 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R231 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R232 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R233 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R234 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R235 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R236 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R237 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R238 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R239 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R240 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R241 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R242 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R243 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R244 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R245 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R246 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R247 n1_m1_470400_4800 n1_m1_475200_4800 5.356235
R248 n1_m1_475200_4800 n1_m1_480000_4800 5.356235
R249 n1_m1_480000_4800 n1_m1_484800_4800 5.356235
R250 n1_m1_484800_4800 n1_m1_489600_4800 5.356235
R251 n1_m1_489600_4800 n1_m1_494400_4800 5.356235
R252 n1_m1_494400_4800 n1_m1_499200_4800 5.356235
R253 n1_m1_499200_4800 n1_m1_504000_4800 5.356235
R254 n1_m1_504000_4800 n1_m1_508000_4800 4.463529
R255 n1_m1_508800_4800 n1_m1_508000_4800 0.892706
R256 n1_m1_508800_4800 n1_m1_513600_4800 5.356235
R257 n1_m1_513600_4800 n1_m1_518400_4800 5.356235
R258 n1_m1_518400_4800 n1_m1_523200_4800 5.356235
R259 n1_m1_523200_4800 n1_m1_528000_4800 5.356235
R260 n1_m1_528000_4800 n1_m1_532800_4800 5.356235
R261 n1_m1_532800_4800 n1_m1_536000_4800 3.570824
R262 n1_m1_537600_4800 n1_m1_536000_4800 1.785412
R263 n1_m1_537600_4800 n1_m1_542400_4800 5.356235
R264 n1_m1_542400_4800 n1_m1_547200_4800 5.356235
R265 n1_m1_547200_4800 n1_m1_552000_4800 5.356235
R266 n1_m1_552000_4800 n1_m1_556800_4800 5.356235
R267 n1_m1_556800_4800 n1_m1_561600_4800 5.356235
R268 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R269 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R270 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R271 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R272 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R273 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R274 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R275 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R276 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R277 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R278 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R279 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R280 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R281 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R282 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R283 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R284 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R285 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R286 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R287 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R288 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R289 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R290 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R291 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R292 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R293 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R294 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R295 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R296 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R297 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R298 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R299 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R300 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R301 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R302 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R303 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R304 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R305 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R306 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R307 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R308 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R309 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R310 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R311 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R312 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R313 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R314 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R315 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R316 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R317 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R318 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R319 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R320 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R321 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R322 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R323 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R324 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R325 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R326 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R327 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R328 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R329 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R330 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R331 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R332 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R333 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R334 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R335 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R336 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R337 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R338 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R339 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R340 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R341 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R342 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R343 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R344 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R345 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R346 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R347 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R348 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R349 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R350 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R351 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R352 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R353 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R354 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R355 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R356 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R357 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R358 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R359 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R360 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R361 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R362 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R363 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R364 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R365 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R366 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R367 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R368 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R369 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R370 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R371 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R372 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R373 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R374 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R375 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R376 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R377 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R378 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R379 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R380 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R381 n1_m1_470400_9600 n1_m1_475200_9600 5.356235
R382 n1_m1_475200_9600 n1_m1_480000_9600 5.356235
R383 n1_m1_480000_9600 n1_m1_484800_9600 5.356235
R384 n1_m1_484800_9600 n1_m1_489600_9600 5.356235
R385 n1_m1_489600_9600 n1_m1_494400_9600 5.356235
R386 n1_m1_494400_9600 n1_m1_499200_9600 5.356235
R387 n1_m1_499200_9600 n1_m1_504000_9600 5.356235
R388 n1_m1_504000_9600 n1_m1_508000_9600 4.463529
R389 n1_m1_508800_9600 n1_m1_508000_9600 0.892706
R390 n1_m1_508800_9600 n1_m1_513600_9600 5.356235
R391 n1_m1_513600_9600 n1_m1_518400_9600 5.356235
R392 n1_m1_518400_9600 n1_m1_523200_9600 5.356235
R393 n1_m1_523200_9600 n1_m1_528000_9600 5.356235
R394 n1_m1_528000_9600 n1_m1_532800_9600 5.356235
R395 n1_m1_532800_9600 n1_m1_536000_9600 3.570824
R396 n1_m1_537600_9600 n1_m1_536000_9600 1.785412
R397 n1_m1_537600_9600 n1_m1_542400_9600 5.356235
R398 n1_m1_542400_9600 n1_m1_547200_9600 5.356235
R399 n1_m1_547200_9600 n1_m1_552000_9600 5.356235
R400 n1_m1_552000_9600 n1_m1_556800_9600 5.356235
R401 n1_m1_556800_9600 n1_m1_561600_9600 5.356235
R402 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R403 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R404 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R405 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R406 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R407 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R408 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R409 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R410 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R411 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R412 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R413 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R414 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R415 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R416 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R417 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R418 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R419 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R420 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R421 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R422 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R423 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R424 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R425 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R426 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R427 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R428 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R429 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R430 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R431 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R432 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R433 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R434 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R435 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R436 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R437 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R438 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R439 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R440 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R441 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R442 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R443 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R444 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R445 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R446 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R447 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R448 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R449 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R450 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R451 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R452 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R453 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R454 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R455 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R456 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R457 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R458 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R459 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R460 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R461 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R462 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R463 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R464 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R465 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R466 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R467 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R468 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R469 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R470 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R471 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R472 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R473 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R474 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R475 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R476 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R477 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R478 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R479 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R480 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R481 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R482 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R483 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R484 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R485 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R486 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R487 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R488 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R489 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R490 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R491 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R492 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R493 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R494 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R495 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R496 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R497 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R498 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R499 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R500 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R501 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R502 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R503 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R504 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R505 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R506 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R507 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R508 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R509 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R510 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R511 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R512 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R513 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R514 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R515 n1_m1_470400_14400 n1_m1_475200_14400 5.356235
R516 n1_m1_475200_14400 n1_m1_480000_14400 5.356235
R517 n1_m1_480000_14400 n1_m1_484800_14400 5.356235
R518 n1_m1_484800_14400 n1_m1_489600_14400 5.356235
R519 n1_m1_489600_14400 n1_m1_494400_14400 5.356235
R520 n1_m1_494400_14400 n1_m1_499200_14400 5.356235
R521 n1_m1_499200_14400 n1_m1_504000_14400 5.356235
R522 n1_m1_504000_14400 n1_m1_508000_14400 4.463529
R523 n1_m1_508800_14400 n1_m1_508000_14400 0.892706
R524 n1_m1_508800_14400 n1_m1_513600_14400 5.356235
R525 n1_m1_513600_14400 n1_m1_518400_14400 5.356235
R526 n1_m1_518400_14400 n1_m1_523200_14400 5.356235
R527 n1_m1_523200_14400 n1_m1_528000_14400 5.356235
R528 n1_m1_528000_14400 n1_m1_532800_14400 5.356235
R529 n1_m1_532800_14400 n1_m1_536000_14400 3.570824
R530 n1_m1_537600_14400 n1_m1_536000_14400 1.785412
R531 n1_m1_537600_14400 n1_m1_542400_14400 5.356235
R532 n1_m1_542400_14400 n1_m1_547200_14400 5.356235
R533 n1_m1_547200_14400 n1_m1_552000_14400 5.356235
R534 n1_m1_552000_14400 n1_m1_556800_14400 5.356235
R535 n1_m1_556800_14400 n1_m1_561600_14400 5.356235
R536 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R537 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R538 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R539 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R540 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R541 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R542 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R543 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R544 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R545 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R546 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R547 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R548 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R549 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R550 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R551 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R552 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R553 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R554 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R555 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R556 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R557 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R558 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R559 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R560 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R561 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R562 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R563 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R564 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R565 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R566 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R567 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R568 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R569 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R570 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R571 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R572 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R573 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R574 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R575 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R576 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R577 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R578 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R579 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R580 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R581 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R582 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R583 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R584 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R585 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R586 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R587 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R588 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R589 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R590 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R591 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R592 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R593 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R594 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R595 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R596 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R597 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R598 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R599 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R600 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R601 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R602 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R603 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R604 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R605 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R606 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R607 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R608 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R609 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R610 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R611 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R612 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R613 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R614 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R615 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R616 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R617 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R618 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R619 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R620 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R621 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R622 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R623 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R624 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R625 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R626 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R627 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R628 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R629 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R630 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R631 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R632 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R633 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R634 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R635 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R636 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R637 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R638 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R639 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R640 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R641 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R642 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R643 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R644 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R645 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R646 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R647 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R648 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R649 n1_m1_470400_19200 n1_m1_475200_19200 5.356235
R650 n1_m1_475200_19200 n1_m1_480000_19200 5.356235
R651 n1_m1_480000_19200 n1_m1_484800_19200 5.356235
R652 n1_m1_484800_19200 n1_m1_489600_19200 5.356235
R653 n1_m1_489600_19200 n1_m1_494400_19200 5.356235
R654 n1_m1_494400_19200 n1_m1_499200_19200 5.356235
R655 n1_m1_499200_19200 n1_m1_504000_19200 5.356235
R656 n1_m1_504000_19200 n1_m1_508000_19200 4.463529
R657 n1_m1_508800_19200 n1_m1_508000_19200 0.892706
R658 n1_m1_508800_19200 n1_m1_513600_19200 5.356235
R659 n1_m1_513600_19200 n1_m1_518400_19200 5.356235
R660 n1_m1_518400_19200 n1_m1_523200_19200 5.356235
R661 n1_m1_523200_19200 n1_m1_528000_19200 5.356235
R662 n1_m1_528000_19200 n1_m1_532800_19200 5.356235
R663 n1_m1_532800_19200 n1_m1_536000_19200 3.570824
R664 n1_m1_537600_19200 n1_m1_536000_19200 1.785412
R665 n1_m1_537600_19200 n1_m1_542400_19200 5.356235
R666 n1_m1_542400_19200 n1_m1_547200_19200 5.356235
R667 n1_m1_547200_19200 n1_m1_552000_19200 5.356235
R668 n1_m1_552000_19200 n1_m1_556800_19200 5.356235
R669 n1_m1_556800_19200 n1_m1_561600_19200 5.356235
R670 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R671 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R672 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R673 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R674 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R675 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R676 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R677 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R678 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R679 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R680 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R681 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R682 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R683 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R684 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R685 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R686 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R687 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R688 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R689 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R690 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R691 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R692 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R693 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R694 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R695 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R696 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R697 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R698 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R699 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R700 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R701 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R702 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R703 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R704 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R705 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R706 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R707 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R708 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R709 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R710 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R711 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R712 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R713 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R714 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R715 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R716 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R717 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R718 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R719 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R720 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R721 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R722 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R723 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R724 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R725 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R726 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R727 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R728 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R729 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R730 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R731 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R732 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R733 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R734 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R735 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R736 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R737 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R738 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R739 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R740 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R741 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R742 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R743 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R744 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R745 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R746 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R747 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R748 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R749 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R750 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R751 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R752 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R753 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R754 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R755 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R756 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R757 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R758 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R759 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R760 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R761 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R762 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R763 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R764 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R765 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R766 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R767 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R768 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R769 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R770 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R771 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R772 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R773 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R774 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R775 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R776 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R777 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R778 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R779 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R780 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R781 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R782 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R783 n1_m1_470400_24000 n1_m1_475200_24000 5.356235
R784 n1_m1_475200_24000 n1_m1_480000_24000 5.356235
R785 n1_m1_480000_24000 n1_m1_484800_24000 5.356235
R786 n1_m1_484800_24000 n1_m1_489600_24000 5.356235
R787 n1_m1_489600_24000 n1_m1_494400_24000 5.356235
R788 n1_m1_494400_24000 n1_m1_499200_24000 5.356235
R789 n1_m1_499200_24000 n1_m1_504000_24000 5.356235
R790 n1_m1_504000_24000 n1_m1_508000_24000 4.463529
R791 n1_m1_508800_24000 n1_m1_508000_24000 0.892706
R792 n1_m1_508800_24000 n1_m1_513600_24000 5.356235
R793 n1_m1_513600_24000 n1_m1_518400_24000 5.356235
R794 n1_m1_518400_24000 n1_m1_523200_24000 5.356235
R795 n1_m1_523200_24000 n1_m1_528000_24000 5.356235
R796 n1_m1_528000_24000 n1_m1_532800_24000 5.356235
R797 n1_m1_532800_24000 n1_m1_536000_24000 3.570824
R798 n1_m1_537600_24000 n1_m1_536000_24000 1.785412
R799 n1_m1_537600_24000 n1_m1_542400_24000 5.356235
R800 n1_m1_542400_24000 n1_m1_547200_24000 5.356235
R801 n1_m1_547200_24000 n1_m1_552000_24000 5.356235
R802 n1_m1_552000_24000 n1_m1_556800_24000 5.356235
R803 n1_m1_556800_24000 n1_m1_561600_24000 5.356235
R804 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R805 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R806 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R807 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R808 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R809 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R810 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R811 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R812 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R813 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R814 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R815 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R816 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R817 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R818 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R819 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R820 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R821 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R822 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R823 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R824 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R825 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R826 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R827 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R828 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R829 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R830 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R831 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R832 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R833 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R834 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R835 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R836 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R837 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R838 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R839 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R840 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R841 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R842 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R843 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R844 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R845 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R846 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R847 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R848 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R849 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R850 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R851 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R852 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R853 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R854 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R855 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R856 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R857 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R858 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R859 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R860 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R861 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R862 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R863 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R864 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R865 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R866 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R867 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R868 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R869 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R870 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R871 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R872 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R873 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R874 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R875 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R876 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R877 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R878 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R879 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R880 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R881 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R882 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R883 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R884 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R885 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R886 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R887 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R888 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R889 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R890 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R891 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R892 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R893 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R894 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R895 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R896 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R897 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R898 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R899 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R900 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R901 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R902 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R903 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R904 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R905 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R906 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R907 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R908 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R909 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R910 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R911 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R912 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R913 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R914 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R915 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R916 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R917 n1_m1_470400_28800 n1_m1_475200_28800 5.356235
R918 n1_m1_475200_28800 n1_m1_480000_28800 5.356235
R919 n1_m1_480000_28800 n1_m1_484800_28800 5.356235
R920 n1_m1_484800_28800 n1_m1_489600_28800 5.356235
R921 n1_m1_489600_28800 n1_m1_494400_28800 5.356235
R922 n1_m1_494400_28800 n1_m1_499200_28800 5.356235
R923 n1_m1_499200_28800 n1_m1_504000_28800 5.356235
R924 n1_m1_504000_28800 n1_m1_508000_28800 4.463529
R925 n1_m1_508800_28800 n1_m1_508000_28800 0.892706
R926 n1_m1_508800_28800 n1_m1_513600_28800 5.356235
R927 n1_m1_513600_28800 n1_m1_518400_28800 5.356235
R928 n1_m1_518400_28800 n1_m1_523200_28800 5.356235
R929 n1_m1_523200_28800 n1_m1_528000_28800 5.356235
R930 n1_m1_528000_28800 n1_m1_532800_28800 5.356235
R931 n1_m1_532800_28800 n1_m1_536000_28800 3.570824
R932 n1_m1_537600_28800 n1_m1_536000_28800 1.785412
R933 n1_m1_537600_28800 n1_m1_542400_28800 5.356235
R934 n1_m1_542400_28800 n1_m1_547200_28800 5.356235
R935 n1_m1_547200_28800 n1_m1_552000_28800 5.356235
R936 n1_m1_552000_28800 n1_m1_556800_28800 5.356235
R937 n1_m1_556800_28800 n1_m1_561600_28800 5.356235
R938 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R939 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R940 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R941 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R942 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R943 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R944 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R945 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R946 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R947 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R948 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R949 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R950 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R951 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R952 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R953 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R954 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R955 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R956 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R957 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R958 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R959 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R960 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R961 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R962 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R963 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R964 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R965 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R966 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R967 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R968 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R969 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R970 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R971 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R972 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R973 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R974 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R975 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R976 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R977 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R978 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R979 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R980 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R981 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R982 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R983 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R984 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R985 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R986 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R987 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R988 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R989 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R990 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R991 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R992 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R993 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R994 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R995 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R996 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R997 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R998 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R999 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R1000 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R1001 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R1002 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R1003 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R1004 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R1005 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R1006 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R1007 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R1008 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R1009 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R1010 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R1011 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R1012 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R1013 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R1014 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R1015 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R1016 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R1017 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R1018 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R1019 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R1020 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R1021 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R1022 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R1023 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R1024 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R1025 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R1026 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R1027 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R1028 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R1029 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R1030 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R1031 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R1032 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R1033 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R1034 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R1035 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R1036 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R1037 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R1038 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R1039 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R1040 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R1041 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R1042 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R1043 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R1044 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R1045 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R1046 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R1047 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R1048 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R1049 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R1050 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R1051 n1_m1_470400_33600 n1_m1_475200_33600 5.356235
R1052 n1_m1_475200_33600 n1_m1_480000_33600 5.356235
R1053 n1_m1_480000_33600 n1_m1_484800_33600 5.356235
R1054 n1_m1_484800_33600 n1_m1_489600_33600 5.356235
R1055 n1_m1_489600_33600 n1_m1_494400_33600 5.356235
R1056 n1_m1_494400_33600 n1_m1_499200_33600 5.356235
R1057 n1_m1_499200_33600 n1_m1_504000_33600 5.356235
R1058 n1_m1_504000_33600 n1_m1_508000_33600 4.463529
R1059 n1_m1_508800_33600 n1_m1_508000_33600 0.892706
R1060 n1_m1_508800_33600 n1_m1_513600_33600 5.356235
R1061 n1_m1_513600_33600 n1_m1_518400_33600 5.356235
R1062 n1_m1_518400_33600 n1_m1_523200_33600 5.356235
R1063 n1_m1_523200_33600 n1_m1_528000_33600 5.356235
R1064 n1_m1_528000_33600 n1_m1_532800_33600 5.356235
R1065 n1_m1_532800_33600 n1_m1_536000_33600 3.570824
R1066 n1_m1_537600_33600 n1_m1_536000_33600 1.785412
R1067 n1_m1_537600_33600 n1_m1_542400_33600 5.356235
R1068 n1_m1_542400_33600 n1_m1_547200_33600 5.356235
R1069 n1_m1_547200_33600 n1_m1_552000_33600 5.356235
R1070 n1_m1_552000_33600 n1_m1_556800_33600 5.356235
R1071 n1_m1_556800_33600 n1_m1_561600_33600 5.356235
R1072 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R1073 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R1074 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R1075 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R1076 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R1077 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R1078 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R1079 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R1080 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R1081 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R1082 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R1083 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R1084 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R1085 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R1086 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R1087 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R1088 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R1089 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R1090 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R1091 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R1092 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R1093 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R1094 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R1095 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R1096 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R1097 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R1098 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R1099 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R1100 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R1101 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R1102 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R1103 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R1104 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R1105 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R1106 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R1107 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R1108 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R1109 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R1110 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R1111 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R1112 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R1113 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R1114 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R1115 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R1116 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R1117 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R1118 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R1119 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R1120 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R1121 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R1122 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R1123 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R1124 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R1125 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R1126 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R1127 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R1128 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R1129 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R1130 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R1131 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R1132 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R1133 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R1134 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R1135 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R1136 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R1137 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R1138 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R1139 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R1140 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R1141 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R1142 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R1143 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R1144 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R1145 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R1146 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R1147 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R1148 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R1149 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R1150 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R1151 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R1152 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R1153 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R1154 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R1155 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R1156 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R1157 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R1158 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R1159 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R1160 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R1161 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R1162 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R1163 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R1164 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R1165 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R1166 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R1167 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1168 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1169 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1170 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1171 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1172 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1173 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1174 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1175 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1176 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1177 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1178 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1179 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1180 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1181 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1182 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1183 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1184 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1185 n1_m1_470400_38400 n1_m1_475200_38400 5.356235
R1186 n1_m1_475200_38400 n1_m1_480000_38400 5.356235
R1187 n1_m1_480000_38400 n1_m1_484800_38400 5.356235
R1188 n1_m1_484800_38400 n1_m1_489600_38400 5.356235
R1189 n1_m1_489600_38400 n1_m1_494400_38400 5.356235
R1190 n1_m1_494400_38400 n1_m1_499200_38400 5.356235
R1191 n1_m1_499200_38400 n1_m1_504000_38400 5.356235
R1192 n1_m1_504000_38400 n1_m1_508000_38400 4.463529
R1193 n1_m1_508800_38400 n1_m1_508000_38400 0.892706
R1194 n1_m1_508800_38400 n1_m1_513600_38400 5.356235
R1195 n1_m1_513600_38400 n1_m1_518400_38400 5.356235
R1196 n1_m1_518400_38400 n1_m1_523200_38400 5.356235
R1197 n1_m1_523200_38400 n1_m1_528000_38400 5.356235
R1198 n1_m1_528000_38400 n1_m1_532800_38400 5.356235
R1199 n1_m1_532800_38400 n1_m1_536000_38400 3.570824
R1200 n1_m1_537600_38400 n1_m1_536000_38400 1.785412
R1201 n1_m1_537600_38400 n1_m1_542400_38400 5.356235
R1202 n1_m1_542400_38400 n1_m1_547200_38400 5.356235
R1203 n1_m1_547200_38400 n1_m1_552000_38400 5.356235
R1204 n1_m1_552000_38400 n1_m1_556800_38400 5.356235
R1205 n1_m1_556800_38400 n1_m1_561600_38400 5.356235
R1206 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1207 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1208 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1209 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1210 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1211 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1212 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1213 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1214 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1215 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1216 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1217 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1218 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1219 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1220 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1221 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1222 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1223 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1224 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1225 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1226 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1227 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1228 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1229 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1230 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1231 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1232 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1233 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1234 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1235 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1236 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1237 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1238 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1239 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1240 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1241 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1242 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1243 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1244 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1245 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1246 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1247 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1248 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1249 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1250 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1251 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1252 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1253 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1254 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1255 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1256 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1257 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1258 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1259 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1260 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1261 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1262 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1263 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1264 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1265 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1266 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1267 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1268 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1269 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1270 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1271 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1272 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1273 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1274 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1275 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1276 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1277 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1278 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1279 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1280 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1281 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1282 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1283 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1284 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1285 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1286 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1287 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1288 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1289 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1290 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1291 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1292 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1293 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1294 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1295 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1296 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1297 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1298 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1299 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1300 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1301 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1302 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1303 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1304 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1305 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1306 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1307 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1308 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1309 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1310 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1311 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1312 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1313 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1314 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1315 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1316 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1317 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1318 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1319 n1_m1_470400_43200 n1_m1_475200_43200 5.356235
R1320 n1_m1_475200_43200 n1_m1_480000_43200 5.356235
R1321 n1_m1_480000_43200 n1_m1_484800_43200 5.356235
R1322 n1_m1_484800_43200 n1_m1_489600_43200 5.356235
R1323 n1_m1_489600_43200 n1_m1_494400_43200 5.356235
R1324 n1_m1_494400_43200 n1_m1_499200_43200 5.356235
R1325 n1_m1_499200_43200 n1_m1_504000_43200 5.356235
R1326 n1_m1_504000_43200 n1_m1_508000_43200 4.463529
R1327 n1_m1_508800_43200 n1_m1_508000_43200 0.892706
R1328 n1_m1_508800_43200 n1_m1_513600_43200 5.356235
R1329 n1_m1_513600_43200 n1_m1_518400_43200 5.356235
R1330 n1_m1_518400_43200 n1_m1_523200_43200 5.356235
R1331 n1_m1_523200_43200 n1_m1_528000_43200 5.356235
R1332 n1_m1_528000_43200 n1_m1_532800_43200 5.356235
R1333 n1_m1_532800_43200 n1_m1_536000_43200 3.570824
R1334 n1_m1_537600_43200 n1_m1_536000_43200 1.785412
R1335 n1_m1_537600_43200 n1_m1_542400_43200 5.356235
R1336 n1_m1_542400_43200 n1_m1_547200_43200 5.356235
R1337 n1_m1_547200_43200 n1_m1_552000_43200 5.356235
R1338 n1_m1_552000_43200 n1_m1_556800_43200 5.356235
R1339 n1_m1_556800_43200 n1_m1_561600_43200 5.356235
R1340 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1341 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1342 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1343 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1344 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1345 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1346 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1347 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1348 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1349 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1350 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1351 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1352 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1353 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1354 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1355 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1356 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1357 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1358 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1359 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1360 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1361 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1362 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1363 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1364 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1365 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1366 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1367 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1368 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1369 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1370 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1371 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1372 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1373 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1374 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1375 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1376 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1377 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1378 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1379 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1380 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1381 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1382 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1383 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1384 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1385 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1386 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1387 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1388 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1389 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1390 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1391 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1392 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1393 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1394 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1395 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1396 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1397 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1398 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1399 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1400 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1401 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1402 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1403 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1404 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1405 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1406 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1407 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1408 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1409 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1410 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1411 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1412 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1413 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1414 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1415 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1416 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1417 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1418 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1419 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1420 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1421 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1422 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1423 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1424 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1425 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1426 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1427 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1428 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1429 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1430 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1431 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1432 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1433 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1434 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1435 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1436 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1437 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1438 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1439 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1440 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1441 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1442 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1443 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1444 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1445 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1446 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1447 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1448 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1449 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1450 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1451 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1452 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1453 n1_m1_470400_48000 n1_m1_475200_48000 5.356235
R1454 n1_m1_475200_48000 n1_m1_480000_48000 5.356235
R1455 n1_m1_480000_48000 n1_m1_484800_48000 5.356235
R1456 n1_m1_484800_48000 n1_m1_489600_48000 5.356235
R1457 n1_m1_489600_48000 n1_m1_494400_48000 5.356235
R1458 n1_m1_494400_48000 n1_m1_499200_48000 5.356235
R1459 n1_m1_499200_48000 n1_m1_504000_48000 5.356235
R1460 n1_m1_504000_48000 n1_m1_508000_48000 4.463529
R1461 n1_m1_508800_48000 n1_m1_508000_48000 0.892706
R1462 n1_m1_508800_48000 n1_m1_513600_48000 5.356235
R1463 n1_m1_513600_48000 n1_m1_518400_48000 5.356235
R1464 n1_m1_518400_48000 n1_m1_523200_48000 5.356235
R1465 n1_m1_523200_48000 n1_m1_528000_48000 5.356235
R1466 n1_m1_528000_48000 n1_m1_532800_48000 5.356235
R1467 n1_m1_532800_48000 n1_m1_536000_48000 3.570824
R1468 n1_m1_537600_48000 n1_m1_536000_48000 1.785412
R1469 n1_m1_537600_48000 n1_m1_542400_48000 5.356235
R1470 n1_m1_542400_48000 n1_m1_547200_48000 5.356235
R1471 n1_m1_547200_48000 n1_m1_552000_48000 5.356235
R1472 n1_m1_552000_48000 n1_m1_556800_48000 5.356235
R1473 n1_m1_556800_48000 n1_m1_561600_48000 5.356235
R1474 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1475 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1476 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1477 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1478 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1479 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1480 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1481 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1482 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1483 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1484 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1485 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1486 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1487 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1488 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1489 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1490 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1491 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1492 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1493 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1494 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1495 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1496 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1497 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1498 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1499 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1500 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1501 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1502 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1503 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1504 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1505 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1506 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1507 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1508 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1509 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1510 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1511 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1512 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1513 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1514 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1515 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1516 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1517 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1518 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1519 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1520 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1521 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1522 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1523 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1524 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1525 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1526 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1527 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1528 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1529 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1530 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1531 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1532 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1533 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1534 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1535 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1536 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1537 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1538 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1539 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1540 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1541 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1542 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1543 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1544 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1545 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1546 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1547 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1548 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1549 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1550 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1551 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1552 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1553 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1554 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1555 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1556 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1557 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1558 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1559 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1560 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1561 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1562 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1563 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1564 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1565 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1566 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1567 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1568 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1569 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1570 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1571 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1572 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1573 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1574 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1575 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1576 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1577 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1578 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1579 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1580 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1581 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1582 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1583 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1584 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1585 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1586 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1587 n1_m1_470400_52800 n1_m1_475200_52800 5.356235
R1588 n1_m1_475200_52800 n1_m1_480000_52800 5.356235
R1589 n1_m1_480000_52800 n1_m1_484800_52800 5.356235
R1590 n1_m1_484800_52800 n1_m1_489600_52800 5.356235
R1591 n1_m1_489600_52800 n1_m1_494400_52800 5.356235
R1592 n1_m1_494400_52800 n1_m1_499200_52800 5.356235
R1593 n1_m1_499200_52800 n1_m1_504000_52800 5.356235
R1594 n1_m1_504000_52800 n1_m1_508000_52800 4.463529
R1595 n1_m1_508800_52800 n1_m1_508000_52800 0.892706
R1596 n1_m1_508800_52800 n1_m1_513600_52800 5.356235
R1597 n1_m1_513600_52800 n1_m1_518400_52800 5.356235
R1598 n1_m1_518400_52800 n1_m1_523200_52800 5.356235
R1599 n1_m1_523200_52800 n1_m1_528000_52800 5.356235
R1600 n1_m1_528000_52800 n1_m1_532800_52800 5.356235
R1601 n1_m1_532800_52800 n1_m1_536000_52800 3.570824
R1602 n1_m1_537600_52800 n1_m1_536000_52800 1.785412
R1603 n1_m1_537600_52800 n1_m1_542400_52800 5.356235
R1604 n1_m1_542400_52800 n1_m1_547200_52800 5.356235
R1605 n1_m1_547200_52800 n1_m1_552000_52800 5.356235
R1606 n1_m1_552000_52800 n1_m1_556800_52800 5.356235
R1607 n1_m1_556800_52800 n1_m1_561600_52800 5.356235
R1608 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1609 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1610 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1611 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1612 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1613 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1614 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1615 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1616 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1617 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1618 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1619 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1620 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1621 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1622 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1623 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1624 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1625 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1626 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1627 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1628 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1629 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1630 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1631 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1632 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1633 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1634 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1635 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1636 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1637 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1638 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1639 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1640 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1641 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1642 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1643 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1644 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1645 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1646 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1647 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1648 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1649 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1650 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1651 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1652 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1653 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1654 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1655 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1656 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1657 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1658 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1659 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1660 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1661 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1662 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1663 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1664 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1665 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1666 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1667 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1668 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1669 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1670 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1671 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1672 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1673 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1674 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1675 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1676 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1677 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1678 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1679 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1680 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1681 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1682 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1683 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1684 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1685 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1686 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1687 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1688 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1689 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1690 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1691 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1692 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1693 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1694 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1695 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1696 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1697 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1698 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1699 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1700 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1701 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1702 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1703 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1704 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1705 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1706 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1707 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1708 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1709 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1710 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1711 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1712 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1713 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1714 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1715 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1716 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1717 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1718 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1719 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1720 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1721 n1_m1_470400_57600 n1_m1_475200_57600 5.356235
R1722 n1_m1_475200_57600 n1_m1_480000_57600 5.356235
R1723 n1_m1_480000_57600 n1_m1_484800_57600 5.356235
R1724 n1_m1_484800_57600 n1_m1_489600_57600 5.356235
R1725 n1_m1_489600_57600 n1_m1_494400_57600 5.356235
R1726 n1_m1_494400_57600 n1_m1_499200_57600 5.356235
R1727 n1_m1_499200_57600 n1_m1_504000_57600 5.356235
R1728 n1_m1_504000_57600 n1_m1_508000_57600 4.463529
R1729 n1_m1_508800_57600 n1_m1_508000_57600 0.892706
R1730 n1_m1_508800_57600 n1_m1_513600_57600 5.356235
R1731 n1_m1_513600_57600 n1_m1_518400_57600 5.356235
R1732 n1_m1_518400_57600 n1_m1_523200_57600 5.356235
R1733 n1_m1_523200_57600 n1_m1_528000_57600 5.356235
R1734 n1_m1_528000_57600 n1_m1_532800_57600 5.356235
R1735 n1_m1_532800_57600 n1_m1_536000_57600 3.570824
R1736 n1_m1_537600_57600 n1_m1_536000_57600 1.785412
R1737 n1_m1_537600_57600 n1_m1_542400_57600 5.356235
R1738 n1_m1_542400_57600 n1_m1_547200_57600 5.356235
R1739 n1_m1_547200_57600 n1_m1_552000_57600 5.356235
R1740 n1_m1_552000_57600 n1_m1_556800_57600 5.356235
R1741 n1_m1_556800_57600 n1_m1_561600_57600 5.356235
R1742 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1743 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1744 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1745 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1746 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1747 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1748 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1749 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1750 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1751 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1752 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1753 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1754 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1755 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1756 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1757 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1758 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1759 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1760 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1761 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1762 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1763 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1764 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1765 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1766 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1767 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1768 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1769 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1770 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1771 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1772 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1773 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1774 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1775 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1776 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1777 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1778 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1779 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1780 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1781 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1782 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1783 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1784 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1785 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1786 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1787 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1788 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1789 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1790 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1791 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1792 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1793 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1794 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1795 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1796 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1797 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1798 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1799 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1800 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1801 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1802 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1803 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1804 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1805 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1806 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1807 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1808 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1809 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1810 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1811 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1812 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1813 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1814 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1815 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1816 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1817 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1818 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1819 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1820 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1821 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1822 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1823 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1824 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1825 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1826 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1827 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1828 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1829 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1830 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1831 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1832 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1833 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1834 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1835 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1836 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1837 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1838 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1839 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1840 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1841 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1842 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1843 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1844 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1845 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1846 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1847 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1848 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1849 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1850 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1851 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1852 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1853 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1854 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1855 n1_m1_470400_62400 n1_m1_475200_62400 5.356235
R1856 n1_m1_475200_62400 n1_m1_480000_62400 5.356235
R1857 n1_m1_480000_62400 n1_m1_484800_62400 5.356235
R1858 n1_m1_484800_62400 n1_m1_489600_62400 5.356235
R1859 n1_m1_489600_62400 n1_m1_494400_62400 5.356235
R1860 n1_m1_494400_62400 n1_m1_499200_62400 5.356235
R1861 n1_m1_499200_62400 n1_m1_504000_62400 5.356235
R1862 n1_m1_504000_62400 n1_m1_508000_62400 4.463529
R1863 n1_m1_508800_62400 n1_m1_508000_62400 0.892706
R1864 n1_m1_508800_62400 n1_m1_513600_62400 5.356235
R1865 n1_m1_513600_62400 n1_m1_518400_62400 5.356235
R1866 n1_m1_518400_62400 n1_m1_523200_62400 5.356235
R1867 n1_m1_523200_62400 n1_m1_528000_62400 5.356235
R1868 n1_m1_528000_62400 n1_m1_532800_62400 5.356235
R1869 n1_m1_532800_62400 n1_m1_536000_62400 3.570824
R1870 n1_m1_537600_62400 n1_m1_536000_62400 1.785412
R1871 n1_m1_537600_62400 n1_m1_542400_62400 5.356235
R1872 n1_m1_542400_62400 n1_m1_547200_62400 5.356235
R1873 n1_m1_547200_62400 n1_m1_552000_62400 5.356235
R1874 n1_m1_552000_62400 n1_m1_556800_62400 5.356235
R1875 n1_m1_556800_62400 n1_m1_561600_62400 5.356235
R1876 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1877 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1878 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1879 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1880 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1881 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1882 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1883 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1884 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1885 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1886 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1887 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1888 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1889 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1890 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1891 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1892 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1893 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1894 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1895 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1896 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1897 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1898 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1899 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1900 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1901 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1902 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1903 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1904 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1905 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1906 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1907 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1908 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1909 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1910 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1911 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1912 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1913 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1914 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1915 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1916 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1917 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1918 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1919 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1920 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1921 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1922 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1923 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1924 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1925 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1926 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1927 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1928 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1929 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1930 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1931 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1932 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1933 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1934 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1935 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1936 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1937 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1938 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1939 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1940 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1941 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1942 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1943 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1944 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1945 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1946 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1947 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1948 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1949 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1950 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1951 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1952 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1953 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1954 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1955 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1956 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1957 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1958 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1959 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1960 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1961 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1962 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1963 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1964 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1965 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1966 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1967 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1968 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1969 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1970 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1971 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1972 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1973 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1974 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R1975 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R1976 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R1977 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R1978 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R1979 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R1980 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R1981 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R1982 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R1983 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R1984 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R1985 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R1986 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R1987 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R1988 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R1989 n1_m1_470400_67200 n1_m1_475200_67200 5.356235
R1990 n1_m1_475200_67200 n1_m1_480000_67200 5.356235
R1991 n1_m1_480000_67200 n1_m1_484800_67200 5.356235
R1992 n1_m1_484800_67200 n1_m1_489600_67200 5.356235
R1993 n1_m1_489600_67200 n1_m1_494400_67200 5.356235
R1994 n1_m1_494400_67200 n1_m1_499200_67200 5.356235
R1995 n1_m1_499200_67200 n1_m1_504000_67200 5.356235
R1996 n1_m1_504000_67200 n1_m1_508000_67200 4.463529
R1997 n1_m1_508800_67200 n1_m1_508000_67200 0.892706
R1998 n1_m1_508800_67200 n1_m1_513600_67200 5.356235
R1999 n1_m1_513600_67200 n1_m1_518400_67200 5.356235
R2000 n1_m1_518400_67200 n1_m1_523200_67200 5.356235
R2001 n1_m1_523200_67200 n1_m1_528000_67200 5.356235
R2002 n1_m1_528000_67200 n1_m1_532800_67200 5.356235
R2003 n1_m1_532800_67200 n1_m1_536000_67200 3.570824
R2004 n1_m1_537600_67200 n1_m1_536000_67200 1.785412
R2005 n1_m1_537600_67200 n1_m1_542400_67200 5.356235
R2006 n1_m1_542400_67200 n1_m1_547200_67200 5.356235
R2007 n1_m1_547200_67200 n1_m1_552000_67200 5.356235
R2008 n1_m1_552000_67200 n1_m1_556800_67200 5.356235
R2009 n1_m1_556800_67200 n1_m1_561600_67200 5.356235
R2010 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R2011 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R2012 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R2013 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R2014 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R2015 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R2016 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R2017 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R2018 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R2019 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R2020 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R2021 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R2022 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R2023 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R2024 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R2025 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R2026 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R2027 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R2028 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R2029 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R2030 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R2031 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R2032 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R2033 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R2034 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R2035 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R2036 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R2037 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R2038 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R2039 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R2040 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R2041 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R2042 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R2043 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R2044 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R2045 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R2046 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R2047 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R2048 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R2049 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R2050 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R2051 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R2052 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R2053 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R2054 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R2055 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R2056 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R2057 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R2058 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R2059 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R2060 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R2061 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R2062 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R2063 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R2064 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R2065 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R2066 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R2067 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R2068 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R2069 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R2070 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R2071 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R2072 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R2073 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R2074 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R2075 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R2076 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R2077 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R2078 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R2079 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R2080 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R2081 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R2082 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R2083 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R2084 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R2085 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R2086 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R2087 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R2088 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R2089 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R2090 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R2091 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R2092 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R2093 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R2094 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R2095 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R2096 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R2097 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R2098 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R2099 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R2100 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R2101 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R2102 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R2103 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R2104 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R2105 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R2106 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R2107 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R2108 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R2109 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R2110 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R2111 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R2112 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R2113 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R2114 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R2115 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R2116 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R2117 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R2118 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R2119 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R2120 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R2121 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R2122 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R2123 n1_m1_470400_72000 n1_m1_475200_72000 5.356235
R2124 n1_m1_475200_72000 n1_m1_480000_72000 5.356235
R2125 n1_m1_480000_72000 n1_m1_484800_72000 5.356235
R2126 n1_m1_484800_72000 n1_m1_489600_72000 5.356235
R2127 n1_m1_489600_72000 n1_m1_494400_72000 5.356235
R2128 n1_m1_494400_72000 n1_m1_499200_72000 5.356235
R2129 n1_m1_499200_72000 n1_m1_504000_72000 5.356235
R2130 n1_m1_504000_72000 n1_m1_508000_72000 4.463529
R2131 n1_m1_508800_72000 n1_m1_508000_72000 0.892706
R2132 n1_m1_508800_72000 n1_m1_513600_72000 5.356235
R2133 n1_m1_513600_72000 n1_m1_518400_72000 5.356235
R2134 n1_m1_518400_72000 n1_m1_523200_72000 5.356235
R2135 n1_m1_523200_72000 n1_m1_528000_72000 5.356235
R2136 n1_m1_528000_72000 n1_m1_532800_72000 5.356235
R2137 n1_m1_532800_72000 n1_m1_536000_72000 3.570824
R2138 n1_m1_537600_72000 n1_m1_536000_72000 1.785412
R2139 n1_m1_537600_72000 n1_m1_542400_72000 5.356235
R2140 n1_m1_542400_72000 n1_m1_547200_72000 5.356235
R2141 n1_m1_547200_72000 n1_m1_552000_72000 5.356235
R2142 n1_m1_552000_72000 n1_m1_556800_72000 5.356235
R2143 n1_m1_556800_72000 n1_m1_561600_72000 5.356235
R2144 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R2145 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R2146 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R2147 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R2148 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R2149 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R2150 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R2151 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R2152 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R2153 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R2154 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R2155 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R2156 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R2157 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R2158 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R2159 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R2160 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R2161 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R2162 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R2163 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R2164 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R2165 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R2166 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R2167 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R2168 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R2169 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R2170 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R2171 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R2172 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R2173 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R2174 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R2175 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R2176 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R2177 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R2178 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R2179 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R2180 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R2181 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R2182 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R2183 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R2184 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R2185 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R2186 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R2187 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R2188 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R2189 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R2190 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R2191 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R2192 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R2193 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R2194 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R2195 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R2196 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R2197 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R2198 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R2199 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R2200 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R2201 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R2202 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R2203 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R2204 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R2205 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R2206 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R2207 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R2208 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R2209 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R2210 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R2211 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R2212 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R2213 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R2214 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R2215 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R2216 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R2217 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R2218 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R2219 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R2220 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R2221 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R2222 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R2223 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R2224 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R2225 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R2226 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R2227 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R2228 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R2229 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R2230 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R2231 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R2232 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R2233 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R2234 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R2235 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R2236 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R2237 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R2238 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R2239 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R2240 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R2241 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R2242 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R2243 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R2244 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R2245 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R2246 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R2247 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R2248 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R2249 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R2250 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R2251 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R2252 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R2253 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R2254 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R2255 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R2256 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R2257 n1_m1_470400_76800 n1_m1_475200_76800 5.356235
R2258 n1_m1_475200_76800 n1_m1_480000_76800 5.356235
R2259 n1_m1_480000_76800 n1_m1_484800_76800 5.356235
R2260 n1_m1_484800_76800 n1_m1_489600_76800 5.356235
R2261 n1_m1_489600_76800 n1_m1_494400_76800 5.356235
R2262 n1_m1_494400_76800 n1_m1_499200_76800 5.356235
R2263 n1_m1_499200_76800 n1_m1_504000_76800 5.356235
R2264 n1_m1_504000_76800 n1_m1_508000_76800 4.463529
R2265 n1_m1_508800_76800 n1_m1_508000_76800 0.892706
R2266 n1_m1_508800_76800 n1_m1_513600_76800 5.356235
R2267 n1_m1_513600_76800 n1_m1_518400_76800 5.356235
R2268 n1_m1_518400_76800 n1_m1_523200_76800 5.356235
R2269 n1_m1_523200_76800 n1_m1_528000_76800 5.356235
R2270 n1_m1_528000_76800 n1_m1_532800_76800 5.356235
R2271 n1_m1_532800_76800 n1_m1_536000_76800 3.570824
R2272 n1_m1_537600_76800 n1_m1_536000_76800 1.785412
R2273 n1_m1_537600_76800 n1_m1_542400_76800 5.356235
R2274 n1_m1_542400_76800 n1_m1_547200_76800 5.356235
R2275 n1_m1_547200_76800 n1_m1_552000_76800 5.356235
R2276 n1_m1_552000_76800 n1_m1_556800_76800 5.356235
R2277 n1_m1_556800_76800 n1_m1_561600_76800 5.356235
R2278 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R2279 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R2280 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R2281 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R2282 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R2283 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R2284 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R2285 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R2286 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R2287 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R2288 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R2289 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R2290 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R2291 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R2292 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R2293 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R2294 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R2295 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R2296 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R2297 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R2298 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R2299 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R2300 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R2301 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R2302 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R2303 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R2304 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R2305 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R2306 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R2307 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R2308 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R2309 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R2310 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R2311 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R2312 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R2313 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R2314 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R2315 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R2316 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R2317 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R2318 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R2319 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R2320 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R2321 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R2322 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R2323 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R2324 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R2325 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R2326 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R2327 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R2328 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R2329 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R2330 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R2331 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R2332 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R2333 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R2334 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R2335 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R2336 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R2337 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R2338 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R2339 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R2340 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R2341 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R2342 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R2343 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R2344 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R2345 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R2346 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R2347 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R2348 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R2349 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R2350 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R2351 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R2352 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R2353 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R2354 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R2355 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R2356 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2357 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2358 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2359 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2360 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2361 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2362 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2363 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2364 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2365 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2366 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2367 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2368 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2369 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2370 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2371 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2372 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2373 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2374 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2375 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2376 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2377 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2378 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2379 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2380 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2381 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2382 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2383 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2384 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2385 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2386 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2387 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2388 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2389 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2390 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2391 n1_m1_470400_81600 n1_m1_475200_81600 5.356235
R2392 n1_m1_475200_81600 n1_m1_480000_81600 5.356235
R2393 n1_m1_480000_81600 n1_m1_484800_81600 5.356235
R2394 n1_m1_484800_81600 n1_m1_489600_81600 5.356235
R2395 n1_m1_489600_81600 n1_m1_494400_81600 5.356235
R2396 n1_m1_494400_81600 n1_m1_499200_81600 5.356235
R2397 n1_m1_499200_81600 n1_m1_504000_81600 5.356235
R2398 n1_m1_504000_81600 n1_m1_508000_81600 4.463529
R2399 n1_m1_508800_81600 n1_m1_508000_81600 0.892706
R2400 n1_m1_508800_81600 n1_m1_513600_81600 5.356235
R2401 n1_m1_513600_81600 n1_m1_518400_81600 5.356235
R2402 n1_m1_518400_81600 n1_m1_523200_81600 5.356235
R2403 n1_m1_523200_81600 n1_m1_528000_81600 5.356235
R2404 n1_m1_528000_81600 n1_m1_532800_81600 5.356235
R2405 n1_m1_532800_81600 n1_m1_536000_81600 3.570824
R2406 n1_m1_537600_81600 n1_m1_536000_81600 1.785412
R2407 n1_m1_537600_81600 n1_m1_542400_81600 5.356235
R2408 n1_m1_542400_81600 n1_m1_547200_81600 5.356235
R2409 n1_m1_547200_81600 n1_m1_552000_81600 5.356235
R2410 n1_m1_552000_81600 n1_m1_556800_81600 5.356235
R2411 n1_m1_556800_81600 n1_m1_561600_81600 5.356235
R2412 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2413 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2414 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2415 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2416 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2417 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2418 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2419 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2420 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2421 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2422 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2423 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2424 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2425 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2426 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2427 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2428 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2429 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2430 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2431 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2432 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2433 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2434 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2435 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2436 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2437 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2438 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2439 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2440 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2441 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2442 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2443 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2444 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2445 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2446 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2447 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2448 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2449 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2450 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2451 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2452 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2453 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2454 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2455 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2456 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2457 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2458 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2459 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2460 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2461 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2462 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2463 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2464 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2465 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2466 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2467 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2468 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2469 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2470 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2471 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2472 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2473 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2474 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2475 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2476 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2477 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2478 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2479 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2480 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2481 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2482 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2483 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2484 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2485 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2486 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2487 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2488 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2489 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2490 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2491 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2492 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2493 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2494 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2495 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2496 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2497 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2498 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2499 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2500 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2501 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2502 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2503 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2504 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2505 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2506 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2507 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2508 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2509 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2510 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2511 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2512 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2513 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2514 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2515 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2516 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2517 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2518 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2519 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2520 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2521 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2522 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2523 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2524 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2525 n1_m1_470400_86400 n1_m1_475200_86400 5.356235
R2526 n1_m1_475200_86400 n1_m1_480000_86400 5.356235
R2527 n1_m1_480000_86400 n1_m1_484800_86400 5.356235
R2528 n1_m1_484800_86400 n1_m1_489600_86400 5.356235
R2529 n1_m1_489600_86400 n1_m1_494400_86400 5.356235
R2530 n1_m1_494400_86400 n1_m1_499200_86400 5.356235
R2531 n1_m1_499200_86400 n1_m1_504000_86400 5.356235
R2532 n1_m1_504000_86400 n1_m1_508000_86400 4.463529
R2533 n1_m1_508800_86400 n1_m1_508000_86400 0.892706
R2534 n1_m1_508800_86400 n1_m1_513600_86400 5.356235
R2535 n1_m1_513600_86400 n1_m1_518400_86400 5.356235
R2536 n1_m1_518400_86400 n1_m1_523200_86400 5.356235
R2537 n1_m1_523200_86400 n1_m1_528000_86400 5.356235
R2538 n1_m1_528000_86400 n1_m1_532800_86400 5.356235
R2539 n1_m1_532800_86400 n1_m1_536000_86400 3.570824
R2540 n1_m1_537600_86400 n1_m1_536000_86400 1.785412
R2541 n1_m1_537600_86400 n1_m1_542400_86400 5.356235
R2542 n1_m1_542400_86400 n1_m1_547200_86400 5.356235
R2543 n1_m1_547200_86400 n1_m1_552000_86400 5.356235
R2544 n1_m1_552000_86400 n1_m1_556800_86400 5.356235
R2545 n1_m1_556800_86400 n1_m1_561600_86400 5.356235
R2546 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2547 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2548 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2549 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2550 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2551 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2552 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2553 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2554 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2555 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2556 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2557 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2558 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2559 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2560 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2561 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2562 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2563 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2564 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2565 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2566 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2567 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2568 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2569 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2570 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2571 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2572 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2573 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2574 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2575 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2576 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2577 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2578 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2579 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2580 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2581 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2582 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2583 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2584 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2585 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2586 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2587 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2588 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2589 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2590 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2591 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2592 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2593 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2594 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2595 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2596 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2597 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2598 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2599 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2600 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2601 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2602 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2603 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2604 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2605 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2606 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2607 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2608 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2609 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2610 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2611 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2612 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2613 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2614 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2615 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2616 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2617 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2618 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2619 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2620 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2621 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2622 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2623 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2624 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2625 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2626 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2627 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2628 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2629 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2630 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2631 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2632 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2633 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2634 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2635 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2636 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2637 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2638 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2639 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2640 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2641 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2642 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2643 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2644 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2645 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2646 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2647 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2648 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2649 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2650 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2651 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2652 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2653 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2654 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2655 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2656 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2657 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2658 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2659 n1_m1_470400_91200 n1_m1_475200_91200 5.356235
R2660 n1_m1_475200_91200 n1_m1_480000_91200 5.356235
R2661 n1_m1_480000_91200 n1_m1_484800_91200 5.356235
R2662 n1_m1_484800_91200 n1_m1_489600_91200 5.356235
R2663 n1_m1_489600_91200 n1_m1_494400_91200 5.356235
R2664 n1_m1_494400_91200 n1_m1_499200_91200 5.356235
R2665 n1_m1_499200_91200 n1_m1_504000_91200 5.356235
R2666 n1_m1_504000_91200 n1_m1_508000_91200 4.463529
R2667 n1_m1_508800_91200 n1_m1_508000_91200 0.892706
R2668 n1_m1_508800_91200 n1_m1_513600_91200 5.356235
R2669 n1_m1_513600_91200 n1_m1_518400_91200 5.356235
R2670 n1_m1_518400_91200 n1_m1_523200_91200 5.356235
R2671 n1_m1_523200_91200 n1_m1_528000_91200 5.356235
R2672 n1_m1_528000_91200 n1_m1_532800_91200 5.356235
R2673 n1_m1_532800_91200 n1_m1_536000_91200 3.570824
R2674 n1_m1_537600_91200 n1_m1_536000_91200 1.785412
R2675 n1_m1_537600_91200 n1_m1_542400_91200 5.356235
R2676 n1_m1_542400_91200 n1_m1_547200_91200 5.356235
R2677 n1_m1_547200_91200 n1_m1_552000_91200 5.356235
R2678 n1_m1_552000_91200 n1_m1_556800_91200 5.356235
R2679 n1_m1_556800_91200 n1_m1_561600_91200 5.356235
R2680 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2681 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2682 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2683 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2684 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2685 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2686 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2687 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2688 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2689 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2690 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2691 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2692 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2693 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2694 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2695 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2696 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2697 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2698 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2699 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2700 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2701 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2702 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2703 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2704 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2705 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2706 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2707 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2708 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2709 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2710 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2711 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2712 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2713 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2714 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2715 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2716 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2717 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2718 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2719 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2720 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2721 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2722 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2723 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2724 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2725 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2726 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2727 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2728 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2729 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2730 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2731 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2732 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2733 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2734 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2735 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2736 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2737 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2738 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2739 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2740 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2741 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2742 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2743 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2744 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2745 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2746 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2747 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2748 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2749 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2750 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2751 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2752 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2753 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2754 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2755 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2756 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2757 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2758 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2759 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2760 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2761 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2762 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2763 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2764 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2765 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2766 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2767 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2768 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2769 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2770 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2771 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2772 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2773 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2774 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2775 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2776 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2777 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2778 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2779 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2780 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2781 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2782 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2783 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2784 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2785 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2786 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2787 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2788 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2789 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2790 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2791 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2792 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2793 n1_m1_470400_96000 n1_m1_475200_96000 5.356235
R2794 n1_m1_475200_96000 n1_m1_480000_96000 5.356235
R2795 n1_m1_480000_96000 n1_m1_484800_96000 5.356235
R2796 n1_m1_484800_96000 n1_m1_489600_96000 5.356235
R2797 n1_m1_489600_96000 n1_m1_494400_96000 5.356235
R2798 n1_m1_494400_96000 n1_m1_499200_96000 5.356235
R2799 n1_m1_499200_96000 n1_m1_504000_96000 5.356235
R2800 n1_m1_504000_96000 n1_m1_508000_96000 4.463529
R2801 n1_m1_508800_96000 n1_m1_508000_96000 0.892706
R2802 n1_m1_508800_96000 n1_m1_513600_96000 5.356235
R2803 n1_m1_513600_96000 n1_m1_518400_96000 5.356235
R2804 n1_m1_518400_96000 n1_m1_523200_96000 5.356235
R2805 n1_m1_523200_96000 n1_m1_528000_96000 5.356235
R2806 n1_m1_528000_96000 n1_m1_532800_96000 5.356235
R2807 n1_m1_532800_96000 n1_m1_536000_96000 3.570824
R2808 n1_m1_537600_96000 n1_m1_536000_96000 1.785412
R2809 n1_m1_537600_96000 n1_m1_542400_96000 5.356235
R2810 n1_m1_542400_96000 n1_m1_547200_96000 5.356235
R2811 n1_m1_547200_96000 n1_m1_552000_96000 5.356235
R2812 n1_m1_552000_96000 n1_m1_556800_96000 5.356235
R2813 n1_m1_556800_96000 n1_m1_561600_96000 5.356235
R2814 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2815 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2816 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2817 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2818 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2819 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2820 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2821 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2822 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2823 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2824 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2825 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2826 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2827 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2828 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2829 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2830 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2831 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2832 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2833 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2834 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2835 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2836 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2837 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2838 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2839 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2840 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2841 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2842 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2843 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2844 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2845 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2846 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2847 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2848 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2849 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2850 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2851 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2852 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2853 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2854 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2855 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2856 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2857 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2858 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2859 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2860 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2861 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2862 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2863 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2864 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2865 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2866 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2867 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2868 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2869 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2870 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2871 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2872 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2873 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2874 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2875 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2876 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2877 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2878 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2879 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2880 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2881 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2882 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2883 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2884 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2885 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2886 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2887 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2888 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2889 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2890 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2891 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2892 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2893 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2894 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2895 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2896 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2897 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2898 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2899 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2900 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2901 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2902 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2903 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2904 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2905 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2906 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2907 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2908 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2909 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2910 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2911 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2912 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R2913 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R2914 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R2915 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R2916 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R2917 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R2918 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R2919 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R2920 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R2921 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R2922 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R2923 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R2924 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R2925 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R2926 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R2927 n1_m1_470400_100800 n1_m1_475200_100800 5.356235
R2928 n1_m1_475200_100800 n1_m1_480000_100800 5.356235
R2929 n1_m1_480000_100800 n1_m1_484800_100800 5.356235
R2930 n1_m1_484800_100800 n1_m1_489600_100800 5.356235
R2931 n1_m1_489600_100800 n1_m1_494400_100800 5.356235
R2932 n1_m1_494400_100800 n1_m1_499200_100800 5.356235
R2933 n1_m1_499200_100800 n1_m1_504000_100800 5.356235
R2934 n1_m1_504000_100800 n1_m1_508000_100800 4.463529
R2935 n1_m1_508800_100800 n1_m1_508000_100800 0.892706
R2936 n1_m1_508800_100800 n1_m1_513600_100800 5.356235
R2937 n1_m1_513600_100800 n1_m1_518400_100800 5.356235
R2938 n1_m1_518400_100800 n1_m1_523200_100800 5.356235
R2939 n1_m1_523200_100800 n1_m1_528000_100800 5.356235
R2940 n1_m1_528000_100800 n1_m1_532800_100800 5.356235
R2941 n1_m1_532800_100800 n1_m1_536000_100800 3.570824
R2942 n1_m1_537600_100800 n1_m1_536000_100800 1.785412
R2943 n1_m1_537600_100800 n1_m1_542400_100800 5.356235
R2944 n1_m1_542400_100800 n1_m1_547200_100800 5.356235
R2945 n1_m1_547200_100800 n1_m1_552000_100800 5.356235
R2946 n1_m1_552000_100800 n1_m1_556800_100800 5.356235
R2947 n1_m1_556800_100800 n1_m1_561600_100800 5.356235
R2948 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2949 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2950 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2951 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2952 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2953 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2954 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2955 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2956 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2957 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2958 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2959 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2960 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2961 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2962 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2963 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2964 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2965 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2966 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2967 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2968 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2969 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2970 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2971 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2972 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2973 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2974 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2975 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2976 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2977 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2978 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2979 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2980 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2981 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2982 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2983 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2984 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2985 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2986 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2987 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2988 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2989 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2990 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2991 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2992 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2993 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2994 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2995 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2996 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2997 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2998 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2999 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R3000 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R3001 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R3002 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R3003 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R3004 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R3005 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R3006 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R3007 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R3008 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R3009 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R3010 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R3011 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R3012 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R3013 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R3014 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R3015 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R3016 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R3017 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R3018 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R3019 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R3020 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R3021 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R3022 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R3023 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R3024 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R3025 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R3026 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R3027 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R3028 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R3029 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R3030 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R3031 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R3032 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R3033 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R3034 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R3035 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R3036 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R3037 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R3038 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R3039 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R3040 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R3041 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R3042 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R3043 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R3044 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R3045 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R3046 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R3047 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R3048 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R3049 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R3050 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R3051 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R3052 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R3053 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R3054 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R3055 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R3056 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R3057 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R3058 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R3059 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R3060 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R3061 n1_m1_470400_105600 n1_m1_475200_105600 5.356235
R3062 n1_m1_475200_105600 n1_m1_480000_105600 5.356235
R3063 n1_m1_480000_105600 n1_m1_484800_105600 5.356235
R3064 n1_m1_484800_105600 n1_m1_489600_105600 5.356235
R3065 n1_m1_489600_105600 n1_m1_494400_105600 5.356235
R3066 n1_m1_494400_105600 n1_m1_499200_105600 5.356235
R3067 n1_m1_499200_105600 n1_m1_504000_105600 5.356235
R3068 n1_m1_504000_105600 n1_m1_508000_105600 4.463529
R3069 n1_m1_508800_105600 n1_m1_508000_105600 0.892706
R3070 n1_m1_508800_105600 n1_m1_513600_105600 5.356235
R3071 n1_m1_513600_105600 n1_m1_518400_105600 5.356235
R3072 n1_m1_518400_105600 n1_m1_523200_105600 5.356235
R3073 n1_m1_523200_105600 n1_m1_528000_105600 5.356235
R3074 n1_m1_528000_105600 n1_m1_532800_105600 5.356235
R3075 n1_m1_532800_105600 n1_m1_536000_105600 3.570824
R3076 n1_m1_537600_105600 n1_m1_536000_105600 1.785412
R3077 n1_m1_537600_105600 n1_m1_542400_105600 5.356235
R3078 n1_m1_542400_105600 n1_m1_547200_105600 5.356235
R3079 n1_m1_547200_105600 n1_m1_552000_105600 5.356235
R3080 n1_m1_552000_105600 n1_m1_556800_105600 5.356235
R3081 n1_m1_556800_105600 n1_m1_561600_105600 5.356235
R3082 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R3083 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R3084 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R3085 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R3086 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R3087 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R3088 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R3089 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R3090 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R3091 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R3092 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R3093 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R3094 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R3095 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R3096 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R3097 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R3098 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R3099 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R3100 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R3101 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R3102 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R3103 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R3104 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R3105 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R3106 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R3107 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R3108 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R3109 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R3110 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R3111 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R3112 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R3113 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R3114 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R3115 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R3116 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R3117 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R3118 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R3119 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R3120 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R3121 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R3122 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R3123 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R3124 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R3125 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R3126 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R3127 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R3128 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R3129 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R3130 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R3131 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R3132 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R3133 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R3134 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R3135 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R3136 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R3137 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R3138 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R3139 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R3140 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R3141 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R3142 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R3143 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R3144 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R3145 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R3146 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R3147 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R3148 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R3149 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R3150 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R3151 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R3152 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R3153 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R3154 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R3155 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R3156 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R3157 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R3158 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R3159 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R3160 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R3161 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R3162 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R3163 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R3164 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R3165 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R3166 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R3167 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R3168 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R3169 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R3170 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R3171 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R3172 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R3173 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R3174 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R3175 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R3176 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R3177 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R3178 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R3179 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R3180 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R3181 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R3182 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R3183 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R3184 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R3185 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R3186 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R3187 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R3188 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R3189 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R3190 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R3191 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R3192 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R3193 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R3194 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R3195 n1_m1_470400_110400 n1_m1_475200_110400 5.356235
R3196 n1_m1_475200_110400 n1_m1_480000_110400 5.356235
R3197 n1_m1_480000_110400 n1_m1_484800_110400 5.356235
R3198 n1_m1_484800_110400 n1_m1_489600_110400 5.356235
R3199 n1_m1_489600_110400 n1_m1_494400_110400 5.356235
R3200 n1_m1_494400_110400 n1_m1_499200_110400 5.356235
R3201 n1_m1_499200_110400 n1_m1_504000_110400 5.356235
R3202 n1_m1_504000_110400 n1_m1_508000_110400 4.463529
R3203 n1_m1_508800_110400 n1_m1_508000_110400 0.892706
R3204 n1_m1_508800_110400 n1_m1_513600_110400 5.356235
R3205 n1_m1_513600_110400 n1_m1_518400_110400 5.356235
R3206 n1_m1_518400_110400 n1_m1_523200_110400 5.356235
R3207 n1_m1_523200_110400 n1_m1_528000_110400 5.356235
R3208 n1_m1_528000_110400 n1_m1_532800_110400 5.356235
R3209 n1_m1_532800_110400 n1_m1_536000_110400 3.570824
R3210 n1_m1_537600_110400 n1_m1_536000_110400 1.785412
R3211 n1_m1_537600_110400 n1_m1_542400_110400 5.356235
R3212 n1_m1_542400_110400 n1_m1_547200_110400 5.356235
R3213 n1_m1_547200_110400 n1_m1_552000_110400 5.356235
R3214 n1_m1_552000_110400 n1_m1_556800_110400 5.356235
R3215 n1_m1_556800_110400 n1_m1_561600_110400 5.356235
R3216 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R3217 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R3218 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R3219 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R3220 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R3221 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R3222 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R3223 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R3224 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R3225 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R3226 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R3227 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R3228 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R3229 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R3230 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R3231 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R3232 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R3233 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R3234 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R3235 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R3236 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R3237 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R3238 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R3239 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R3240 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R3241 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R3242 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R3243 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R3244 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R3245 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R3246 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R3247 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R3248 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R3249 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R3250 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R3251 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R3252 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R3253 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R3254 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R3255 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R3256 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R3257 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R3258 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R3259 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R3260 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R3261 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R3262 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R3263 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R3264 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R3265 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R3266 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R3267 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R3268 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R3269 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R3270 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R3271 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R3272 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R3273 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R3274 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R3275 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R3276 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R3277 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R3278 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R3279 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R3280 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R3281 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R3282 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R3283 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R3284 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R3285 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R3286 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R3287 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R3288 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R3289 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R3290 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R3291 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R3292 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R3293 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R3294 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R3295 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R3296 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R3297 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R3298 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R3299 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R3300 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R3301 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R3302 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R3303 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R3304 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R3305 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R3306 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R3307 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R3308 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R3309 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R3310 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R3311 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R3312 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R3313 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R3314 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R3315 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R3316 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R3317 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R3318 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R3319 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R3320 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R3321 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R3322 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R3323 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R3324 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R3325 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R3326 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R3327 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R3328 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R3329 n1_m1_470400_115200 n1_m1_475200_115200 5.356235
R3330 n1_m1_475200_115200 n1_m1_480000_115200 5.356235
R3331 n1_m1_480000_115200 n1_m1_484800_115200 5.356235
R3332 n1_m1_484800_115200 n1_m1_489600_115200 5.356235
R3333 n1_m1_489600_115200 n1_m1_494400_115200 5.356235
R3334 n1_m1_494400_115200 n1_m1_499200_115200 5.356235
R3335 n1_m1_499200_115200 n1_m1_504000_115200 5.356235
R3336 n1_m1_504000_115200 n1_m1_508000_115200 4.463529
R3337 n1_m1_508800_115200 n1_m1_508000_115200 0.892706
R3338 n1_m1_508800_115200 n1_m1_513600_115200 5.356235
R3339 n1_m1_513600_115200 n1_m1_518400_115200 5.356235
R3340 n1_m1_518400_115200 n1_m1_523200_115200 5.356235
R3341 n1_m1_523200_115200 n1_m1_528000_115200 5.356235
R3342 n1_m1_528000_115200 n1_m1_532800_115200 5.356235
R3343 n1_m1_532800_115200 n1_m1_536000_115200 3.570824
R3344 n1_m1_537600_115200 n1_m1_536000_115200 1.785412
R3345 n1_m1_537600_115200 n1_m1_542400_115200 5.356235
R3346 n1_m1_542400_115200 n1_m1_547200_115200 5.356235
R3347 n1_m1_547200_115200 n1_m1_552000_115200 5.356235
R3348 n1_m1_552000_115200 n1_m1_556800_115200 5.356235
R3349 n1_m1_556800_115200 n1_m1_561600_115200 5.356235
R3350 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R3351 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R3352 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R3353 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R3354 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R3355 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R3356 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R3357 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R3358 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R3359 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R3360 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R3361 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R3362 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R3363 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R3364 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R3365 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R3366 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R3367 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R3368 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R3369 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R3370 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R3371 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R3372 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R3373 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R3374 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R3375 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R3376 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R3377 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R3378 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R3379 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R3380 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R3381 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R3382 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R3383 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R3384 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R3385 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R3386 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R3387 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R3388 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R3389 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R3390 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R3391 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R3392 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R3393 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R3394 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R3395 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R3396 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R3397 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R3398 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R3399 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R3400 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R3401 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R3402 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R3403 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R3404 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R3405 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R3406 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R3407 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R3408 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R3409 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R3410 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R3411 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R3412 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R3413 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R3414 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R3415 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R3416 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R3417 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R3418 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R3419 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R3420 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R3421 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R3422 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R3423 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R3424 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R3425 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R3426 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R3427 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R3428 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R3429 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R3430 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R3431 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R3432 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R3433 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R3434 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R3435 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R3436 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R3437 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R3438 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R3439 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R3440 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R3441 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R3442 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R3443 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R3444 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R3445 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R3446 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R3447 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R3448 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R3449 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R3450 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R3451 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R3452 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R3453 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R3454 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R3455 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R3456 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R3457 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R3458 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R3459 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R3460 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R3461 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R3462 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R3463 n1_m1_470400_120000 n1_m1_475200_120000 5.356235
R3464 n1_m1_475200_120000 n1_m1_480000_120000 5.356235
R3465 n1_m1_480000_120000 n1_m1_484800_120000 5.356235
R3466 n1_m1_484800_120000 n1_m1_489600_120000 5.356235
R3467 n1_m1_489600_120000 n1_m1_494400_120000 5.356235
R3468 n1_m1_494400_120000 n1_m1_499200_120000 5.356235
R3469 n1_m1_499200_120000 n1_m1_504000_120000 5.356235
R3470 n1_m1_504000_120000 n1_m1_508000_120000 4.463529
R3471 n1_m1_508800_120000 n1_m1_508000_120000 0.892706
R3472 n1_m1_508800_120000 n1_m1_513600_120000 5.356235
R3473 n1_m1_513600_120000 n1_m1_518400_120000 5.356235
R3474 n1_m1_518400_120000 n1_m1_523200_120000 5.356235
R3475 n1_m1_523200_120000 n1_m1_528000_120000 5.356235
R3476 n1_m1_528000_120000 n1_m1_532800_120000 5.356235
R3477 n1_m1_532800_120000 n1_m1_536000_120000 3.570824
R3478 n1_m1_537600_120000 n1_m1_536000_120000 1.785412
R3479 n1_m1_537600_120000 n1_m1_542400_120000 5.356235
R3480 n1_m1_542400_120000 n1_m1_547200_120000 5.356235
R3481 n1_m1_547200_120000 n1_m1_552000_120000 5.356235
R3482 n1_m1_552000_120000 n1_m1_556800_120000 5.356235
R3483 n1_m1_556800_120000 n1_m1_561600_120000 5.356235
R3484 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R3485 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R3486 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R3487 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R3488 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R3489 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R3490 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R3491 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R3492 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R3493 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R3494 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R3495 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R3496 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R3497 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R3498 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R3499 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R3500 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R3501 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R3502 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R3503 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R3504 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R3505 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R3506 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R3507 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R3508 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R3509 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R3510 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R3511 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R3512 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R3513 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R3514 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R3515 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R3516 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R3517 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R3518 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R3519 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R3520 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R3521 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R3522 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R3523 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R3524 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R3525 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R3526 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R3527 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R3528 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R3529 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R3530 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R3531 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R3532 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R3533 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R3534 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R3535 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R3536 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R3537 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R3538 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R3539 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R3540 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R3541 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R3542 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R3543 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R3544 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R3545 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3546 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3547 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3548 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3549 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3550 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3551 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3552 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3553 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3554 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3555 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3556 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3557 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3558 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3559 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3560 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3561 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3562 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3563 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3564 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3565 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3566 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3567 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3568 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3569 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3570 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3571 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3572 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3573 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3574 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3575 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3576 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3577 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3578 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3579 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3580 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3581 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3582 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3583 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3584 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3585 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3586 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3587 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3588 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3589 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3590 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3591 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3592 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3593 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3594 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3595 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3596 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3597 n1_m1_470400_124800 n1_m1_475200_124800 5.356235
R3598 n1_m1_475200_124800 n1_m1_480000_124800 5.356235
R3599 n1_m1_480000_124800 n1_m1_484800_124800 5.356235
R3600 n1_m1_484800_124800 n1_m1_489600_124800 5.356235
R3601 n1_m1_489600_124800 n1_m1_494400_124800 5.356235
R3602 n1_m1_494400_124800 n1_m1_499200_124800 5.356235
R3603 n1_m1_499200_124800 n1_m1_504000_124800 5.356235
R3604 n1_m1_504000_124800 n1_m1_508000_124800 4.463529
R3605 n1_m1_508800_124800 n1_m1_508000_124800 0.892706
R3606 n1_m1_508800_124800 n1_m1_513600_124800 5.356235
R3607 n1_m1_513600_124800 n1_m1_518400_124800 5.356235
R3608 n1_m1_518400_124800 n1_m1_523200_124800 5.356235
R3609 n1_m1_523200_124800 n1_m1_528000_124800 5.356235
R3610 n1_m1_528000_124800 n1_m1_532800_124800 5.356235
R3611 n1_m1_532800_124800 n1_m1_536000_124800 3.570824
R3612 n1_m1_537600_124800 n1_m1_536000_124800 1.785412
R3613 n1_m1_537600_124800 n1_m1_542400_124800 5.356235
R3614 n1_m1_542400_124800 n1_m1_547200_124800 5.356235
R3615 n1_m1_547200_124800 n1_m1_552000_124800 5.356235
R3616 n1_m1_552000_124800 n1_m1_556800_124800 5.356235
R3617 n1_m1_556800_124800 n1_m1_561600_124800 5.356235
R3618 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3619 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3620 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3621 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3622 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3623 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3624 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3625 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3626 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3627 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3628 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3629 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3630 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3631 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3632 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3633 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3634 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3635 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3636 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3637 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3638 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3639 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3640 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3641 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3642 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3643 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3644 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3645 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3646 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3647 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3648 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3649 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3650 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3651 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3652 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3653 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3654 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3655 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3656 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3657 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3658 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3659 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3660 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3661 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3662 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3663 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3664 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3665 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3666 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3667 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3668 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3669 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3670 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3671 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3672 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3673 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3674 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3675 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3676 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3677 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3678 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3679 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3680 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3681 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3682 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3683 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3684 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3685 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3686 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3687 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3688 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3689 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3690 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3691 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3692 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3693 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3694 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3695 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3696 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3697 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3698 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3699 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3700 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3701 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3702 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3703 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3704 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3705 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3706 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3707 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3708 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3709 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3710 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3711 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3712 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3713 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3714 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3715 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3716 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3717 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3718 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3719 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3720 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3721 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3722 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3723 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3724 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3725 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3726 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3727 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3728 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3729 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3730 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3731 n1_m1_470400_129600 n1_m1_475200_129600 5.356235
R3732 n1_m1_475200_129600 n1_m1_480000_129600 5.356235
R3733 n1_m1_480000_129600 n1_m1_484800_129600 5.356235
R3734 n1_m1_484800_129600 n1_m1_489600_129600 5.356235
R3735 n1_m1_489600_129600 n1_m1_494400_129600 5.356235
R3736 n1_m1_494400_129600 n1_m1_499200_129600 5.356235
R3737 n1_m1_499200_129600 n1_m1_504000_129600 5.356235
R3738 n1_m1_504000_129600 n1_m1_508000_129600 4.463529
R3739 n1_m1_508800_129600 n1_m1_508000_129600 0.892706
R3740 n1_m1_508800_129600 n1_m1_513600_129600 5.356235
R3741 n1_m1_513600_129600 n1_m1_518400_129600 5.356235
R3742 n1_m1_518400_129600 n1_m1_523200_129600 5.356235
R3743 n1_m1_523200_129600 n1_m1_528000_129600 5.356235
R3744 n1_m1_528000_129600 n1_m1_532800_129600 5.356235
R3745 n1_m1_532800_129600 n1_m1_536000_129600 3.570824
R3746 n1_m1_537600_129600 n1_m1_536000_129600 1.785412
R3747 n1_m1_537600_129600 n1_m1_542400_129600 5.356235
R3748 n1_m1_542400_129600 n1_m1_547200_129600 5.356235
R3749 n1_m1_547200_129600 n1_m1_552000_129600 5.356235
R3750 n1_m1_552000_129600 n1_m1_556800_129600 5.356235
R3751 n1_m1_556800_129600 n1_m1_561600_129600 5.356235
R3752 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R3753 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R3754 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R3755 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R3756 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R3757 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R3758 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R3759 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R3760 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R3761 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R3762 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R3763 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R3764 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R3765 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R3766 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R3767 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R3768 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R3769 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R3770 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R3771 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R3772 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R3773 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R3774 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R3775 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R3776 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R3777 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R3778 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R3779 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R3780 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R3781 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R3782 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R3783 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R3784 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R3785 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R3786 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R3787 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R3788 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R3789 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R3790 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R3791 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R3792 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R3793 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R3794 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R3795 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R3796 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R3797 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R3798 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R3799 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R3800 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R3801 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R3802 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R3803 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R3804 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R3805 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R3806 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R3807 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R3808 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R3809 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R3810 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R3811 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R3812 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R3813 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R3814 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R3815 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R3816 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R3817 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R3818 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R3819 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R3820 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R3821 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R3822 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R3823 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R3824 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R3825 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R3826 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R3827 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R3828 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R3829 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R3830 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R3831 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R3832 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R3833 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R3834 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R3835 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R3836 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R3837 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R3838 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R3839 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R3840 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R3841 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R3842 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R3843 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R3844 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R3845 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R3846 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R3847 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R3848 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R3849 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R3850 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R3851 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R3852 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R3853 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R3854 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R3855 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R3856 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R3857 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R3858 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R3859 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R3860 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R3861 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R3862 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R3863 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R3864 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R3865 n1_m1_470400_134400 n1_m1_475200_134400 5.356235
R3866 n1_m1_475200_134400 n1_m1_480000_134400 5.356235
R3867 n1_m1_480000_134400 n1_m1_484800_134400 5.356235
R3868 n1_m1_484800_134400 n1_m1_489600_134400 5.356235
R3869 n1_m1_489600_134400 n1_m1_494400_134400 5.356235
R3870 n1_m1_494400_134400 n1_m1_499200_134400 5.356235
R3871 n1_m1_499200_134400 n1_m1_504000_134400 5.356235
R3872 n1_m1_504000_134400 n1_m1_508000_134400 4.463529
R3873 n1_m1_508800_134400 n1_m1_508000_134400 0.892706
R3874 n1_m1_508800_134400 n1_m1_513600_134400 5.356235
R3875 n1_m1_513600_134400 n1_m1_518400_134400 5.356235
R3876 n1_m1_518400_134400 n1_m1_523200_134400 5.356235
R3877 n1_m1_523200_134400 n1_m1_528000_134400 5.356235
R3878 n1_m1_528000_134400 n1_m1_532800_134400 5.356235
R3879 n1_m1_532800_134400 n1_m1_536000_134400 3.570824
R3880 n1_m1_537600_134400 n1_m1_536000_134400 1.785412
R3881 n1_m1_537600_134400 n1_m1_542400_134400 5.356235
R3882 n1_m1_542400_134400 n1_m1_547200_134400 5.356235
R3883 n1_m1_547200_134400 n1_m1_552000_134400 5.356235
R3884 n1_m1_552000_134400 n1_m1_556800_134400 5.356235
R3885 n1_m1_556800_134400 n1_m1_561600_134400 5.356235
R3886 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R3887 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R3888 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R3889 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R3890 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R3891 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R3892 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R3893 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R3894 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R3895 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R3896 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R3897 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R3898 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R3899 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R3900 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R3901 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R3902 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R3903 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R3904 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R3905 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R3906 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R3907 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R3908 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R3909 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R3910 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R3911 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R3912 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R3913 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R3914 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R3915 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R3916 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R3917 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R3918 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R3919 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R3920 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R3921 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R3922 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R3923 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R3924 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R3925 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R3926 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R3927 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R3928 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R3929 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R3930 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R3931 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R3932 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R3933 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R3934 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R3935 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R3936 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R3937 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R3938 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R3939 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R3940 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R3941 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R3942 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R3943 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R3944 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R3945 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R3946 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R3947 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R3948 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R3949 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R3950 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R3951 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R3952 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R3953 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R3954 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R3955 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R3956 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R3957 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R3958 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R3959 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R3960 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R3961 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R3962 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R3963 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R3964 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R3965 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R3966 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R3967 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R3968 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R3969 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R3970 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R3971 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R3972 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R3973 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R3974 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R3975 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R3976 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R3977 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R3978 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R3979 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R3980 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R3981 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R3982 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R3983 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R3984 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R3985 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R3986 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R3987 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R3988 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R3989 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R3990 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R3991 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R3992 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R3993 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R3994 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R3995 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R3996 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R3997 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R3998 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R3999 n1_m1_470400_139200 n1_m1_475200_139200 5.356235
R4000 n1_m1_475200_139200 n1_m1_480000_139200 5.356235
R4001 n1_m1_480000_139200 n1_m1_484800_139200 5.356235
R4002 n1_m1_484800_139200 n1_m1_489600_139200 5.356235
R4003 n1_m1_489600_139200 n1_m1_494400_139200 5.356235
R4004 n1_m1_494400_139200 n1_m1_499200_139200 5.356235
R4005 n1_m1_499200_139200 n1_m1_504000_139200 5.356235
R4006 n1_m1_504000_139200 n1_m1_508000_139200 4.463529
R4007 n1_m1_508800_139200 n1_m1_508000_139200 0.892706
R4008 n1_m1_508800_139200 n1_m1_513600_139200 5.356235
R4009 n1_m1_513600_139200 n1_m1_518400_139200 5.356235
R4010 n1_m1_518400_139200 n1_m1_523200_139200 5.356235
R4011 n1_m1_523200_139200 n1_m1_528000_139200 5.356235
R4012 n1_m1_528000_139200 n1_m1_532800_139200 5.356235
R4013 n1_m1_532800_139200 n1_m1_536000_139200 3.570824
R4014 n1_m1_537600_139200 n1_m1_536000_139200 1.785412
R4015 n1_m1_537600_139200 n1_m1_542400_139200 5.356235
R4016 n1_m1_542400_139200 n1_m1_547200_139200 5.356235
R4017 n1_m1_547200_139200 n1_m1_552000_139200 5.356235
R4018 n1_m1_552000_139200 n1_m1_556800_139200 5.356235
R4019 n1_m1_556800_139200 n1_m1_561600_139200 5.356235
R4020 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R4021 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R4022 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R4023 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R4024 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R4025 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R4026 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R4027 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R4028 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R4029 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R4030 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R4031 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R4032 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R4033 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R4034 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R4035 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R4036 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R4037 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R4038 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R4039 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R4040 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R4041 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R4042 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R4043 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R4044 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R4045 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R4046 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R4047 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R4048 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R4049 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R4050 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R4051 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R4052 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R4053 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R4054 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R4055 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R4056 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R4057 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R4058 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R4059 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R4060 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R4061 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R4062 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R4063 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R4064 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R4065 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R4066 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R4067 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R4068 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R4069 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R4070 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R4071 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R4072 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R4073 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R4074 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R4075 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R4076 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R4077 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R4078 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R4079 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R4080 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R4081 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R4082 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R4083 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R4084 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R4085 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R4086 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R4087 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R4088 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R4089 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R4090 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R4091 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R4092 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R4093 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R4094 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R4095 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R4096 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R4097 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R4098 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R4099 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R4100 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R4101 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R4102 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R4103 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R4104 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R4105 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R4106 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R4107 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R4108 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R4109 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R4110 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R4111 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R4112 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R4113 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R4114 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R4115 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R4116 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R4117 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R4118 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R4119 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R4120 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R4121 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R4122 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R4123 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R4124 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R4125 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R4126 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R4127 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R4128 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R4129 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R4130 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R4131 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R4132 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R4133 n1_m1_470400_144000 n1_m1_475200_144000 5.356235
R4134 n1_m1_475200_144000 n1_m1_480000_144000 5.356235
R4135 n1_m1_480000_144000 n1_m1_484800_144000 5.356235
R4136 n1_m1_484800_144000 n1_m1_489600_144000 5.356235
R4137 n1_m1_489600_144000 n1_m1_494400_144000 5.356235
R4138 n1_m1_494400_144000 n1_m1_499200_144000 5.356235
R4139 n1_m1_499200_144000 n1_m1_504000_144000 5.356235
R4140 n1_m1_504000_144000 n1_m1_508000_144000 4.463529
R4141 n1_m1_508800_144000 n1_m1_508000_144000 0.892706
R4142 n1_m1_508800_144000 n1_m1_513600_144000 5.356235
R4143 n1_m1_513600_144000 n1_m1_518400_144000 5.356235
R4144 n1_m1_518400_144000 n1_m1_523200_144000 5.356235
R4145 n1_m1_523200_144000 n1_m1_528000_144000 5.356235
R4146 n1_m1_528000_144000 n1_m1_532800_144000 5.356235
R4147 n1_m1_532800_144000 n1_m1_536000_144000 3.570824
R4148 n1_m1_537600_144000 n1_m1_536000_144000 1.785412
R4149 n1_m1_537600_144000 n1_m1_542400_144000 5.356235
R4150 n1_m1_542400_144000 n1_m1_547200_144000 5.356235
R4151 n1_m1_547200_144000 n1_m1_552000_144000 5.356235
R4152 n1_m1_552000_144000 n1_m1_556800_144000 5.356235
R4153 n1_m1_556800_144000 n1_m1_561600_144000 5.356235
R4154 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R4155 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R4156 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R4157 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R4158 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R4159 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R4160 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R4161 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R4162 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R4163 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R4164 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R4165 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R4166 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R4167 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R4168 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R4169 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R4170 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R4171 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R4172 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R4173 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R4174 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R4175 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R4176 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R4177 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R4178 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R4179 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R4180 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R4181 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R4182 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R4183 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R4184 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R4185 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R4186 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R4187 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R4188 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R4189 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R4190 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R4191 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R4192 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R4193 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R4194 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R4195 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R4196 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R4197 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R4198 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R4199 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R4200 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R4201 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R4202 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R4203 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R4204 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R4205 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R4206 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R4207 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R4208 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R4209 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R4210 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R4211 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R4212 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R4213 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R4214 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R4215 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R4216 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R4217 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R4218 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R4219 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R4220 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R4221 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R4222 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R4223 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R4224 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R4225 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R4226 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R4227 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R4228 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R4229 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R4230 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R4231 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R4232 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R4233 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R4234 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R4235 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R4236 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R4237 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R4238 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R4239 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R4240 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R4241 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R4242 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R4243 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R4244 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R4245 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R4246 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R4247 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R4248 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R4249 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R4250 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R4251 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R4252 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R4253 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R4254 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R4255 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R4256 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R4257 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R4258 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R4259 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R4260 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R4261 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R4262 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R4263 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R4264 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R4265 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R4266 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R4267 n1_m1_470400_148800 n1_m1_475200_148800 5.356235
R4268 n1_m1_475200_148800 n1_m1_480000_148800 5.356235
R4269 n1_m1_480000_148800 n1_m1_484800_148800 5.356235
R4270 n1_m1_484800_148800 n1_m1_489600_148800 5.356235
R4271 n1_m1_489600_148800 n1_m1_494400_148800 5.356235
R4272 n1_m1_494400_148800 n1_m1_499200_148800 5.356235
R4273 n1_m1_499200_148800 n1_m1_504000_148800 5.356235
R4274 n1_m1_504000_148800 n1_m1_508000_148800 4.463529
R4275 n1_m1_508800_148800 n1_m1_508000_148800 0.892706
R4276 n1_m1_508800_148800 n1_m1_513600_148800 5.356235
R4277 n1_m1_513600_148800 n1_m1_518400_148800 5.356235
R4278 n1_m1_518400_148800 n1_m1_523200_148800 5.356235
R4279 n1_m1_523200_148800 n1_m1_528000_148800 5.356235
R4280 n1_m1_528000_148800 n1_m1_532800_148800 5.356235
R4281 n1_m1_532800_148800 n1_m1_536000_148800 3.570824
R4282 n1_m1_537600_148800 n1_m1_536000_148800 1.785412
R4283 n1_m1_537600_148800 n1_m1_542400_148800 5.356235
R4284 n1_m1_542400_148800 n1_m1_547200_148800 5.356235
R4285 n1_m1_547200_148800 n1_m1_552000_148800 5.356235
R4286 n1_m1_552000_148800 n1_m1_556800_148800 5.356235
R4287 n1_m1_556800_148800 n1_m1_561600_148800 5.356235
R4288 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R4289 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R4290 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R4291 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R4292 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R4293 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R4294 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R4295 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R4296 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R4297 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R4298 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R4299 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R4300 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R4301 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R4302 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R4303 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R4304 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R4305 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R4306 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R4307 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R4308 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R4309 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R4310 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R4311 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R4312 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R4313 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R4314 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R4315 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R4316 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R4317 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R4318 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R4319 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R4320 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R4321 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R4322 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R4323 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R4324 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R4325 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R4326 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R4327 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R4328 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R4329 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R4330 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R4331 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R4332 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R4333 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R4334 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R4335 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R4336 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R4337 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R4338 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R4339 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R4340 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R4341 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R4342 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R4343 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R4344 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R4345 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R4346 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R4347 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R4348 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R4349 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R4350 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R4351 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R4352 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R4353 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R4354 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R4355 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R4356 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R4357 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R4358 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R4359 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R4360 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R4361 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R4362 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R4363 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R4364 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R4365 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R4366 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R4367 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R4368 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R4369 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R4370 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R4371 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R4372 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R4373 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R4374 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R4375 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R4376 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R4377 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R4378 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R4379 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R4380 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R4381 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R4382 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R4383 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R4384 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R4385 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R4386 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R4387 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R4388 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R4389 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R4390 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R4391 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R4392 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R4393 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R4394 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R4395 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R4396 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R4397 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R4398 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R4399 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R4400 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R4401 n1_m1_470400_153600 n1_m1_475200_153600 5.356235
R4402 n1_m1_475200_153600 n1_m1_480000_153600 5.356235
R4403 n1_m1_480000_153600 n1_m1_484800_153600 5.356235
R4404 n1_m1_484800_153600 n1_m1_489600_153600 5.356235
R4405 n1_m1_489600_153600 n1_m1_494400_153600 5.356235
R4406 n1_m1_494400_153600 n1_m1_499200_153600 5.356235
R4407 n1_m1_499200_153600 n1_m1_504000_153600 5.356235
R4408 n1_m1_504000_153600 n1_m1_508000_153600 4.463529
R4409 n1_m1_508800_153600 n1_m1_508000_153600 0.892706
R4410 n1_m1_508800_153600 n1_m1_513600_153600 5.356235
R4411 n1_m1_513600_153600 n1_m1_518400_153600 5.356235
R4412 n1_m1_518400_153600 n1_m1_523200_153600 5.356235
R4413 n1_m1_523200_153600 n1_m1_528000_153600 5.356235
R4414 n1_m1_528000_153600 n1_m1_532800_153600 5.356235
R4415 n1_m1_532800_153600 n1_m1_536000_153600 3.570824
R4416 n1_m1_537600_153600 n1_m1_536000_153600 1.785412
R4417 n1_m1_537600_153600 n1_m1_542400_153600 5.356235
R4418 n1_m1_542400_153600 n1_m1_547200_153600 5.356235
R4419 n1_m1_547200_153600 n1_m1_552000_153600 5.356235
R4420 n1_m1_552000_153600 n1_m1_556800_153600 5.356235
R4421 n1_m1_556800_153600 n1_m1_561600_153600 5.356235
R4422 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R4423 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R4424 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R4425 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R4426 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R4427 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R4428 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R4429 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R4430 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R4431 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R4432 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R4433 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R4434 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R4435 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R4436 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R4437 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R4438 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R4439 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R4440 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R4441 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R4442 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R4443 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R4444 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R4445 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R4446 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R4447 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R4448 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R4449 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R4450 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R4451 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R4452 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R4453 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R4454 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R4455 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R4456 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R4457 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R4458 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R4459 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R4460 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R4461 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R4462 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R4463 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R4464 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R4465 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R4466 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R4467 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R4468 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R4469 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R4470 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R4471 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R4472 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R4473 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R4474 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R4475 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R4476 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R4477 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R4478 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R4479 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R4480 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R4481 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R4482 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R4483 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R4484 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R4485 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R4486 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R4487 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R4488 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R4489 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R4490 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R4491 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R4492 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R4493 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R4494 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R4495 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R4496 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R4497 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R4498 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R4499 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R4500 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R4501 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R4502 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R4503 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R4504 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R4505 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R4506 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R4507 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R4508 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R4509 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R4510 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R4511 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R4512 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R4513 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R4514 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R4515 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R4516 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R4517 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R4518 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R4519 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R4520 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R4521 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R4522 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R4523 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R4524 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R4525 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R4526 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R4527 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R4528 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R4529 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R4530 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R4531 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R4532 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R4533 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R4534 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R4535 n1_m1_470400_158400 n1_m1_475200_158400 5.356235
R4536 n1_m1_475200_158400 n1_m1_480000_158400 5.356235
R4537 n1_m1_480000_158400 n1_m1_484800_158400 5.356235
R4538 n1_m1_484800_158400 n1_m1_489600_158400 5.356235
R4539 n1_m1_489600_158400 n1_m1_494400_158400 5.356235
R4540 n1_m1_494400_158400 n1_m1_499200_158400 5.356235
R4541 n1_m1_499200_158400 n1_m1_504000_158400 5.356235
R4542 n1_m1_504000_158400 n1_m1_508000_158400 4.463529
R4543 n1_m1_508800_158400 n1_m1_508000_158400 0.892706
R4544 n1_m1_508800_158400 n1_m1_513600_158400 5.356235
R4545 n1_m1_513600_158400 n1_m1_518400_158400 5.356235
R4546 n1_m1_518400_158400 n1_m1_523200_158400 5.356235
R4547 n1_m1_523200_158400 n1_m1_528000_158400 5.356235
R4548 n1_m1_528000_158400 n1_m1_532800_158400 5.356235
R4549 n1_m1_532800_158400 n1_m1_536000_158400 3.570824
R4550 n1_m1_537600_158400 n1_m1_536000_158400 1.785412
R4551 n1_m1_537600_158400 n1_m1_542400_158400 5.356235
R4552 n1_m1_542400_158400 n1_m1_547200_158400 5.356235
R4553 n1_m1_547200_158400 n1_m1_552000_158400 5.356235
R4554 n1_m1_552000_158400 n1_m1_556800_158400 5.356235
R4555 n1_m1_556800_158400 n1_m1_561600_158400 5.356235
R4556 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R4557 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R4558 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R4559 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R4560 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R4561 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R4562 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R4563 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R4564 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R4565 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R4566 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R4567 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R4568 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R4569 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R4570 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R4571 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R4572 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R4573 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R4574 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R4575 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R4576 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R4577 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R4578 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R4579 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R4580 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R4581 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R4582 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R4583 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R4584 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R4585 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R4586 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R4587 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R4588 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R4589 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R4590 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R4591 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R4592 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R4593 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R4594 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R4595 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R4596 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R4597 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R4598 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R4599 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R4600 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R4601 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R4602 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R4603 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R4604 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R4605 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R4606 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R4607 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R4608 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R4609 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R4610 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R4611 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R4612 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R4613 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R4614 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R4615 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R4616 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R4617 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R4618 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R4619 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R4620 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R4621 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R4622 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R4623 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R4624 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R4625 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R4626 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R4627 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R4628 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R4629 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R4630 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R4631 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R4632 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R4633 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R4634 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R4635 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R4636 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R4637 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R4638 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R4639 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R4640 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R4641 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R4642 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R4643 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R4644 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R4645 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R4646 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R4647 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R4648 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R4649 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R4650 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R4651 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R4652 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R4653 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R4654 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R4655 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R4656 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R4657 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R4658 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R4659 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R4660 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R4661 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R4662 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R4663 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R4664 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R4665 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R4666 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R4667 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R4668 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R4669 n1_m1_470400_163200 n1_m1_475200_163200 5.356235
R4670 n1_m1_475200_163200 n1_m1_480000_163200 5.356235
R4671 n1_m1_480000_163200 n1_m1_484800_163200 5.356235
R4672 n1_m1_484800_163200 n1_m1_489600_163200 5.356235
R4673 n1_m1_489600_163200 n1_m1_494400_163200 5.356235
R4674 n1_m1_494400_163200 n1_m1_499200_163200 5.356235
R4675 n1_m1_499200_163200 n1_m1_504000_163200 5.356235
R4676 n1_m1_504000_163200 n1_m1_508000_163200 4.463529
R4677 n1_m1_508800_163200 n1_m1_508000_163200 0.892706
R4678 n1_m1_508800_163200 n1_m1_513600_163200 5.356235
R4679 n1_m1_513600_163200 n1_m1_518400_163200 5.356235
R4680 n1_m1_518400_163200 n1_m1_523200_163200 5.356235
R4681 n1_m1_523200_163200 n1_m1_528000_163200 5.356235
R4682 n1_m1_528000_163200 n1_m1_532800_163200 5.356235
R4683 n1_m1_532800_163200 n1_m1_536000_163200 3.570824
R4684 n1_m1_537600_163200 n1_m1_536000_163200 1.785412
R4685 n1_m1_537600_163200 n1_m1_542400_163200 5.356235
R4686 n1_m1_542400_163200 n1_m1_547200_163200 5.356235
R4687 n1_m1_547200_163200 n1_m1_552000_163200 5.356235
R4688 n1_m1_552000_163200 n1_m1_556800_163200 5.356235
R4689 n1_m1_556800_163200 n1_m1_561600_163200 5.356235
R4690 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R4691 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R4692 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R4693 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R4694 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R4695 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R4696 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R4697 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R4698 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R4699 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R4700 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R4701 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R4702 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R4703 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R4704 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R4705 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R4706 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R4707 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R4708 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R4709 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R4710 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R4711 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R4712 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R4713 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R4714 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R4715 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R4716 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R4717 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R4718 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R4719 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R4720 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R4721 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R4722 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R4723 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R4724 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R4725 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R4726 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R4727 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R4728 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R4729 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R4730 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R4731 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R4732 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R4733 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R4734 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R4735 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R4736 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R4737 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R4738 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R4739 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R4740 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R4741 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R4742 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R4743 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R4744 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R4745 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R4746 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R4747 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R4748 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R4749 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R4750 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R4751 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R4752 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R4753 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R4754 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R4755 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R4756 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R4757 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R4758 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R4759 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R4760 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R4761 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R4762 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R4763 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R4764 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R4765 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R4766 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R4767 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R4768 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R4769 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R4770 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R4771 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R4772 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R4773 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R4774 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R4775 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R4776 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R4777 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R4778 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R4779 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R4780 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R4781 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R4782 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R4783 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R4784 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R4785 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R4786 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R4787 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R4788 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R4789 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R4790 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R4791 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R4792 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R4793 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R4794 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R4795 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R4796 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R4797 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R4798 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R4799 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R4800 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R4801 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R4802 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R4803 n1_m1_470400_168000 n1_m1_475200_168000 5.356235
R4804 n1_m1_475200_168000 n1_m1_480000_168000 5.356235
R4805 n1_m1_480000_168000 n1_m1_484800_168000 5.356235
R4806 n1_m1_484800_168000 n1_m1_489600_168000 5.356235
R4807 n1_m1_489600_168000 n1_m1_494400_168000 5.356235
R4808 n1_m1_494400_168000 n1_m1_499200_168000 5.356235
R4809 n1_m1_499200_168000 n1_m1_504000_168000 5.356235
R4810 n1_m1_504000_168000 n1_m1_508000_168000 4.463529
R4811 n1_m1_508800_168000 n1_m1_508000_168000 0.892706
R4812 n1_m1_508800_168000 n1_m1_513600_168000 5.356235
R4813 n1_m1_513600_168000 n1_m1_518400_168000 5.356235
R4814 n1_m1_518400_168000 n1_m1_523200_168000 5.356235
R4815 n1_m1_523200_168000 n1_m1_528000_168000 5.356235
R4816 n1_m1_528000_168000 n1_m1_532800_168000 5.356235
R4817 n1_m1_532800_168000 n1_m1_536000_168000 3.570824
R4818 n1_m1_537600_168000 n1_m1_536000_168000 1.785412
R4819 n1_m1_537600_168000 n1_m1_542400_168000 5.356235
R4820 n1_m1_542400_168000 n1_m1_547200_168000 5.356235
R4821 n1_m1_547200_168000 n1_m1_552000_168000 5.356235
R4822 n1_m1_552000_168000 n1_m1_556800_168000 5.356235
R4823 n1_m1_556800_168000 n1_m1_561600_168000 5.356235
R4824 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R4825 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R4826 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R4827 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R4828 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R4829 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R4830 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R4831 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R4832 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R4833 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R4834 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R4835 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R4836 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R4837 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R4838 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R4839 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R4840 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R4841 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R4842 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R4843 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R4844 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R4845 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R4846 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R4847 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R4848 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R4849 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R4850 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R4851 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R4852 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R4853 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R4854 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R4855 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R4856 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R4857 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R4858 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R4859 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R4860 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R4861 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R4862 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R4863 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R4864 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R4865 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R4866 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R4867 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R4868 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R4869 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R4870 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R4871 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R4872 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R4873 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R4874 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R4875 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R4876 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R4877 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R4878 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R4879 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R4880 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R4881 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R4882 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R4883 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R4884 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R4885 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R4886 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R4887 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R4888 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R4889 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R4890 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R4891 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R4892 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R4893 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R4894 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R4895 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R4896 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R4897 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R4898 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R4899 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R4900 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R4901 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R4902 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R4903 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R4904 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R4905 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R4906 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R4907 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R4908 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R4909 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R4910 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R4911 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R4912 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R4913 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R4914 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R4915 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R4916 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R4917 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R4918 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R4919 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R4920 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R4921 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R4922 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R4923 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R4924 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R4925 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R4926 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R4927 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R4928 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R4929 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R4930 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R4931 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R4932 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R4933 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R4934 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R4935 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R4936 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R4937 n1_m1_470400_172800 n1_m1_475200_172800 5.356235
R4938 n1_m1_475200_172800 n1_m1_480000_172800 5.356235
R4939 n1_m1_480000_172800 n1_m1_484800_172800 5.356235
R4940 n1_m1_484800_172800 n1_m1_489600_172800 5.356235
R4941 n1_m1_489600_172800 n1_m1_494400_172800 5.356235
R4942 n1_m1_494400_172800 n1_m1_499200_172800 5.356235
R4943 n1_m1_499200_172800 n1_m1_504000_172800 5.356235
R4944 n1_m1_504000_172800 n1_m1_508000_172800 4.463529
R4945 n1_m1_508800_172800 n1_m1_508000_172800 0.892706
R4946 n1_m1_508800_172800 n1_m1_513600_172800 5.356235
R4947 n1_m1_513600_172800 n1_m1_518400_172800 5.356235
R4948 n1_m1_518400_172800 n1_m1_523200_172800 5.356235
R4949 n1_m1_523200_172800 n1_m1_528000_172800 5.356235
R4950 n1_m1_528000_172800 n1_m1_532800_172800 5.356235
R4951 n1_m1_532800_172800 n1_m1_536000_172800 3.570824
R4952 n1_m1_537600_172800 n1_m1_536000_172800 1.785412
R4953 n1_m1_537600_172800 n1_m1_542400_172800 5.356235
R4954 n1_m1_542400_172800 n1_m1_547200_172800 5.356235
R4955 n1_m1_547200_172800 n1_m1_552000_172800 5.356235
R4956 n1_m1_552000_172800 n1_m1_556800_172800 5.356235
R4957 n1_m1_556800_172800 n1_m1_561600_172800 5.356235
R4958 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R4959 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R4960 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R4961 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R4962 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R4963 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R4964 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R4965 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R4966 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R4967 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R4968 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R4969 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R4970 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R4971 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R4972 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R4973 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R4974 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R4975 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R4976 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R4977 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R4978 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R4979 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R4980 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R4981 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R4982 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R4983 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R4984 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R4985 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R4986 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R4987 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R4988 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R4989 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R4990 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R4991 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R4992 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R4993 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R4994 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R4995 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R4996 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R4997 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R4998 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R4999 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R5000 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R5001 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R5002 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R5003 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R5004 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R5005 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R5006 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R5007 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R5008 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R5009 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R5010 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R5011 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R5012 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R5013 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R5014 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R5015 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R5016 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R5017 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R5018 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R5019 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R5020 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R5021 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R5022 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R5023 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R5024 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R5025 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R5026 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R5027 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R5028 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R5029 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R5030 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R5031 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R5032 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R5033 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R5034 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R5035 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R5036 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R5037 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R5038 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R5039 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R5040 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R5041 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R5042 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R5043 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R5044 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R5045 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R5046 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R5047 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R5048 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R5049 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R5050 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R5051 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R5052 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R5053 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R5054 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R5055 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R5056 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R5057 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R5058 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R5059 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R5060 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R5061 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R5062 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R5063 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R5064 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R5065 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R5066 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R5067 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R5068 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R5069 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R5070 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R5071 n1_m1_470400_177600 n1_m1_475200_177600 5.356235
R5072 n1_m1_475200_177600 n1_m1_480000_177600 5.356235
R5073 n1_m1_480000_177600 n1_m1_484800_177600 5.356235
R5074 n1_m1_484800_177600 n1_m1_489600_177600 5.356235
R5075 n1_m1_489600_177600 n1_m1_494400_177600 5.356235
R5076 n1_m1_494400_177600 n1_m1_499200_177600 5.356235
R5077 n1_m1_499200_177600 n1_m1_504000_177600 5.356235
R5078 n1_m1_504000_177600 n1_m1_508000_177600 4.463529
R5079 n1_m1_508800_177600 n1_m1_508000_177600 0.892706
R5080 n1_m1_508800_177600 n1_m1_513600_177600 5.356235
R5081 n1_m1_513600_177600 n1_m1_518400_177600 5.356235
R5082 n1_m1_518400_177600 n1_m1_523200_177600 5.356235
R5083 n1_m1_523200_177600 n1_m1_528000_177600 5.356235
R5084 n1_m1_528000_177600 n1_m1_532800_177600 5.356235
R5085 n1_m1_532800_177600 n1_m1_536000_177600 3.570824
R5086 n1_m1_537600_177600 n1_m1_536000_177600 1.785412
R5087 n1_m1_537600_177600 n1_m1_542400_177600 5.356235
R5088 n1_m1_542400_177600 n1_m1_547200_177600 5.356235
R5089 n1_m1_547200_177600 n1_m1_552000_177600 5.356235
R5090 n1_m1_552000_177600 n1_m1_556800_177600 5.356235
R5091 n1_m1_556800_177600 n1_m1_561600_177600 5.356235
R5092 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R5093 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R5094 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R5095 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R5096 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R5097 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R5098 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R5099 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R5100 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R5101 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R5102 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R5103 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R5104 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R5105 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R5106 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R5107 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R5108 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R5109 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R5110 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R5111 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R5112 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R5113 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R5114 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R5115 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R5116 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R5117 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R5118 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R5119 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R5120 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R5121 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R5122 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R5123 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R5124 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R5125 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R5126 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R5127 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R5128 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R5129 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R5130 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R5131 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R5132 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R5133 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R5134 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R5135 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R5136 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R5137 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R5138 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R5139 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R5140 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R5141 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R5142 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R5143 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R5144 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R5145 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R5146 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R5147 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R5148 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R5149 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R5150 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R5151 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R5152 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R5153 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R5154 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R5155 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R5156 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R5157 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R5158 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R5159 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R5160 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R5161 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R5162 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R5163 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R5164 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R5165 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R5166 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R5167 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R5168 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R5169 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R5170 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R5171 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R5172 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R5173 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R5174 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R5175 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R5176 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R5177 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R5178 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R5179 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R5180 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R5181 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R5182 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R5183 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R5184 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R5185 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R5186 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R5187 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R5188 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R5189 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R5190 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R5191 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R5192 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R5193 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R5194 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R5195 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R5196 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R5197 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R5198 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R5199 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R5200 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R5201 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R5202 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R5203 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R5204 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R5205 n1_m1_470400_182400 n1_m1_475200_182400 5.356235
R5206 n1_m1_475200_182400 n1_m1_480000_182400 5.356235
R5207 n1_m1_480000_182400 n1_m1_484800_182400 5.356235
R5208 n1_m1_484800_182400 n1_m1_489600_182400 5.356235
R5209 n1_m1_489600_182400 n1_m1_494400_182400 5.356235
R5210 n1_m1_494400_182400 n1_m1_499200_182400 5.356235
R5211 n1_m1_499200_182400 n1_m1_504000_182400 5.356235
R5212 n1_m1_504000_182400 n1_m1_508000_182400 4.463529
R5213 n1_m1_508800_182400 n1_m1_508000_182400 0.892706
R5214 n1_m1_508800_182400 n1_m1_513600_182400 5.356235
R5215 n1_m1_513600_182400 n1_m1_518400_182400 5.356235
R5216 n1_m1_518400_182400 n1_m1_523200_182400 5.356235
R5217 n1_m1_523200_182400 n1_m1_528000_182400 5.356235
R5218 n1_m1_528000_182400 n1_m1_532800_182400 5.356235
R5219 n1_m1_532800_182400 n1_m1_536000_182400 3.570824
R5220 n1_m1_537600_182400 n1_m1_536000_182400 1.785412
R5221 n1_m1_537600_182400 n1_m1_542400_182400 5.356235
R5222 n1_m1_542400_182400 n1_m1_547200_182400 5.356235
R5223 n1_m1_547200_182400 n1_m1_552000_182400 5.356235
R5224 n1_m1_552000_182400 n1_m1_556800_182400 5.356235
R5225 n1_m1_556800_182400 n1_m1_561600_182400 5.356235
R5226 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R5227 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R5228 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R5229 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R5230 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R5231 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R5232 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R5233 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R5234 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R5235 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R5236 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R5237 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R5238 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R5239 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R5240 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R5241 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R5242 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R5243 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R5244 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R5245 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R5246 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R5247 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R5248 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R5249 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R5250 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R5251 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R5252 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R5253 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R5254 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R5255 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R5256 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R5257 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R5258 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R5259 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R5260 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R5261 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R5262 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R5263 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R5264 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R5265 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R5266 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R5267 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R5268 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R5269 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R5270 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R5271 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R5272 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R5273 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R5274 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R5275 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R5276 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R5277 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R5278 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R5279 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R5280 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R5281 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R5282 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R5283 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R5284 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R5285 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R5286 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R5287 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R5288 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R5289 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R5290 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R5291 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R5292 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R5293 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R5294 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R5295 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R5296 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R5297 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R5298 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R5299 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R5300 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R5301 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R5302 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R5303 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R5304 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R5305 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R5306 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R5307 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R5308 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R5309 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R5310 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R5311 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R5312 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R5313 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R5314 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R5315 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R5316 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R5317 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R5318 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R5319 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R5320 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R5321 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R5322 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R5323 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R5324 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R5325 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R5326 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R5327 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R5328 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R5329 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R5330 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R5331 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R5332 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R5333 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R5334 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R5335 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R5336 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R5337 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R5338 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R5339 n1_m1_470400_187200 n1_m1_475200_187200 5.356235
R5340 n1_m1_475200_187200 n1_m1_480000_187200 5.356235
R5341 n1_m1_480000_187200 n1_m1_484800_187200 5.356235
R5342 n1_m1_484800_187200 n1_m1_489600_187200 5.356235
R5343 n1_m1_489600_187200 n1_m1_494400_187200 5.356235
R5344 n1_m1_494400_187200 n1_m1_499200_187200 5.356235
R5345 n1_m1_499200_187200 n1_m1_504000_187200 5.356235
R5346 n1_m1_504000_187200 n1_m1_508000_187200 4.463529
R5347 n1_m1_508800_187200 n1_m1_508000_187200 0.892706
R5348 n1_m1_508800_187200 n1_m1_513600_187200 5.356235
R5349 n1_m1_513600_187200 n1_m1_518400_187200 5.356235
R5350 n1_m1_518400_187200 n1_m1_523200_187200 5.356235
R5351 n1_m1_523200_187200 n1_m1_528000_187200 5.356235
R5352 n1_m1_528000_187200 n1_m1_532800_187200 5.356235
R5353 n1_m1_532800_187200 n1_m1_536000_187200 3.570824
R5354 n1_m1_537600_187200 n1_m1_536000_187200 1.785412
R5355 n1_m1_537600_187200 n1_m1_542400_187200 5.356235
R5356 n1_m1_542400_187200 n1_m1_547200_187200 5.356235
R5357 n1_m1_547200_187200 n1_m1_552000_187200 5.356235
R5358 n1_m1_552000_187200 n1_m1_556800_187200 5.356235
R5359 n1_m1_556800_187200 n1_m1_561600_187200 5.356235
R5360 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R5361 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R5362 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R5363 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R5364 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R5365 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R5366 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R5367 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R5368 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R5369 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R5370 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R5371 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R5372 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R5373 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R5374 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R5375 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R5376 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R5377 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R5378 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R5379 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R5380 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R5381 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R5382 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R5383 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R5384 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R5385 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R5386 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R5387 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R5388 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R5389 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R5390 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R5391 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R5392 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R5393 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R5394 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R5395 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R5396 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R5397 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R5398 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R5399 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R5400 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R5401 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R5402 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R5403 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R5404 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R5405 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R5406 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R5407 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R5408 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R5409 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R5410 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R5411 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R5412 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R5413 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R5414 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R5415 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R5416 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R5417 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R5418 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R5419 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R5420 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R5421 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R5422 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R5423 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R5424 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R5425 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R5426 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R5427 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R5428 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R5429 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R5430 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R5431 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R5432 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R5433 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R5434 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R5435 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R5436 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R5437 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R5438 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R5439 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R5440 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R5441 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R5442 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R5443 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R5444 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R5445 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R5446 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R5447 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R5448 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R5449 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R5450 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R5451 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R5452 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R5453 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R5454 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R5455 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R5456 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R5457 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R5458 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R5459 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R5460 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R5461 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R5462 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R5463 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R5464 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R5465 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R5466 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R5467 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R5468 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R5469 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R5470 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R5471 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R5472 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R5473 n1_m1_470400_192000 n1_m1_475200_192000 5.356235
R5474 n1_m1_475200_192000 n1_m1_480000_192000 5.356235
R5475 n1_m1_480000_192000 n1_m1_484800_192000 5.356235
R5476 n1_m1_484800_192000 n1_m1_489600_192000 5.356235
R5477 n1_m1_489600_192000 n1_m1_494400_192000 5.356235
R5478 n1_m1_494400_192000 n1_m1_499200_192000 5.356235
R5479 n1_m1_499200_192000 n1_m1_504000_192000 5.356235
R5480 n1_m1_504000_192000 n1_m1_508000_192000 4.463529
R5481 n1_m1_508800_192000 n1_m1_508000_192000 0.892706
R5482 n1_m1_508800_192000 n1_m1_513600_192000 5.356235
R5483 n1_m1_513600_192000 n1_m1_518400_192000 5.356235
R5484 n1_m1_518400_192000 n1_m1_523200_192000 5.356235
R5485 n1_m1_523200_192000 n1_m1_528000_192000 5.356235
R5486 n1_m1_528000_192000 n1_m1_532800_192000 5.356235
R5487 n1_m1_532800_192000 n1_m1_536000_192000 3.570824
R5488 n1_m1_537600_192000 n1_m1_536000_192000 1.785412
R5489 n1_m1_537600_192000 n1_m1_542400_192000 5.356235
R5490 n1_m1_542400_192000 n1_m1_547200_192000 5.356235
R5491 n1_m1_547200_192000 n1_m1_552000_192000 5.356235
R5492 n1_m1_552000_192000 n1_m1_556800_192000 5.356235
R5493 n1_m1_556800_192000 n1_m1_561600_192000 5.356235
R5494 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R5495 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R5496 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R5497 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R5498 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R5499 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R5500 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R5501 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R5502 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R5503 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R5504 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R5505 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R5506 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R5507 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R5508 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R5509 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R5510 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R5511 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R5512 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R5513 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R5514 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R5515 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R5516 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R5517 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R5518 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R5519 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R5520 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R5521 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R5522 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R5523 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R5524 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R5525 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R5526 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R5527 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R5528 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R5529 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R5530 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R5531 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R5532 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R5533 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R5534 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R5535 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R5536 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R5537 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R5538 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R5539 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R5540 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R5541 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R5542 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R5543 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R5544 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R5545 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R5546 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R5547 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R5548 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R5549 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R5550 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R5551 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R5552 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R5553 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R5554 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R5555 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R5556 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R5557 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R5558 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R5559 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R5560 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R5561 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R5562 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R5563 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R5564 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R5565 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R5566 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R5567 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R5568 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R5569 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R5570 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R5571 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R5572 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R5573 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R5574 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R5575 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R5576 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R5577 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R5578 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R5579 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R5580 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R5581 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R5582 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R5583 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R5584 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R5585 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R5586 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R5587 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R5588 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R5589 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R5590 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R5591 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R5592 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R5593 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R5594 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R5595 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R5596 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R5597 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R5598 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R5599 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R5600 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R5601 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R5602 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R5603 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R5604 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R5605 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R5606 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R5607 n1_m1_470400_196800 n1_m1_475200_196800 5.356235
R5608 n1_m1_475200_196800 n1_m1_480000_196800 5.356235
R5609 n1_m1_480000_196800 n1_m1_484800_196800 5.356235
R5610 n1_m1_484800_196800 n1_m1_489600_196800 5.356235
R5611 n1_m1_489600_196800 n1_m1_494400_196800 5.356235
R5612 n1_m1_494400_196800 n1_m1_499200_196800 5.356235
R5613 n1_m1_499200_196800 n1_m1_504000_196800 5.356235
R5614 n1_m1_504000_196800 n1_m1_508000_196800 4.463529
R5615 n1_m1_508800_196800 n1_m1_508000_196800 0.892706
R5616 n1_m1_508800_196800 n1_m1_513600_196800 5.356235
R5617 n1_m1_513600_196800 n1_m1_518400_196800 5.356235
R5618 n1_m1_518400_196800 n1_m1_523200_196800 5.356235
R5619 n1_m1_523200_196800 n1_m1_528000_196800 5.356235
R5620 n1_m1_528000_196800 n1_m1_532800_196800 5.356235
R5621 n1_m1_532800_196800 n1_m1_536000_196800 3.570824
R5622 n1_m1_537600_196800 n1_m1_536000_196800 1.785412
R5623 n1_m1_537600_196800 n1_m1_542400_196800 5.356235
R5624 n1_m1_542400_196800 n1_m1_547200_196800 5.356235
R5625 n1_m1_547200_196800 n1_m1_552000_196800 5.356235
R5626 n1_m1_552000_196800 n1_m1_556800_196800 5.356235
R5627 n1_m1_556800_196800 n1_m1_561600_196800 5.356235
R5628 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R5629 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R5630 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R5631 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R5632 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R5633 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R5634 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R5635 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R5636 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R5637 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R5638 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R5639 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R5640 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R5641 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R5642 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R5643 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R5644 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R5645 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R5646 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R5647 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R5648 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R5649 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R5650 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R5651 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R5652 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R5653 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R5654 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R5655 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R5656 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R5657 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R5658 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R5659 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R5660 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R5661 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R5662 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R5663 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R5664 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R5665 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R5666 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R5667 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R5668 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R5669 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R5670 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R5671 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R5672 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R5673 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R5674 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R5675 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R5676 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R5677 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R5678 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R5679 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R5680 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R5681 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R5682 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R5683 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R5684 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R5685 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R5686 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R5687 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R5688 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R5689 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R5690 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R5691 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R5692 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R5693 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R5694 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R5695 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R5696 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R5697 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R5698 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R5699 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R5700 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R5701 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R5702 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R5703 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R5704 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R5705 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R5706 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R5707 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R5708 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R5709 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R5710 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R5711 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R5712 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R5713 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R5714 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R5715 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R5716 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R5717 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R5718 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R5719 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R5720 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R5721 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R5722 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R5723 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R5724 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R5725 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R5726 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R5727 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R5728 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R5729 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R5730 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R5731 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R5732 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R5733 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R5734 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R5735 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R5736 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R5737 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R5738 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R5739 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R5740 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R5741 n1_m1_470400_201600 n1_m1_475200_201600 5.356235
R5742 n1_m1_475200_201600 n1_m1_480000_201600 5.356235
R5743 n1_m1_480000_201600 n1_m1_484800_201600 5.356235
R5744 n1_m1_484800_201600 n1_m1_489600_201600 5.356235
R5745 n1_m1_489600_201600 n1_m1_494400_201600 5.356235
R5746 n1_m1_494400_201600 n1_m1_499200_201600 5.356235
R5747 n1_m1_499200_201600 n1_m1_504000_201600 5.356235
R5748 n1_m1_504000_201600 n1_m1_508000_201600 4.463529
R5749 n1_m1_508800_201600 n1_m1_508000_201600 0.892706
R5750 n1_m1_508800_201600 n1_m1_513600_201600 5.356235
R5751 n1_m1_513600_201600 n1_m1_518400_201600 5.356235
R5752 n1_m1_518400_201600 n1_m1_523200_201600 5.356235
R5753 n1_m1_523200_201600 n1_m1_528000_201600 5.356235
R5754 n1_m1_528000_201600 n1_m1_532800_201600 5.356235
R5755 n1_m1_532800_201600 n1_m1_536000_201600 3.570824
R5756 n1_m1_537600_201600 n1_m1_536000_201600 1.785412
R5757 n1_m1_537600_201600 n1_m1_542400_201600 5.356235
R5758 n1_m1_542400_201600 n1_m1_547200_201600 5.356235
R5759 n1_m1_547200_201600 n1_m1_552000_201600 5.356235
R5760 n1_m1_552000_201600 n1_m1_556800_201600 5.356235
R5761 n1_m1_556800_201600 n1_m1_561600_201600 5.356235
R5762 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R5763 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R5764 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R5765 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R5766 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R5767 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R5768 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R5769 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R5770 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R5771 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R5772 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R5773 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R5774 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R5775 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R5776 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R5777 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R5778 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R5779 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R5780 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R5781 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R5782 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R5783 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R5784 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R5785 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R5786 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R5787 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R5788 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R5789 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R5790 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R5791 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R5792 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R5793 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R5794 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R5795 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R5796 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R5797 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R5798 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R5799 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R5800 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R5801 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R5802 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R5803 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R5804 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R5805 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R5806 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R5807 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R5808 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R5809 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R5810 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R5811 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R5812 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R5813 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R5814 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R5815 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R5816 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R5817 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R5818 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R5819 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R5820 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R5821 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R5822 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R5823 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R5824 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R5825 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R5826 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R5827 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R5828 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R5829 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R5830 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R5831 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R5832 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R5833 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R5834 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R5835 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R5836 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R5837 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R5838 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R5839 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R5840 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R5841 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R5842 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R5843 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R5844 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R5845 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R5846 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R5847 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R5848 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R5849 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R5850 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R5851 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R5852 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R5853 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R5854 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R5855 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R5856 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R5857 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R5858 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R5859 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R5860 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R5861 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R5862 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R5863 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R5864 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R5865 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R5866 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R5867 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R5868 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R5869 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R5870 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R5871 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R5872 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R5873 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R5874 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R5875 n1_m1_470400_206400 n1_m1_475200_206400 5.356235
R5876 n1_m1_475200_206400 n1_m1_480000_206400 5.356235
R5877 n1_m1_480000_206400 n1_m1_484800_206400 5.356235
R5878 n1_m1_484800_206400 n1_m1_489600_206400 5.356235
R5879 n1_m1_489600_206400 n1_m1_494400_206400 5.356235
R5880 n1_m1_494400_206400 n1_m1_499200_206400 5.356235
R5881 n1_m1_499200_206400 n1_m1_504000_206400 5.356235
R5882 n1_m1_504000_206400 n1_m1_508000_206400 4.463529
R5883 n1_m1_508800_206400 n1_m1_508000_206400 0.892706
R5884 n1_m1_508800_206400 n1_m1_513600_206400 5.356235
R5885 n1_m1_513600_206400 n1_m1_518400_206400 5.356235
R5886 n1_m1_518400_206400 n1_m1_523200_206400 5.356235
R5887 n1_m1_523200_206400 n1_m1_528000_206400 5.356235
R5888 n1_m1_528000_206400 n1_m1_532800_206400 5.356235
R5889 n1_m1_532800_206400 n1_m1_536000_206400 3.570824
R5890 n1_m1_537600_206400 n1_m1_536000_206400 1.785412
R5891 n1_m1_537600_206400 n1_m1_542400_206400 5.356235
R5892 n1_m1_542400_206400 n1_m1_547200_206400 5.356235
R5893 n1_m1_547200_206400 n1_m1_552000_206400 5.356235
R5894 n1_m1_552000_206400 n1_m1_556800_206400 5.356235
R5895 n1_m1_556800_206400 n1_m1_561600_206400 5.356235
R5896 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R5897 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R5898 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R5899 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R5900 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R5901 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R5902 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R5903 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R5904 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R5905 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R5906 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R5907 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R5908 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R5909 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R5910 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R5911 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R5912 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R5913 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R5914 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R5915 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R5916 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R5917 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R5918 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R5919 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R5920 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R5921 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R5922 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R5923 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R5924 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R5925 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R5926 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R5927 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R5928 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R5929 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R5930 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R5931 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R5932 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R5933 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R5934 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R5935 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R5936 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R5937 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R5938 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R5939 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R5940 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R5941 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R5942 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R5943 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R5944 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R5945 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R5946 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R5947 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R5948 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R5949 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R5950 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R5951 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R5952 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R5953 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R5954 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R5955 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R5956 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R5957 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R5958 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R5959 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R5960 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R5961 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R5962 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R5963 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R5964 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R5965 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R5966 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R5967 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R5968 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R5969 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R5970 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R5971 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R5972 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R5973 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R5974 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R5975 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R5976 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R5977 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R5978 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R5979 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R5980 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R5981 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R5982 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R5983 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R5984 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R5985 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R5986 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R5987 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R5988 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R5989 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R5990 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R5991 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R5992 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R5993 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R5994 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R5995 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R5996 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R5997 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R5998 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R5999 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R6000 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R6001 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R6002 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R6003 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R6004 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R6005 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R6006 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R6007 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R6008 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R6009 n1_m1_470400_211200 n1_m1_475200_211200 5.356235
R6010 n1_m1_475200_211200 n1_m1_480000_211200 5.356235
R6011 n1_m1_480000_211200 n1_m1_484800_211200 5.356235
R6012 n1_m1_484800_211200 n1_m1_489600_211200 5.356235
R6013 n1_m1_489600_211200 n1_m1_494400_211200 5.356235
R6014 n1_m1_494400_211200 n1_m1_499200_211200 5.356235
R6015 n1_m1_499200_211200 n1_m1_504000_211200 5.356235
R6016 n1_m1_504000_211200 n1_m1_508000_211200 4.463529
R6017 n1_m1_508800_211200 n1_m1_508000_211200 0.892706
R6018 n1_m1_508800_211200 n1_m1_513600_211200 5.356235
R6019 n1_m1_513600_211200 n1_m1_518400_211200 5.356235
R6020 n1_m1_518400_211200 n1_m1_523200_211200 5.356235
R6021 n1_m1_523200_211200 n1_m1_528000_211200 5.356235
R6022 n1_m1_528000_211200 n1_m1_532800_211200 5.356235
R6023 n1_m1_532800_211200 n1_m1_536000_211200 3.570824
R6024 n1_m1_537600_211200 n1_m1_536000_211200 1.785412
R6025 n1_m1_537600_211200 n1_m1_542400_211200 5.356235
R6026 n1_m1_542400_211200 n1_m1_547200_211200 5.356235
R6027 n1_m1_547200_211200 n1_m1_552000_211200 5.356235
R6028 n1_m1_552000_211200 n1_m1_556800_211200 5.356235
R6029 n1_m1_556800_211200 n1_m1_561600_211200 5.356235
R6030 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R6031 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R6032 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R6033 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R6034 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R6035 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R6036 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R6037 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R6038 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R6039 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R6040 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R6041 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R6042 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R6043 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R6044 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R6045 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R6046 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R6047 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R6048 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R6049 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R6050 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R6051 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R6052 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R6053 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R6054 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R6055 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R6056 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R6057 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R6058 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R6059 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R6060 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R6061 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R6062 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R6063 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R6064 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R6065 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R6066 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R6067 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R6068 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R6069 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R6070 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R6071 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R6072 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R6073 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R6074 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R6075 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R6076 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R6077 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R6078 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R6079 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R6080 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R6081 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R6082 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R6083 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R6084 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R6085 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R6086 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R6087 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R6088 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R6089 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R6090 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R6091 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R6092 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R6093 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R6094 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R6095 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R6096 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R6097 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R6098 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R6099 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R6100 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R6101 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R6102 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R6103 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R6104 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R6105 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R6106 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R6107 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R6108 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R6109 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R6110 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R6111 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R6112 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R6113 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R6114 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R6115 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R6116 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R6117 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R6118 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R6119 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R6120 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R6121 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R6122 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R6123 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R6124 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R6125 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R6126 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R6127 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R6128 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R6129 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R6130 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R6131 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R6132 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R6133 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R6134 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R6135 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R6136 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R6137 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R6138 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R6139 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R6140 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R6141 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R6142 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R6143 n1_m1_470400_216000 n1_m1_475200_216000 5.356235
R6144 n1_m1_475200_216000 n1_m1_480000_216000 5.356235
R6145 n1_m1_480000_216000 n1_m1_484800_216000 5.356235
R6146 n1_m1_484800_216000 n1_m1_489600_216000 5.356235
R6147 n1_m1_489600_216000 n1_m1_494400_216000 5.356235
R6148 n1_m1_494400_216000 n1_m1_499200_216000 5.356235
R6149 n1_m1_499200_216000 n1_m1_504000_216000 5.356235
R6150 n1_m1_504000_216000 n1_m1_508000_216000 4.463529
R6151 n1_m1_508800_216000 n1_m1_508000_216000 0.892706
R6152 n1_m1_508800_216000 n1_m1_513600_216000 5.356235
R6153 n1_m1_513600_216000 n1_m1_518400_216000 5.356235
R6154 n1_m1_518400_216000 n1_m1_523200_216000 5.356235
R6155 n1_m1_523200_216000 n1_m1_528000_216000 5.356235
R6156 n1_m1_528000_216000 n1_m1_532800_216000 5.356235
R6157 n1_m1_532800_216000 n1_m1_536000_216000 3.570824
R6158 n1_m1_537600_216000 n1_m1_536000_216000 1.785412
R6159 n1_m1_537600_216000 n1_m1_542400_216000 5.356235
R6160 n1_m1_542400_216000 n1_m1_547200_216000 5.356235
R6161 n1_m1_547200_216000 n1_m1_552000_216000 5.356235
R6162 n1_m1_552000_216000 n1_m1_556800_216000 5.356235
R6163 n1_m1_556800_216000 n1_m1_561600_216000 5.356235
R6164 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R6165 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R6166 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R6167 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R6168 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R6169 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R6170 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R6171 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R6172 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R6173 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R6174 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R6175 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R6176 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R6177 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R6178 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R6179 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R6180 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R6181 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R6182 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R6183 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R6184 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R6185 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R6186 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R6187 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R6188 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R6189 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R6190 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R6191 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R6192 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R6193 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R6194 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R6195 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R6196 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R6197 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R6198 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R6199 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R6200 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R6201 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R6202 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R6203 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R6204 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R6205 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R6206 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R6207 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R6208 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R6209 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R6210 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R6211 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R6212 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R6213 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R6214 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R6215 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R6216 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R6217 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R6218 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R6219 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R6220 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R6221 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R6222 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R6223 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R6224 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R6225 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R6226 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R6227 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R6228 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R6229 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R6230 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R6231 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R6232 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R6233 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R6234 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R6235 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R6236 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R6237 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R6238 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R6239 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R6240 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R6241 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R6242 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R6243 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R6244 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R6245 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R6246 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R6247 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R6248 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R6249 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R6250 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R6251 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R6252 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R6253 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R6254 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R6255 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R6256 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R6257 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R6258 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R6259 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R6260 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R6261 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R6262 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R6263 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R6264 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R6265 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R6266 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R6267 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R6268 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R6269 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R6270 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R6271 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R6272 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R6273 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R6274 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R6275 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R6276 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R6277 n1_m1_470400_220800 n1_m1_475200_220800 5.356235
R6278 n1_m1_475200_220800 n1_m1_480000_220800 5.356235
R6279 n1_m1_480000_220800 n1_m1_484800_220800 5.356235
R6280 n1_m1_484800_220800 n1_m1_489600_220800 5.356235
R6281 n1_m1_489600_220800 n1_m1_494400_220800 5.356235
R6282 n1_m1_494400_220800 n1_m1_499200_220800 5.356235
R6283 n1_m1_499200_220800 n1_m1_504000_220800 5.356235
R6284 n1_m1_504000_220800 n1_m1_508000_220800 4.463529
R6285 n1_m1_508800_220800 n1_m1_508000_220800 0.892706
R6286 n1_m1_508800_220800 n1_m1_513600_220800 5.356235
R6287 n1_m1_513600_220800 n1_m1_518400_220800 5.356235
R6288 n1_m1_518400_220800 n1_m1_523200_220800 5.356235
R6289 n1_m1_523200_220800 n1_m1_528000_220800 5.356235
R6290 n1_m1_528000_220800 n1_m1_532800_220800 5.356235
R6291 n1_m1_532800_220800 n1_m1_536000_220800 3.570824
R6292 n1_m1_537600_220800 n1_m1_536000_220800 1.785412
R6293 n1_m1_537600_220800 n1_m1_542400_220800 5.356235
R6294 n1_m1_542400_220800 n1_m1_547200_220800 5.356235
R6295 n1_m1_547200_220800 n1_m1_552000_220800 5.356235
R6296 n1_m1_552000_220800 n1_m1_556800_220800 5.356235
R6297 n1_m1_556800_220800 n1_m1_561600_220800 5.356235
R6298 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R6299 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R6300 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R6301 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R6302 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R6303 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R6304 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R6305 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R6306 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R6307 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R6308 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R6309 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R6310 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R6311 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R6312 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R6313 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R6314 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R6315 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R6316 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R6317 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R6318 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R6319 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R6320 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R6321 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R6322 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R6323 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R6324 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R6325 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R6326 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R6327 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R6328 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R6329 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R6330 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R6331 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R6332 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R6333 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R6334 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R6335 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R6336 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R6337 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R6338 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R6339 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R6340 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R6341 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R6342 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R6343 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R6344 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R6345 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R6346 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R6347 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R6348 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R6349 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R6350 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R6351 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R6352 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R6353 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R6354 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R6355 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R6356 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R6357 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R6358 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R6359 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R6360 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R6361 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R6362 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R6363 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R6364 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R6365 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R6366 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R6367 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R6368 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R6369 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R6370 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R6371 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R6372 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R6373 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R6374 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R6375 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R6376 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R6377 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R6378 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R6379 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R6380 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R6381 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R6382 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R6383 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R6384 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R6385 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R6386 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R6387 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R6388 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R6389 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R6390 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R6391 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R6392 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R6393 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R6394 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R6395 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R6396 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R6397 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R6398 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R6399 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R6400 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R6401 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R6402 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R6403 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R6404 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R6405 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R6406 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R6407 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R6408 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R6409 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R6410 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R6411 n1_m1_470400_225600 n1_m1_475200_225600 5.356235
R6412 n1_m1_475200_225600 n1_m1_480000_225600 5.356235
R6413 n1_m1_480000_225600 n1_m1_484800_225600 5.356235
R6414 n1_m1_484800_225600 n1_m1_489600_225600 5.356235
R6415 n1_m1_489600_225600 n1_m1_494400_225600 5.356235
R6416 n1_m1_494400_225600 n1_m1_499200_225600 5.356235
R6417 n1_m1_499200_225600 n1_m1_504000_225600 5.356235
R6418 n1_m1_504000_225600 n1_m1_508000_225600 4.463529
R6419 n1_m1_508800_225600 n1_m1_508000_225600 0.892706
R6420 n1_m1_508800_225600 n1_m1_513600_225600 5.356235
R6421 n1_m1_513600_225600 n1_m1_518400_225600 5.356235
R6422 n1_m1_518400_225600 n1_m1_523200_225600 5.356235
R6423 n1_m1_523200_225600 n1_m1_528000_225600 5.356235
R6424 n1_m1_528000_225600 n1_m1_532800_225600 5.356235
R6425 n1_m1_532800_225600 n1_m1_536000_225600 3.570824
R6426 n1_m1_537600_225600 n1_m1_536000_225600 1.785412
R6427 n1_m1_537600_225600 n1_m1_542400_225600 5.356235
R6428 n1_m1_542400_225600 n1_m1_547200_225600 5.356235
R6429 n1_m1_547200_225600 n1_m1_552000_225600 5.356235
R6430 n1_m1_552000_225600 n1_m1_556800_225600 5.356235
R6431 n1_m1_556800_225600 n1_m1_561600_225600 5.356235
R6432 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R6433 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R6434 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R6435 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R6436 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R6437 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R6438 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R6439 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R6440 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R6441 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R6442 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R6443 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R6444 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R6445 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R6446 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R6447 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R6448 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R6449 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R6450 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R6451 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R6452 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R6453 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R6454 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R6455 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R6456 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R6457 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R6458 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R6459 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R6460 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R6461 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R6462 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R6463 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R6464 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R6465 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R6466 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R6467 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R6468 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R6469 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R6470 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R6471 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R6472 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R6473 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R6474 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R6475 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R6476 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R6477 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R6478 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R6479 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R6480 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R6481 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R6482 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R6483 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R6484 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R6485 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R6486 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R6487 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R6488 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R6489 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R6490 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R6491 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R6492 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R6493 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R6494 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R6495 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R6496 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R6497 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R6498 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R6499 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R6500 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R6501 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R6502 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R6503 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R6504 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R6505 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R6506 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R6507 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R6508 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R6509 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R6510 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R6511 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R6512 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R6513 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R6514 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R6515 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R6516 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R6517 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R6518 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R6519 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R6520 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R6521 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R6522 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R6523 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R6524 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R6525 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R6526 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R6527 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R6528 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R6529 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R6530 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R6531 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R6532 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R6533 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R6534 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R6535 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R6536 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R6537 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R6538 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R6539 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R6540 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R6541 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R6542 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R6543 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R6544 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R6545 n1_m1_470400_230400 n1_m1_475200_230400 5.356235
R6546 n1_m1_475200_230400 n1_m1_480000_230400 5.356235
R6547 n1_m1_480000_230400 n1_m1_484800_230400 5.356235
R6548 n1_m1_484800_230400 n1_m1_489600_230400 5.356235
R6549 n1_m1_489600_230400 n1_m1_494400_230400 5.356235
R6550 n1_m1_494400_230400 n1_m1_499200_230400 5.356235
R6551 n1_m1_499200_230400 n1_m1_504000_230400 5.356235
R6552 n1_m1_504000_230400 n1_m1_508000_230400 4.463529
R6553 n1_m1_508800_230400 n1_m1_508000_230400 0.892706
R6554 n1_m1_508800_230400 n1_m1_513600_230400 5.356235
R6555 n1_m1_513600_230400 n1_m1_518400_230400 5.356235
R6556 n1_m1_518400_230400 n1_m1_523200_230400 5.356235
R6557 n1_m1_523200_230400 n1_m1_528000_230400 5.356235
R6558 n1_m1_528000_230400 n1_m1_532800_230400 5.356235
R6559 n1_m1_532800_230400 n1_m1_536000_230400 3.570824
R6560 n1_m1_537600_230400 n1_m1_536000_230400 1.785412
R6561 n1_m1_537600_230400 n1_m1_542400_230400 5.356235
R6562 n1_m1_542400_230400 n1_m1_547200_230400 5.356235
R6563 n1_m1_547200_230400 n1_m1_552000_230400 5.356235
R6564 n1_m1_552000_230400 n1_m1_556800_230400 5.356235
R6565 n1_m1_556800_230400 n1_m1_561600_230400 5.356235
R6566 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R6567 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R6568 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R6569 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R6570 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R6571 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R6572 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R6573 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R6574 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R6575 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R6576 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R6577 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R6578 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R6579 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R6580 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R6581 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R6582 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R6583 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R6584 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R6585 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R6586 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R6587 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R6588 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R6589 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R6590 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R6591 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R6592 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R6593 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R6594 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R6595 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R6596 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R6597 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R6598 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R6599 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R6600 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R6601 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R6602 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R6603 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R6604 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R6605 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R6606 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R6607 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R6608 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R6609 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R6610 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R6611 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R6612 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R6613 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R6614 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R6615 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R6616 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R6617 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R6618 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R6619 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R6620 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R6621 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R6622 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R6623 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R6624 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R6625 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R6626 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R6627 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R6628 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R6629 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R6630 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R6631 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R6632 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R6633 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R6634 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R6635 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R6636 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R6637 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R6638 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R6639 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R6640 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R6641 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R6642 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R6643 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R6644 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R6645 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R6646 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R6647 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R6648 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R6649 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R6650 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R6651 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R6652 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R6653 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R6654 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R6655 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R6656 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R6657 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R6658 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R6659 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R6660 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R6661 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R6662 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R6663 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R6664 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R6665 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R6666 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R6667 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R6668 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R6669 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R6670 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R6671 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R6672 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R6673 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R6674 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R6675 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R6676 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R6677 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R6678 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R6679 n1_m1_470400_235200 n1_m1_475200_235200 5.356235
R6680 n1_m1_475200_235200 n1_m1_480000_235200 5.356235
R6681 n1_m1_480000_235200 n1_m1_484800_235200 5.356235
R6682 n1_m1_484800_235200 n1_m1_489600_235200 5.356235
R6683 n1_m1_489600_235200 n1_m1_494400_235200 5.356235
R6684 n1_m1_494400_235200 n1_m1_499200_235200 5.356235
R6685 n1_m1_499200_235200 n1_m1_504000_235200 5.356235
R6686 n1_m1_504000_235200 n1_m1_508000_235200 4.463529
R6687 n1_m1_508800_235200 n1_m1_508000_235200 0.892706
R6688 n1_m1_508800_235200 n1_m1_513600_235200 5.356235
R6689 n1_m1_513600_235200 n1_m1_518400_235200 5.356235
R6690 n1_m1_518400_235200 n1_m1_523200_235200 5.356235
R6691 n1_m1_523200_235200 n1_m1_528000_235200 5.356235
R6692 n1_m1_528000_235200 n1_m1_532800_235200 5.356235
R6693 n1_m1_532800_235200 n1_m1_536000_235200 3.570824
R6694 n1_m1_537600_235200 n1_m1_536000_235200 1.785412
R6695 n1_m1_537600_235200 n1_m1_542400_235200 5.356235
R6696 n1_m1_542400_235200 n1_m1_547200_235200 5.356235
R6697 n1_m1_547200_235200 n1_m1_552000_235200 5.356235
R6698 n1_m1_552000_235200 n1_m1_556800_235200 5.356235
R6699 n1_m1_556800_235200 n1_m1_561600_235200 5.356235
R6700 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R6701 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R6702 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R6703 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R6704 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R6705 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R6706 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R6707 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R6708 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R6709 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R6710 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R6711 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R6712 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R6713 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R6714 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R6715 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R6716 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R6717 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R6718 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R6719 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R6720 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R6721 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R6722 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R6723 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R6724 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R6725 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R6726 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R6727 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R6728 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R6729 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R6730 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R6731 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R6732 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R6733 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R6734 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R6735 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R6736 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R6737 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R6738 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R6739 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R6740 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R6741 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R6742 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R6743 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R6744 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R6745 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R6746 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R6747 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R6748 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R6749 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R6750 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R6751 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R6752 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R6753 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R6754 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R6755 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R6756 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R6757 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R6758 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R6759 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R6760 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R6761 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R6762 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R6763 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R6764 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R6765 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R6766 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R6767 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R6768 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R6769 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R6770 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R6771 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R6772 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R6773 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R6774 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R6775 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R6776 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R6777 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R6778 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R6779 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R6780 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R6781 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R6782 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R6783 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R6784 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R6785 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R6786 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R6787 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R6788 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R6789 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R6790 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R6791 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R6792 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R6793 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R6794 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R6795 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R6796 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R6797 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R6798 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R6799 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R6800 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R6801 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R6802 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R6803 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R6804 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R6805 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R6806 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R6807 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R6808 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R6809 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R6810 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R6811 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R6812 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R6813 n1_m1_470400_240000 n1_m1_475200_240000 5.356235
R6814 n1_m1_475200_240000 n1_m1_480000_240000 5.356235
R6815 n1_m1_480000_240000 n1_m1_484800_240000 5.356235
R6816 n1_m1_484800_240000 n1_m1_489600_240000 5.356235
R6817 n1_m1_489600_240000 n1_m1_494400_240000 5.356235
R6818 n1_m1_494400_240000 n1_m1_499200_240000 5.356235
R6819 n1_m1_499200_240000 n1_m1_504000_240000 5.356235
R6820 n1_m1_504000_240000 n1_m1_508000_240000 4.463529
R6821 n1_m1_508800_240000 n1_m1_508000_240000 0.892706
R6822 n1_m1_508800_240000 n1_m1_513600_240000 5.356235
R6823 n1_m1_513600_240000 n1_m1_518400_240000 5.356235
R6824 n1_m1_518400_240000 n1_m1_523200_240000 5.356235
R6825 n1_m1_523200_240000 n1_m1_528000_240000 5.356235
R6826 n1_m1_528000_240000 n1_m1_532800_240000 5.356235
R6827 n1_m1_532800_240000 n1_m1_536000_240000 3.570824
R6828 n1_m1_537600_240000 n1_m1_536000_240000 1.785412
R6829 n1_m1_537600_240000 n1_m1_542400_240000 5.356235
R6830 n1_m1_542400_240000 n1_m1_547200_240000 5.356235
R6831 n1_m1_547200_240000 n1_m1_552000_240000 5.356235
R6832 n1_m1_552000_240000 n1_m1_556800_240000 5.356235
R6833 n1_m1_556800_240000 n1_m1_561600_240000 5.356235
R6834 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R6835 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R6836 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R6837 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R6838 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R6839 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R6840 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R6841 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R6842 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R6843 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R6844 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R6845 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R6846 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R6847 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R6848 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R6849 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R6850 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R6851 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R6852 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R6853 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R6854 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R6855 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R6856 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R6857 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R6858 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R6859 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R6860 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R6861 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R6862 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R6863 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R6864 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R6865 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R6866 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R6867 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R6868 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R6869 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R6870 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R6871 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R6872 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R6873 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R6874 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R6875 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R6876 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R6877 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R6878 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R6879 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R6880 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R6881 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R6882 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R6883 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R6884 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R6885 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R6886 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R6887 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R6888 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R6889 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R6890 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R6891 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R6892 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R6893 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R6894 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R6895 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R6896 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R6897 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R6898 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R6899 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R6900 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R6901 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R6902 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R6903 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R6904 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R6905 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R6906 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R6907 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R6908 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R6909 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R6910 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R6911 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R6912 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R6913 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R6914 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R6915 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R6916 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R6917 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R6918 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R6919 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R6920 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R6921 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R6922 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R6923 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R6924 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R6925 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R6926 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R6927 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R6928 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R6929 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R6930 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R6931 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R6932 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R6933 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R6934 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R6935 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R6936 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R6937 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R6938 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R6939 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R6940 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R6941 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R6942 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R6943 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R6944 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R6945 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R6946 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R6947 n1_m1_470400_244800 n1_m1_475200_244800 5.356235
R6948 n1_m1_475200_244800 n1_m1_480000_244800 5.356235
R6949 n1_m1_480000_244800 n1_m1_484800_244800 5.356235
R6950 n1_m1_484800_244800 n1_m1_489600_244800 5.356235
R6951 n1_m1_489600_244800 n1_m1_494400_244800 5.356235
R6952 n1_m1_494400_244800 n1_m1_499200_244800 5.356235
R6953 n1_m1_499200_244800 n1_m1_504000_244800 5.356235
R6954 n1_m1_504000_244800 n1_m1_508000_244800 4.463529
R6955 n1_m1_508800_244800 n1_m1_508000_244800 0.892706
R6956 n1_m1_508800_244800 n1_m1_513600_244800 5.356235
R6957 n1_m1_513600_244800 n1_m1_518400_244800 5.356235
R6958 n1_m1_518400_244800 n1_m1_523200_244800 5.356235
R6959 n1_m1_523200_244800 n1_m1_528000_244800 5.356235
R6960 n1_m1_528000_244800 n1_m1_532800_244800 5.356235
R6961 n1_m1_532800_244800 n1_m1_536000_244800 3.570824
R6962 n1_m1_537600_244800 n1_m1_536000_244800 1.785412
R6963 n1_m1_537600_244800 n1_m1_542400_244800 5.356235
R6964 n1_m1_542400_244800 n1_m1_547200_244800 5.356235
R6965 n1_m1_547200_244800 n1_m1_552000_244800 5.356235
R6966 n1_m1_552000_244800 n1_m1_556800_244800 5.356235
R6967 n1_m1_556800_244800 n1_m1_561600_244800 5.356235
R6968 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R6969 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R6970 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R6971 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R6972 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R6973 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R6974 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R6975 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R6976 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R6977 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R6978 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R6979 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R6980 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R6981 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R6982 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R6983 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R6984 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R6985 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R6986 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R6987 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R6988 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R6989 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R6990 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R6991 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R6992 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R6993 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R6994 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R6995 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R6996 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R6997 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R6998 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R6999 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R7000 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R7001 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R7002 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R7003 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R7004 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R7005 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R7006 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R7007 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R7008 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R7009 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R7010 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R7011 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R7012 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R7013 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R7014 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R7015 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R7016 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R7017 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R7018 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R7019 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R7020 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R7021 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R7022 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R7023 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R7024 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R7025 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R7026 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R7027 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R7028 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R7029 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R7030 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R7031 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R7032 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R7033 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R7034 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R7035 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R7036 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R7037 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R7038 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R7039 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R7040 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R7041 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R7042 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R7043 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R7044 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R7045 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R7046 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R7047 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R7048 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R7049 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R7050 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R7051 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R7052 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R7053 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R7054 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R7055 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R7056 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R7057 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R7058 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R7059 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R7060 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R7061 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R7062 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R7063 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R7064 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R7065 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R7066 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R7067 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R7068 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R7069 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R7070 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R7071 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R7072 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R7073 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R7074 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R7075 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R7076 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R7077 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R7078 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R7079 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R7080 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R7081 n1_m1_470400_249600 n1_m1_475200_249600 5.356235
R7082 n1_m1_475200_249600 n1_m1_480000_249600 5.356235
R7083 n1_m1_480000_249600 n1_m1_484800_249600 5.356235
R7084 n1_m1_484800_249600 n1_m1_489600_249600 5.356235
R7085 n1_m1_489600_249600 n1_m1_494400_249600 5.356235
R7086 n1_m1_494400_249600 n1_m1_499200_249600 5.356235
R7087 n1_m1_499200_249600 n1_m1_504000_249600 5.356235
R7088 n1_m1_504000_249600 n1_m1_508000_249600 4.463529
R7089 n1_m1_508800_249600 n1_m1_508000_249600 0.892706
R7090 n1_m1_508800_249600 n1_m1_513600_249600 5.356235
R7091 n1_m1_513600_249600 n1_m1_518400_249600 5.356235
R7092 n1_m1_518400_249600 n1_m1_523200_249600 5.356235
R7093 n1_m1_523200_249600 n1_m1_528000_249600 5.356235
R7094 n1_m1_528000_249600 n1_m1_532800_249600 5.356235
R7095 n1_m1_532800_249600 n1_m1_536000_249600 3.570824
R7096 n1_m1_537600_249600 n1_m1_536000_249600 1.785412
R7097 n1_m1_537600_249600 n1_m1_542400_249600 5.356235
R7098 n1_m1_542400_249600 n1_m1_547200_249600 5.356235
R7099 n1_m1_547200_249600 n1_m1_552000_249600 5.356235
R7100 n1_m1_552000_249600 n1_m1_556800_249600 5.356235
R7101 n1_m1_556800_249600 n1_m1_561600_249600 5.356235
R7102 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R7103 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R7104 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R7105 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R7106 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R7107 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R7108 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R7109 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R7110 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R7111 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R7112 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R7113 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R7114 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R7115 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R7116 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R7117 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R7118 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R7119 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R7120 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R7121 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R7122 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R7123 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R7124 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R7125 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R7126 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R7127 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R7128 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R7129 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R7130 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R7131 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R7132 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R7133 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R7134 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R7135 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R7136 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R7137 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R7138 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R7139 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R7140 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R7141 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R7142 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R7143 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R7144 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R7145 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R7146 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R7147 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R7148 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R7149 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R7150 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R7151 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R7152 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R7153 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R7154 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R7155 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R7156 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R7157 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R7158 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R7159 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R7160 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R7161 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R7162 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R7163 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R7164 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R7165 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R7166 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R7167 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R7168 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R7169 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R7170 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R7171 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R7172 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R7173 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R7174 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R7175 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R7176 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R7177 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R7178 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R7179 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R7180 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R7181 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R7182 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R7183 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R7184 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R7185 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R7186 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R7187 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R7188 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R7189 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R7190 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R7191 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R7192 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R7193 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R7194 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R7195 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R7196 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R7197 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R7198 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R7199 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R7200 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R7201 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R7202 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R7203 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R7204 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R7205 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R7206 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R7207 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R7208 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R7209 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R7210 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R7211 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R7212 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R7213 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R7214 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R7215 n1_m1_470400_254400 n1_m1_475200_254400 5.356235
R7216 n1_m1_475200_254400 n1_m1_480000_254400 5.356235
R7217 n1_m1_480000_254400 n1_m1_484800_254400 5.356235
R7218 n1_m1_484800_254400 n1_m1_489600_254400 5.356235
R7219 n1_m1_489600_254400 n1_m1_494400_254400 5.356235
R7220 n1_m1_494400_254400 n1_m1_499200_254400 5.356235
R7221 n1_m1_499200_254400 n1_m1_504000_254400 5.356235
R7222 n1_m1_504000_254400 n1_m1_508000_254400 4.463529
R7223 n1_m1_508800_254400 n1_m1_508000_254400 0.892706
R7224 n1_m1_508800_254400 n1_m1_513600_254400 5.356235
R7225 n1_m1_513600_254400 n1_m1_518400_254400 5.356235
R7226 n1_m1_518400_254400 n1_m1_523200_254400 5.356235
R7227 n1_m1_523200_254400 n1_m1_528000_254400 5.356235
R7228 n1_m1_528000_254400 n1_m1_532800_254400 5.356235
R7229 n1_m1_532800_254400 n1_m1_536000_254400 3.570824
R7230 n1_m1_537600_254400 n1_m1_536000_254400 1.785412
R7231 n1_m1_537600_254400 n1_m1_542400_254400 5.356235
R7232 n1_m1_542400_254400 n1_m1_547200_254400 5.356235
R7233 n1_m1_547200_254400 n1_m1_552000_254400 5.356235
R7234 n1_m1_552000_254400 n1_m1_556800_254400 5.356235
R7235 n1_m1_556800_254400 n1_m1_561600_254400 5.356235
R7236 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R7237 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R7238 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R7239 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R7240 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R7241 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R7242 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R7243 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R7244 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R7245 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R7246 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R7247 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R7248 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R7249 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R7250 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R7251 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R7252 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R7253 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R7254 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R7255 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R7256 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R7257 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R7258 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R7259 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R7260 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R7261 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R7262 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R7263 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R7264 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R7265 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R7266 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R7267 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R7268 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R7269 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R7270 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R7271 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R7272 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R7273 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R7274 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R7275 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R7276 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R7277 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R7278 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R7279 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R7280 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R7281 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R7282 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R7283 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R7284 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R7285 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R7286 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R7287 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R7288 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R7289 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R7290 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R7291 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R7292 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R7293 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R7294 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R7295 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R7296 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R7297 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R7298 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R7299 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R7300 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R7301 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R7302 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R7303 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R7304 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R7305 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R7306 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R7307 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R7308 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R7309 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R7310 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R7311 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R7312 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R7313 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R7314 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R7315 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R7316 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R7317 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R7318 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R7319 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R7320 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R7321 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R7322 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R7323 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R7324 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R7325 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R7326 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R7327 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R7328 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R7329 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R7330 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R7331 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R7332 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R7333 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R7334 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R7335 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R7336 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R7337 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R7338 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R7339 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R7340 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R7341 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R7342 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R7343 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R7344 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R7345 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R7346 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R7347 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R7348 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R7349 n1_m1_470400_259200 n1_m1_475200_259200 5.356235
R7350 n1_m1_475200_259200 n1_m1_480000_259200 5.356235
R7351 n1_m1_480000_259200 n1_m1_484800_259200 5.356235
R7352 n1_m1_484800_259200 n1_m1_489600_259200 5.356235
R7353 n1_m1_489600_259200 n1_m1_494400_259200 5.356235
R7354 n1_m1_494400_259200 n1_m1_499200_259200 5.356235
R7355 n1_m1_499200_259200 n1_m1_504000_259200 5.356235
R7356 n1_m1_504000_259200 n1_m1_508000_259200 4.463529
R7357 n1_m1_508800_259200 n1_m1_508000_259200 0.892706
R7358 n1_m1_508800_259200 n1_m1_513600_259200 5.356235
R7359 n1_m1_513600_259200 n1_m1_518400_259200 5.356235
R7360 n1_m1_518400_259200 n1_m1_523200_259200 5.356235
R7361 n1_m1_523200_259200 n1_m1_528000_259200 5.356235
R7362 n1_m1_528000_259200 n1_m1_532800_259200 5.356235
R7363 n1_m1_532800_259200 n1_m1_536000_259200 3.570824
R7364 n1_m1_537600_259200 n1_m1_536000_259200 1.785412
R7365 n1_m1_537600_259200 n1_m1_542400_259200 5.356235
R7366 n1_m1_542400_259200 n1_m1_547200_259200 5.356235
R7367 n1_m1_547200_259200 n1_m1_552000_259200 5.356235
R7368 n1_m1_552000_259200 n1_m1_556800_259200 5.356235
R7369 n1_m1_556800_259200 n1_m1_561600_259200 5.356235
R7370 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R7371 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R7372 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R7373 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R7374 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R7375 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R7376 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R7377 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R7378 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R7379 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R7380 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R7381 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R7382 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R7383 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R7384 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R7385 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R7386 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R7387 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R7388 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R7389 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R7390 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R7391 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R7392 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R7393 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R7394 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R7395 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R7396 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R7397 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R7398 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R7399 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R7400 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R7401 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R7402 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R7403 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R7404 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R7405 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R7406 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R7407 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R7408 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R7409 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R7410 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R7411 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R7412 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R7413 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R7414 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R7415 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R7416 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R7417 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R7418 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R7419 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R7420 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R7421 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R7422 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R7423 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R7424 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R7425 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R7426 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R7427 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R7428 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R7429 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R7430 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R7431 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R7432 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R7433 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R7434 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R7435 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R7436 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R7437 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R7438 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R7439 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R7440 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R7441 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R7442 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R7443 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R7444 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R7445 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R7446 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R7447 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R7448 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R7449 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R7450 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R7451 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R7452 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R7453 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R7454 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R7455 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R7456 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R7457 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R7458 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R7459 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R7460 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R7461 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R7462 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R7463 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R7464 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R7465 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R7466 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R7467 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R7468 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R7469 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R7470 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R7471 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R7472 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R7473 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R7474 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R7475 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R7476 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R7477 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R7478 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R7479 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R7480 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R7481 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R7482 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R7483 n1_m1_470400_264000 n1_m1_475200_264000 5.356235
R7484 n1_m1_475200_264000 n1_m1_480000_264000 5.356235
R7485 n1_m1_480000_264000 n1_m1_484800_264000 5.356235
R7486 n1_m1_484800_264000 n1_m1_489600_264000 5.356235
R7487 n1_m1_489600_264000 n1_m1_494400_264000 5.356235
R7488 n1_m1_494400_264000 n1_m1_499200_264000 5.356235
R7489 n1_m1_499200_264000 n1_m1_504000_264000 5.356235
R7490 n1_m1_504000_264000 n1_m1_508000_264000 4.463529
R7491 n1_m1_508800_264000 n1_m1_508000_264000 0.892706
R7492 n1_m1_508800_264000 n1_m1_513600_264000 5.356235
R7493 n1_m1_513600_264000 n1_m1_518400_264000 5.356235
R7494 n1_m1_518400_264000 n1_m1_523200_264000 5.356235
R7495 n1_m1_523200_264000 n1_m1_528000_264000 5.356235
R7496 n1_m1_528000_264000 n1_m1_532800_264000 5.356235
R7497 n1_m1_532800_264000 n1_m1_536000_264000 3.570824
R7498 n1_m1_537600_264000 n1_m1_536000_264000 1.785412
R7499 n1_m1_537600_264000 n1_m1_542400_264000 5.356235
R7500 n1_m1_542400_264000 n1_m1_547200_264000 5.356235
R7501 n1_m1_547200_264000 n1_m1_552000_264000 5.356235
R7502 n1_m1_552000_264000 n1_m1_556800_264000 5.356235
R7503 n1_m1_556800_264000 n1_m1_561600_264000 5.356235
R7504 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R7505 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R7506 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R7507 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R7508 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R7509 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R7510 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R7511 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R7512 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R7513 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R7514 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R7515 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R7516 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R7517 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R7518 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R7519 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R7520 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R7521 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R7522 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R7523 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R7524 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R7525 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R7526 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R7527 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R7528 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R7529 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R7530 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R7531 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R7532 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R7533 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R7534 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R7535 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R7536 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R7537 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R7538 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R7539 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R7540 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R7541 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R7542 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R7543 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R7544 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R7545 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R7546 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R7547 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R7548 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R7549 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R7550 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R7551 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R7552 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R7553 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R7554 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R7555 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R7556 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R7557 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R7558 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R7559 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R7560 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R7561 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R7562 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R7563 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R7564 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R7565 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R7566 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R7567 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R7568 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R7569 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R7570 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R7571 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R7572 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R7573 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R7574 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R7575 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R7576 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R7577 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R7578 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R7579 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R7580 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R7581 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R7582 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R7583 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R7584 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R7585 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R7586 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R7587 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R7588 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R7589 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R7590 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R7591 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R7592 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R7593 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R7594 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R7595 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R7596 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R7597 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R7598 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R7599 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R7600 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R7601 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R7602 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R7603 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R7604 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R7605 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R7606 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R7607 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R7608 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R7609 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R7610 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R7611 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R7612 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R7613 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R7614 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R7615 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R7616 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R7617 n1_m1_470400_268800 n1_m1_475200_268800 5.356235
R7618 n1_m1_475200_268800 n1_m1_480000_268800 5.356235
R7619 n1_m1_480000_268800 n1_m1_484800_268800 5.356235
R7620 n1_m1_484800_268800 n1_m1_489600_268800 5.356235
R7621 n1_m1_489600_268800 n1_m1_494400_268800 5.356235
R7622 n1_m1_494400_268800 n1_m1_499200_268800 5.356235
R7623 n1_m1_499200_268800 n1_m1_504000_268800 5.356235
R7624 n1_m1_504000_268800 n1_m1_508000_268800 4.463529
R7625 n1_m1_508800_268800 n1_m1_508000_268800 0.892706
R7626 n1_m1_508800_268800 n1_m1_513600_268800 5.356235
R7627 n1_m1_513600_268800 n1_m1_518400_268800 5.356235
R7628 n1_m1_518400_268800 n1_m1_523200_268800 5.356235
R7629 n1_m1_523200_268800 n1_m1_528000_268800 5.356235
R7630 n1_m1_528000_268800 n1_m1_532800_268800 5.356235
R7631 n1_m1_532800_268800 n1_m1_536000_268800 3.570824
R7632 n1_m1_537600_268800 n1_m1_536000_268800 1.785412
R7633 n1_m1_537600_268800 n1_m1_542400_268800 5.356235
R7634 n1_m1_542400_268800 n1_m1_547200_268800 5.356235
R7635 n1_m1_547200_268800 n1_m1_552000_268800 5.356235
R7636 n1_m1_552000_268800 n1_m1_556800_268800 5.356235
R7637 n1_m1_556800_268800 n1_m1_561600_268800 5.356235
R7638 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R7639 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R7640 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R7641 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R7642 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R7643 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R7644 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R7645 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R7646 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R7647 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R7648 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R7649 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R7650 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R7651 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R7652 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R7653 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R7654 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R7655 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R7656 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R7657 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R7658 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R7659 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R7660 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R7661 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R7662 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R7663 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R7664 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R7665 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R7666 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R7667 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R7668 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R7669 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R7670 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R7671 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R7672 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R7673 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R7674 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R7675 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R7676 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R7677 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R7678 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R7679 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R7680 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R7681 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R7682 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R7683 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R7684 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R7685 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R7686 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R7687 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R7688 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R7689 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R7690 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R7691 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R7692 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R7693 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R7694 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R7695 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R7696 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R7697 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R7698 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R7699 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R7700 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R7701 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R7702 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R7703 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R7704 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R7705 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R7706 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R7707 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R7708 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R7709 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R7710 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R7711 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R7712 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R7713 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R7714 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R7715 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R7716 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R7717 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R7718 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R7719 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R7720 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R7721 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R7722 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R7723 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R7724 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R7725 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R7726 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R7727 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R7728 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R7729 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R7730 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R7731 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R7732 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R7733 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R7734 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R7735 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R7736 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R7737 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R7738 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R7739 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R7740 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R7741 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R7742 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R7743 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R7744 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R7745 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R7746 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R7747 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R7748 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R7749 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R7750 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R7751 n1_m1_470400_273600 n1_m1_475200_273600 5.356235
R7752 n1_m1_475200_273600 n1_m1_480000_273600 5.356235
R7753 n1_m1_480000_273600 n1_m1_484800_273600 5.356235
R7754 n1_m1_484800_273600 n1_m1_489600_273600 5.356235
R7755 n1_m1_489600_273600 n1_m1_494400_273600 5.356235
R7756 n1_m1_494400_273600 n1_m1_499200_273600 5.356235
R7757 n1_m1_499200_273600 n1_m1_504000_273600 5.356235
R7758 n1_m1_504000_273600 n1_m1_508000_273600 4.463529
R7759 n1_m1_508800_273600 n1_m1_508000_273600 0.892706
R7760 n1_m1_508800_273600 n1_m1_513600_273600 5.356235
R7761 n1_m1_513600_273600 n1_m1_518400_273600 5.356235
R7762 n1_m1_518400_273600 n1_m1_523200_273600 5.356235
R7763 n1_m1_523200_273600 n1_m1_528000_273600 5.356235
R7764 n1_m1_528000_273600 n1_m1_532800_273600 5.356235
R7765 n1_m1_532800_273600 n1_m1_536000_273600 3.570824
R7766 n1_m1_537600_273600 n1_m1_536000_273600 1.785412
R7767 n1_m1_537600_273600 n1_m1_542400_273600 5.356235
R7768 n1_m1_542400_273600 n1_m1_547200_273600 5.356235
R7769 n1_m1_547200_273600 n1_m1_552000_273600 5.356235
R7770 n1_m1_552000_273600 n1_m1_556800_273600 5.356235
R7771 n1_m1_556800_273600 n1_m1_561600_273600 5.356235
R7772 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R7773 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R7774 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R7775 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R7776 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R7777 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R7778 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R7779 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R7780 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R7781 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R7782 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R7783 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R7784 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R7785 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R7786 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R7787 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R7788 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R7789 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R7790 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R7791 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R7792 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R7793 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R7794 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R7795 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R7796 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R7797 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R7798 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R7799 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R7800 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R7801 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R7802 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R7803 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R7804 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R7805 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R7806 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R7807 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R7808 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R7809 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R7810 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R7811 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R7812 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R7813 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R7814 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R7815 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R7816 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R7817 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R7818 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R7819 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R7820 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R7821 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R7822 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R7823 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R7824 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R7825 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R7826 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R7827 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R7828 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R7829 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R7830 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R7831 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R7832 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R7833 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R7834 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R7835 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R7836 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R7837 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R7838 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R7839 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R7840 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R7841 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R7842 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R7843 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R7844 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R7845 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R7846 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R7847 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R7848 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R7849 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R7850 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R7851 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R7852 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R7853 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R7854 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R7855 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R7856 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R7857 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R7858 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R7859 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R7860 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R7861 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R7862 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R7863 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R7864 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R7865 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R7866 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R7867 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R7868 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R7869 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R7870 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R7871 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R7872 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R7873 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R7874 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R7875 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R7876 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R7877 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R7878 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R7879 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R7880 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R7881 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R7882 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R7883 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R7884 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R7885 n1_m1_470400_278400 n1_m1_475200_278400 5.356235
R7886 n1_m1_475200_278400 n1_m1_480000_278400 5.356235
R7887 n1_m1_480000_278400 n1_m1_484800_278400 5.356235
R7888 n1_m1_484800_278400 n1_m1_489600_278400 5.356235
R7889 n1_m1_489600_278400 n1_m1_494400_278400 5.356235
R7890 n1_m1_494400_278400 n1_m1_499200_278400 5.356235
R7891 n1_m1_499200_278400 n1_m1_504000_278400 5.356235
R7892 n1_m1_504000_278400 n1_m1_508000_278400 4.463529
R7893 n1_m1_508800_278400 n1_m1_508000_278400 0.892706
R7894 n1_m1_508800_278400 n1_m1_513600_278400 5.356235
R7895 n1_m1_513600_278400 n1_m1_518400_278400 5.356235
R7896 n1_m1_518400_278400 n1_m1_523200_278400 5.356235
R7897 n1_m1_523200_278400 n1_m1_528000_278400 5.356235
R7898 n1_m1_528000_278400 n1_m1_532800_278400 5.356235
R7899 n1_m1_532800_278400 n1_m1_536000_278400 3.570824
R7900 n1_m1_537600_278400 n1_m1_536000_278400 1.785412
R7901 n1_m1_537600_278400 n1_m1_542400_278400 5.356235
R7902 n1_m1_542400_278400 n1_m1_547200_278400 5.356235
R7903 n1_m1_547200_278400 n1_m1_552000_278400 5.356235
R7904 n1_m1_552000_278400 n1_m1_556800_278400 5.356235
R7905 n1_m1_556800_278400 n1_m1_561600_278400 5.356235
R7906 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R7907 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R7908 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R7909 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R7910 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R7911 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R7912 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R7913 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R7914 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R7915 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R7916 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R7917 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R7918 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R7919 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R7920 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R7921 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R7922 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R7923 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R7924 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R7925 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R7926 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R7927 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R7928 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R7929 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R7930 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R7931 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R7932 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R7933 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R7934 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R7935 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R7936 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R7937 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R7938 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R7939 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R7940 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R7941 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R7942 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R7943 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R7944 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R7945 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R7946 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R7947 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R7948 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R7949 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R7950 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R7951 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R7952 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R7953 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R7954 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R7955 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R7956 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R7957 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R7958 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R7959 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R7960 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R7961 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R7962 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R7963 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R7964 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R7965 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R7966 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R7967 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R7968 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R7969 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R7970 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R7971 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R7972 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R7973 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R7974 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R7975 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R7976 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R7977 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R7978 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R7979 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R7980 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R7981 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R7982 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R7983 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R7984 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R7985 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R7986 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R7987 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R7988 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R7989 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R7990 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R7991 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R7992 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R7993 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R7994 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R7995 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R7996 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R7997 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R7998 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R7999 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R8000 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R8001 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R8002 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R8003 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R8004 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R8005 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R8006 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R8007 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R8008 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R8009 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R8010 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R8011 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R8012 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R8013 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R8014 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R8015 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R8016 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R8017 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R8018 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R8019 n1_m1_470400_283200 n1_m1_475200_283200 5.356235
R8020 n1_m1_475200_283200 n1_m1_480000_283200 5.356235
R8021 n1_m1_480000_283200 n1_m1_484800_283200 5.356235
R8022 n1_m1_484800_283200 n1_m1_489600_283200 5.356235
R8023 n1_m1_489600_283200 n1_m1_494400_283200 5.356235
R8024 n1_m1_494400_283200 n1_m1_499200_283200 5.356235
R8025 n1_m1_499200_283200 n1_m1_504000_283200 5.356235
R8026 n1_m1_504000_283200 n1_m1_508000_283200 4.463529
R8027 n1_m1_508800_283200 n1_m1_508000_283200 0.892706
R8028 n1_m1_508800_283200 n1_m1_513600_283200 5.356235
R8029 n1_m1_513600_283200 n1_m1_518400_283200 5.356235
R8030 n1_m1_518400_283200 n1_m1_523200_283200 5.356235
R8031 n1_m1_523200_283200 n1_m1_528000_283200 5.356235
R8032 n1_m1_528000_283200 n1_m1_532800_283200 5.356235
R8033 n1_m1_532800_283200 n1_m1_536000_283200 3.570824
R8034 n1_m1_537600_283200 n1_m1_536000_283200 1.785412
R8035 n1_m1_537600_283200 n1_m1_542400_283200 5.356235
R8036 n1_m1_542400_283200 n1_m1_547200_283200 5.356235
R8037 n1_m1_547200_283200 n1_m1_552000_283200 5.356235
R8038 n1_m1_552000_283200 n1_m1_556800_283200 5.356235
R8039 n1_m1_556800_283200 n1_m1_561600_283200 5.356235
R8040 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R8041 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R8042 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R8043 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R8044 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R8045 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R8046 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R8047 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R8048 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R8049 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R8050 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R8051 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R8052 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R8053 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R8054 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R8055 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R8056 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R8057 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R8058 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R8059 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R8060 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R8061 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R8062 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R8063 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R8064 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R8065 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R8066 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R8067 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R8068 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R8069 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R8070 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R8071 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R8072 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R8073 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R8074 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R8075 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R8076 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R8077 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R8078 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R8079 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R8080 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R8081 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R8082 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R8083 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R8084 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R8085 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R8086 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R8087 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R8088 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R8089 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R8090 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R8091 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R8092 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R8093 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R8094 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R8095 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R8096 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R8097 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R8098 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R8099 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R8100 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R8101 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R8102 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R8103 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R8104 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R8105 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R8106 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R8107 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R8108 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R8109 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R8110 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R8111 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R8112 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R8113 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R8114 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R8115 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R8116 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R8117 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R8118 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R8119 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R8120 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R8121 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R8122 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R8123 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R8124 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R8125 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R8126 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R8127 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R8128 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R8129 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R8130 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R8131 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R8132 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R8133 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R8134 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R8135 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R8136 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R8137 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R8138 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R8139 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R8140 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R8141 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R8142 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R8143 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R8144 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R8145 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R8146 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R8147 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R8148 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R8149 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R8150 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R8151 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R8152 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R8153 n1_m1_470400_288000 n1_m1_475200_288000 5.356235
R8154 n1_m1_475200_288000 n1_m1_480000_288000 5.356235
R8155 n1_m1_480000_288000 n1_m1_484800_288000 5.356235
R8156 n1_m1_484800_288000 n1_m1_489600_288000 5.356235
R8157 n1_m1_489600_288000 n1_m1_494400_288000 5.356235
R8158 n1_m1_494400_288000 n1_m1_499200_288000 5.356235
R8159 n1_m1_499200_288000 n1_m1_504000_288000 5.356235
R8160 n1_m1_504000_288000 n1_m1_508000_288000 4.463529
R8161 n1_m1_508800_288000 n1_m1_508000_288000 0.892706
R8162 n1_m1_508800_288000 n1_m1_513600_288000 5.356235
R8163 n1_m1_513600_288000 n1_m1_518400_288000 5.356235
R8164 n1_m1_518400_288000 n1_m1_523200_288000 5.356235
R8165 n1_m1_523200_288000 n1_m1_528000_288000 5.356235
R8166 n1_m1_528000_288000 n1_m1_532800_288000 5.356235
R8167 n1_m1_532800_288000 n1_m1_536000_288000 3.570824
R8168 n1_m1_537600_288000 n1_m1_536000_288000 1.785412
R8169 n1_m1_537600_288000 n1_m1_542400_288000 5.356235
R8170 n1_m1_542400_288000 n1_m1_547200_288000 5.356235
R8171 n1_m1_547200_288000 n1_m1_552000_288000 5.356235
R8172 n1_m1_552000_288000 n1_m1_556800_288000 5.356235
R8173 n1_m1_556800_288000 n1_m1_561600_288000 5.356235
R8174 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R8175 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R8176 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R8177 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R8178 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R8179 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R8180 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R8181 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R8182 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R8183 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R8184 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R8185 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R8186 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R8187 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R8188 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R8189 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R8190 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R8191 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R8192 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R8193 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R8194 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R8195 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R8196 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R8197 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R8198 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R8199 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R8200 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R8201 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R8202 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R8203 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R8204 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R8205 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R8206 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R8207 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R8208 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R8209 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R8210 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R8211 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R8212 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R8213 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R8214 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R8215 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R8216 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R8217 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R8218 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R8219 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R8220 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R8221 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R8222 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R8223 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R8224 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R8225 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R8226 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R8227 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R8228 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R8229 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R8230 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R8231 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R8232 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R8233 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R8234 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R8235 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R8236 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R8237 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R8238 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R8239 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R8240 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R8241 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R8242 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R8243 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R8244 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R8245 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R8246 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R8247 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R8248 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R8249 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R8250 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R8251 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R8252 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R8253 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R8254 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R8255 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R8256 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R8257 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R8258 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R8259 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R8260 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R8261 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R8262 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R8263 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R8264 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R8265 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R8266 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R8267 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R8268 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R8269 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R8270 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R8271 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R8272 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R8273 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R8274 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R8275 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R8276 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R8277 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R8278 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R8279 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R8280 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R8281 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R8282 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R8283 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R8284 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R8285 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R8286 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R8287 n1_m1_470400_292800 n1_m1_475200_292800 5.356235
R8288 n1_m1_475200_292800 n1_m1_480000_292800 5.356235
R8289 n1_m1_480000_292800 n1_m1_484800_292800 5.356235
R8290 n1_m1_484800_292800 n1_m1_489600_292800 5.356235
R8291 n1_m1_489600_292800 n1_m1_494400_292800 5.356235
R8292 n1_m1_494400_292800 n1_m1_499200_292800 5.356235
R8293 n1_m1_499200_292800 n1_m1_504000_292800 5.356235
R8294 n1_m1_504000_292800 n1_m1_508000_292800 4.463529
R8295 n1_m1_508800_292800 n1_m1_508000_292800 0.892706
R8296 n1_m1_508800_292800 n1_m1_513600_292800 5.356235
R8297 n1_m1_513600_292800 n1_m1_518400_292800 5.356235
R8298 n1_m1_518400_292800 n1_m1_523200_292800 5.356235
R8299 n1_m1_523200_292800 n1_m1_528000_292800 5.356235
R8300 n1_m1_528000_292800 n1_m1_532800_292800 5.356235
R8301 n1_m1_532800_292800 n1_m1_536000_292800 3.570824
R8302 n1_m1_537600_292800 n1_m1_536000_292800 1.785412
R8303 n1_m1_537600_292800 n1_m1_542400_292800 5.356235
R8304 n1_m1_542400_292800 n1_m1_547200_292800 5.356235
R8305 n1_m1_547200_292800 n1_m1_552000_292800 5.356235
R8306 n1_m1_552000_292800 n1_m1_556800_292800 5.356235
R8307 n1_m1_556800_292800 n1_m1_561600_292800 5.356235
R8308 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R8309 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R8310 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R8311 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R8312 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R8313 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R8314 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R8315 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R8316 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R8317 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R8318 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R8319 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R8320 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R8321 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R8322 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R8323 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R8324 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R8325 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R8326 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R8327 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R8328 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R8329 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R8330 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R8331 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R8332 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R8333 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R8334 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R8335 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R8336 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R8337 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R8338 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R8339 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R8340 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R8341 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R8342 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R8343 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R8344 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R8345 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R8346 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R8347 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R8348 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R8349 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R8350 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R8351 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R8352 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R8353 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R8354 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R8355 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R8356 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R8357 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R8358 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R8359 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R8360 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R8361 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R8362 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R8363 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R8364 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R8365 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R8366 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R8367 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R8368 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R8369 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R8370 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R8371 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R8372 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R8373 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R8374 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R8375 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R8376 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R8377 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R8378 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R8379 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R8380 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R8381 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R8382 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R8383 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R8384 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R8385 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R8386 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R8387 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R8388 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R8389 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R8390 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R8391 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R8392 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R8393 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R8394 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R8395 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R8396 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R8397 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R8398 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R8399 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R8400 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R8401 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R8402 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R8403 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R8404 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R8405 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R8406 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R8407 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R8408 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R8409 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R8410 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R8411 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R8412 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R8413 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R8414 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R8415 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R8416 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R8417 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R8418 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R8419 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R8420 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R8421 n1_m1_470400_297600 n1_m1_475200_297600 5.356235
R8422 n1_m1_475200_297600 n1_m1_480000_297600 5.356235
R8423 n1_m1_480000_297600 n1_m1_484800_297600 5.356235
R8424 n1_m1_484800_297600 n1_m1_489600_297600 5.356235
R8425 n1_m1_489600_297600 n1_m1_494400_297600 5.356235
R8426 n1_m1_494400_297600 n1_m1_499200_297600 5.356235
R8427 n1_m1_499200_297600 n1_m1_504000_297600 5.356235
R8428 n1_m1_504000_297600 n1_m1_508000_297600 4.463529
R8429 n1_m1_508800_297600 n1_m1_508000_297600 0.892706
R8430 n1_m1_508800_297600 n1_m1_513600_297600 5.356235
R8431 n1_m1_513600_297600 n1_m1_518400_297600 5.356235
R8432 n1_m1_518400_297600 n1_m1_523200_297600 5.356235
R8433 n1_m1_523200_297600 n1_m1_528000_297600 5.356235
R8434 n1_m1_528000_297600 n1_m1_532800_297600 5.356235
R8435 n1_m1_532800_297600 n1_m1_536000_297600 3.570824
R8436 n1_m1_537600_297600 n1_m1_536000_297600 1.785412
R8437 n1_m1_537600_297600 n1_m1_542400_297600 5.356235
R8438 n1_m1_542400_297600 n1_m1_547200_297600 5.356235
R8439 n1_m1_547200_297600 n1_m1_552000_297600 5.356235
R8440 n1_m1_552000_297600 n1_m1_556800_297600 5.356235
R8441 n1_m1_556800_297600 n1_m1_561600_297600 5.356235
R8442 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R8443 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R8444 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R8445 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R8446 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R8447 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R8448 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R8449 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R8450 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R8451 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R8452 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R8453 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R8454 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R8455 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R8456 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R8457 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R8458 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R8459 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R8460 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R8461 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R8462 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R8463 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R8464 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R8465 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R8466 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R8467 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R8468 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R8469 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R8470 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R8471 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R8472 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R8473 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R8474 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R8475 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R8476 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R8477 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R8478 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R8479 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R8480 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R8481 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R8482 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R8483 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R8484 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R8485 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R8486 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R8487 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R8488 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R8489 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R8490 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R8491 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R8492 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R8493 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R8494 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R8495 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R8496 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R8497 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R8498 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R8499 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R8500 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R8501 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R8502 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R8503 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R8504 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R8505 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R8506 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R8507 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R8508 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R8509 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R8510 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R8511 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R8512 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R8513 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R8514 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R8515 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R8516 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R8517 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R8518 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R8519 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R8520 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R8521 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R8522 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R8523 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R8524 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R8525 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R8526 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R8527 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R8528 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R8529 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R8530 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R8531 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R8532 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R8533 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R8534 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R8535 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R8536 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R8537 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R8538 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R8539 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R8540 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R8541 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R8542 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R8543 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R8544 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R8545 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R8546 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R8547 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R8548 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R8549 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R8550 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R8551 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R8552 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R8553 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R8554 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R8555 n1_m1_470400_302400 n1_m1_475200_302400 5.356235
R8556 n1_m1_475200_302400 n1_m1_480000_302400 5.356235
R8557 n1_m1_480000_302400 n1_m1_484800_302400 5.356235
R8558 n1_m1_484800_302400 n1_m1_489600_302400 5.356235
R8559 n1_m1_489600_302400 n1_m1_494400_302400 5.356235
R8560 n1_m1_494400_302400 n1_m1_499200_302400 5.356235
R8561 n1_m1_499200_302400 n1_m1_504000_302400 5.356235
R8562 n1_m1_504000_302400 n1_m1_508000_302400 4.463529
R8563 n1_m1_508800_302400 n1_m1_508000_302400 0.892706
R8564 n1_m1_508800_302400 n1_m1_513600_302400 5.356235
R8565 n1_m1_513600_302400 n1_m1_518400_302400 5.356235
R8566 n1_m1_518400_302400 n1_m1_523200_302400 5.356235
R8567 n1_m1_523200_302400 n1_m1_528000_302400 5.356235
R8568 n1_m1_528000_302400 n1_m1_532800_302400 5.356235
R8569 n1_m1_532800_302400 n1_m1_536000_302400 3.570824
R8570 n1_m1_537600_302400 n1_m1_536000_302400 1.785412
R8571 n1_m1_537600_302400 n1_m1_542400_302400 5.356235
R8572 n1_m1_542400_302400 n1_m1_547200_302400 5.356235
R8573 n1_m1_547200_302400 n1_m1_552000_302400 5.356235
R8574 n1_m1_552000_302400 n1_m1_556800_302400 5.356235
R8575 n1_m1_556800_302400 n1_m1_561600_302400 5.356235
R8576 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R8577 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R8578 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R8579 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R8580 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R8581 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R8582 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R8583 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R8584 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R8585 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R8586 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R8587 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R8588 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R8589 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R8590 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R8591 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R8592 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R8593 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R8594 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R8595 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R8596 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R8597 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R8598 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R8599 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R8600 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R8601 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R8602 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R8603 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R8604 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R8605 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R8606 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R8607 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R8608 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R8609 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R8610 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R8611 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R8612 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R8613 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R8614 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R8615 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R8616 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R8617 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R8618 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R8619 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R8620 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R8621 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R8622 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R8623 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R8624 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R8625 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R8626 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R8627 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R8628 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R8629 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R8630 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R8631 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R8632 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R8633 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R8634 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R8635 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R8636 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R8637 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R8638 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R8639 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R8640 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R8641 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R8642 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R8643 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R8644 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R8645 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R8646 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R8647 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R8648 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R8649 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R8650 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R8651 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R8652 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R8653 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R8654 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R8655 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R8656 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R8657 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R8658 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R8659 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R8660 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R8661 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R8662 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R8663 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R8664 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R8665 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R8666 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R8667 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R8668 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R8669 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R8670 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R8671 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R8672 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R8673 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R8674 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R8675 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R8676 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R8677 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R8678 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R8679 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R8680 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R8681 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R8682 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R8683 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R8684 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R8685 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R8686 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R8687 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R8688 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R8689 n1_m1_470400_307200 n1_m1_475200_307200 5.356235
R8690 n1_m1_475200_307200 n1_m1_480000_307200 5.356235
R8691 n1_m1_480000_307200 n1_m1_484800_307200 5.356235
R8692 n1_m1_484800_307200 n1_m1_489600_307200 5.356235
R8693 n1_m1_489600_307200 n1_m1_494400_307200 5.356235
R8694 n1_m1_494400_307200 n1_m1_499200_307200 5.356235
R8695 n1_m1_499200_307200 n1_m1_504000_307200 5.356235
R8696 n1_m1_504000_307200 n1_m1_508000_307200 4.463529
R8697 n1_m1_508800_307200 n1_m1_508000_307200 0.892706
R8698 n1_m1_508800_307200 n1_m1_513600_307200 5.356235
R8699 n1_m1_513600_307200 n1_m1_518400_307200 5.356235
R8700 n1_m1_518400_307200 n1_m1_523200_307200 5.356235
R8701 n1_m1_523200_307200 n1_m1_528000_307200 5.356235
R8702 n1_m1_528000_307200 n1_m1_532800_307200 5.356235
R8703 n1_m1_532800_307200 n1_m1_536000_307200 3.570824
R8704 n1_m1_537600_307200 n1_m1_536000_307200 1.785412
R8705 n1_m1_537600_307200 n1_m1_542400_307200 5.356235
R8706 n1_m1_542400_307200 n1_m1_547200_307200 5.356235
R8707 n1_m1_547200_307200 n1_m1_552000_307200 5.356235
R8708 n1_m1_552000_307200 n1_m1_556800_307200 5.356235
R8709 n1_m1_556800_307200 n1_m1_561600_307200 5.356235
R8710 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R8711 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R8712 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R8713 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R8714 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R8715 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R8716 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R8717 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R8718 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R8719 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R8720 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R8721 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R8722 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R8723 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R8724 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R8725 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R8726 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R8727 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R8728 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R8729 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R8730 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R8731 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R8732 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R8733 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R8734 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R8735 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R8736 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R8737 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R8738 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R8739 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R8740 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R8741 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R8742 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R8743 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R8744 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R8745 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R8746 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R8747 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R8748 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R8749 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R8750 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R8751 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R8752 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R8753 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R8754 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R8755 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R8756 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R8757 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R8758 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R8759 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R8760 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R8761 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R8762 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R8763 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R8764 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R8765 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R8766 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R8767 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R8768 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R8769 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R8770 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R8771 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R8772 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R8773 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R8774 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R8775 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R8776 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R8777 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R8778 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R8779 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R8780 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R8781 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R8782 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R8783 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R8784 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R8785 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R8786 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R8787 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R8788 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R8789 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R8790 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R8791 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R8792 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R8793 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R8794 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R8795 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R8796 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R8797 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R8798 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R8799 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R8800 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R8801 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R8802 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R8803 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R8804 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R8805 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R8806 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R8807 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R8808 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R8809 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R8810 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R8811 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R8812 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R8813 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R8814 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R8815 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R8816 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R8817 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R8818 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R8819 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R8820 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R8821 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R8822 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R8823 n1_m1_470400_312000 n1_m1_475200_312000 5.356235
R8824 n1_m1_475200_312000 n1_m1_480000_312000 5.356235
R8825 n1_m1_480000_312000 n1_m1_484800_312000 5.356235
R8826 n1_m1_484800_312000 n1_m1_489600_312000 5.356235
R8827 n1_m1_489600_312000 n1_m1_494400_312000 5.356235
R8828 n1_m1_494400_312000 n1_m1_499200_312000 5.356235
R8829 n1_m1_499200_312000 n1_m1_504000_312000 5.356235
R8830 n1_m1_504000_312000 n1_m1_508000_312000 4.463529
R8831 n1_m1_508800_312000 n1_m1_508000_312000 0.892706
R8832 n1_m1_508800_312000 n1_m1_513600_312000 5.356235
R8833 n1_m1_513600_312000 n1_m1_518400_312000 5.356235
R8834 n1_m1_518400_312000 n1_m1_523200_312000 5.356235
R8835 n1_m1_523200_312000 n1_m1_528000_312000 5.356235
R8836 n1_m1_528000_312000 n1_m1_532800_312000 5.356235
R8837 n1_m1_532800_312000 n1_m1_536000_312000 3.570824
R8838 n1_m1_537600_312000 n1_m1_536000_312000 1.785412
R8839 n1_m1_537600_312000 n1_m1_542400_312000 5.356235
R8840 n1_m1_542400_312000 n1_m1_547200_312000 5.356235
R8841 n1_m1_547200_312000 n1_m1_552000_312000 5.356235
R8842 n1_m1_552000_312000 n1_m1_556800_312000 5.356235
R8843 n1_m1_556800_312000 n1_m1_561600_312000 5.356235
R8844 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R8845 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R8846 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R8847 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R8848 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R8849 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R8850 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R8851 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R8852 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R8853 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R8854 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R8855 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R8856 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R8857 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R8858 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R8859 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R8860 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R8861 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R8862 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R8863 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R8864 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R8865 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R8866 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R8867 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R8868 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R8869 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R8870 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R8871 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R8872 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R8873 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R8874 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R8875 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R8876 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R8877 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R8878 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R8879 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R8880 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R8881 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R8882 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R8883 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R8884 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R8885 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R8886 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R8887 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R8888 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R8889 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R8890 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R8891 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R8892 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R8893 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R8894 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R8895 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R8896 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R8897 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R8898 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R8899 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R8900 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R8901 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R8902 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R8903 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R8904 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R8905 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R8906 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R8907 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R8908 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R8909 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R8910 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R8911 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R8912 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R8913 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R8914 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R8915 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R8916 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R8917 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R8918 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R8919 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R8920 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R8921 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R8922 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R8923 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R8924 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R8925 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R8926 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R8927 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R8928 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R8929 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R8930 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R8931 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R8932 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R8933 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R8934 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R8935 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R8936 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R8937 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R8938 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R8939 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R8940 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R8941 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R8942 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R8943 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R8944 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R8945 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R8946 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R8947 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R8948 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R8949 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R8950 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R8951 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R8952 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R8953 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R8954 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R8955 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R8956 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R8957 n1_m1_470400_316800 n1_m1_475200_316800 5.356235
R8958 n1_m1_475200_316800 n1_m1_480000_316800 5.356235
R8959 n1_m1_480000_316800 n1_m1_484800_316800 5.356235
R8960 n1_m1_484800_316800 n1_m1_489600_316800 5.356235
R8961 n1_m1_489600_316800 n1_m1_494400_316800 5.356235
R8962 n1_m1_494400_316800 n1_m1_499200_316800 5.356235
R8963 n1_m1_499200_316800 n1_m1_504000_316800 5.356235
R8964 n1_m1_504000_316800 n1_m1_508000_316800 4.463529
R8965 n1_m1_508800_316800 n1_m1_508000_316800 0.892706
R8966 n1_m1_508800_316800 n1_m1_513600_316800 5.356235
R8967 n1_m1_513600_316800 n1_m1_518400_316800 5.356235
R8968 n1_m1_518400_316800 n1_m1_523200_316800 5.356235
R8969 n1_m1_523200_316800 n1_m1_528000_316800 5.356235
R8970 n1_m1_528000_316800 n1_m1_532800_316800 5.356235
R8971 n1_m1_532800_316800 n1_m1_536000_316800 3.570824
R8972 n1_m1_537600_316800 n1_m1_536000_316800 1.785412
R8973 n1_m1_537600_316800 n1_m1_542400_316800 5.356235
R8974 n1_m1_542400_316800 n1_m1_547200_316800 5.356235
R8975 n1_m1_547200_316800 n1_m1_552000_316800 5.356235
R8976 n1_m1_552000_316800 n1_m1_556800_316800 5.356235
R8977 n1_m1_556800_316800 n1_m1_561600_316800 5.356235
R8978 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R8979 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R8980 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R8981 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R8982 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R8983 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R8984 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R8985 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R8986 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R8987 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R8988 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R8989 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R8990 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R8991 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R8992 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R8993 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R8994 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R8995 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R8996 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R8997 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R8998 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R8999 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R9000 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R9001 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R9002 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R9003 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R9004 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R9005 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R9006 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R9007 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R9008 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R9009 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R9010 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R9011 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R9012 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R9013 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R9014 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R9015 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R9016 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R9017 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R9018 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R9019 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R9020 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R9021 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R9022 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R9023 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R9024 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R9025 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R9026 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R9027 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R9028 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R9029 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R9030 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R9031 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R9032 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R9033 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R9034 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R9035 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R9036 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R9037 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R9038 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R9039 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R9040 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R9041 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R9042 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R9043 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R9044 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R9045 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R9046 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R9047 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R9048 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R9049 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R9050 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R9051 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R9052 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R9053 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R9054 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R9055 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R9056 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R9057 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R9058 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R9059 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R9060 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R9061 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R9062 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R9063 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R9064 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R9065 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R9066 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R9067 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R9068 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R9069 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R9070 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R9071 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R9072 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R9073 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R9074 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R9075 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R9076 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R9077 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R9078 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R9079 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R9080 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R9081 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R9082 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R9083 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R9084 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R9085 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R9086 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R9087 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R9088 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R9089 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R9090 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R9091 n1_m1_470400_321600 n1_m1_475200_321600 5.356235
R9092 n1_m1_475200_321600 n1_m1_480000_321600 5.356235
R9093 n1_m1_480000_321600 n1_m1_484800_321600 5.356235
R9094 n1_m1_484800_321600 n1_m1_489600_321600 5.356235
R9095 n1_m1_489600_321600 n1_m1_494400_321600 5.356235
R9096 n1_m1_494400_321600 n1_m1_499200_321600 5.356235
R9097 n1_m1_499200_321600 n1_m1_504000_321600 5.356235
R9098 n1_m1_504000_321600 n1_m1_508000_321600 4.463529
R9099 n1_m1_508800_321600 n1_m1_508000_321600 0.892706
R9100 n1_m1_508800_321600 n1_m1_513600_321600 5.356235
R9101 n1_m1_513600_321600 n1_m1_518400_321600 5.356235
R9102 n1_m1_518400_321600 n1_m1_523200_321600 5.356235
R9103 n1_m1_523200_321600 n1_m1_528000_321600 5.356235
R9104 n1_m1_528000_321600 n1_m1_532800_321600 5.356235
R9105 n1_m1_532800_321600 n1_m1_536000_321600 3.570824
R9106 n1_m1_537600_321600 n1_m1_536000_321600 1.785412
R9107 n1_m1_537600_321600 n1_m1_542400_321600 5.356235
R9108 n1_m1_542400_321600 n1_m1_547200_321600 5.356235
R9109 n1_m1_547200_321600 n1_m1_552000_321600 5.356235
R9110 n1_m1_552000_321600 n1_m1_556800_321600 5.356235
R9111 n1_m1_556800_321600 n1_m1_561600_321600 5.356235
R9112 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R9113 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R9114 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R9115 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R9116 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R9117 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R9118 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R9119 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R9120 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R9121 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R9122 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R9123 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R9124 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R9125 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R9126 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R9127 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R9128 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R9129 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R9130 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R9131 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R9132 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R9133 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R9134 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R9135 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R9136 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R9137 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R9138 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R9139 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R9140 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R9141 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R9142 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R9143 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R9144 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R9145 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R9146 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R9147 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R9148 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R9149 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R9150 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R9151 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R9152 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R9153 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R9154 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R9155 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R9156 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R9157 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R9158 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R9159 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R9160 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R9161 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R9162 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R9163 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R9164 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R9165 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R9166 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R9167 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R9168 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R9169 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R9170 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R9171 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R9172 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R9173 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R9174 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R9175 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R9176 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R9177 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R9178 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R9179 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R9180 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R9181 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R9182 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R9183 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R9184 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R9185 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R9186 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R9187 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R9188 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R9189 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R9190 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R9191 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R9192 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R9193 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R9194 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R9195 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R9196 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R9197 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R9198 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R9199 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R9200 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R9201 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R9202 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R9203 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R9204 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R9205 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R9206 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R9207 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R9208 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R9209 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R9210 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R9211 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R9212 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R9213 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R9214 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R9215 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R9216 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R9217 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R9218 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R9219 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R9220 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R9221 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R9222 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R9223 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R9224 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R9225 n1_m1_470400_326400 n1_m1_475200_326400 5.356235
R9226 n1_m1_475200_326400 n1_m1_480000_326400 5.356235
R9227 n1_m1_480000_326400 n1_m1_484800_326400 5.356235
R9228 n1_m1_484800_326400 n1_m1_489600_326400 5.356235
R9229 n1_m1_489600_326400 n1_m1_494400_326400 5.356235
R9230 n1_m1_494400_326400 n1_m1_499200_326400 5.356235
R9231 n1_m1_499200_326400 n1_m1_504000_326400 5.356235
R9232 n1_m1_504000_326400 n1_m1_508000_326400 4.463529
R9233 n1_m1_508800_326400 n1_m1_508000_326400 0.892706
R9234 n1_m1_508800_326400 n1_m1_513600_326400 5.356235
R9235 n1_m1_513600_326400 n1_m1_518400_326400 5.356235
R9236 n1_m1_518400_326400 n1_m1_523200_326400 5.356235
R9237 n1_m1_523200_326400 n1_m1_528000_326400 5.356235
R9238 n1_m1_528000_326400 n1_m1_532800_326400 5.356235
R9239 n1_m1_532800_326400 n1_m1_536000_326400 3.570824
R9240 n1_m1_537600_326400 n1_m1_536000_326400 1.785412
R9241 n1_m1_537600_326400 n1_m1_542400_326400 5.356235
R9242 n1_m1_542400_326400 n1_m1_547200_326400 5.356235
R9243 n1_m1_547200_326400 n1_m1_552000_326400 5.356235
R9244 n1_m1_552000_326400 n1_m1_556800_326400 5.356235
R9245 n1_m1_556800_326400 n1_m1_561600_326400 5.356235
R9246 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R9247 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R9248 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R9249 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R9250 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R9251 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R9252 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R9253 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R9254 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R9255 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R9256 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R9257 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R9258 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R9259 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R9260 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R9261 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R9262 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R9263 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R9264 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R9265 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R9266 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R9267 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R9268 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R9269 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R9270 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R9271 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R9272 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R9273 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R9274 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R9275 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R9276 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R9277 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R9278 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R9279 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R9280 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R9281 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R9282 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R9283 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R9284 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R9285 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R9286 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R9287 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R9288 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R9289 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R9290 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R9291 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R9292 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R9293 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R9294 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R9295 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R9296 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R9297 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R9298 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R9299 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R9300 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R9301 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R9302 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R9303 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R9304 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R9305 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R9306 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R9307 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R9308 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R9309 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R9310 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R9311 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R9312 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R9313 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R9314 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R9315 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R9316 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R9317 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R9318 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R9319 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R9320 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R9321 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R9322 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R9323 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R9324 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R9325 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R9326 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R9327 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R9328 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R9329 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R9330 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R9331 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R9332 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R9333 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R9334 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R9335 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R9336 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R9337 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R9338 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R9339 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R9340 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R9341 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R9342 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R9343 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R9344 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R9345 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R9346 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R9347 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R9348 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R9349 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R9350 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R9351 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R9352 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R9353 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R9354 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R9355 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R9356 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R9357 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R9358 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R9359 n1_m1_470400_331200 n1_m1_475200_331200 5.356235
R9360 n1_m1_475200_331200 n1_m1_480000_331200 5.356235
R9361 n1_m1_480000_331200 n1_m1_484800_331200 5.356235
R9362 n1_m1_484800_331200 n1_m1_489600_331200 5.356235
R9363 n1_m1_489600_331200 n1_m1_494400_331200 5.356235
R9364 n1_m1_494400_331200 n1_m1_499200_331200 5.356235
R9365 n1_m1_499200_331200 n1_m1_504000_331200 5.356235
R9366 n1_m1_504000_331200 n1_m1_508000_331200 4.463529
R9367 n1_m1_508800_331200 n1_m1_508000_331200 0.892706
R9368 n1_m1_508800_331200 n1_m1_513600_331200 5.356235
R9369 n1_m1_513600_331200 n1_m1_518400_331200 5.356235
R9370 n1_m1_518400_331200 n1_m1_523200_331200 5.356235
R9371 n1_m1_523200_331200 n1_m1_528000_331200 5.356235
R9372 n1_m1_528000_331200 n1_m1_532800_331200 5.356235
R9373 n1_m1_532800_331200 n1_m1_536000_331200 3.570824
R9374 n1_m1_537600_331200 n1_m1_536000_331200 1.785412
R9375 n1_m1_537600_331200 n1_m1_542400_331200 5.356235
R9376 n1_m1_542400_331200 n1_m1_547200_331200 5.356235
R9377 n1_m1_547200_331200 n1_m1_552000_331200 5.356235
R9378 n1_m1_552000_331200 n1_m1_556800_331200 5.356235
R9379 n1_m1_556800_331200 n1_m1_561600_331200 5.356235
R9380 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R9381 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R9382 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R9383 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R9384 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R9385 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R9386 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R9387 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R9388 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R9389 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R9390 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R9391 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R9392 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R9393 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R9394 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R9395 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R9396 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R9397 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R9398 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R9399 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R9400 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R9401 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R9402 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R9403 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R9404 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R9405 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R9406 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R9407 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R9408 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R9409 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R9410 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R9411 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R9412 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R9413 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R9414 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R9415 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R9416 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R9417 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R9418 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R9419 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R9420 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R9421 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R9422 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R9423 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R9424 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R9425 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R9426 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R9427 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R9428 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R9429 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R9430 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R9431 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R9432 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R9433 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R9434 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R9435 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R9436 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R9437 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R9438 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R9439 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R9440 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R9441 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R9442 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R9443 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R9444 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R9445 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R9446 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R9447 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R9448 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R9449 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R9450 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R9451 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R9452 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R9453 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R9454 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R9455 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R9456 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R9457 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R9458 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R9459 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R9460 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R9461 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R9462 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R9463 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R9464 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R9465 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R9466 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R9467 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R9468 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R9469 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R9470 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R9471 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R9472 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R9473 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R9474 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R9475 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R9476 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R9477 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R9478 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R9479 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R9480 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R9481 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R9482 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R9483 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R9484 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R9485 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R9486 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R9487 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R9488 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R9489 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R9490 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R9491 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R9492 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R9493 n1_m1_470400_336000 n1_m1_475200_336000 5.356235
R9494 n1_m1_475200_336000 n1_m1_480000_336000 5.356235
R9495 n1_m1_480000_336000 n1_m1_484800_336000 5.356235
R9496 n1_m1_484800_336000 n1_m1_489600_336000 5.356235
R9497 n1_m1_489600_336000 n1_m1_494400_336000 5.356235
R9498 n1_m1_494400_336000 n1_m1_499200_336000 5.356235
R9499 n1_m1_499200_336000 n1_m1_504000_336000 5.356235
R9500 n1_m1_504000_336000 n1_m1_508000_336000 4.463529
R9501 n1_m1_508800_336000 n1_m1_508000_336000 0.892706
R9502 n1_m1_508800_336000 n1_m1_513600_336000 5.356235
R9503 n1_m1_513600_336000 n1_m1_518400_336000 5.356235
R9504 n1_m1_518400_336000 n1_m1_523200_336000 5.356235
R9505 n1_m1_523200_336000 n1_m1_528000_336000 5.356235
R9506 n1_m1_528000_336000 n1_m1_532800_336000 5.356235
R9507 n1_m1_532800_336000 n1_m1_536000_336000 3.570824
R9508 n1_m1_537600_336000 n1_m1_536000_336000 1.785412
R9509 n1_m1_537600_336000 n1_m1_542400_336000 5.356235
R9510 n1_m1_542400_336000 n1_m1_547200_336000 5.356235
R9511 n1_m1_547200_336000 n1_m1_552000_336000 5.356235
R9512 n1_m1_552000_336000 n1_m1_556800_336000 5.356235
R9513 n1_m1_556800_336000 n1_m1_561600_336000 5.356235
R9514 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R9515 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R9516 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R9517 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R9518 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R9519 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R9520 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R9521 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R9522 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R9523 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R9524 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R9525 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R9526 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R9527 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R9528 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R9529 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R9530 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R9531 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R9532 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R9533 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R9534 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R9535 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R9536 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R9537 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R9538 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R9539 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R9540 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R9541 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R9542 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R9543 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R9544 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R9545 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R9546 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R9547 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R9548 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R9549 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R9550 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R9551 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R9552 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R9553 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R9554 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R9555 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R9556 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R9557 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R9558 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R9559 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R9560 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R9561 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R9562 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R9563 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R9564 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R9565 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R9566 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R9567 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R9568 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R9569 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R9570 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R9571 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R9572 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R9573 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R9574 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R9575 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R9576 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R9577 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R9578 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R9579 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R9580 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R9581 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R9582 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R9583 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R9584 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R9585 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R9586 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R9587 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R9588 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R9589 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R9590 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R9591 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R9592 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R9593 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R9594 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R9595 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R9596 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R9597 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R9598 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R9599 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R9600 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R9601 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R9602 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R9603 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R9604 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R9605 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R9606 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R9607 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R9608 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R9609 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R9610 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R9611 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R9612 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R9613 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R9614 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R9615 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R9616 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R9617 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R9618 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R9619 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R9620 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R9621 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R9622 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R9623 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R9624 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R9625 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R9626 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R9627 n1_m1_470400_340800 n1_m1_475200_340800 5.356235
R9628 n1_m1_475200_340800 n1_m1_480000_340800 5.356235
R9629 n1_m1_480000_340800 n1_m1_484800_340800 5.356235
R9630 n1_m1_484800_340800 n1_m1_489600_340800 5.356235
R9631 n1_m1_489600_340800 n1_m1_494400_340800 5.356235
R9632 n1_m1_494400_340800 n1_m1_499200_340800 5.356235
R9633 n1_m1_499200_340800 n1_m1_504000_340800 5.356235
R9634 n1_m1_504000_340800 n1_m1_508000_340800 4.463529
R9635 n1_m1_508800_340800 n1_m1_508000_340800 0.892706
R9636 n1_m1_508800_340800 n1_m1_513600_340800 5.356235
R9637 n1_m1_513600_340800 n1_m1_518400_340800 5.356235
R9638 n1_m1_518400_340800 n1_m1_523200_340800 5.356235
R9639 n1_m1_523200_340800 n1_m1_528000_340800 5.356235
R9640 n1_m1_528000_340800 n1_m1_532800_340800 5.356235
R9641 n1_m1_532800_340800 n1_m1_536000_340800 3.570824
R9642 n1_m1_537600_340800 n1_m1_536000_340800 1.785412
R9643 n1_m1_537600_340800 n1_m1_542400_340800 5.356235
R9644 n1_m1_542400_340800 n1_m1_547200_340800 5.356235
R9645 n1_m1_547200_340800 n1_m1_552000_340800 5.356235
R9646 n1_m1_552000_340800 n1_m1_556800_340800 5.356235
R9647 n1_m1_556800_340800 n1_m1_561600_340800 5.356235
R9648 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R9649 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R9650 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R9651 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R9652 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R9653 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R9654 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R9655 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R9656 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R9657 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R9658 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R9659 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R9660 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R9661 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R9662 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R9663 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R9664 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R9665 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R9666 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R9667 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R9668 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R9669 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R9670 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R9671 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R9672 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R9673 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R9674 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R9675 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R9676 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R9677 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R9678 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R9679 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R9680 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R9681 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R9682 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R9683 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R9684 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R9685 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R9686 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R9687 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R9688 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R9689 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R9690 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R9691 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R9692 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R9693 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R9694 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R9695 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R9696 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R9697 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R9698 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R9699 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R9700 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R9701 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R9702 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R9703 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R9704 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R9705 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R9706 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R9707 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R9708 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R9709 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R9710 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R9711 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R9712 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R9713 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R9714 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R9715 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R9716 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R9717 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R9718 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R9719 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R9720 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R9721 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R9722 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R9723 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R9724 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R9725 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R9726 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R9727 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R9728 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R9729 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R9730 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R9731 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R9732 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R9733 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R9734 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R9735 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R9736 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R9737 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R9738 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R9739 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R9740 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R9741 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R9742 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R9743 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R9744 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R9745 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R9746 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R9747 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R9748 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R9749 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R9750 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R9751 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R9752 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R9753 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R9754 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R9755 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R9756 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R9757 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R9758 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R9759 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R9760 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R9761 n1_m1_470400_345600 n1_m1_475200_345600 5.356235
R9762 n1_m1_475200_345600 n1_m1_480000_345600 5.356235
R9763 n1_m1_480000_345600 n1_m1_484800_345600 5.356235
R9764 n1_m1_484800_345600 n1_m1_489600_345600 5.356235
R9765 n1_m1_489600_345600 n1_m1_494400_345600 5.356235
R9766 n1_m1_494400_345600 n1_m1_499200_345600 5.356235
R9767 n1_m1_499200_345600 n1_m1_504000_345600 5.356235
R9768 n1_m1_504000_345600 n1_m1_508000_345600 4.463529
R9769 n1_m1_508800_345600 n1_m1_508000_345600 0.892706
R9770 n1_m1_508800_345600 n1_m1_513600_345600 5.356235
R9771 n1_m1_513600_345600 n1_m1_518400_345600 5.356235
R9772 n1_m1_518400_345600 n1_m1_523200_345600 5.356235
R9773 n1_m1_523200_345600 n1_m1_528000_345600 5.356235
R9774 n1_m1_528000_345600 n1_m1_532800_345600 5.356235
R9775 n1_m1_532800_345600 n1_m1_536000_345600 3.570824
R9776 n1_m1_537600_345600 n1_m1_536000_345600 1.785412
R9777 n1_m1_537600_345600 n1_m1_542400_345600 5.356235
R9778 n1_m1_542400_345600 n1_m1_547200_345600 5.356235
R9779 n1_m1_547200_345600 n1_m1_552000_345600 5.356235
R9780 n1_m1_552000_345600 n1_m1_556800_345600 5.356235
R9781 n1_m1_556800_345600 n1_m1_561600_345600 5.356235
R9782 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R9783 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R9784 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R9785 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R9786 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R9787 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R9788 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R9789 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R9790 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R9791 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R9792 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R9793 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R9794 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R9795 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R9796 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R9797 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R9798 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R9799 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R9800 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R9801 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R9802 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R9803 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R9804 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R9805 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R9806 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R9807 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R9808 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R9809 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R9810 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R9811 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R9812 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R9813 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R9814 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R9815 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R9816 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R9817 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R9818 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R9819 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R9820 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R9821 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R9822 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R9823 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R9824 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R9825 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R9826 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R9827 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R9828 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R9829 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R9830 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R9831 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R9832 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R9833 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R9834 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R9835 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R9836 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R9837 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R9838 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R9839 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R9840 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R9841 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R9842 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R9843 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R9844 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R9845 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R9846 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R9847 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R9848 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R9849 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R9850 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R9851 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R9852 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R9853 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R9854 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R9855 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R9856 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R9857 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R9858 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R9859 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R9860 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R9861 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R9862 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R9863 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R9864 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R9865 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R9866 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R9867 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R9868 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R9869 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R9870 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R9871 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R9872 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R9873 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R9874 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R9875 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R9876 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R9877 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R9878 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R9879 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R9880 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R9881 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R9882 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R9883 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R9884 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R9885 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R9886 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R9887 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R9888 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R9889 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R9890 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R9891 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R9892 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R9893 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R9894 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R9895 n1_m1_470400_350400 n1_m1_475200_350400 5.356235
R9896 n1_m1_475200_350400 n1_m1_480000_350400 5.356235
R9897 n1_m1_480000_350400 n1_m1_484800_350400 5.356235
R9898 n1_m1_484800_350400 n1_m1_489600_350400 5.356235
R9899 n1_m1_489600_350400 n1_m1_494400_350400 5.356235
R9900 n1_m1_494400_350400 n1_m1_499200_350400 5.356235
R9901 n1_m1_499200_350400 n1_m1_504000_350400 5.356235
R9902 n1_m1_504000_350400 n1_m1_508000_350400 4.463529
R9903 n1_m1_508800_350400 n1_m1_508000_350400 0.892706
R9904 n1_m1_508800_350400 n1_m1_513600_350400 5.356235
R9905 n1_m1_513600_350400 n1_m1_518400_350400 5.356235
R9906 n1_m1_518400_350400 n1_m1_523200_350400 5.356235
R9907 n1_m1_523200_350400 n1_m1_528000_350400 5.356235
R9908 n1_m1_528000_350400 n1_m1_532800_350400 5.356235
R9909 n1_m1_532800_350400 n1_m1_536000_350400 3.570824
R9910 n1_m1_537600_350400 n1_m1_536000_350400 1.785412
R9911 n1_m1_537600_350400 n1_m1_542400_350400 5.356235
R9912 n1_m1_542400_350400 n1_m1_547200_350400 5.356235
R9913 n1_m1_547200_350400 n1_m1_552000_350400 5.356235
R9914 n1_m1_552000_350400 n1_m1_556800_350400 5.356235
R9915 n1_m1_556800_350400 n1_m1_561600_350400 5.356235
R9916 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R9917 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R9918 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R9919 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R9920 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R9921 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R9922 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R9923 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R9924 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R9925 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R9926 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R9927 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R9928 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R9929 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R9930 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R9931 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R9932 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R9933 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R9934 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R9935 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R9936 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R9937 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R9938 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R9939 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R9940 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R9941 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R9942 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R9943 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R9944 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R9945 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R9946 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R9947 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R9948 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R9949 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R9950 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R9951 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R9952 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R9953 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R9954 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R9955 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R9956 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R9957 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R9958 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R9959 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R9960 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R9961 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R9962 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R9963 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R9964 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R9965 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R9966 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R9967 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R9968 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R9969 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R9970 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R9971 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R9972 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R9973 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R9974 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R9975 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R9976 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R9977 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R9978 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R9979 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R9980 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R9981 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R9982 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R9983 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R9984 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R9985 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R9986 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R9987 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R9988 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R9989 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R9990 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R9991 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R9992 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R9993 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R9994 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R9995 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R9996 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R9997 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R9998 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R9999 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R10000 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R10001 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R10002 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R10003 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R10004 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R10005 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R10006 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R10007 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R10008 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R10009 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R10010 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R10011 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R10012 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R10013 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R10014 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R10015 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R10016 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R10017 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R10018 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R10019 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R10020 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R10021 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R10022 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R10023 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R10024 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R10025 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R10026 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R10027 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R10028 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R10029 n1_m1_470400_355200 n1_m1_475200_355200 5.356235
R10030 n1_m1_475200_355200 n1_m1_480000_355200 5.356235
R10031 n1_m1_480000_355200 n1_m1_484800_355200 5.356235
R10032 n1_m1_484800_355200 n1_m1_489600_355200 5.356235
R10033 n1_m1_489600_355200 n1_m1_494400_355200 5.356235
R10034 n1_m1_494400_355200 n1_m1_499200_355200 5.356235
R10035 n1_m1_499200_355200 n1_m1_504000_355200 5.356235
R10036 n1_m1_504000_355200 n1_m1_508000_355200 4.463529
R10037 n1_m1_508800_355200 n1_m1_508000_355200 0.892706
R10038 n1_m1_508800_355200 n1_m1_513600_355200 5.356235
R10039 n1_m1_513600_355200 n1_m1_518400_355200 5.356235
R10040 n1_m1_518400_355200 n1_m1_523200_355200 5.356235
R10041 n1_m1_523200_355200 n1_m1_528000_355200 5.356235
R10042 n1_m1_528000_355200 n1_m1_532800_355200 5.356235
R10043 n1_m1_532800_355200 n1_m1_536000_355200 3.570824
R10044 n1_m1_537600_355200 n1_m1_536000_355200 1.785412
R10045 n1_m1_537600_355200 n1_m1_542400_355200 5.356235
R10046 n1_m1_542400_355200 n1_m1_547200_355200 5.356235
R10047 n1_m1_547200_355200 n1_m1_552000_355200 5.356235
R10048 n1_m1_552000_355200 n1_m1_556800_355200 5.356235
R10049 n1_m1_556800_355200 n1_m1_561600_355200 5.356235
R10050 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R10051 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R10052 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R10053 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R10054 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R10055 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R10056 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R10057 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R10058 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R10059 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R10060 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R10061 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R10062 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R10063 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R10064 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R10065 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R10066 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R10067 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R10068 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R10069 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R10070 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R10071 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R10072 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R10073 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R10074 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R10075 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R10076 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R10077 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R10078 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R10079 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R10080 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R10081 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R10082 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R10083 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R10084 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R10085 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R10086 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R10087 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R10088 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R10089 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R10090 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R10091 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R10092 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R10093 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R10094 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R10095 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R10096 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R10097 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R10098 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R10099 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R10100 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R10101 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R10102 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R10103 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R10104 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R10105 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R10106 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R10107 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R10108 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R10109 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R10110 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R10111 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R10112 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R10113 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R10114 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R10115 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R10116 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R10117 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R10118 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R10119 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R10120 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R10121 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R10122 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R10123 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R10124 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R10125 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R10126 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R10127 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R10128 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R10129 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R10130 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R10131 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R10132 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R10133 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R10134 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R10135 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R10136 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R10137 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R10138 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R10139 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R10140 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R10141 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R10142 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R10143 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R10144 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R10145 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R10146 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R10147 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R10148 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R10149 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R10150 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R10151 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R10152 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R10153 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R10154 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R10155 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R10156 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R10157 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R10158 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R10159 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R10160 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R10161 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R10162 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R10163 n1_m1_470400_360000 n1_m1_475200_360000 5.356235
R10164 n1_m1_475200_360000 n1_m1_480000_360000 5.356235
R10165 n1_m1_480000_360000 n1_m1_484800_360000 5.356235
R10166 n1_m1_484800_360000 n1_m1_489600_360000 5.356235
R10167 n1_m1_489600_360000 n1_m1_494400_360000 5.356235
R10168 n1_m1_494400_360000 n1_m1_499200_360000 5.356235
R10169 n1_m1_499200_360000 n1_m1_504000_360000 5.356235
R10170 n1_m1_504000_360000 n1_m1_508000_360000 4.463529
R10171 n1_m1_508800_360000 n1_m1_508000_360000 0.892706
R10172 n1_m1_508800_360000 n1_m1_513600_360000 5.356235
R10173 n1_m1_513600_360000 n1_m1_518400_360000 5.356235
R10174 n1_m1_518400_360000 n1_m1_523200_360000 5.356235
R10175 n1_m1_523200_360000 n1_m1_528000_360000 5.356235
R10176 n1_m1_528000_360000 n1_m1_532800_360000 5.356235
R10177 n1_m1_532800_360000 n1_m1_536000_360000 3.570824
R10178 n1_m1_537600_360000 n1_m1_536000_360000 1.785412
R10179 n1_m1_537600_360000 n1_m1_542400_360000 5.356235
R10180 n1_m1_542400_360000 n1_m1_547200_360000 5.356235
R10181 n1_m1_547200_360000 n1_m1_552000_360000 5.356235
R10182 n1_m1_552000_360000 n1_m1_556800_360000 5.356235
R10183 n1_m1_556800_360000 n1_m1_561600_360000 5.356235
R10184 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R10185 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R10186 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R10187 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R10188 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R10189 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R10190 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R10191 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R10192 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R10193 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R10194 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R10195 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R10196 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R10197 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R10198 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R10199 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R10200 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R10201 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R10202 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R10203 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R10204 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R10205 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R10206 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R10207 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R10208 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R10209 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R10210 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R10211 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R10212 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R10213 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R10214 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R10215 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R10216 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R10217 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R10218 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R10219 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R10220 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R10221 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R10222 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R10223 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R10224 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R10225 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R10226 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R10227 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R10228 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R10229 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R10230 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R10231 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R10232 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R10233 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R10234 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R10235 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R10236 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R10237 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R10238 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R10239 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R10240 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R10241 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R10242 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R10243 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R10244 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R10245 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R10246 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R10247 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R10248 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R10249 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R10250 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R10251 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R10252 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R10253 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R10254 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R10255 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R10256 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R10257 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R10258 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R10259 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R10260 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R10261 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R10262 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R10263 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R10264 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R10265 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R10266 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R10267 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R10268 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R10269 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R10270 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R10271 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R10272 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R10273 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R10274 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R10275 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R10276 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R10277 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R10278 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R10279 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R10280 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R10281 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R10282 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R10283 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R10284 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R10285 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R10286 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R10287 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R10288 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R10289 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R10290 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R10291 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R10292 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R10293 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R10294 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R10295 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R10296 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R10297 n1_m1_470400_364800 n1_m1_475200_364800 5.356235
R10298 n1_m1_475200_364800 n1_m1_480000_364800 5.356235
R10299 n1_m1_480000_364800 n1_m1_484800_364800 5.356235
R10300 n1_m1_484800_364800 n1_m1_489600_364800 5.356235
R10301 n1_m1_489600_364800 n1_m1_494400_364800 5.356235
R10302 n1_m1_494400_364800 n1_m1_499200_364800 5.356235
R10303 n1_m1_499200_364800 n1_m1_504000_364800 5.356235
R10304 n1_m1_504000_364800 n1_m1_508000_364800 4.463529
R10305 n1_m1_508800_364800 n1_m1_508000_364800 0.892706
R10306 n1_m1_508800_364800 n1_m1_513600_364800 5.356235
R10307 n1_m1_513600_364800 n1_m1_518400_364800 5.356235
R10308 n1_m1_518400_364800 n1_m1_523200_364800 5.356235
R10309 n1_m1_523200_364800 n1_m1_528000_364800 5.356235
R10310 n1_m1_528000_364800 n1_m1_532800_364800 5.356235
R10311 n1_m1_532800_364800 n1_m1_536000_364800 3.570824
R10312 n1_m1_537600_364800 n1_m1_536000_364800 1.785412
R10313 n1_m1_537600_364800 n1_m1_542400_364800 5.356235
R10314 n1_m1_542400_364800 n1_m1_547200_364800 5.356235
R10315 n1_m1_547200_364800 n1_m1_552000_364800 5.356235
R10316 n1_m1_552000_364800 n1_m1_556800_364800 5.356235
R10317 n1_m1_556800_364800 n1_m1_561600_364800 5.356235
R10318 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R10319 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R10320 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R10321 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R10322 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R10323 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R10324 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R10325 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R10326 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R10327 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R10328 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R10329 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R10330 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R10331 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R10332 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R10333 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R10334 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R10335 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R10336 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R10337 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R10338 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R10339 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R10340 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R10341 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R10342 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R10343 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R10344 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R10345 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R10346 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R10347 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R10348 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R10349 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R10350 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R10351 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R10352 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R10353 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R10354 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R10355 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R10356 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R10357 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R10358 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R10359 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R10360 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R10361 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R10362 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R10363 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R10364 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R10365 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R10366 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R10367 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R10368 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R10369 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R10370 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R10371 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R10372 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R10373 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R10374 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R10375 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R10376 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R10377 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R10378 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R10379 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R10380 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R10381 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R10382 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R10383 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R10384 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R10385 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R10386 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R10387 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R10388 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R10389 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R10390 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R10391 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R10392 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R10393 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R10394 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R10395 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R10396 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R10397 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R10398 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R10399 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R10400 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R10401 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R10402 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R10403 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R10404 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R10405 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R10406 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R10407 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R10408 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R10409 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R10410 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R10411 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R10412 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R10413 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R10414 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R10415 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R10416 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R10417 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R10418 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R10419 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R10420 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R10421 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R10422 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R10423 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R10424 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R10425 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R10426 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R10427 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R10428 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R10429 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R10430 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R10431 n1_m1_470400_369600 n1_m1_475200_369600 5.356235
R10432 n1_m1_475200_369600 n1_m1_480000_369600 5.356235
R10433 n1_m1_480000_369600 n1_m1_484800_369600 5.356235
R10434 n1_m1_484800_369600 n1_m1_489600_369600 5.356235
R10435 n1_m1_489600_369600 n1_m1_494400_369600 5.356235
R10436 n1_m1_494400_369600 n1_m1_499200_369600 5.356235
R10437 n1_m1_499200_369600 n1_m1_504000_369600 5.356235
R10438 n1_m1_504000_369600 n1_m1_508000_369600 4.463529
R10439 n1_m1_508800_369600 n1_m1_508000_369600 0.892706
R10440 n1_m1_508800_369600 n1_m1_513600_369600 5.356235
R10441 n1_m1_513600_369600 n1_m1_518400_369600 5.356235
R10442 n1_m1_518400_369600 n1_m1_523200_369600 5.356235
R10443 n1_m1_523200_369600 n1_m1_528000_369600 5.356235
R10444 n1_m1_528000_369600 n1_m1_532800_369600 5.356235
R10445 n1_m1_532800_369600 n1_m1_536000_369600 3.570824
R10446 n1_m1_537600_369600 n1_m1_536000_369600 1.785412
R10447 n1_m1_537600_369600 n1_m1_542400_369600 5.356235
R10448 n1_m1_542400_369600 n1_m1_547200_369600 5.356235
R10449 n1_m1_547200_369600 n1_m1_552000_369600 5.356235
R10450 n1_m1_552000_369600 n1_m1_556800_369600 5.356235
R10451 n1_m1_556800_369600 n1_m1_561600_369600 5.356235
R10452 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R10453 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R10454 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R10455 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R10456 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R10457 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R10458 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R10459 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R10460 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R10461 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R10462 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R10463 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R10464 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R10465 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R10466 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R10467 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R10468 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R10469 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R10470 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R10471 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R10472 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R10473 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R10474 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R10475 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R10476 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R10477 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R10478 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R10479 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R10480 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R10481 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R10482 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R10483 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R10484 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R10485 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R10486 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R10487 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R10488 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R10489 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R10490 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R10491 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R10492 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R10493 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R10494 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R10495 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R10496 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R10497 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R10498 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R10499 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R10500 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R10501 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R10502 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R10503 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R10504 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R10505 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R10506 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R10507 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R10508 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R10509 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R10510 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R10511 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R10512 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R10513 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R10514 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R10515 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R10516 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R10517 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R10518 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R10519 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R10520 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R10521 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R10522 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R10523 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R10524 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R10525 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R10526 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R10527 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R10528 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R10529 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R10530 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R10531 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R10532 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R10533 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R10534 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R10535 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R10536 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R10537 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R10538 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R10539 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R10540 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R10541 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R10542 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R10543 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R10544 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R10545 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R10546 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R10547 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R10548 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R10549 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R10550 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R10551 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R10552 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R10553 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R10554 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R10555 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R10556 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R10557 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R10558 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R10559 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R10560 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R10561 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R10562 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R10563 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R10564 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R10565 n1_m1_470400_374400 n1_m1_475200_374400 5.356235
R10566 n1_m1_475200_374400 n1_m1_480000_374400 5.356235
R10567 n1_m1_480000_374400 n1_m1_484800_374400 5.356235
R10568 n1_m1_484800_374400 n1_m1_489600_374400 5.356235
R10569 n1_m1_489600_374400 n1_m1_494400_374400 5.356235
R10570 n1_m1_494400_374400 n1_m1_499200_374400 5.356235
R10571 n1_m1_499200_374400 n1_m1_504000_374400 5.356235
R10572 n1_m1_504000_374400 n1_m1_508000_374400 4.463529
R10573 n1_m1_508800_374400 n1_m1_508000_374400 0.892706
R10574 n1_m1_508800_374400 n1_m1_513600_374400 5.356235
R10575 n1_m1_513600_374400 n1_m1_518400_374400 5.356235
R10576 n1_m1_518400_374400 n1_m1_523200_374400 5.356235
R10577 n1_m1_523200_374400 n1_m1_528000_374400 5.356235
R10578 n1_m1_528000_374400 n1_m1_532800_374400 5.356235
R10579 n1_m1_532800_374400 n1_m1_536000_374400 3.570824
R10580 n1_m1_537600_374400 n1_m1_536000_374400 1.785412
R10581 n1_m1_537600_374400 n1_m1_542400_374400 5.356235
R10582 n1_m1_542400_374400 n1_m1_547200_374400 5.356235
R10583 n1_m1_547200_374400 n1_m1_552000_374400 5.356235
R10584 n1_m1_552000_374400 n1_m1_556800_374400 5.356235
R10585 n1_m1_556800_374400 n1_m1_561600_374400 5.356235
R10586 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R10587 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R10588 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R10589 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R10590 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R10591 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R10592 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R10593 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R10594 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R10595 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R10596 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R10597 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R10598 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R10599 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R10600 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R10601 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R10602 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R10603 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R10604 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R10605 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R10606 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R10607 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R10608 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R10609 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R10610 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R10611 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R10612 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R10613 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R10614 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R10615 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R10616 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R10617 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R10618 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R10619 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R10620 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R10621 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R10622 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R10623 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R10624 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R10625 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R10626 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R10627 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R10628 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R10629 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R10630 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R10631 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R10632 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R10633 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R10634 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R10635 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R10636 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R10637 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R10638 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R10639 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R10640 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R10641 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R10642 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R10643 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R10644 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R10645 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R10646 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R10647 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R10648 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R10649 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R10650 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R10651 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R10652 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R10653 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R10654 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R10655 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R10656 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R10657 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R10658 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R10659 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R10660 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R10661 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R10662 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R10663 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R10664 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R10665 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R10666 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R10667 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R10668 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R10669 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R10670 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R10671 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R10672 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R10673 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R10674 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R10675 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R10676 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R10677 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R10678 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R10679 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R10680 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R10681 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R10682 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R10683 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R10684 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R10685 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R10686 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R10687 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R10688 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R10689 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R10690 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R10691 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R10692 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R10693 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R10694 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R10695 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R10696 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R10697 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R10698 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R10699 n1_m1_470400_379200 n1_m1_475200_379200 5.356235
R10700 n1_m1_475200_379200 n1_m1_480000_379200 5.356235
R10701 n1_m1_480000_379200 n1_m1_484800_379200 5.356235
R10702 n1_m1_484800_379200 n1_m1_489600_379200 5.356235
R10703 n1_m1_489600_379200 n1_m1_494400_379200 5.356235
R10704 n1_m1_494400_379200 n1_m1_499200_379200 5.356235
R10705 n1_m1_499200_379200 n1_m1_504000_379200 5.356235
R10706 n1_m1_504000_379200 n1_m1_508000_379200 4.463529
R10707 n1_m1_508800_379200 n1_m1_508000_379200 0.892706
R10708 n1_m1_508800_379200 n1_m1_513600_379200 5.356235
R10709 n1_m1_513600_379200 n1_m1_518400_379200 5.356235
R10710 n1_m1_518400_379200 n1_m1_523200_379200 5.356235
R10711 n1_m1_523200_379200 n1_m1_528000_379200 5.356235
R10712 n1_m1_528000_379200 n1_m1_532800_379200 5.356235
R10713 n1_m1_532800_379200 n1_m1_536000_379200 3.570824
R10714 n1_m1_537600_379200 n1_m1_536000_379200 1.785412
R10715 n1_m1_537600_379200 n1_m1_542400_379200 5.356235
R10716 n1_m1_542400_379200 n1_m1_547200_379200 5.356235
R10717 n1_m1_547200_379200 n1_m1_552000_379200 5.356235
R10718 n1_m1_552000_379200 n1_m1_556800_379200 5.356235
R10719 n1_m1_556800_379200 n1_m1_561600_379200 5.356235
R10720 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R10721 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R10722 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R10723 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R10724 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R10725 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R10726 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R10727 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R10728 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R10729 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R10730 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R10731 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R10732 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R10733 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R10734 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R10735 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R10736 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R10737 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R10738 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R10739 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R10740 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R10741 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R10742 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R10743 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R10744 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R10745 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R10746 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R10747 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R10748 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R10749 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R10750 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R10751 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R10752 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R10753 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R10754 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R10755 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R10756 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R10757 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R10758 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R10759 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R10760 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R10761 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R10762 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R10763 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R10764 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R10765 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R10766 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R10767 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R10768 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R10769 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R10770 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R10771 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R10772 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R10773 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R10774 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R10775 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R10776 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R10777 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R10778 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R10779 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R10780 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R10781 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R10782 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R10783 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R10784 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R10785 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R10786 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R10787 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R10788 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R10789 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R10790 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R10791 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R10792 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R10793 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R10794 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R10795 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R10796 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R10797 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R10798 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R10799 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R10800 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R10801 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R10802 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R10803 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R10804 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R10805 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R10806 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R10807 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R10808 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R10809 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R10810 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R10811 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R10812 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R10813 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R10814 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R10815 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R10816 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R10817 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R10818 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R10819 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R10820 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R10821 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R10822 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R10823 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R10824 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R10825 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R10826 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R10827 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R10828 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R10829 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R10830 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R10831 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R10832 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R10833 n1_m1_470400_384000 n1_m1_475200_384000 5.356235
R10834 n1_m1_475200_384000 n1_m1_480000_384000 5.356235
R10835 n1_m1_480000_384000 n1_m1_484800_384000 5.356235
R10836 n1_m1_484800_384000 n1_m1_489600_384000 5.356235
R10837 n1_m1_489600_384000 n1_m1_494400_384000 5.356235
R10838 n1_m1_494400_384000 n1_m1_499200_384000 5.356235
R10839 n1_m1_499200_384000 n1_m1_504000_384000 5.356235
R10840 n1_m1_504000_384000 n1_m1_508000_384000 4.463529
R10841 n1_m1_508800_384000 n1_m1_508000_384000 0.892706
R10842 n1_m1_508800_384000 n1_m1_513600_384000 5.356235
R10843 n1_m1_513600_384000 n1_m1_518400_384000 5.356235
R10844 n1_m1_518400_384000 n1_m1_523200_384000 5.356235
R10845 n1_m1_523200_384000 n1_m1_528000_384000 5.356235
R10846 n1_m1_528000_384000 n1_m1_532800_384000 5.356235
R10847 n1_m1_532800_384000 n1_m1_536000_384000 3.570824
R10848 n1_m1_537600_384000 n1_m1_536000_384000 1.785412
R10849 n1_m1_537600_384000 n1_m1_542400_384000 5.356235
R10850 n1_m1_542400_384000 n1_m1_547200_384000 5.356235
R10851 n1_m1_547200_384000 n1_m1_552000_384000 5.356235
R10852 n1_m1_552000_384000 n1_m1_556800_384000 5.356235
R10853 n1_m1_556800_384000 n1_m1_561600_384000 5.356235
R10854 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R10855 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R10856 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R10857 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R10858 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R10859 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R10860 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R10861 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R10862 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R10863 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R10864 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R10865 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R10866 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R10867 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R10868 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R10869 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R10870 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R10871 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R10872 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R10873 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R10874 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R10875 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R10876 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R10877 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R10878 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R10879 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R10880 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R10881 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R10882 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R10883 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R10884 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R10885 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R10886 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R10887 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R10888 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R10889 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R10890 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R10891 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R10892 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R10893 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R10894 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R10895 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R10896 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R10897 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R10898 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R10899 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R10900 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R10901 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R10902 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R10903 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R10904 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R10905 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R10906 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R10907 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R10908 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R10909 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R10910 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R10911 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R10912 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R10913 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R10914 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R10915 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R10916 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R10917 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R10918 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R10919 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R10920 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R10921 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R10922 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R10923 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R10924 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R10925 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R10926 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R10927 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R10928 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R10929 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R10930 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R10931 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R10932 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R10933 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R10934 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R10935 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R10936 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R10937 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R10938 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R10939 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R10940 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R10941 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R10942 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R10943 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R10944 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R10945 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R10946 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R10947 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R10948 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R10949 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R10950 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R10951 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R10952 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R10953 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R10954 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R10955 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R10956 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R10957 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R10958 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R10959 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R10960 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R10961 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R10962 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R10963 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R10964 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R10965 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R10966 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R10967 n1_m1_470400_388800 n1_m1_475200_388800 5.356235
R10968 n1_m1_475200_388800 n1_m1_480000_388800 5.356235
R10969 n1_m1_480000_388800 n1_m1_484800_388800 5.356235
R10970 n1_m1_484800_388800 n1_m1_489600_388800 5.356235
R10971 n1_m1_489600_388800 n1_m1_494400_388800 5.356235
R10972 n1_m1_494400_388800 n1_m1_499200_388800 5.356235
R10973 n1_m1_499200_388800 n1_m1_504000_388800 5.356235
R10974 n1_m1_504000_388800 n1_m1_508000_388800 4.463529
R10975 n1_m1_508800_388800 n1_m1_508000_388800 0.892706
R10976 n1_m1_508800_388800 n1_m1_513600_388800 5.356235
R10977 n1_m1_513600_388800 n1_m1_518400_388800 5.356235
R10978 n1_m1_518400_388800 n1_m1_523200_388800 5.356235
R10979 n1_m1_523200_388800 n1_m1_528000_388800 5.356235
R10980 n1_m1_528000_388800 n1_m1_532800_388800 5.356235
R10981 n1_m1_532800_388800 n1_m1_536000_388800 3.570824
R10982 n1_m1_537600_388800 n1_m1_536000_388800 1.785412
R10983 n1_m1_537600_388800 n1_m1_542400_388800 5.356235
R10984 n1_m1_542400_388800 n1_m1_547200_388800 5.356235
R10985 n1_m1_547200_388800 n1_m1_552000_388800 5.356235
R10986 n1_m1_552000_388800 n1_m1_556800_388800 5.356235
R10987 n1_m1_556800_388800 n1_m1_561600_388800 5.356235
R10988 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R10989 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R10990 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R10991 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R10992 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R10993 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R10994 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R10995 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R10996 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R10997 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R10998 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R10999 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R11000 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R11001 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R11002 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R11003 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R11004 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R11005 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R11006 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R11007 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R11008 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R11009 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R11010 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R11011 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R11012 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R11013 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R11014 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R11015 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R11016 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R11017 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R11018 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R11019 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R11020 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R11021 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R11022 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R11023 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R11024 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R11025 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R11026 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R11027 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R11028 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R11029 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R11030 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R11031 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R11032 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R11033 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R11034 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R11035 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R11036 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R11037 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R11038 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R11039 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R11040 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R11041 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R11042 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R11043 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R11044 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R11045 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R11046 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R11047 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R11048 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R11049 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R11050 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R11051 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R11052 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R11053 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R11054 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R11055 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R11056 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R11057 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R11058 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R11059 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R11060 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R11061 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R11062 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R11063 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R11064 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R11065 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R11066 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R11067 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R11068 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R11069 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R11070 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R11071 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R11072 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R11073 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R11074 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R11075 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R11076 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R11077 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R11078 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R11079 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R11080 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R11081 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R11082 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R11083 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R11084 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R11085 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R11086 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R11087 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R11088 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R11089 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R11090 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R11091 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R11092 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R11093 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R11094 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R11095 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R11096 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R11097 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R11098 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R11099 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R11100 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R11101 n1_m1_470400_393600 n1_m1_475200_393600 5.356235
R11102 n1_m1_475200_393600 n1_m1_480000_393600 5.356235
R11103 n1_m1_480000_393600 n1_m1_484800_393600 5.356235
R11104 n1_m1_484800_393600 n1_m1_489600_393600 5.356235
R11105 n1_m1_489600_393600 n1_m1_494400_393600 5.356235
R11106 n1_m1_494400_393600 n1_m1_499200_393600 5.356235
R11107 n1_m1_499200_393600 n1_m1_504000_393600 5.356235
R11108 n1_m1_504000_393600 n1_m1_508000_393600 4.463529
R11109 n1_m1_508800_393600 n1_m1_508000_393600 0.892706
R11110 n1_m1_508800_393600 n1_m1_513600_393600 5.356235
R11111 n1_m1_513600_393600 n1_m1_518400_393600 5.356235
R11112 n1_m1_518400_393600 n1_m1_523200_393600 5.356235
R11113 n1_m1_523200_393600 n1_m1_528000_393600 5.356235
R11114 n1_m1_528000_393600 n1_m1_532800_393600 5.356235
R11115 n1_m1_532800_393600 n1_m1_536000_393600 3.570824
R11116 n1_m1_537600_393600 n1_m1_536000_393600 1.785412
R11117 n1_m1_537600_393600 n1_m1_542400_393600 5.356235
R11118 n1_m1_542400_393600 n1_m1_547200_393600 5.356235
R11119 n1_m1_547200_393600 n1_m1_552000_393600 5.356235
R11120 n1_m1_552000_393600 n1_m1_556800_393600 5.356235
R11121 n1_m1_556800_393600 n1_m1_561600_393600 5.356235
R11122 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R11123 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R11124 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R11125 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R11126 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R11127 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R11128 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R11129 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R11130 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R11131 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R11132 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R11133 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R11134 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R11135 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R11136 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R11137 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R11138 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R11139 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R11140 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R11141 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R11142 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R11143 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R11144 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R11145 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R11146 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R11147 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R11148 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R11149 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R11150 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R11151 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R11152 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R11153 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R11154 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R11155 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R11156 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R11157 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R11158 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R11159 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R11160 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R11161 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R11162 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R11163 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R11164 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R11165 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R11166 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R11167 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R11168 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R11169 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R11170 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R11171 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R11172 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R11173 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R11174 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R11175 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R11176 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R11177 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R11178 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R11179 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R11180 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R11181 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R11182 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R11183 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R11184 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R11185 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R11186 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R11187 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R11188 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R11189 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R11190 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R11191 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R11192 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R11193 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R11194 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R11195 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R11196 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R11197 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R11198 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R11199 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R11200 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R11201 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R11202 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R11203 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R11204 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R11205 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R11206 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R11207 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R11208 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R11209 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R11210 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R11211 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R11212 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R11213 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R11214 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R11215 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R11216 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R11217 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R11218 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R11219 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R11220 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R11221 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R11222 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R11223 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R11224 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R11225 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R11226 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R11227 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R11228 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R11229 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R11230 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R11231 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R11232 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R11233 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R11234 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R11235 n1_m1_470400_398400 n1_m1_475200_398400 5.356235
R11236 n1_m1_475200_398400 n1_m1_480000_398400 5.356235
R11237 n1_m1_480000_398400 n1_m1_484800_398400 5.356235
R11238 n1_m1_484800_398400 n1_m1_489600_398400 5.356235
R11239 n1_m1_489600_398400 n1_m1_494400_398400 5.356235
R11240 n1_m1_494400_398400 n1_m1_499200_398400 5.356235
R11241 n1_m1_499200_398400 n1_m1_504000_398400 5.356235
R11242 n1_m1_504000_398400 n1_m1_508000_398400 4.463529
R11243 n1_m1_508800_398400 n1_m1_508000_398400 0.892706
R11244 n1_m1_508800_398400 n1_m1_513600_398400 5.356235
R11245 n1_m1_513600_398400 n1_m1_518400_398400 5.356235
R11246 n1_m1_518400_398400 n1_m1_523200_398400 5.356235
R11247 n1_m1_523200_398400 n1_m1_528000_398400 5.356235
R11248 n1_m1_528000_398400 n1_m1_532800_398400 5.356235
R11249 n1_m1_532800_398400 n1_m1_536000_398400 3.570824
R11250 n1_m1_537600_398400 n1_m1_536000_398400 1.785412
R11251 n1_m1_537600_398400 n1_m1_542400_398400 5.356235
R11252 n1_m1_542400_398400 n1_m1_547200_398400 5.356235
R11253 n1_m1_547200_398400 n1_m1_552000_398400 5.356235
R11254 n1_m1_552000_398400 n1_m1_556800_398400 5.356235
R11255 n1_m1_556800_398400 n1_m1_561600_398400 5.356235
R11256 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R11257 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R11258 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R11259 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R11260 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R11261 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R11262 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R11263 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R11264 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R11265 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R11266 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R11267 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R11268 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R11269 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R11270 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R11271 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R11272 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R11273 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R11274 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R11275 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R11276 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R11277 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R11278 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R11279 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R11280 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R11281 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R11282 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R11283 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R11284 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R11285 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R11286 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R11287 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R11288 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R11289 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R11290 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R11291 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R11292 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R11293 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R11294 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R11295 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R11296 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R11297 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R11298 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R11299 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R11300 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R11301 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R11302 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R11303 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R11304 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R11305 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R11306 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R11307 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R11308 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R11309 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R11310 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R11311 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R11312 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R11313 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R11314 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R11315 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R11316 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R11317 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R11318 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R11319 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R11320 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R11321 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R11322 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R11323 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R11324 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R11325 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R11326 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R11327 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R11328 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R11329 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R11330 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R11331 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R11332 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R11333 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R11334 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R11335 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R11336 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R11337 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R11338 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R11339 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R11340 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R11341 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R11342 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R11343 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R11344 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R11345 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R11346 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R11347 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R11348 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R11349 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R11350 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R11351 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R11352 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R11353 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R11354 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R11355 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R11356 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R11357 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R11358 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R11359 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R11360 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R11361 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R11362 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R11363 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R11364 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R11365 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R11366 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R11367 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R11368 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R11369 n1_m1_470400_403200 n1_m1_475200_403200 5.356235
R11370 n1_m1_475200_403200 n1_m1_480000_403200 5.356235
R11371 n1_m1_480000_403200 n1_m1_484800_403200 5.356235
R11372 n1_m1_484800_403200 n1_m1_489600_403200 5.356235
R11373 n1_m1_489600_403200 n1_m1_494400_403200 5.356235
R11374 n1_m1_494400_403200 n1_m1_499200_403200 5.356235
R11375 n1_m1_499200_403200 n1_m1_504000_403200 5.356235
R11376 n1_m1_504000_403200 n1_m1_508000_403200 4.463529
R11377 n1_m1_508800_403200 n1_m1_508000_403200 0.892706
R11378 n1_m1_508800_403200 n1_m1_513600_403200 5.356235
R11379 n1_m1_513600_403200 n1_m1_518400_403200 5.356235
R11380 n1_m1_518400_403200 n1_m1_523200_403200 5.356235
R11381 n1_m1_523200_403200 n1_m1_528000_403200 5.356235
R11382 n1_m1_528000_403200 n1_m1_532800_403200 5.356235
R11383 n1_m1_532800_403200 n1_m1_536000_403200 3.570824
R11384 n1_m1_537600_403200 n1_m1_536000_403200 1.785412
R11385 n1_m1_537600_403200 n1_m1_542400_403200 5.356235
R11386 n1_m1_542400_403200 n1_m1_547200_403200 5.356235
R11387 n1_m1_547200_403200 n1_m1_552000_403200 5.356235
R11388 n1_m1_552000_403200 n1_m1_556800_403200 5.356235
R11389 n1_m1_556800_403200 n1_m1_561600_403200 5.356235
R11390 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R11391 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R11392 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R11393 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R11394 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R11395 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R11396 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R11397 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R11398 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R11399 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R11400 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R11401 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R11402 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R11403 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R11404 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R11405 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R11406 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R11407 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R11408 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R11409 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R11410 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R11411 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R11412 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R11413 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R11414 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R11415 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R11416 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R11417 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R11418 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R11419 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R11420 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R11421 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R11422 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R11423 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R11424 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R11425 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R11426 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R11427 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R11428 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R11429 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R11430 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R11431 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R11432 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R11433 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R11434 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R11435 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R11436 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R11437 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R11438 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R11439 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R11440 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R11441 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R11442 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R11443 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R11444 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R11445 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R11446 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R11447 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R11448 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R11449 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R11450 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R11451 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R11452 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R11453 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R11454 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R11455 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R11456 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R11457 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R11458 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R11459 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R11460 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R11461 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R11462 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R11463 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R11464 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R11465 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R11466 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R11467 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R11468 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R11469 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R11470 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R11471 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R11472 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R11473 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R11474 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R11475 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R11476 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R11477 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R11478 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R11479 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R11480 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R11481 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R11482 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R11483 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R11484 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R11485 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R11486 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R11487 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R11488 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R11489 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R11490 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R11491 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R11492 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R11493 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R11494 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R11495 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R11496 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R11497 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R11498 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R11499 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R11500 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R11501 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R11502 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R11503 n1_m1_470400_408000 n1_m1_475200_408000 5.356235
R11504 n1_m1_475200_408000 n1_m1_480000_408000 5.356235
R11505 n1_m1_480000_408000 n1_m1_484800_408000 5.356235
R11506 n1_m1_484800_408000 n1_m1_489600_408000 5.356235
R11507 n1_m1_489600_408000 n1_m1_494400_408000 5.356235
R11508 n1_m1_494400_408000 n1_m1_499200_408000 5.356235
R11509 n1_m1_499200_408000 n1_m1_504000_408000 5.356235
R11510 n1_m1_504000_408000 n1_m1_508000_408000 4.463529
R11511 n1_m1_508800_408000 n1_m1_508000_408000 0.892706
R11512 n1_m1_508800_408000 n1_m1_513600_408000 5.356235
R11513 n1_m1_513600_408000 n1_m1_518400_408000 5.356235
R11514 n1_m1_518400_408000 n1_m1_523200_408000 5.356235
R11515 n1_m1_523200_408000 n1_m1_528000_408000 5.356235
R11516 n1_m1_528000_408000 n1_m1_532800_408000 5.356235
R11517 n1_m1_532800_408000 n1_m1_536000_408000 3.570824
R11518 n1_m1_537600_408000 n1_m1_536000_408000 1.785412
R11519 n1_m1_537600_408000 n1_m1_542400_408000 5.356235
R11520 n1_m1_542400_408000 n1_m1_547200_408000 5.356235
R11521 n1_m1_547200_408000 n1_m1_552000_408000 5.356235
R11522 n1_m1_552000_408000 n1_m1_556800_408000 5.356235
R11523 n1_m1_556800_408000 n1_m1_561600_408000 5.356235
R11524 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R11525 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R11526 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R11527 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R11528 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R11529 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R11530 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R11531 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R11532 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R11533 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R11534 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R11535 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R11536 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R11537 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R11538 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R11539 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R11540 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R11541 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R11542 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R11543 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R11544 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R11545 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R11546 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R11547 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R11548 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R11549 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R11550 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R11551 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R11552 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R11553 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R11554 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R11555 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R11556 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R11557 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R11558 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R11559 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R11560 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R11561 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R11562 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R11563 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R11564 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R11565 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R11566 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R11567 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R11568 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R11569 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R11570 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R11571 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R11572 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R11573 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R11574 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R11575 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R11576 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R11577 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R11578 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R11579 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R11580 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R11581 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R11582 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R11583 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R11584 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R11585 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R11586 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R11587 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R11588 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R11589 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R11590 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R11591 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R11592 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R11593 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R11594 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R11595 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R11596 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R11597 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R11598 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R11599 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R11600 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R11601 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R11602 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R11603 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R11604 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R11605 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R11606 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R11607 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R11608 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R11609 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R11610 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R11611 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R11612 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R11613 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R11614 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R11615 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R11616 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R11617 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R11618 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R11619 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R11620 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R11621 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R11622 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R11623 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R11624 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R11625 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R11626 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R11627 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R11628 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R11629 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R11630 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R11631 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R11632 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R11633 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R11634 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R11635 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R11636 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R11637 n1_m1_470400_412800 n1_m1_475200_412800 5.356235
R11638 n1_m1_475200_412800 n1_m1_480000_412800 5.356235
R11639 n1_m1_480000_412800 n1_m1_484800_412800 5.356235
R11640 n1_m1_484800_412800 n1_m1_489600_412800 5.356235
R11641 n1_m1_489600_412800 n1_m1_494400_412800 5.356235
R11642 n1_m1_494400_412800 n1_m1_499200_412800 5.356235
R11643 n1_m1_499200_412800 n1_m1_504000_412800 5.356235
R11644 n1_m1_504000_412800 n1_m1_508000_412800 4.463529
R11645 n1_m1_508800_412800 n1_m1_508000_412800 0.892706
R11646 n1_m1_508800_412800 n1_m1_513600_412800 5.356235
R11647 n1_m1_513600_412800 n1_m1_518400_412800 5.356235
R11648 n1_m1_518400_412800 n1_m1_523200_412800 5.356235
R11649 n1_m1_523200_412800 n1_m1_528000_412800 5.356235
R11650 n1_m1_528000_412800 n1_m1_532800_412800 5.356235
R11651 n1_m1_532800_412800 n1_m1_536000_412800 3.570824
R11652 n1_m1_537600_412800 n1_m1_536000_412800 1.785412
R11653 n1_m1_537600_412800 n1_m1_542400_412800 5.356235
R11654 n1_m1_542400_412800 n1_m1_547200_412800 5.356235
R11655 n1_m1_547200_412800 n1_m1_552000_412800 5.356235
R11656 n1_m1_552000_412800 n1_m1_556800_412800 5.356235
R11657 n1_m1_556800_412800 n1_m1_561600_412800 5.356235
R11658 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R11659 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R11660 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R11661 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R11662 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R11663 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R11664 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R11665 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R11666 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R11667 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R11668 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R11669 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R11670 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R11671 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R11672 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R11673 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R11674 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R11675 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R11676 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R11677 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R11678 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R11679 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R11680 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R11681 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R11682 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R11683 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R11684 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R11685 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R11686 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R11687 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R11688 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R11689 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R11690 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R11691 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R11692 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R11693 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R11694 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R11695 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R11696 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R11697 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R11698 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R11699 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R11700 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R11701 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R11702 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R11703 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R11704 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R11705 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R11706 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R11707 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R11708 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R11709 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R11710 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R11711 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R11712 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R11713 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R11714 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R11715 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R11716 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R11717 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R11718 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R11719 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R11720 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R11721 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R11722 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R11723 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R11724 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R11725 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R11726 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R11727 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R11728 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R11729 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R11730 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R11731 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R11732 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R11733 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R11734 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R11735 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R11736 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R11737 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R11738 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R11739 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R11740 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R11741 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R11742 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R11743 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R11744 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R11745 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R11746 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R11747 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R11748 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R11749 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R11750 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R11751 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R11752 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R11753 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R11754 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R11755 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R11756 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R11757 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R11758 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R11759 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R11760 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R11761 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R11762 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R11763 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R11764 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R11765 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R11766 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R11767 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R11768 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R11769 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R11770 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R11771 n1_m1_470400_417600 n1_m1_475200_417600 5.356235
R11772 n1_m1_475200_417600 n1_m1_480000_417600 5.356235
R11773 n1_m1_480000_417600 n1_m1_484800_417600 5.356235
R11774 n1_m1_484800_417600 n1_m1_489600_417600 5.356235
R11775 n1_m1_489600_417600 n1_m1_494400_417600 5.356235
R11776 n1_m1_494400_417600 n1_m1_499200_417600 5.356235
R11777 n1_m1_499200_417600 n1_m1_504000_417600 5.356235
R11778 n1_m1_504000_417600 n1_m1_508000_417600 4.463529
R11779 n1_m1_508800_417600 n1_m1_508000_417600 0.892706
R11780 n1_m1_508800_417600 n1_m1_513600_417600 5.356235
R11781 n1_m1_513600_417600 n1_m1_518400_417600 5.356235
R11782 n1_m1_518400_417600 n1_m1_523200_417600 5.356235
R11783 n1_m1_523200_417600 n1_m1_528000_417600 5.356235
R11784 n1_m1_528000_417600 n1_m1_532800_417600 5.356235
R11785 n1_m1_532800_417600 n1_m1_536000_417600 3.570824
R11786 n1_m1_537600_417600 n1_m1_536000_417600 1.785412
R11787 n1_m1_537600_417600 n1_m1_542400_417600 5.356235
R11788 n1_m1_542400_417600 n1_m1_547200_417600 5.356235
R11789 n1_m1_547200_417600 n1_m1_552000_417600 5.356235
R11790 n1_m1_552000_417600 n1_m1_556800_417600 5.356235
R11791 n1_m1_556800_417600 n1_m1_561600_417600 5.356235
R11792 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R11793 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R11794 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R11795 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R11796 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R11797 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R11798 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R11799 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R11800 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R11801 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R11802 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R11803 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R11804 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R11805 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R11806 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R11807 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R11808 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R11809 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R11810 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R11811 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R11812 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R11813 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R11814 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R11815 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R11816 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R11817 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R11818 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R11819 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R11820 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R11821 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R11822 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R11823 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R11824 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R11825 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R11826 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R11827 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R11828 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R11829 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R11830 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R11831 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R11832 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R11833 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R11834 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R11835 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R11836 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R11837 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R11838 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R11839 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R11840 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R11841 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R11842 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R11843 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R11844 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R11845 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R11846 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R11847 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R11848 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R11849 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R11850 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R11851 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R11852 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R11853 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R11854 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R11855 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R11856 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R11857 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R11858 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R11859 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R11860 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R11861 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R11862 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R11863 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R11864 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R11865 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R11866 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R11867 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R11868 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R11869 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R11870 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R11871 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R11872 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R11873 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R11874 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R11875 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R11876 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R11877 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R11878 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R11879 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R11880 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R11881 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R11882 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R11883 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R11884 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R11885 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R11886 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R11887 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R11888 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R11889 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R11890 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R11891 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R11892 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R11893 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R11894 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R11895 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R11896 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R11897 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R11898 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R11899 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R11900 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R11901 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R11902 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R11903 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R11904 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R11905 n1_m1_470400_422400 n1_m1_475200_422400 5.356235
R11906 n1_m1_475200_422400 n1_m1_480000_422400 5.356235
R11907 n1_m1_480000_422400 n1_m1_484800_422400 5.356235
R11908 n1_m1_484800_422400 n1_m1_489600_422400 5.356235
R11909 n1_m1_489600_422400 n1_m1_494400_422400 5.356235
R11910 n1_m1_494400_422400 n1_m1_499200_422400 5.356235
R11911 n1_m1_499200_422400 n1_m1_504000_422400 5.356235
R11912 n1_m1_504000_422400 n1_m1_508000_422400 4.463529
R11913 n1_m1_508800_422400 n1_m1_508000_422400 0.892706
R11914 n1_m1_508800_422400 n1_m1_513600_422400 5.356235
R11915 n1_m1_513600_422400 n1_m1_518400_422400 5.356235
R11916 n1_m1_518400_422400 n1_m1_523200_422400 5.356235
R11917 n1_m1_523200_422400 n1_m1_528000_422400 5.356235
R11918 n1_m1_528000_422400 n1_m1_532800_422400 5.356235
R11919 n1_m1_532800_422400 n1_m1_536000_422400 3.570824
R11920 n1_m1_537600_422400 n1_m1_536000_422400 1.785412
R11921 n1_m1_537600_422400 n1_m1_542400_422400 5.356235
R11922 n1_m1_542400_422400 n1_m1_547200_422400 5.356235
R11923 n1_m1_547200_422400 n1_m1_552000_422400 5.356235
R11924 n1_m1_552000_422400 n1_m1_556800_422400 5.356235
R11925 n1_m1_556800_422400 n1_m1_561600_422400 5.356235
R11926 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R11927 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R11928 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R11929 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R11930 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R11931 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R11932 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R11933 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R11934 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R11935 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R11936 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R11937 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R11938 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R11939 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R11940 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R11941 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R11942 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R11943 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R11944 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R11945 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R11946 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R11947 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R11948 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R11949 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R11950 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R11951 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R11952 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R11953 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R11954 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R11955 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R11956 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R11957 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R11958 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R11959 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R11960 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R11961 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R11962 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R11963 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R11964 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R11965 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R11966 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R11967 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R11968 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R11969 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R11970 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R11971 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R11972 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R11973 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R11974 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R11975 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R11976 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R11977 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R11978 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R11979 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R11980 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R11981 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R11982 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R11983 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R11984 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R11985 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R11986 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R11987 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R11988 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R11989 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R11990 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R11991 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R11992 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R11993 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R11994 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R11995 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R11996 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R11997 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R11998 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R11999 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R12000 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R12001 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R12002 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R12003 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R12004 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R12005 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R12006 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R12007 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R12008 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R12009 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R12010 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R12011 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R12012 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R12013 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R12014 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R12015 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R12016 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R12017 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R12018 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R12019 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R12020 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R12021 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R12022 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R12023 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R12024 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R12025 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R12026 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R12027 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R12028 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R12029 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R12030 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R12031 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R12032 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R12033 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R12034 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R12035 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R12036 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R12037 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R12038 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R12039 n1_m1_470400_427200 n1_m1_475200_427200 5.356235
R12040 n1_m1_475200_427200 n1_m1_480000_427200 5.356235
R12041 n1_m1_480000_427200 n1_m1_484800_427200 5.356235
R12042 n1_m1_484800_427200 n1_m1_489600_427200 5.356235
R12043 n1_m1_489600_427200 n1_m1_494400_427200 5.356235
R12044 n1_m1_494400_427200 n1_m1_499200_427200 5.356235
R12045 n1_m1_499200_427200 n1_m1_504000_427200 5.356235
R12046 n1_m1_504000_427200 n1_m1_508000_427200 4.463529
R12047 n1_m1_508800_427200 n1_m1_508000_427200 0.892706
R12048 n1_m1_508800_427200 n1_m1_513600_427200 5.356235
R12049 n1_m1_513600_427200 n1_m1_518400_427200 5.356235
R12050 n1_m1_518400_427200 n1_m1_523200_427200 5.356235
R12051 n1_m1_523200_427200 n1_m1_528000_427200 5.356235
R12052 n1_m1_528000_427200 n1_m1_532800_427200 5.356235
R12053 n1_m1_532800_427200 n1_m1_536000_427200 3.570824
R12054 n1_m1_537600_427200 n1_m1_536000_427200 1.785412
R12055 n1_m1_537600_427200 n1_m1_542400_427200 5.356235
R12056 n1_m1_542400_427200 n1_m1_547200_427200 5.356235
R12057 n1_m1_547200_427200 n1_m1_552000_427200 5.356235
R12058 n1_m1_552000_427200 n1_m1_556800_427200 5.356235
R12059 n1_m1_556800_427200 n1_m1_561600_427200 5.356235
R12060 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R12061 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R12062 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R12063 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R12064 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R12065 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R12066 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R12067 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R12068 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R12069 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R12070 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R12071 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R12072 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R12073 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R12074 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R12075 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R12076 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R12077 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R12078 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R12079 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R12080 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R12081 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R12082 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R12083 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R12084 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R12085 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R12086 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R12087 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R12088 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R12089 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R12090 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R12091 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R12092 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R12093 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R12094 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R12095 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R12096 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R12097 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R12098 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R12099 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R12100 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R12101 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R12102 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R12103 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R12104 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R12105 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R12106 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R12107 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R12108 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R12109 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R12110 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R12111 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R12112 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R12113 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R12114 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R12115 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R12116 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R12117 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R12118 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R12119 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R12120 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R12121 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R12122 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R12123 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R12124 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R12125 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R12126 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R12127 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R12128 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R12129 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R12130 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R12131 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R12132 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R12133 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R12134 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R12135 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R12136 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R12137 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R12138 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R12139 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R12140 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R12141 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R12142 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R12143 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R12144 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R12145 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R12146 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R12147 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R12148 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R12149 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R12150 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R12151 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R12152 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R12153 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R12154 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R12155 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R12156 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R12157 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R12158 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R12159 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R12160 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R12161 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R12162 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R12163 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R12164 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R12165 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R12166 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R12167 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R12168 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R12169 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R12170 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R12171 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R12172 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R12173 n1_m1_470400_432000 n1_m1_475200_432000 5.356235
R12174 n1_m1_475200_432000 n1_m1_480000_432000 5.356235
R12175 n1_m1_480000_432000 n1_m1_484800_432000 5.356235
R12176 n1_m1_484800_432000 n1_m1_489600_432000 5.356235
R12177 n1_m1_489600_432000 n1_m1_494400_432000 5.356235
R12178 n1_m1_494400_432000 n1_m1_499200_432000 5.356235
R12179 n1_m1_499200_432000 n1_m1_504000_432000 5.356235
R12180 n1_m1_504000_432000 n1_m1_508000_432000 4.463529
R12181 n1_m1_508800_432000 n1_m1_508000_432000 0.892706
R12182 n1_m1_508800_432000 n1_m1_513600_432000 5.356235
R12183 n1_m1_513600_432000 n1_m1_518400_432000 5.356235
R12184 n1_m1_518400_432000 n1_m1_523200_432000 5.356235
R12185 n1_m1_523200_432000 n1_m1_528000_432000 5.356235
R12186 n1_m1_528000_432000 n1_m1_532800_432000 5.356235
R12187 n1_m1_532800_432000 n1_m1_536000_432000 3.570824
R12188 n1_m1_537600_432000 n1_m1_536000_432000 1.785412
R12189 n1_m1_537600_432000 n1_m1_542400_432000 5.356235
R12190 n1_m1_542400_432000 n1_m1_547200_432000 5.356235
R12191 n1_m1_547200_432000 n1_m1_552000_432000 5.356235
R12192 n1_m1_552000_432000 n1_m1_556800_432000 5.356235
R12193 n1_m1_556800_432000 n1_m1_561600_432000 5.356235
R12194 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R12195 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R12196 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R12197 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R12198 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R12199 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R12200 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R12201 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R12202 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R12203 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R12204 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R12205 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R12206 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R12207 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R12208 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R12209 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R12210 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R12211 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R12212 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R12213 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R12214 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R12215 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R12216 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R12217 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R12218 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R12219 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R12220 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R12221 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R12222 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R12223 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R12224 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R12225 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R12226 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R12227 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R12228 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R12229 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R12230 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R12231 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R12232 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R12233 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R12234 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R12235 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R12236 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R12237 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R12238 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R12239 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R12240 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R12241 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R12242 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R12243 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R12244 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R12245 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R12246 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R12247 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R12248 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R12249 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R12250 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R12251 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R12252 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R12253 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R12254 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R12255 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R12256 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R12257 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R12258 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R12259 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R12260 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R12261 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R12262 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R12263 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R12264 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R12265 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R12266 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R12267 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R12268 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R12269 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R12270 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R12271 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R12272 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R12273 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R12274 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R12275 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R12276 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R12277 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R12278 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R12279 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R12280 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R12281 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R12282 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R12283 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R12284 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R12285 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R12286 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R12287 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R12288 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R12289 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R12290 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R12291 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R12292 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R12293 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R12294 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R12295 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R12296 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R12297 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R12298 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R12299 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R12300 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R12301 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R12302 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R12303 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R12304 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R12305 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R12306 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R12307 n1_m1_470400_436800 n1_m1_475200_436800 5.356235
R12308 n1_m1_475200_436800 n1_m1_480000_436800 5.356235
R12309 n1_m1_480000_436800 n1_m1_484800_436800 5.356235
R12310 n1_m1_484800_436800 n1_m1_489600_436800 5.356235
R12311 n1_m1_489600_436800 n1_m1_494400_436800 5.356235
R12312 n1_m1_494400_436800 n1_m1_499200_436800 5.356235
R12313 n1_m1_499200_436800 n1_m1_504000_436800 5.356235
R12314 n1_m1_504000_436800 n1_m1_508000_436800 4.463529
R12315 n1_m1_508800_436800 n1_m1_508000_436800 0.892706
R12316 n1_m1_508800_436800 n1_m1_513600_436800 5.356235
R12317 n1_m1_513600_436800 n1_m1_518400_436800 5.356235
R12318 n1_m1_518400_436800 n1_m1_523200_436800 5.356235
R12319 n1_m1_523200_436800 n1_m1_528000_436800 5.356235
R12320 n1_m1_528000_436800 n1_m1_532800_436800 5.356235
R12321 n1_m1_532800_436800 n1_m1_536000_436800 3.570824
R12322 n1_m1_537600_436800 n1_m1_536000_436800 1.785412
R12323 n1_m1_537600_436800 n1_m1_542400_436800 5.356235
R12324 n1_m1_542400_436800 n1_m1_547200_436800 5.356235
R12325 n1_m1_547200_436800 n1_m1_552000_436800 5.356235
R12326 n1_m1_552000_436800 n1_m1_556800_436800 5.356235
R12327 n1_m1_556800_436800 n1_m1_561600_436800 5.356235
R12328 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R12329 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R12330 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R12331 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R12332 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R12333 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R12334 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R12335 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R12336 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R12337 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R12338 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R12339 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R12340 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R12341 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R12342 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R12343 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R12344 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R12345 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R12346 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R12347 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R12348 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R12349 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R12350 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R12351 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R12352 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R12353 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R12354 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R12355 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R12356 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R12357 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R12358 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R12359 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R12360 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R12361 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R12362 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R12363 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R12364 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R12365 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R12366 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R12367 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R12368 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R12369 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R12370 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R12371 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R12372 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R12373 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R12374 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R12375 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R12376 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R12377 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R12378 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R12379 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R12380 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R12381 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R12382 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R12383 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R12384 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R12385 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R12386 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R12387 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R12388 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R12389 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R12390 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R12391 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R12392 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R12393 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R12394 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R12395 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R12396 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R12397 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R12398 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R12399 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R12400 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R12401 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R12402 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R12403 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R12404 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R12405 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R12406 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R12407 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R12408 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R12409 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R12410 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R12411 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R12412 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R12413 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R12414 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R12415 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R12416 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R12417 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R12418 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R12419 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R12420 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R12421 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R12422 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R12423 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R12424 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R12425 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R12426 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R12427 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R12428 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R12429 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R12430 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R12431 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R12432 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R12433 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R12434 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R12435 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R12436 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R12437 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R12438 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R12439 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R12440 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R12441 n1_m1_470400_441600 n1_m1_475200_441600 5.356235
R12442 n1_m1_475200_441600 n1_m1_480000_441600 5.356235
R12443 n1_m1_480000_441600 n1_m1_484800_441600 5.356235
R12444 n1_m1_484800_441600 n1_m1_489600_441600 5.356235
R12445 n1_m1_489600_441600 n1_m1_494400_441600 5.356235
R12446 n1_m1_494400_441600 n1_m1_499200_441600 5.356235
R12447 n1_m1_499200_441600 n1_m1_504000_441600 5.356235
R12448 n1_m1_504000_441600 n1_m1_508000_441600 4.463529
R12449 n1_m1_508800_441600 n1_m1_508000_441600 0.892706
R12450 n1_m1_508800_441600 n1_m1_513600_441600 5.356235
R12451 n1_m1_513600_441600 n1_m1_518400_441600 5.356235
R12452 n1_m1_518400_441600 n1_m1_523200_441600 5.356235
R12453 n1_m1_523200_441600 n1_m1_528000_441600 5.356235
R12454 n1_m1_528000_441600 n1_m1_532800_441600 5.356235
R12455 n1_m1_532800_441600 n1_m1_536000_441600 3.570824
R12456 n1_m1_537600_441600 n1_m1_536000_441600 1.785412
R12457 n1_m1_537600_441600 n1_m1_542400_441600 5.356235
R12458 n1_m1_542400_441600 n1_m1_547200_441600 5.356235
R12459 n1_m1_547200_441600 n1_m1_552000_441600 5.356235
R12460 n1_m1_552000_441600 n1_m1_556800_441600 5.356235
R12461 n1_m1_556800_441600 n1_m1_561600_441600 5.356235
R12462 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R12463 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R12464 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R12465 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R12466 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R12467 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R12468 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R12469 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R12470 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R12471 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R12472 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R12473 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R12474 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R12475 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R12476 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R12477 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R12478 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R12479 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R12480 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R12481 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R12482 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R12483 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R12484 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R12485 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R12486 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R12487 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R12488 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R12489 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R12490 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R12491 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R12492 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R12493 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R12494 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R12495 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R12496 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R12497 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R12498 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R12499 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R12500 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R12501 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R12502 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R12503 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R12504 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R12505 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R12506 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R12507 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R12508 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R12509 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R12510 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R12511 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R12512 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R12513 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R12514 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R12515 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R12516 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R12517 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R12518 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R12519 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R12520 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R12521 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R12522 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R12523 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R12524 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R12525 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R12526 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R12527 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R12528 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R12529 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R12530 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R12531 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R12532 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R12533 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R12534 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R12535 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R12536 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R12537 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R12538 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R12539 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R12540 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R12541 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R12542 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R12543 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R12544 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R12545 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R12546 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R12547 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R12548 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R12549 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R12550 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R12551 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R12552 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R12553 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R12554 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R12555 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R12556 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R12557 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R12558 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R12559 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R12560 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R12561 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R12562 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R12563 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R12564 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R12565 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R12566 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R12567 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R12568 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R12569 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R12570 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R12571 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R12572 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R12573 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R12574 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R12575 n1_m1_470400_446400 n1_m1_475200_446400 5.356235
R12576 n1_m1_475200_446400 n1_m1_480000_446400 5.356235
R12577 n1_m1_480000_446400 n1_m1_484800_446400 5.356235
R12578 n1_m1_484800_446400 n1_m1_489600_446400 5.356235
R12579 n1_m1_489600_446400 n1_m1_494400_446400 5.356235
R12580 n1_m1_494400_446400 n1_m1_499200_446400 5.356235
R12581 n1_m1_499200_446400 n1_m1_504000_446400 5.356235
R12582 n1_m1_504000_446400 n1_m1_508000_446400 4.463529
R12583 n1_m1_508800_446400 n1_m1_508000_446400 0.892706
R12584 n1_m1_508800_446400 n1_m1_513600_446400 5.356235
R12585 n1_m1_513600_446400 n1_m1_518400_446400 5.356235
R12586 n1_m1_518400_446400 n1_m1_523200_446400 5.356235
R12587 n1_m1_523200_446400 n1_m1_528000_446400 5.356235
R12588 n1_m1_528000_446400 n1_m1_532800_446400 5.356235
R12589 n1_m1_532800_446400 n1_m1_536000_446400 3.570824
R12590 n1_m1_537600_446400 n1_m1_536000_446400 1.785412
R12591 n1_m1_537600_446400 n1_m1_542400_446400 5.356235
R12592 n1_m1_542400_446400 n1_m1_547200_446400 5.356235
R12593 n1_m1_547200_446400 n1_m1_552000_446400 5.356235
R12594 n1_m1_552000_446400 n1_m1_556800_446400 5.356235
R12595 n1_m1_556800_446400 n1_m1_561600_446400 5.356235
R12596 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R12597 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R12598 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R12599 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R12600 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R12601 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R12602 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R12603 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R12604 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R12605 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R12606 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R12607 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R12608 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R12609 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R12610 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R12611 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R12612 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R12613 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R12614 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R12615 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R12616 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R12617 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R12618 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R12619 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R12620 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R12621 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R12622 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R12623 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R12624 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R12625 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R12626 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R12627 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R12628 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R12629 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R12630 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R12631 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R12632 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R12633 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R12634 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R12635 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R12636 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R12637 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R12638 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R12639 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R12640 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R12641 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R12642 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R12643 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R12644 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R12645 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R12646 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R12647 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R12648 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R12649 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R12650 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R12651 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R12652 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R12653 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R12654 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R12655 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R12656 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R12657 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R12658 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R12659 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R12660 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R12661 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R12662 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R12663 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R12664 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R12665 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R12666 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R12667 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R12668 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R12669 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R12670 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R12671 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R12672 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R12673 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R12674 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R12675 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R12676 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R12677 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R12678 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R12679 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R12680 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R12681 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R12682 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R12683 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R12684 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R12685 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R12686 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R12687 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R12688 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R12689 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R12690 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R12691 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R12692 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R12693 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R12694 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R12695 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R12696 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R12697 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R12698 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R12699 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R12700 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R12701 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R12702 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R12703 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R12704 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R12705 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R12706 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R12707 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R12708 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R12709 n1_m1_470400_451200 n1_m1_475200_451200 5.356235
R12710 n1_m1_475200_451200 n1_m1_480000_451200 5.356235
R12711 n1_m1_480000_451200 n1_m1_484800_451200 5.356235
R12712 n1_m1_484800_451200 n1_m1_489600_451200 5.356235
R12713 n1_m1_489600_451200 n1_m1_494400_451200 5.356235
R12714 n1_m1_494400_451200 n1_m1_499200_451200 5.356235
R12715 n1_m1_499200_451200 n1_m1_504000_451200 5.356235
R12716 n1_m1_504000_451200 n1_m1_508000_451200 4.463529
R12717 n1_m1_508800_451200 n1_m1_508000_451200 0.892706
R12718 n1_m1_508800_451200 n1_m1_513600_451200 5.356235
R12719 n1_m1_513600_451200 n1_m1_518400_451200 5.356235
R12720 n1_m1_518400_451200 n1_m1_523200_451200 5.356235
R12721 n1_m1_523200_451200 n1_m1_528000_451200 5.356235
R12722 n1_m1_528000_451200 n1_m1_532800_451200 5.356235
R12723 n1_m1_532800_451200 n1_m1_536000_451200 3.570824
R12724 n1_m1_537600_451200 n1_m1_536000_451200 1.785412
R12725 n1_m1_537600_451200 n1_m1_542400_451200 5.356235
R12726 n1_m1_542400_451200 n1_m1_547200_451200 5.356235
R12727 n1_m1_547200_451200 n1_m1_552000_451200 5.356235
R12728 n1_m1_552000_451200 n1_m1_556800_451200 5.356235
R12729 n1_m1_556800_451200 n1_m1_561600_451200 5.356235
R12730 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R12731 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R12732 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R12733 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R12734 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R12735 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R12736 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R12737 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R12738 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R12739 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R12740 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R12741 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R12742 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R12743 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R12744 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R12745 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R12746 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R12747 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R12748 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R12749 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R12750 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R12751 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R12752 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R12753 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R12754 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R12755 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R12756 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R12757 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R12758 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R12759 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R12760 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R12761 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R12762 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R12763 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R12764 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R12765 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R12766 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R12767 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R12768 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R12769 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R12770 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R12771 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R12772 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R12773 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R12774 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R12775 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R12776 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R12777 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R12778 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R12779 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R12780 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R12781 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R12782 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R12783 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R12784 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R12785 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R12786 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R12787 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R12788 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R12789 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R12790 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R12791 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R12792 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R12793 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R12794 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R12795 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R12796 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R12797 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R12798 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R12799 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R12800 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R12801 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R12802 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R12803 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R12804 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R12805 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R12806 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R12807 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R12808 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R12809 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R12810 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R12811 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R12812 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R12813 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R12814 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R12815 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R12816 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R12817 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R12818 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R12819 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R12820 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R12821 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R12822 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R12823 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R12824 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R12825 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R12826 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R12827 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R12828 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R12829 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R12830 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R12831 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R12832 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R12833 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R12834 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R12835 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R12836 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R12837 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R12838 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R12839 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R12840 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R12841 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R12842 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R12843 n1_m1_470400_456000 n1_m1_475200_456000 5.356235
R12844 n1_m1_475200_456000 n1_m1_480000_456000 5.356235
R12845 n1_m1_480000_456000 n1_m1_484800_456000 5.356235
R12846 n1_m1_484800_456000 n1_m1_489600_456000 5.356235
R12847 n1_m1_489600_456000 n1_m1_494400_456000 5.356235
R12848 n1_m1_494400_456000 n1_m1_499200_456000 5.356235
R12849 n1_m1_499200_456000 n1_m1_504000_456000 5.356235
R12850 n1_m1_504000_456000 n1_m1_508000_456000 4.463529
R12851 n1_m1_508800_456000 n1_m1_508000_456000 0.892706
R12852 n1_m1_508800_456000 n1_m1_513600_456000 5.356235
R12853 n1_m1_513600_456000 n1_m1_518400_456000 5.356235
R12854 n1_m1_518400_456000 n1_m1_523200_456000 5.356235
R12855 n1_m1_523200_456000 n1_m1_528000_456000 5.356235
R12856 n1_m1_528000_456000 n1_m1_532800_456000 5.356235
R12857 n1_m1_532800_456000 n1_m1_536000_456000 3.570824
R12858 n1_m1_537600_456000 n1_m1_536000_456000 1.785412
R12859 n1_m1_537600_456000 n1_m1_542400_456000 5.356235
R12860 n1_m1_542400_456000 n1_m1_547200_456000 5.356235
R12861 n1_m1_547200_456000 n1_m1_552000_456000 5.356235
R12862 n1_m1_552000_456000 n1_m1_556800_456000 5.356235
R12863 n1_m1_556800_456000 n1_m1_561600_456000 5.356235
R12864 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R12865 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R12866 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R12867 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R12868 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R12869 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R12870 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R12871 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R12872 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R12873 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R12874 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R12875 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R12876 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R12877 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R12878 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R12879 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R12880 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R12881 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R12882 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R12883 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R12884 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R12885 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R12886 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R12887 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R12888 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R12889 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R12890 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R12891 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R12892 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R12893 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R12894 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R12895 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R12896 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R12897 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R12898 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R12899 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R12900 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R12901 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R12902 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R12903 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R12904 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R12905 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R12906 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R12907 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R12908 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R12909 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R12910 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R12911 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R12912 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R12913 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R12914 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R12915 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R12916 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R12917 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R12918 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R12919 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R12920 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R12921 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R12922 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R12923 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R12924 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R12925 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R12926 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R12927 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R12928 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R12929 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R12930 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R12931 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R12932 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R12933 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R12934 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R12935 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R12936 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R12937 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R12938 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R12939 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R12940 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R12941 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R12942 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R12943 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R12944 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R12945 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R12946 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R12947 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R12948 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R12949 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R12950 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R12951 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R12952 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R12953 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R12954 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R12955 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R12956 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R12957 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R12958 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R12959 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R12960 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R12961 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R12962 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R12963 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R12964 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R12965 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R12966 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R12967 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R12968 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R12969 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R12970 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R12971 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R12972 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R12973 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R12974 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R12975 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R12976 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R12977 n1_m1_470400_460800 n1_m1_475200_460800 5.356235
R12978 n1_m1_475200_460800 n1_m1_480000_460800 5.356235
R12979 n1_m1_480000_460800 n1_m1_484800_460800 5.356235
R12980 n1_m1_484800_460800 n1_m1_489600_460800 5.356235
R12981 n1_m1_489600_460800 n1_m1_494400_460800 5.356235
R12982 n1_m1_494400_460800 n1_m1_499200_460800 5.356235
R12983 n1_m1_499200_460800 n1_m1_504000_460800 5.356235
R12984 n1_m1_504000_460800 n1_m1_508000_460800 4.463529
R12985 n1_m1_508800_460800 n1_m1_508000_460800 0.892706
R12986 n1_m1_508800_460800 n1_m1_513600_460800 5.356235
R12987 n1_m1_513600_460800 n1_m1_518400_460800 5.356235
R12988 n1_m1_518400_460800 n1_m1_523200_460800 5.356235
R12989 n1_m1_523200_460800 n1_m1_528000_460800 5.356235
R12990 n1_m1_528000_460800 n1_m1_532800_460800 5.356235
R12991 n1_m1_532800_460800 n1_m1_536000_460800 3.570824
R12992 n1_m1_537600_460800 n1_m1_536000_460800 1.785412
R12993 n1_m1_537600_460800 n1_m1_542400_460800 5.356235
R12994 n1_m1_542400_460800 n1_m1_547200_460800 5.356235
R12995 n1_m1_547200_460800 n1_m1_552000_460800 5.356235
R12996 n1_m1_552000_460800 n1_m1_556800_460800 5.356235
R12997 n1_m1_556800_460800 n1_m1_561600_460800 5.356235
R12998 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R12999 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R13000 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R13001 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R13002 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R13003 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R13004 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R13005 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R13006 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R13007 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R13008 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R13009 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R13010 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R13011 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R13012 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R13013 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R13014 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R13015 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R13016 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R13017 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R13018 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R13019 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R13020 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R13021 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R13022 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R13023 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R13024 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R13025 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R13026 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R13027 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R13028 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R13029 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R13030 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R13031 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R13032 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R13033 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R13034 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R13035 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R13036 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R13037 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R13038 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R13039 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R13040 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R13041 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R13042 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R13043 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R13044 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R13045 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R13046 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R13047 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R13048 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R13049 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R13050 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R13051 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R13052 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R13053 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R13054 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R13055 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R13056 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R13057 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R13058 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R13059 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R13060 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R13061 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R13062 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R13063 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R13064 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R13065 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R13066 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R13067 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R13068 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R13069 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R13070 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R13071 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R13072 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R13073 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R13074 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R13075 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R13076 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R13077 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R13078 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R13079 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R13080 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R13081 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R13082 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R13083 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R13084 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R13085 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R13086 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R13087 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R13088 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R13089 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R13090 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R13091 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R13092 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R13093 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R13094 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R13095 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R13096 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R13097 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R13098 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R13099 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R13100 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R13101 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R13102 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R13103 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R13104 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R13105 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R13106 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R13107 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R13108 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R13109 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R13110 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R13111 n1_m1_470400_465600 n1_m1_475200_465600 5.356235
R13112 n1_m1_475200_465600 n1_m1_480000_465600 5.356235
R13113 n1_m1_480000_465600 n1_m1_484800_465600 5.356235
R13114 n1_m1_484800_465600 n1_m1_489600_465600 5.356235
R13115 n1_m1_489600_465600 n1_m1_494400_465600 5.356235
R13116 n1_m1_494400_465600 n1_m1_499200_465600 5.356235
R13117 n1_m1_499200_465600 n1_m1_504000_465600 5.356235
R13118 n1_m1_504000_465600 n1_m1_508000_465600 4.463529
R13119 n1_m1_508800_465600 n1_m1_508000_465600 0.892706
R13120 n1_m1_508800_465600 n1_m1_513600_465600 5.356235
R13121 n1_m1_513600_465600 n1_m1_518400_465600 5.356235
R13122 n1_m1_518400_465600 n1_m1_523200_465600 5.356235
R13123 n1_m1_523200_465600 n1_m1_528000_465600 5.356235
R13124 n1_m1_528000_465600 n1_m1_532800_465600 5.356235
R13125 n1_m1_532800_465600 n1_m1_536000_465600 3.570824
R13126 n1_m1_537600_465600 n1_m1_536000_465600 1.785412
R13127 n1_m1_537600_465600 n1_m1_542400_465600 5.356235
R13128 n1_m1_542400_465600 n1_m1_547200_465600 5.356235
R13129 n1_m1_547200_465600 n1_m1_552000_465600 5.356235
R13130 n1_m1_552000_465600 n1_m1_556800_465600 5.356235
R13131 n1_m1_556800_465600 n1_m1_561600_465600 5.356235
R13132 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R13133 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R13134 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R13135 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R13136 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R13137 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R13138 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R13139 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R13140 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R13141 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R13142 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R13143 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R13144 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R13145 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R13146 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R13147 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R13148 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R13149 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R13150 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R13151 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R13152 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R13153 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R13154 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R13155 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R13156 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R13157 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R13158 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R13159 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R13160 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R13161 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R13162 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R13163 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R13164 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R13165 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R13166 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R13167 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R13168 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R13169 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R13170 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R13171 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R13172 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R13173 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R13174 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R13175 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R13176 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R13177 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R13178 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R13179 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R13180 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R13181 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R13182 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R13183 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R13184 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R13185 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R13186 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R13187 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R13188 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R13189 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R13190 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R13191 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R13192 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R13193 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R13194 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R13195 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R13196 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R13197 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R13198 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R13199 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R13200 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R13201 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R13202 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R13203 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R13204 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R13205 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R13206 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R13207 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R13208 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R13209 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R13210 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R13211 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R13212 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R13213 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R13214 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R13215 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R13216 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R13217 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R13218 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R13219 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R13220 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R13221 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R13222 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R13223 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R13224 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R13225 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R13226 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R13227 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R13228 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R13229 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R13230 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R13231 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R13232 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R13233 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R13234 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R13235 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R13236 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R13237 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R13238 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R13239 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R13240 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R13241 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R13242 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R13243 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R13244 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R13245 n1_m1_470400_470400 n1_m1_475200_470400 5.356235
R13246 n1_m1_475200_470400 n1_m1_480000_470400 5.356235
R13247 n1_m1_480000_470400 n1_m1_484800_470400 5.356235
R13248 n1_m1_484800_470400 n1_m1_489600_470400 5.356235
R13249 n1_m1_489600_470400 n1_m1_494400_470400 5.356235
R13250 n1_m1_494400_470400 n1_m1_499200_470400 5.356235
R13251 n1_m1_499200_470400 n1_m1_504000_470400 5.356235
R13252 n1_m1_504000_470400 n1_m1_508000_470400 4.463529
R13253 n1_m1_508800_470400 n1_m1_508000_470400 0.892706
R13254 n1_m1_508800_470400 n1_m1_513600_470400 5.356235
R13255 n1_m1_513600_470400 n1_m1_518400_470400 5.356235
R13256 n1_m1_518400_470400 n1_m1_523200_470400 5.356235
R13257 n1_m1_523200_470400 n1_m1_528000_470400 5.356235
R13258 n1_m1_528000_470400 n1_m1_532800_470400 5.356235
R13259 n1_m1_532800_470400 n1_m1_536000_470400 3.570824
R13260 n1_m1_537600_470400 n1_m1_536000_470400 1.785412
R13261 n1_m1_537600_470400 n1_m1_542400_470400 5.356235
R13262 n1_m1_542400_470400 n1_m1_547200_470400 5.356235
R13263 n1_m1_547200_470400 n1_m1_552000_470400 5.356235
R13264 n1_m1_552000_470400 n1_m1_556800_470400 5.356235
R13265 n1_m1_556800_470400 n1_m1_561600_470400 5.356235
R13266 n1_m1_0_475200 n1_m1_4000_475200 4.463529
R13267 n1_m1_4800_475200 n1_m1_4000_475200 0.892706
R13268 n1_m1_4800_475200 n1_m1_9600_475200 5.356235
R13269 n1_m1_9600_475200 n1_m1_14400_475200 5.356235
R13270 n1_m1_14400_475200 n1_m1_19200_475200 5.356235
R13271 n1_m1_19200_475200 n1_m1_24000_475200 5.356235
R13272 n1_m1_24000_475200 n1_m1_28800_475200 5.356235
R13273 n1_m1_28800_475200 n1_m1_32000_475200 3.570824
R13274 n1_m1_33600_475200 n1_m1_32000_475200 1.785412
R13275 n1_m1_33600_475200 n1_m1_38400_475200 5.356235
R13276 n1_m1_38400_475200 n1_m1_43200_475200 5.356235
R13277 n1_m1_43200_475200 n1_m1_48000_475200 5.356235
R13278 n1_m1_48000_475200 n1_m1_52800_475200 5.356235
R13279 n1_m1_52800_475200 n1_m1_57600_475200 5.356235
R13280 n1_m1_57600_475200 n1_m1_60000_475200 2.678118
R13281 n1_m1_62400_475200 n1_m1_60000_475200 2.678118
R13282 n1_m1_62400_475200 n1_m1_67200_475200 5.356235
R13283 n1_m1_67200_475200 n1_m1_72000_475200 5.356235
R13284 n1_m1_72000_475200 n1_m1_76800_475200 5.356235
R13285 n1_m1_76800_475200 n1_m1_81600_475200 5.356235
R13286 n1_m1_81600_475200 n1_m1_86400_475200 5.356235
R13287 n1_m1_86400_475200 n1_m1_88000_475200 1.785412
R13288 n1_m1_91200_475200 n1_m1_88000_475200 3.570824
R13289 n1_m1_91200_475200 n1_m1_96000_475200 5.356235
R13290 n1_m1_96000_475200 n1_m1_100800_475200 5.356235
R13291 n1_m1_100800_475200 n1_m1_105600_475200 5.356235
R13292 n1_m1_105600_475200 n1_m1_110400_475200 5.356235
R13293 n1_m1_110400_475200 n1_m1_115200_475200 5.356235
R13294 n1_m1_115200_475200 n1_m1_116000_475200 0.892706
R13295 n1_m1_120000_475200 n1_m1_116000_475200 4.463529
R13296 n1_m1_120000_475200 n1_m1_124800_475200 5.356235
R13297 n1_m1_124800_475200 n1_m1_129600_475200 5.356235
R13298 n1_m1_129600_475200 n1_m1_134400_475200 5.356235
R13299 n1_m1_134400_475200 n1_m1_139200_475200 5.356235
R13300 n1_m1_139200_475200 n1_m1_144000_475200 5.356235
R13301 n1_m1_144000_475200 n1_m1_148800_475200 5.356235
R13302 n1_m1_148800_475200 n1_m1_153600_475200 5.356235
R13303 n1_m1_153600_475200 n1_m1_158400_475200 5.356235
R13304 n1_m1_158400_475200 n1_m1_163200_475200 5.356235
R13305 n1_m1_163200_475200 n1_m1_168000_475200 5.356235
R13306 n1_m1_168000_475200 n1_m1_172000_475200 4.463529
R13307 n1_m1_172800_475200 n1_m1_172000_475200 0.892706
R13308 n1_m1_172800_475200 n1_m1_177600_475200 5.356235
R13309 n1_m1_177600_475200 n1_m1_182400_475200 5.356235
R13310 n1_m1_182400_475200 n1_m1_187200_475200 5.356235
R13311 n1_m1_187200_475200 n1_m1_192000_475200 5.356235
R13312 n1_m1_192000_475200 n1_m1_196800_475200 5.356235
R13313 n1_m1_196800_475200 n1_m1_200000_475200 3.570824
R13314 n1_m1_201600_475200 n1_m1_200000_475200 1.785412
R13315 n1_m1_201600_475200 n1_m1_206400_475200 5.356235
R13316 n1_m1_206400_475200 n1_m1_211200_475200 5.356235
R13317 n1_m1_211200_475200 n1_m1_216000_475200 5.356235
R13318 n1_m1_216000_475200 n1_m1_220800_475200 5.356235
R13319 n1_m1_220800_475200 n1_m1_225600_475200 5.356235
R13320 n1_m1_225600_475200 n1_m1_228000_475200 2.678118
R13321 n1_m1_230400_475200 n1_m1_228000_475200 2.678118
R13322 n1_m1_230400_475200 n1_m1_235200_475200 5.356235
R13323 n1_m1_235200_475200 n1_m1_240000_475200 5.356235
R13324 n1_m1_240000_475200 n1_m1_244800_475200 5.356235
R13325 n1_m1_244800_475200 n1_m1_249600_475200 5.356235
R13326 n1_m1_249600_475200 n1_m1_254400_475200 5.356235
R13327 n1_m1_254400_475200 n1_m1_256000_475200 1.785412
R13328 n1_m1_259200_475200 n1_m1_256000_475200 3.570824
R13329 n1_m1_259200_475200 n1_m1_264000_475200 5.356235
R13330 n1_m1_264000_475200 n1_m1_268800_475200 5.356235
R13331 n1_m1_268800_475200 n1_m1_273600_475200 5.356235
R13332 n1_m1_273600_475200 n1_m1_278400_475200 5.356235
R13333 n1_m1_278400_475200 n1_m1_283200_475200 5.356235
R13334 n1_m1_283200_475200 n1_m1_284000_475200 0.892706
R13335 n1_m1_288000_475200 n1_m1_284000_475200 4.463529
R13336 n1_m1_288000_475200 n1_m1_292800_475200 5.356235
R13337 n1_m1_292800_475200 n1_m1_297600_475200 5.356235
R13338 n1_m1_297600_475200 n1_m1_302400_475200 5.356235
R13339 n1_m1_302400_475200 n1_m1_307200_475200 5.356235
R13340 n1_m1_307200_475200 n1_m1_312000_475200 5.356235
R13341 n1_m1_312000_475200 n1_m1_316800_475200 5.356235
R13342 n1_m1_316800_475200 n1_m1_321600_475200 5.356235
R13343 n1_m1_321600_475200 n1_m1_326400_475200 5.356235
R13344 n1_m1_326400_475200 n1_m1_331200_475200 5.356235
R13345 n1_m1_331200_475200 n1_m1_336000_475200 5.356235
R13346 n1_m1_336000_475200 n1_m1_340000_475200 4.463529
R13347 n1_m1_340800_475200 n1_m1_340000_475200 0.892706
R13348 n1_m1_340800_475200 n1_m1_345600_475200 5.356235
R13349 n1_m1_345600_475200 n1_m1_350400_475200 5.356235
R13350 n1_m1_350400_475200 n1_m1_355200_475200 5.356235
R13351 n1_m1_355200_475200 n1_m1_360000_475200 5.356235
R13352 n1_m1_360000_475200 n1_m1_364800_475200 5.356235
R13353 n1_m1_364800_475200 n1_m1_368000_475200 3.570824
R13354 n1_m1_369600_475200 n1_m1_368000_475200 1.785412
R13355 n1_m1_369600_475200 n1_m1_374400_475200 5.356235
R13356 n1_m1_374400_475200 n1_m1_379200_475200 5.356235
R13357 n1_m1_379200_475200 n1_m1_384000_475200 5.356235
R13358 n1_m1_384000_475200 n1_m1_388800_475200 5.356235
R13359 n1_m1_388800_475200 n1_m1_393600_475200 5.356235
R13360 n1_m1_393600_475200 n1_m1_396000_475200 2.678118
R13361 n1_m1_398400_475200 n1_m1_396000_475200 2.678118
R13362 n1_m1_398400_475200 n1_m1_403200_475200 5.356235
R13363 n1_m1_403200_475200 n1_m1_408000_475200 5.356235
R13364 n1_m1_408000_475200 n1_m1_412800_475200 5.356235
R13365 n1_m1_412800_475200 n1_m1_417600_475200 5.356235
R13366 n1_m1_417600_475200 n1_m1_422400_475200 5.356235
R13367 n1_m1_422400_475200 n1_m1_424000_475200 1.785412
R13368 n1_m1_427200_475200 n1_m1_424000_475200 3.570824
R13369 n1_m1_427200_475200 n1_m1_432000_475200 5.356235
R13370 n1_m1_432000_475200 n1_m1_436800_475200 5.356235
R13371 n1_m1_436800_475200 n1_m1_441600_475200 5.356235
R13372 n1_m1_441600_475200 n1_m1_446400_475200 5.356235
R13373 n1_m1_446400_475200 n1_m1_451200_475200 5.356235
R13374 n1_m1_451200_475200 n1_m1_452000_475200 0.892706
R13375 n1_m1_456000_475200 n1_m1_452000_475200 4.463529
R13376 n1_m1_456000_475200 n1_m1_460800_475200 5.356235
R13377 n1_m1_460800_475200 n1_m1_465600_475200 5.356235
R13378 n1_m1_465600_475200 n1_m1_470400_475200 5.356235
R13379 n1_m1_470400_475200 n1_m1_475200_475200 5.356235
R13380 n1_m1_475200_475200 n1_m1_480000_475200 5.356235
R13381 n1_m1_480000_475200 n1_m1_484800_475200 5.356235
R13382 n1_m1_484800_475200 n1_m1_489600_475200 5.356235
R13383 n1_m1_489600_475200 n1_m1_494400_475200 5.356235
R13384 n1_m1_494400_475200 n1_m1_499200_475200 5.356235
R13385 n1_m1_499200_475200 n1_m1_504000_475200 5.356235
R13386 n1_m1_504000_475200 n1_m1_508000_475200 4.463529
R13387 n1_m1_508800_475200 n1_m1_508000_475200 0.892706
R13388 n1_m1_508800_475200 n1_m1_513600_475200 5.356235
R13389 n1_m1_513600_475200 n1_m1_518400_475200 5.356235
R13390 n1_m1_518400_475200 n1_m1_523200_475200 5.356235
R13391 n1_m1_523200_475200 n1_m1_528000_475200 5.356235
R13392 n1_m1_528000_475200 n1_m1_532800_475200 5.356235
R13393 n1_m1_532800_475200 n1_m1_536000_475200 3.570824
R13394 n1_m1_537600_475200 n1_m1_536000_475200 1.785412
R13395 n1_m1_537600_475200 n1_m1_542400_475200 5.356235
R13396 n1_m1_542400_475200 n1_m1_547200_475200 5.356235
R13397 n1_m1_547200_475200 n1_m1_552000_475200 5.356235
R13398 n1_m1_552000_475200 n1_m1_556800_475200 5.356235
R13399 n1_m1_556800_475200 n1_m1_561600_475200 5.356235
R13400 n1_m1_0_480000 n1_m1_4000_480000 4.463529
R13401 n1_m1_4800_480000 n1_m1_4000_480000 0.892706
R13402 n1_m1_4800_480000 n1_m1_9600_480000 5.356235
R13403 n1_m1_9600_480000 n1_m1_14400_480000 5.356235
R13404 n1_m1_14400_480000 n1_m1_19200_480000 5.356235
R13405 n1_m1_19200_480000 n1_m1_24000_480000 5.356235
R13406 n1_m1_24000_480000 n1_m1_28800_480000 5.356235
R13407 n1_m1_28800_480000 n1_m1_32000_480000 3.570824
R13408 n1_m1_33600_480000 n1_m1_32000_480000 1.785412
R13409 n1_m1_33600_480000 n1_m1_38400_480000 5.356235
R13410 n1_m1_38400_480000 n1_m1_43200_480000 5.356235
R13411 n1_m1_43200_480000 n1_m1_48000_480000 5.356235
R13412 n1_m1_48000_480000 n1_m1_52800_480000 5.356235
R13413 n1_m1_52800_480000 n1_m1_57600_480000 5.356235
R13414 n1_m1_57600_480000 n1_m1_60000_480000 2.678118
R13415 n1_m1_62400_480000 n1_m1_60000_480000 2.678118
R13416 n1_m1_62400_480000 n1_m1_67200_480000 5.356235
R13417 n1_m1_67200_480000 n1_m1_72000_480000 5.356235
R13418 n1_m1_72000_480000 n1_m1_76800_480000 5.356235
R13419 n1_m1_76800_480000 n1_m1_81600_480000 5.356235
R13420 n1_m1_81600_480000 n1_m1_86400_480000 5.356235
R13421 n1_m1_86400_480000 n1_m1_88000_480000 1.785412
R13422 n1_m1_91200_480000 n1_m1_88000_480000 3.570824
R13423 n1_m1_91200_480000 n1_m1_96000_480000 5.356235
R13424 n1_m1_96000_480000 n1_m1_100800_480000 5.356235
R13425 n1_m1_100800_480000 n1_m1_105600_480000 5.356235
R13426 n1_m1_105600_480000 n1_m1_110400_480000 5.356235
R13427 n1_m1_110400_480000 n1_m1_115200_480000 5.356235
R13428 n1_m1_115200_480000 n1_m1_116000_480000 0.892706
R13429 n1_m1_120000_480000 n1_m1_116000_480000 4.463529
R13430 n1_m1_120000_480000 n1_m1_124800_480000 5.356235
R13431 n1_m1_124800_480000 n1_m1_129600_480000 5.356235
R13432 n1_m1_129600_480000 n1_m1_134400_480000 5.356235
R13433 n1_m1_134400_480000 n1_m1_139200_480000 5.356235
R13434 n1_m1_139200_480000 n1_m1_144000_480000 5.356235
R13435 n1_m1_144000_480000 n1_m1_148800_480000 5.356235
R13436 n1_m1_148800_480000 n1_m1_153600_480000 5.356235
R13437 n1_m1_153600_480000 n1_m1_158400_480000 5.356235
R13438 n1_m1_158400_480000 n1_m1_163200_480000 5.356235
R13439 n1_m1_163200_480000 n1_m1_168000_480000 5.356235
R13440 n1_m1_168000_480000 n1_m1_172000_480000 4.463529
R13441 n1_m1_172800_480000 n1_m1_172000_480000 0.892706
R13442 n1_m1_172800_480000 n1_m1_177600_480000 5.356235
R13443 n1_m1_177600_480000 n1_m1_182400_480000 5.356235
R13444 n1_m1_182400_480000 n1_m1_187200_480000 5.356235
R13445 n1_m1_187200_480000 n1_m1_192000_480000 5.356235
R13446 n1_m1_192000_480000 n1_m1_196800_480000 5.356235
R13447 n1_m1_196800_480000 n1_m1_200000_480000 3.570824
R13448 n1_m1_201600_480000 n1_m1_200000_480000 1.785412
R13449 n1_m1_201600_480000 n1_m1_206400_480000 5.356235
R13450 n1_m1_206400_480000 n1_m1_211200_480000 5.356235
R13451 n1_m1_211200_480000 n1_m1_216000_480000 5.356235
R13452 n1_m1_216000_480000 n1_m1_220800_480000 5.356235
R13453 n1_m1_220800_480000 n1_m1_225600_480000 5.356235
R13454 n1_m1_225600_480000 n1_m1_228000_480000 2.678118
R13455 n1_m1_230400_480000 n1_m1_228000_480000 2.678118
R13456 n1_m1_230400_480000 n1_m1_235200_480000 5.356235
R13457 n1_m1_235200_480000 n1_m1_240000_480000 5.356235
R13458 n1_m1_240000_480000 n1_m1_244800_480000 5.356235
R13459 n1_m1_244800_480000 n1_m1_249600_480000 5.356235
R13460 n1_m1_249600_480000 n1_m1_254400_480000 5.356235
R13461 n1_m1_254400_480000 n1_m1_256000_480000 1.785412
R13462 n1_m1_259200_480000 n1_m1_256000_480000 3.570824
R13463 n1_m1_259200_480000 n1_m1_264000_480000 5.356235
R13464 n1_m1_264000_480000 n1_m1_268800_480000 5.356235
R13465 n1_m1_268800_480000 n1_m1_273600_480000 5.356235
R13466 n1_m1_273600_480000 n1_m1_278400_480000 5.356235
R13467 n1_m1_278400_480000 n1_m1_283200_480000 5.356235
R13468 n1_m1_283200_480000 n1_m1_284000_480000 0.892706
R13469 n1_m1_288000_480000 n1_m1_284000_480000 4.463529
R13470 n1_m1_288000_480000 n1_m1_292800_480000 5.356235
R13471 n1_m1_292800_480000 n1_m1_297600_480000 5.356235
R13472 n1_m1_297600_480000 n1_m1_302400_480000 5.356235
R13473 n1_m1_302400_480000 n1_m1_307200_480000 5.356235
R13474 n1_m1_307200_480000 n1_m1_312000_480000 5.356235
R13475 n1_m1_312000_480000 n1_m1_316800_480000 5.356235
R13476 n1_m1_316800_480000 n1_m1_321600_480000 5.356235
R13477 n1_m1_321600_480000 n1_m1_326400_480000 5.356235
R13478 n1_m1_326400_480000 n1_m1_331200_480000 5.356235
R13479 n1_m1_331200_480000 n1_m1_336000_480000 5.356235
R13480 n1_m1_336000_480000 n1_m1_340000_480000 4.463529
R13481 n1_m1_340800_480000 n1_m1_340000_480000 0.892706
R13482 n1_m1_340800_480000 n1_m1_345600_480000 5.356235
R13483 n1_m1_345600_480000 n1_m1_350400_480000 5.356235
R13484 n1_m1_350400_480000 n1_m1_355200_480000 5.356235
R13485 n1_m1_355200_480000 n1_m1_360000_480000 5.356235
R13486 n1_m1_360000_480000 n1_m1_364800_480000 5.356235
R13487 n1_m1_364800_480000 n1_m1_368000_480000 3.570824
R13488 n1_m1_369600_480000 n1_m1_368000_480000 1.785412
R13489 n1_m1_369600_480000 n1_m1_374400_480000 5.356235
R13490 n1_m1_374400_480000 n1_m1_379200_480000 5.356235
R13491 n1_m1_379200_480000 n1_m1_384000_480000 5.356235
R13492 n1_m1_384000_480000 n1_m1_388800_480000 5.356235
R13493 n1_m1_388800_480000 n1_m1_393600_480000 5.356235
R13494 n1_m1_393600_480000 n1_m1_396000_480000 2.678118
R13495 n1_m1_398400_480000 n1_m1_396000_480000 2.678118
R13496 n1_m1_398400_480000 n1_m1_403200_480000 5.356235
R13497 n1_m1_403200_480000 n1_m1_408000_480000 5.356235
R13498 n1_m1_408000_480000 n1_m1_412800_480000 5.356235
R13499 n1_m1_412800_480000 n1_m1_417600_480000 5.356235
R13500 n1_m1_417600_480000 n1_m1_422400_480000 5.356235
R13501 n1_m1_422400_480000 n1_m1_424000_480000 1.785412
R13502 n1_m1_427200_480000 n1_m1_424000_480000 3.570824
R13503 n1_m1_427200_480000 n1_m1_432000_480000 5.356235
R13504 n1_m1_432000_480000 n1_m1_436800_480000 5.356235
R13505 n1_m1_436800_480000 n1_m1_441600_480000 5.356235
R13506 n1_m1_441600_480000 n1_m1_446400_480000 5.356235
R13507 n1_m1_446400_480000 n1_m1_451200_480000 5.356235
R13508 n1_m1_451200_480000 n1_m1_452000_480000 0.892706
R13509 n1_m1_456000_480000 n1_m1_452000_480000 4.463529
R13510 n1_m1_456000_480000 n1_m1_460800_480000 5.356235
R13511 n1_m1_460800_480000 n1_m1_465600_480000 5.356235
R13512 n1_m1_465600_480000 n1_m1_470400_480000 5.356235
R13513 n1_m1_470400_480000 n1_m1_475200_480000 5.356235
R13514 n1_m1_475200_480000 n1_m1_480000_480000 5.356235
R13515 n1_m1_480000_480000 n1_m1_484800_480000 5.356235
R13516 n1_m1_484800_480000 n1_m1_489600_480000 5.356235
R13517 n1_m1_489600_480000 n1_m1_494400_480000 5.356235
R13518 n1_m1_494400_480000 n1_m1_499200_480000 5.356235
R13519 n1_m1_499200_480000 n1_m1_504000_480000 5.356235
R13520 n1_m1_504000_480000 n1_m1_508000_480000 4.463529
R13521 n1_m1_508800_480000 n1_m1_508000_480000 0.892706
R13522 n1_m1_508800_480000 n1_m1_513600_480000 5.356235
R13523 n1_m1_513600_480000 n1_m1_518400_480000 5.356235
R13524 n1_m1_518400_480000 n1_m1_523200_480000 5.356235
R13525 n1_m1_523200_480000 n1_m1_528000_480000 5.356235
R13526 n1_m1_528000_480000 n1_m1_532800_480000 5.356235
R13527 n1_m1_532800_480000 n1_m1_536000_480000 3.570824
R13528 n1_m1_537600_480000 n1_m1_536000_480000 1.785412
R13529 n1_m1_537600_480000 n1_m1_542400_480000 5.356235
R13530 n1_m1_542400_480000 n1_m1_547200_480000 5.356235
R13531 n1_m1_547200_480000 n1_m1_552000_480000 5.356235
R13532 n1_m1_552000_480000 n1_m1_556800_480000 5.356235
R13533 n1_m1_556800_480000 n1_m1_561600_480000 5.356235
R13534 n1_m1_0_484800 n1_m1_4000_484800 4.463529
R13535 n1_m1_4800_484800 n1_m1_4000_484800 0.892706
R13536 n1_m1_4800_484800 n1_m1_9600_484800 5.356235
R13537 n1_m1_9600_484800 n1_m1_14400_484800 5.356235
R13538 n1_m1_14400_484800 n1_m1_19200_484800 5.356235
R13539 n1_m1_19200_484800 n1_m1_24000_484800 5.356235
R13540 n1_m1_24000_484800 n1_m1_28800_484800 5.356235
R13541 n1_m1_28800_484800 n1_m1_32000_484800 3.570824
R13542 n1_m1_33600_484800 n1_m1_32000_484800 1.785412
R13543 n1_m1_33600_484800 n1_m1_38400_484800 5.356235
R13544 n1_m1_38400_484800 n1_m1_43200_484800 5.356235
R13545 n1_m1_43200_484800 n1_m1_48000_484800 5.356235
R13546 n1_m1_48000_484800 n1_m1_52800_484800 5.356235
R13547 n1_m1_52800_484800 n1_m1_57600_484800 5.356235
R13548 n1_m1_57600_484800 n1_m1_60000_484800 2.678118
R13549 n1_m1_62400_484800 n1_m1_60000_484800 2.678118
R13550 n1_m1_62400_484800 n1_m1_67200_484800 5.356235
R13551 n1_m1_67200_484800 n1_m1_72000_484800 5.356235
R13552 n1_m1_72000_484800 n1_m1_76800_484800 5.356235
R13553 n1_m1_76800_484800 n1_m1_81600_484800 5.356235
R13554 n1_m1_81600_484800 n1_m1_86400_484800 5.356235
R13555 n1_m1_86400_484800 n1_m1_88000_484800 1.785412
R13556 n1_m1_91200_484800 n1_m1_88000_484800 3.570824
R13557 n1_m1_91200_484800 n1_m1_96000_484800 5.356235
R13558 n1_m1_96000_484800 n1_m1_100800_484800 5.356235
R13559 n1_m1_100800_484800 n1_m1_105600_484800 5.356235
R13560 n1_m1_105600_484800 n1_m1_110400_484800 5.356235
R13561 n1_m1_110400_484800 n1_m1_115200_484800 5.356235
R13562 n1_m1_115200_484800 n1_m1_116000_484800 0.892706
R13563 n1_m1_120000_484800 n1_m1_116000_484800 4.463529
R13564 n1_m1_120000_484800 n1_m1_124800_484800 5.356235
R13565 n1_m1_124800_484800 n1_m1_129600_484800 5.356235
R13566 n1_m1_129600_484800 n1_m1_134400_484800 5.356235
R13567 n1_m1_134400_484800 n1_m1_139200_484800 5.356235
R13568 n1_m1_139200_484800 n1_m1_144000_484800 5.356235
R13569 n1_m1_144000_484800 n1_m1_148800_484800 5.356235
R13570 n1_m1_148800_484800 n1_m1_153600_484800 5.356235
R13571 n1_m1_153600_484800 n1_m1_158400_484800 5.356235
R13572 n1_m1_158400_484800 n1_m1_163200_484800 5.356235
R13573 n1_m1_163200_484800 n1_m1_168000_484800 5.356235
R13574 n1_m1_168000_484800 n1_m1_172000_484800 4.463529
R13575 n1_m1_172800_484800 n1_m1_172000_484800 0.892706
R13576 n1_m1_172800_484800 n1_m1_177600_484800 5.356235
R13577 n1_m1_177600_484800 n1_m1_182400_484800 5.356235
R13578 n1_m1_182400_484800 n1_m1_187200_484800 5.356235
R13579 n1_m1_187200_484800 n1_m1_192000_484800 5.356235
R13580 n1_m1_192000_484800 n1_m1_196800_484800 5.356235
R13581 n1_m1_196800_484800 n1_m1_200000_484800 3.570824
R13582 n1_m1_201600_484800 n1_m1_200000_484800 1.785412
R13583 n1_m1_201600_484800 n1_m1_206400_484800 5.356235
R13584 n1_m1_206400_484800 n1_m1_211200_484800 5.356235
R13585 n1_m1_211200_484800 n1_m1_216000_484800 5.356235
R13586 n1_m1_216000_484800 n1_m1_220800_484800 5.356235
R13587 n1_m1_220800_484800 n1_m1_225600_484800 5.356235
R13588 n1_m1_225600_484800 n1_m1_228000_484800 2.678118
R13589 n1_m1_230400_484800 n1_m1_228000_484800 2.678118
R13590 n1_m1_230400_484800 n1_m1_235200_484800 5.356235
R13591 n1_m1_235200_484800 n1_m1_240000_484800 5.356235
R13592 n1_m1_240000_484800 n1_m1_244800_484800 5.356235
R13593 n1_m1_244800_484800 n1_m1_249600_484800 5.356235
R13594 n1_m1_249600_484800 n1_m1_254400_484800 5.356235
R13595 n1_m1_254400_484800 n1_m1_256000_484800 1.785412
R13596 n1_m1_259200_484800 n1_m1_256000_484800 3.570824
R13597 n1_m1_259200_484800 n1_m1_264000_484800 5.356235
R13598 n1_m1_264000_484800 n1_m1_268800_484800 5.356235
R13599 n1_m1_268800_484800 n1_m1_273600_484800 5.356235
R13600 n1_m1_273600_484800 n1_m1_278400_484800 5.356235
R13601 n1_m1_278400_484800 n1_m1_283200_484800 5.356235
R13602 n1_m1_283200_484800 n1_m1_284000_484800 0.892706
R13603 n1_m1_288000_484800 n1_m1_284000_484800 4.463529
R13604 n1_m1_288000_484800 n1_m1_292800_484800 5.356235
R13605 n1_m1_292800_484800 n1_m1_297600_484800 5.356235
R13606 n1_m1_297600_484800 n1_m1_302400_484800 5.356235
R13607 n1_m1_302400_484800 n1_m1_307200_484800 5.356235
R13608 n1_m1_307200_484800 n1_m1_312000_484800 5.356235
R13609 n1_m1_312000_484800 n1_m1_316800_484800 5.356235
R13610 n1_m1_316800_484800 n1_m1_321600_484800 5.356235
R13611 n1_m1_321600_484800 n1_m1_326400_484800 5.356235
R13612 n1_m1_326400_484800 n1_m1_331200_484800 5.356235
R13613 n1_m1_331200_484800 n1_m1_336000_484800 5.356235
R13614 n1_m1_336000_484800 n1_m1_340000_484800 4.463529
R13615 n1_m1_340800_484800 n1_m1_340000_484800 0.892706
R13616 n1_m1_340800_484800 n1_m1_345600_484800 5.356235
R13617 n1_m1_345600_484800 n1_m1_350400_484800 5.356235
R13618 n1_m1_350400_484800 n1_m1_355200_484800 5.356235
R13619 n1_m1_355200_484800 n1_m1_360000_484800 5.356235
R13620 n1_m1_360000_484800 n1_m1_364800_484800 5.356235
R13621 n1_m1_364800_484800 n1_m1_368000_484800 3.570824
R13622 n1_m1_369600_484800 n1_m1_368000_484800 1.785412
R13623 n1_m1_369600_484800 n1_m1_374400_484800 5.356235
R13624 n1_m1_374400_484800 n1_m1_379200_484800 5.356235
R13625 n1_m1_379200_484800 n1_m1_384000_484800 5.356235
R13626 n1_m1_384000_484800 n1_m1_388800_484800 5.356235
R13627 n1_m1_388800_484800 n1_m1_393600_484800 5.356235
R13628 n1_m1_393600_484800 n1_m1_396000_484800 2.678118
R13629 n1_m1_398400_484800 n1_m1_396000_484800 2.678118
R13630 n1_m1_398400_484800 n1_m1_403200_484800 5.356235
R13631 n1_m1_403200_484800 n1_m1_408000_484800 5.356235
R13632 n1_m1_408000_484800 n1_m1_412800_484800 5.356235
R13633 n1_m1_412800_484800 n1_m1_417600_484800 5.356235
R13634 n1_m1_417600_484800 n1_m1_422400_484800 5.356235
R13635 n1_m1_422400_484800 n1_m1_424000_484800 1.785412
R13636 n1_m1_427200_484800 n1_m1_424000_484800 3.570824
R13637 n1_m1_427200_484800 n1_m1_432000_484800 5.356235
R13638 n1_m1_432000_484800 n1_m1_436800_484800 5.356235
R13639 n1_m1_436800_484800 n1_m1_441600_484800 5.356235
R13640 n1_m1_441600_484800 n1_m1_446400_484800 5.356235
R13641 n1_m1_446400_484800 n1_m1_451200_484800 5.356235
R13642 n1_m1_451200_484800 n1_m1_452000_484800 0.892706
R13643 n1_m1_456000_484800 n1_m1_452000_484800 4.463529
R13644 n1_m1_456000_484800 n1_m1_460800_484800 5.356235
R13645 n1_m1_460800_484800 n1_m1_465600_484800 5.356235
R13646 n1_m1_465600_484800 n1_m1_470400_484800 5.356235
R13647 n1_m1_470400_484800 n1_m1_475200_484800 5.356235
R13648 n1_m1_475200_484800 n1_m1_480000_484800 5.356235
R13649 n1_m1_480000_484800 n1_m1_484800_484800 5.356235
R13650 n1_m1_484800_484800 n1_m1_489600_484800 5.356235
R13651 n1_m1_489600_484800 n1_m1_494400_484800 5.356235
R13652 n1_m1_494400_484800 n1_m1_499200_484800 5.356235
R13653 n1_m1_499200_484800 n1_m1_504000_484800 5.356235
R13654 n1_m1_504000_484800 n1_m1_508000_484800 4.463529
R13655 n1_m1_508800_484800 n1_m1_508000_484800 0.892706
R13656 n1_m1_508800_484800 n1_m1_513600_484800 5.356235
R13657 n1_m1_513600_484800 n1_m1_518400_484800 5.356235
R13658 n1_m1_518400_484800 n1_m1_523200_484800 5.356235
R13659 n1_m1_523200_484800 n1_m1_528000_484800 5.356235
R13660 n1_m1_528000_484800 n1_m1_532800_484800 5.356235
R13661 n1_m1_532800_484800 n1_m1_536000_484800 3.570824
R13662 n1_m1_537600_484800 n1_m1_536000_484800 1.785412
R13663 n1_m1_537600_484800 n1_m1_542400_484800 5.356235
R13664 n1_m1_542400_484800 n1_m1_547200_484800 5.356235
R13665 n1_m1_547200_484800 n1_m1_552000_484800 5.356235
R13666 n1_m1_552000_484800 n1_m1_556800_484800 5.356235
R13667 n1_m1_556800_484800 n1_m1_561600_484800 5.356235
R13668 n1_m1_0_489600 n1_m1_4000_489600 4.463529
R13669 n1_m1_4800_489600 n1_m1_4000_489600 0.892706
R13670 n1_m1_4800_489600 n1_m1_9600_489600 5.356235
R13671 n1_m1_9600_489600 n1_m1_14400_489600 5.356235
R13672 n1_m1_14400_489600 n1_m1_19200_489600 5.356235
R13673 n1_m1_19200_489600 n1_m1_24000_489600 5.356235
R13674 n1_m1_24000_489600 n1_m1_28800_489600 5.356235
R13675 n1_m1_28800_489600 n1_m1_32000_489600 3.570824
R13676 n1_m1_33600_489600 n1_m1_32000_489600 1.785412
R13677 n1_m1_33600_489600 n1_m1_38400_489600 5.356235
R13678 n1_m1_38400_489600 n1_m1_43200_489600 5.356235
R13679 n1_m1_43200_489600 n1_m1_48000_489600 5.356235
R13680 n1_m1_48000_489600 n1_m1_52800_489600 5.356235
R13681 n1_m1_52800_489600 n1_m1_57600_489600 5.356235
R13682 n1_m1_57600_489600 n1_m1_60000_489600 2.678118
R13683 n1_m1_62400_489600 n1_m1_60000_489600 2.678118
R13684 n1_m1_62400_489600 n1_m1_67200_489600 5.356235
R13685 n1_m1_67200_489600 n1_m1_72000_489600 5.356235
R13686 n1_m1_72000_489600 n1_m1_76800_489600 5.356235
R13687 n1_m1_76800_489600 n1_m1_81600_489600 5.356235
R13688 n1_m1_81600_489600 n1_m1_86400_489600 5.356235
R13689 n1_m1_86400_489600 n1_m1_88000_489600 1.785412
R13690 n1_m1_91200_489600 n1_m1_88000_489600 3.570824
R13691 n1_m1_91200_489600 n1_m1_96000_489600 5.356235
R13692 n1_m1_96000_489600 n1_m1_100800_489600 5.356235
R13693 n1_m1_100800_489600 n1_m1_105600_489600 5.356235
R13694 n1_m1_105600_489600 n1_m1_110400_489600 5.356235
R13695 n1_m1_110400_489600 n1_m1_115200_489600 5.356235
R13696 n1_m1_115200_489600 n1_m1_116000_489600 0.892706
R13697 n1_m1_120000_489600 n1_m1_116000_489600 4.463529
R13698 n1_m1_120000_489600 n1_m1_124800_489600 5.356235
R13699 n1_m1_124800_489600 n1_m1_129600_489600 5.356235
R13700 n1_m1_129600_489600 n1_m1_134400_489600 5.356235
R13701 n1_m1_134400_489600 n1_m1_139200_489600 5.356235
R13702 n1_m1_139200_489600 n1_m1_144000_489600 5.356235
R13703 n1_m1_144000_489600 n1_m1_148800_489600 5.356235
R13704 n1_m1_148800_489600 n1_m1_153600_489600 5.356235
R13705 n1_m1_153600_489600 n1_m1_158400_489600 5.356235
R13706 n1_m1_158400_489600 n1_m1_163200_489600 5.356235
R13707 n1_m1_163200_489600 n1_m1_168000_489600 5.356235
R13708 n1_m1_168000_489600 n1_m1_172000_489600 4.463529
R13709 n1_m1_172800_489600 n1_m1_172000_489600 0.892706
R13710 n1_m1_172800_489600 n1_m1_177600_489600 5.356235
R13711 n1_m1_177600_489600 n1_m1_182400_489600 5.356235
R13712 n1_m1_182400_489600 n1_m1_187200_489600 5.356235
R13713 n1_m1_187200_489600 n1_m1_192000_489600 5.356235
R13714 n1_m1_192000_489600 n1_m1_196800_489600 5.356235
R13715 n1_m1_196800_489600 n1_m1_200000_489600 3.570824
R13716 n1_m1_201600_489600 n1_m1_200000_489600 1.785412
R13717 n1_m1_201600_489600 n1_m1_206400_489600 5.356235
R13718 n1_m1_206400_489600 n1_m1_211200_489600 5.356235
R13719 n1_m1_211200_489600 n1_m1_216000_489600 5.356235
R13720 n1_m1_216000_489600 n1_m1_220800_489600 5.356235
R13721 n1_m1_220800_489600 n1_m1_225600_489600 5.356235
R13722 n1_m1_225600_489600 n1_m1_228000_489600 2.678118
R13723 n1_m1_230400_489600 n1_m1_228000_489600 2.678118
R13724 n1_m1_230400_489600 n1_m1_235200_489600 5.356235
R13725 n1_m1_235200_489600 n1_m1_240000_489600 5.356235
R13726 n1_m1_240000_489600 n1_m1_244800_489600 5.356235
R13727 n1_m1_244800_489600 n1_m1_249600_489600 5.356235
R13728 n1_m1_249600_489600 n1_m1_254400_489600 5.356235
R13729 n1_m1_254400_489600 n1_m1_256000_489600 1.785412
R13730 n1_m1_259200_489600 n1_m1_256000_489600 3.570824
R13731 n1_m1_259200_489600 n1_m1_264000_489600 5.356235
R13732 n1_m1_264000_489600 n1_m1_268800_489600 5.356235
R13733 n1_m1_268800_489600 n1_m1_273600_489600 5.356235
R13734 n1_m1_273600_489600 n1_m1_278400_489600 5.356235
R13735 n1_m1_278400_489600 n1_m1_283200_489600 5.356235
R13736 n1_m1_283200_489600 n1_m1_284000_489600 0.892706
R13737 n1_m1_288000_489600 n1_m1_284000_489600 4.463529
R13738 n1_m1_288000_489600 n1_m1_292800_489600 5.356235
R13739 n1_m1_292800_489600 n1_m1_297600_489600 5.356235
R13740 n1_m1_297600_489600 n1_m1_302400_489600 5.356235
R13741 n1_m1_302400_489600 n1_m1_307200_489600 5.356235
R13742 n1_m1_307200_489600 n1_m1_312000_489600 5.356235
R13743 n1_m1_312000_489600 n1_m1_316800_489600 5.356235
R13744 n1_m1_316800_489600 n1_m1_321600_489600 5.356235
R13745 n1_m1_321600_489600 n1_m1_326400_489600 5.356235
R13746 n1_m1_326400_489600 n1_m1_331200_489600 5.356235
R13747 n1_m1_331200_489600 n1_m1_336000_489600 5.356235
R13748 n1_m1_336000_489600 n1_m1_340000_489600 4.463529
R13749 n1_m1_340800_489600 n1_m1_340000_489600 0.892706
R13750 n1_m1_340800_489600 n1_m1_345600_489600 5.356235
R13751 n1_m1_345600_489600 n1_m1_350400_489600 5.356235
R13752 n1_m1_350400_489600 n1_m1_355200_489600 5.356235
R13753 n1_m1_355200_489600 n1_m1_360000_489600 5.356235
R13754 n1_m1_360000_489600 n1_m1_364800_489600 5.356235
R13755 n1_m1_364800_489600 n1_m1_368000_489600 3.570824
R13756 n1_m1_369600_489600 n1_m1_368000_489600 1.785412
R13757 n1_m1_369600_489600 n1_m1_374400_489600 5.356235
R13758 n1_m1_374400_489600 n1_m1_379200_489600 5.356235
R13759 n1_m1_379200_489600 n1_m1_384000_489600 5.356235
R13760 n1_m1_384000_489600 n1_m1_388800_489600 5.356235
R13761 n1_m1_388800_489600 n1_m1_393600_489600 5.356235
R13762 n1_m1_393600_489600 n1_m1_396000_489600 2.678118
R13763 n1_m1_398400_489600 n1_m1_396000_489600 2.678118
R13764 n1_m1_398400_489600 n1_m1_403200_489600 5.356235
R13765 n1_m1_403200_489600 n1_m1_408000_489600 5.356235
R13766 n1_m1_408000_489600 n1_m1_412800_489600 5.356235
R13767 n1_m1_412800_489600 n1_m1_417600_489600 5.356235
R13768 n1_m1_417600_489600 n1_m1_422400_489600 5.356235
R13769 n1_m1_422400_489600 n1_m1_424000_489600 1.785412
R13770 n1_m1_427200_489600 n1_m1_424000_489600 3.570824
R13771 n1_m1_427200_489600 n1_m1_432000_489600 5.356235
R13772 n1_m1_432000_489600 n1_m1_436800_489600 5.356235
R13773 n1_m1_436800_489600 n1_m1_441600_489600 5.356235
R13774 n1_m1_441600_489600 n1_m1_446400_489600 5.356235
R13775 n1_m1_446400_489600 n1_m1_451200_489600 5.356235
R13776 n1_m1_451200_489600 n1_m1_452000_489600 0.892706
R13777 n1_m1_456000_489600 n1_m1_452000_489600 4.463529
R13778 n1_m1_456000_489600 n1_m1_460800_489600 5.356235
R13779 n1_m1_460800_489600 n1_m1_465600_489600 5.356235
R13780 n1_m1_465600_489600 n1_m1_470400_489600 5.356235
R13781 n1_m1_470400_489600 n1_m1_475200_489600 5.356235
R13782 n1_m1_475200_489600 n1_m1_480000_489600 5.356235
R13783 n1_m1_480000_489600 n1_m1_484800_489600 5.356235
R13784 n1_m1_484800_489600 n1_m1_489600_489600 5.356235
R13785 n1_m1_489600_489600 n1_m1_494400_489600 5.356235
R13786 n1_m1_494400_489600 n1_m1_499200_489600 5.356235
R13787 n1_m1_499200_489600 n1_m1_504000_489600 5.356235
R13788 n1_m1_504000_489600 n1_m1_508000_489600 4.463529
R13789 n1_m1_508800_489600 n1_m1_508000_489600 0.892706
R13790 n1_m1_508800_489600 n1_m1_513600_489600 5.356235
R13791 n1_m1_513600_489600 n1_m1_518400_489600 5.356235
R13792 n1_m1_518400_489600 n1_m1_523200_489600 5.356235
R13793 n1_m1_523200_489600 n1_m1_528000_489600 5.356235
R13794 n1_m1_528000_489600 n1_m1_532800_489600 5.356235
R13795 n1_m1_532800_489600 n1_m1_536000_489600 3.570824
R13796 n1_m1_537600_489600 n1_m1_536000_489600 1.785412
R13797 n1_m1_537600_489600 n1_m1_542400_489600 5.356235
R13798 n1_m1_542400_489600 n1_m1_547200_489600 5.356235
R13799 n1_m1_547200_489600 n1_m1_552000_489600 5.356235
R13800 n1_m1_552000_489600 n1_m1_556800_489600 5.356235
R13801 n1_m1_556800_489600 n1_m1_561600_489600 5.356235
R13802 n1_m1_0_494400 n1_m1_4000_494400 4.463529
R13803 n1_m1_4800_494400 n1_m1_4000_494400 0.892706
R13804 n1_m1_4800_494400 n1_m1_9600_494400 5.356235
R13805 n1_m1_9600_494400 n1_m1_14400_494400 5.356235
R13806 n1_m1_14400_494400 n1_m1_19200_494400 5.356235
R13807 n1_m1_19200_494400 n1_m1_24000_494400 5.356235
R13808 n1_m1_24000_494400 n1_m1_28800_494400 5.356235
R13809 n1_m1_28800_494400 n1_m1_32000_494400 3.570824
R13810 n1_m1_33600_494400 n1_m1_32000_494400 1.785412
R13811 n1_m1_33600_494400 n1_m1_38400_494400 5.356235
R13812 n1_m1_38400_494400 n1_m1_43200_494400 5.356235
R13813 n1_m1_43200_494400 n1_m1_48000_494400 5.356235
R13814 n1_m1_48000_494400 n1_m1_52800_494400 5.356235
R13815 n1_m1_52800_494400 n1_m1_57600_494400 5.356235
R13816 n1_m1_57600_494400 n1_m1_60000_494400 2.678118
R13817 n1_m1_62400_494400 n1_m1_60000_494400 2.678118
R13818 n1_m1_62400_494400 n1_m1_67200_494400 5.356235
R13819 n1_m1_67200_494400 n1_m1_72000_494400 5.356235
R13820 n1_m1_72000_494400 n1_m1_76800_494400 5.356235
R13821 n1_m1_76800_494400 n1_m1_81600_494400 5.356235
R13822 n1_m1_81600_494400 n1_m1_86400_494400 5.356235
R13823 n1_m1_86400_494400 n1_m1_88000_494400 1.785412
R13824 n1_m1_91200_494400 n1_m1_88000_494400 3.570824
R13825 n1_m1_91200_494400 n1_m1_96000_494400 5.356235
R13826 n1_m1_96000_494400 n1_m1_100800_494400 5.356235
R13827 n1_m1_100800_494400 n1_m1_105600_494400 5.356235
R13828 n1_m1_105600_494400 n1_m1_110400_494400 5.356235
R13829 n1_m1_110400_494400 n1_m1_115200_494400 5.356235
R13830 n1_m1_115200_494400 n1_m1_116000_494400 0.892706
R13831 n1_m1_120000_494400 n1_m1_116000_494400 4.463529
R13832 n1_m1_120000_494400 n1_m1_124800_494400 5.356235
R13833 n1_m1_124800_494400 n1_m1_129600_494400 5.356235
R13834 n1_m1_129600_494400 n1_m1_134400_494400 5.356235
R13835 n1_m1_134400_494400 n1_m1_139200_494400 5.356235
R13836 n1_m1_139200_494400 n1_m1_144000_494400 5.356235
R13837 n1_m1_144000_494400 n1_m1_148800_494400 5.356235
R13838 n1_m1_148800_494400 n1_m1_153600_494400 5.356235
R13839 n1_m1_153600_494400 n1_m1_158400_494400 5.356235
R13840 n1_m1_158400_494400 n1_m1_163200_494400 5.356235
R13841 n1_m1_163200_494400 n1_m1_168000_494400 5.356235
R13842 n1_m1_168000_494400 n1_m1_172000_494400 4.463529
R13843 n1_m1_172800_494400 n1_m1_172000_494400 0.892706
R13844 n1_m1_172800_494400 n1_m1_177600_494400 5.356235
R13845 n1_m1_177600_494400 n1_m1_182400_494400 5.356235
R13846 n1_m1_182400_494400 n1_m1_187200_494400 5.356235
R13847 n1_m1_187200_494400 n1_m1_192000_494400 5.356235
R13848 n1_m1_192000_494400 n1_m1_196800_494400 5.356235
R13849 n1_m1_196800_494400 n1_m1_200000_494400 3.570824
R13850 n1_m1_201600_494400 n1_m1_200000_494400 1.785412
R13851 n1_m1_201600_494400 n1_m1_206400_494400 5.356235
R13852 n1_m1_206400_494400 n1_m1_211200_494400 5.356235
R13853 n1_m1_211200_494400 n1_m1_216000_494400 5.356235
R13854 n1_m1_216000_494400 n1_m1_220800_494400 5.356235
R13855 n1_m1_220800_494400 n1_m1_225600_494400 5.356235
R13856 n1_m1_225600_494400 n1_m1_228000_494400 2.678118
R13857 n1_m1_230400_494400 n1_m1_228000_494400 2.678118
R13858 n1_m1_230400_494400 n1_m1_235200_494400 5.356235
R13859 n1_m1_235200_494400 n1_m1_240000_494400 5.356235
R13860 n1_m1_240000_494400 n1_m1_244800_494400 5.356235
R13861 n1_m1_244800_494400 n1_m1_249600_494400 5.356235
R13862 n1_m1_249600_494400 n1_m1_254400_494400 5.356235
R13863 n1_m1_254400_494400 n1_m1_256000_494400 1.785412
R13864 n1_m1_259200_494400 n1_m1_256000_494400 3.570824
R13865 n1_m1_259200_494400 n1_m1_264000_494400 5.356235
R13866 n1_m1_264000_494400 n1_m1_268800_494400 5.356235
R13867 n1_m1_268800_494400 n1_m1_273600_494400 5.356235
R13868 n1_m1_273600_494400 n1_m1_278400_494400 5.356235
R13869 n1_m1_278400_494400 n1_m1_283200_494400 5.356235
R13870 n1_m1_283200_494400 n1_m1_284000_494400 0.892706
R13871 n1_m1_288000_494400 n1_m1_284000_494400 4.463529
R13872 n1_m1_288000_494400 n1_m1_292800_494400 5.356235
R13873 n1_m1_292800_494400 n1_m1_297600_494400 5.356235
R13874 n1_m1_297600_494400 n1_m1_302400_494400 5.356235
R13875 n1_m1_302400_494400 n1_m1_307200_494400 5.356235
R13876 n1_m1_307200_494400 n1_m1_312000_494400 5.356235
R13877 n1_m1_312000_494400 n1_m1_316800_494400 5.356235
R13878 n1_m1_316800_494400 n1_m1_321600_494400 5.356235
R13879 n1_m1_321600_494400 n1_m1_326400_494400 5.356235
R13880 n1_m1_326400_494400 n1_m1_331200_494400 5.356235
R13881 n1_m1_331200_494400 n1_m1_336000_494400 5.356235
R13882 n1_m1_336000_494400 n1_m1_340000_494400 4.463529
R13883 n1_m1_340800_494400 n1_m1_340000_494400 0.892706
R13884 n1_m1_340800_494400 n1_m1_345600_494400 5.356235
R13885 n1_m1_345600_494400 n1_m1_350400_494400 5.356235
R13886 n1_m1_350400_494400 n1_m1_355200_494400 5.356235
R13887 n1_m1_355200_494400 n1_m1_360000_494400 5.356235
R13888 n1_m1_360000_494400 n1_m1_364800_494400 5.356235
R13889 n1_m1_364800_494400 n1_m1_368000_494400 3.570824
R13890 n1_m1_369600_494400 n1_m1_368000_494400 1.785412
R13891 n1_m1_369600_494400 n1_m1_374400_494400 5.356235
R13892 n1_m1_374400_494400 n1_m1_379200_494400 5.356235
R13893 n1_m1_379200_494400 n1_m1_384000_494400 5.356235
R13894 n1_m1_384000_494400 n1_m1_388800_494400 5.356235
R13895 n1_m1_388800_494400 n1_m1_393600_494400 5.356235
R13896 n1_m1_393600_494400 n1_m1_396000_494400 2.678118
R13897 n1_m1_398400_494400 n1_m1_396000_494400 2.678118
R13898 n1_m1_398400_494400 n1_m1_403200_494400 5.356235
R13899 n1_m1_403200_494400 n1_m1_408000_494400 5.356235
R13900 n1_m1_408000_494400 n1_m1_412800_494400 5.356235
R13901 n1_m1_412800_494400 n1_m1_417600_494400 5.356235
R13902 n1_m1_417600_494400 n1_m1_422400_494400 5.356235
R13903 n1_m1_422400_494400 n1_m1_424000_494400 1.785412
R13904 n1_m1_427200_494400 n1_m1_424000_494400 3.570824
R13905 n1_m1_427200_494400 n1_m1_432000_494400 5.356235
R13906 n1_m1_432000_494400 n1_m1_436800_494400 5.356235
R13907 n1_m1_436800_494400 n1_m1_441600_494400 5.356235
R13908 n1_m1_441600_494400 n1_m1_446400_494400 5.356235
R13909 n1_m1_446400_494400 n1_m1_451200_494400 5.356235
R13910 n1_m1_451200_494400 n1_m1_452000_494400 0.892706
R13911 n1_m1_456000_494400 n1_m1_452000_494400 4.463529
R13912 n1_m1_456000_494400 n1_m1_460800_494400 5.356235
R13913 n1_m1_460800_494400 n1_m1_465600_494400 5.356235
R13914 n1_m1_465600_494400 n1_m1_470400_494400 5.356235
R13915 n1_m1_470400_494400 n1_m1_475200_494400 5.356235
R13916 n1_m1_475200_494400 n1_m1_480000_494400 5.356235
R13917 n1_m1_480000_494400 n1_m1_484800_494400 5.356235
R13918 n1_m1_484800_494400 n1_m1_489600_494400 5.356235
R13919 n1_m1_489600_494400 n1_m1_494400_494400 5.356235
R13920 n1_m1_494400_494400 n1_m1_499200_494400 5.356235
R13921 n1_m1_499200_494400 n1_m1_504000_494400 5.356235
R13922 n1_m1_504000_494400 n1_m1_508000_494400 4.463529
R13923 n1_m1_508800_494400 n1_m1_508000_494400 0.892706
R13924 n1_m1_508800_494400 n1_m1_513600_494400 5.356235
R13925 n1_m1_513600_494400 n1_m1_518400_494400 5.356235
R13926 n1_m1_518400_494400 n1_m1_523200_494400 5.356235
R13927 n1_m1_523200_494400 n1_m1_528000_494400 5.356235
R13928 n1_m1_528000_494400 n1_m1_532800_494400 5.356235
R13929 n1_m1_532800_494400 n1_m1_536000_494400 3.570824
R13930 n1_m1_537600_494400 n1_m1_536000_494400 1.785412
R13931 n1_m1_537600_494400 n1_m1_542400_494400 5.356235
R13932 n1_m1_542400_494400 n1_m1_547200_494400 5.356235
R13933 n1_m1_547200_494400 n1_m1_552000_494400 5.356235
R13934 n1_m1_552000_494400 n1_m1_556800_494400 5.356235
R13935 n1_m1_556800_494400 n1_m1_561600_494400 5.356235
R13936 n1_m1_0_499200 n1_m1_4000_499200 4.463529
R13937 n1_m1_4800_499200 n1_m1_4000_499200 0.892706
R13938 n1_m1_4800_499200 n1_m1_9600_499200 5.356235
R13939 n1_m1_9600_499200 n1_m1_14400_499200 5.356235
R13940 n1_m1_14400_499200 n1_m1_19200_499200 5.356235
R13941 n1_m1_19200_499200 n1_m1_24000_499200 5.356235
R13942 n1_m1_24000_499200 n1_m1_28800_499200 5.356235
R13943 n1_m1_28800_499200 n1_m1_32000_499200 3.570824
R13944 n1_m1_33600_499200 n1_m1_32000_499200 1.785412
R13945 n1_m1_33600_499200 n1_m1_38400_499200 5.356235
R13946 n1_m1_38400_499200 n1_m1_43200_499200 5.356235
R13947 n1_m1_43200_499200 n1_m1_48000_499200 5.356235
R13948 n1_m1_48000_499200 n1_m1_52800_499200 5.356235
R13949 n1_m1_52800_499200 n1_m1_57600_499200 5.356235
R13950 n1_m1_57600_499200 n1_m1_60000_499200 2.678118
R13951 n1_m1_62400_499200 n1_m1_60000_499200 2.678118
R13952 n1_m1_62400_499200 n1_m1_67200_499200 5.356235
R13953 n1_m1_67200_499200 n1_m1_72000_499200 5.356235
R13954 n1_m1_72000_499200 n1_m1_76800_499200 5.356235
R13955 n1_m1_76800_499200 n1_m1_81600_499200 5.356235
R13956 n1_m1_81600_499200 n1_m1_86400_499200 5.356235
R13957 n1_m1_86400_499200 n1_m1_88000_499200 1.785412
R13958 n1_m1_91200_499200 n1_m1_88000_499200 3.570824
R13959 n1_m1_91200_499200 n1_m1_96000_499200 5.356235
R13960 n1_m1_96000_499200 n1_m1_100800_499200 5.356235
R13961 n1_m1_100800_499200 n1_m1_105600_499200 5.356235
R13962 n1_m1_105600_499200 n1_m1_110400_499200 5.356235
R13963 n1_m1_110400_499200 n1_m1_115200_499200 5.356235
R13964 n1_m1_115200_499200 n1_m1_116000_499200 0.892706
R13965 n1_m1_120000_499200 n1_m1_116000_499200 4.463529
R13966 n1_m1_120000_499200 n1_m1_124800_499200 5.356235
R13967 n1_m1_124800_499200 n1_m1_129600_499200 5.356235
R13968 n1_m1_129600_499200 n1_m1_134400_499200 5.356235
R13969 n1_m1_134400_499200 n1_m1_139200_499200 5.356235
R13970 n1_m1_139200_499200 n1_m1_144000_499200 5.356235
R13971 n1_m1_144000_499200 n1_m1_148800_499200 5.356235
R13972 n1_m1_148800_499200 n1_m1_153600_499200 5.356235
R13973 n1_m1_153600_499200 n1_m1_158400_499200 5.356235
R13974 n1_m1_158400_499200 n1_m1_163200_499200 5.356235
R13975 n1_m1_163200_499200 n1_m1_168000_499200 5.356235
R13976 n1_m1_168000_499200 n1_m1_172000_499200 4.463529
R13977 n1_m1_172800_499200 n1_m1_172000_499200 0.892706
R13978 n1_m1_172800_499200 n1_m1_177600_499200 5.356235
R13979 n1_m1_177600_499200 n1_m1_182400_499200 5.356235
R13980 n1_m1_182400_499200 n1_m1_187200_499200 5.356235
R13981 n1_m1_187200_499200 n1_m1_192000_499200 5.356235
R13982 n1_m1_192000_499200 n1_m1_196800_499200 5.356235
R13983 n1_m1_196800_499200 n1_m1_200000_499200 3.570824
R13984 n1_m1_201600_499200 n1_m1_200000_499200 1.785412
R13985 n1_m1_201600_499200 n1_m1_206400_499200 5.356235
R13986 n1_m1_206400_499200 n1_m1_211200_499200 5.356235
R13987 n1_m1_211200_499200 n1_m1_216000_499200 5.356235
R13988 n1_m1_216000_499200 n1_m1_220800_499200 5.356235
R13989 n1_m1_220800_499200 n1_m1_225600_499200 5.356235
R13990 n1_m1_225600_499200 n1_m1_228000_499200 2.678118
R13991 n1_m1_230400_499200 n1_m1_228000_499200 2.678118
R13992 n1_m1_230400_499200 n1_m1_235200_499200 5.356235
R13993 n1_m1_235200_499200 n1_m1_240000_499200 5.356235
R13994 n1_m1_240000_499200 n1_m1_244800_499200 5.356235
R13995 n1_m1_244800_499200 n1_m1_249600_499200 5.356235
R13996 n1_m1_249600_499200 n1_m1_254400_499200 5.356235
R13997 n1_m1_254400_499200 n1_m1_256000_499200 1.785412
R13998 n1_m1_259200_499200 n1_m1_256000_499200 3.570824
R13999 n1_m1_259200_499200 n1_m1_264000_499200 5.356235
R14000 n1_m1_264000_499200 n1_m1_268800_499200 5.356235
R14001 n1_m1_268800_499200 n1_m1_273600_499200 5.356235
R14002 n1_m1_273600_499200 n1_m1_278400_499200 5.356235
R14003 n1_m1_278400_499200 n1_m1_283200_499200 5.356235
R14004 n1_m1_283200_499200 n1_m1_284000_499200 0.892706
R14005 n1_m1_288000_499200 n1_m1_284000_499200 4.463529
R14006 n1_m1_288000_499200 n1_m1_292800_499200 5.356235
R14007 n1_m1_292800_499200 n1_m1_297600_499200 5.356235
R14008 n1_m1_297600_499200 n1_m1_302400_499200 5.356235
R14009 n1_m1_302400_499200 n1_m1_307200_499200 5.356235
R14010 n1_m1_307200_499200 n1_m1_312000_499200 5.356235
R14011 n1_m1_312000_499200 n1_m1_316800_499200 5.356235
R14012 n1_m1_316800_499200 n1_m1_321600_499200 5.356235
R14013 n1_m1_321600_499200 n1_m1_326400_499200 5.356235
R14014 n1_m1_326400_499200 n1_m1_331200_499200 5.356235
R14015 n1_m1_331200_499200 n1_m1_336000_499200 5.356235
R14016 n1_m1_336000_499200 n1_m1_340000_499200 4.463529
R14017 n1_m1_340800_499200 n1_m1_340000_499200 0.892706
R14018 n1_m1_340800_499200 n1_m1_345600_499200 5.356235
R14019 n1_m1_345600_499200 n1_m1_350400_499200 5.356235
R14020 n1_m1_350400_499200 n1_m1_355200_499200 5.356235
R14021 n1_m1_355200_499200 n1_m1_360000_499200 5.356235
R14022 n1_m1_360000_499200 n1_m1_364800_499200 5.356235
R14023 n1_m1_364800_499200 n1_m1_368000_499200 3.570824
R14024 n1_m1_369600_499200 n1_m1_368000_499200 1.785412
R14025 n1_m1_369600_499200 n1_m1_374400_499200 5.356235
R14026 n1_m1_374400_499200 n1_m1_379200_499200 5.356235
R14027 n1_m1_379200_499200 n1_m1_384000_499200 5.356235
R14028 n1_m1_384000_499200 n1_m1_388800_499200 5.356235
R14029 n1_m1_388800_499200 n1_m1_393600_499200 5.356235
R14030 n1_m1_393600_499200 n1_m1_396000_499200 2.678118
R14031 n1_m1_398400_499200 n1_m1_396000_499200 2.678118
R14032 n1_m1_398400_499200 n1_m1_403200_499200 5.356235
R14033 n1_m1_403200_499200 n1_m1_408000_499200 5.356235
R14034 n1_m1_408000_499200 n1_m1_412800_499200 5.356235
R14035 n1_m1_412800_499200 n1_m1_417600_499200 5.356235
R14036 n1_m1_417600_499200 n1_m1_422400_499200 5.356235
R14037 n1_m1_422400_499200 n1_m1_424000_499200 1.785412
R14038 n1_m1_427200_499200 n1_m1_424000_499200 3.570824
R14039 n1_m1_427200_499200 n1_m1_432000_499200 5.356235
R14040 n1_m1_432000_499200 n1_m1_436800_499200 5.356235
R14041 n1_m1_436800_499200 n1_m1_441600_499200 5.356235
R14042 n1_m1_441600_499200 n1_m1_446400_499200 5.356235
R14043 n1_m1_446400_499200 n1_m1_451200_499200 5.356235
R14044 n1_m1_451200_499200 n1_m1_452000_499200 0.892706
R14045 n1_m1_456000_499200 n1_m1_452000_499200 4.463529
R14046 n1_m1_456000_499200 n1_m1_460800_499200 5.356235
R14047 n1_m1_460800_499200 n1_m1_465600_499200 5.356235
R14048 n1_m1_465600_499200 n1_m1_470400_499200 5.356235
R14049 n1_m1_470400_499200 n1_m1_475200_499200 5.356235
R14050 n1_m1_475200_499200 n1_m1_480000_499200 5.356235
R14051 n1_m1_480000_499200 n1_m1_484800_499200 5.356235
R14052 n1_m1_484800_499200 n1_m1_489600_499200 5.356235
R14053 n1_m1_489600_499200 n1_m1_494400_499200 5.356235
R14054 n1_m1_494400_499200 n1_m1_499200_499200 5.356235
R14055 n1_m1_499200_499200 n1_m1_504000_499200 5.356235
R14056 n1_m1_504000_499200 n1_m1_508000_499200 4.463529
R14057 n1_m1_508800_499200 n1_m1_508000_499200 0.892706
R14058 n1_m1_508800_499200 n1_m1_513600_499200 5.356235
R14059 n1_m1_513600_499200 n1_m1_518400_499200 5.356235
R14060 n1_m1_518400_499200 n1_m1_523200_499200 5.356235
R14061 n1_m1_523200_499200 n1_m1_528000_499200 5.356235
R14062 n1_m1_528000_499200 n1_m1_532800_499200 5.356235
R14063 n1_m1_532800_499200 n1_m1_536000_499200 3.570824
R14064 n1_m1_537600_499200 n1_m1_536000_499200 1.785412
R14065 n1_m1_537600_499200 n1_m1_542400_499200 5.356235
R14066 n1_m1_542400_499200 n1_m1_547200_499200 5.356235
R14067 n1_m1_547200_499200 n1_m1_552000_499200 5.356235
R14068 n1_m1_552000_499200 n1_m1_556800_499200 5.356235
R14069 n1_m1_556800_499200 n1_m1_561600_499200 5.356235
R14070 n1_m1_0_504000 n1_m1_4000_504000 4.463529
R14071 n1_m1_4800_504000 n1_m1_4000_504000 0.892706
R14072 n1_m1_4800_504000 n1_m1_9600_504000 5.356235
R14073 n1_m1_9600_504000 n1_m1_14400_504000 5.356235
R14074 n1_m1_14400_504000 n1_m1_19200_504000 5.356235
R14075 n1_m1_19200_504000 n1_m1_24000_504000 5.356235
R14076 n1_m1_24000_504000 n1_m1_28800_504000 5.356235
R14077 n1_m1_28800_504000 n1_m1_32000_504000 3.570824
R14078 n1_m1_33600_504000 n1_m1_32000_504000 1.785412
R14079 n1_m1_33600_504000 n1_m1_38400_504000 5.356235
R14080 n1_m1_38400_504000 n1_m1_43200_504000 5.356235
R14081 n1_m1_43200_504000 n1_m1_48000_504000 5.356235
R14082 n1_m1_48000_504000 n1_m1_52800_504000 5.356235
R14083 n1_m1_52800_504000 n1_m1_57600_504000 5.356235
R14084 n1_m1_57600_504000 n1_m1_60000_504000 2.678118
R14085 n1_m1_62400_504000 n1_m1_60000_504000 2.678118
R14086 n1_m1_62400_504000 n1_m1_67200_504000 5.356235
R14087 n1_m1_67200_504000 n1_m1_72000_504000 5.356235
R14088 n1_m1_72000_504000 n1_m1_76800_504000 5.356235
R14089 n1_m1_76800_504000 n1_m1_81600_504000 5.356235
R14090 n1_m1_81600_504000 n1_m1_86400_504000 5.356235
R14091 n1_m1_86400_504000 n1_m1_88000_504000 1.785412
R14092 n1_m1_91200_504000 n1_m1_88000_504000 3.570824
R14093 n1_m1_91200_504000 n1_m1_96000_504000 5.356235
R14094 n1_m1_96000_504000 n1_m1_100800_504000 5.356235
R14095 n1_m1_100800_504000 n1_m1_105600_504000 5.356235
R14096 n1_m1_105600_504000 n1_m1_110400_504000 5.356235
R14097 n1_m1_110400_504000 n1_m1_115200_504000 5.356235
R14098 n1_m1_115200_504000 n1_m1_116000_504000 0.892706
R14099 n1_m1_120000_504000 n1_m1_116000_504000 4.463529
R14100 n1_m1_120000_504000 n1_m1_124800_504000 5.356235
R14101 n1_m1_124800_504000 n1_m1_129600_504000 5.356235
R14102 n1_m1_129600_504000 n1_m1_134400_504000 5.356235
R14103 n1_m1_134400_504000 n1_m1_139200_504000 5.356235
R14104 n1_m1_139200_504000 n1_m1_144000_504000 5.356235
R14105 n1_m1_144000_504000 n1_m1_148800_504000 5.356235
R14106 n1_m1_148800_504000 n1_m1_153600_504000 5.356235
R14107 n1_m1_153600_504000 n1_m1_158400_504000 5.356235
R14108 n1_m1_158400_504000 n1_m1_163200_504000 5.356235
R14109 n1_m1_163200_504000 n1_m1_168000_504000 5.356235
R14110 n1_m1_168000_504000 n1_m1_172000_504000 4.463529
R14111 n1_m1_172800_504000 n1_m1_172000_504000 0.892706
R14112 n1_m1_172800_504000 n1_m1_177600_504000 5.356235
R14113 n1_m1_177600_504000 n1_m1_182400_504000 5.356235
R14114 n1_m1_182400_504000 n1_m1_187200_504000 5.356235
R14115 n1_m1_187200_504000 n1_m1_192000_504000 5.356235
R14116 n1_m1_192000_504000 n1_m1_196800_504000 5.356235
R14117 n1_m1_196800_504000 n1_m1_200000_504000 3.570824
R14118 n1_m1_201600_504000 n1_m1_200000_504000 1.785412
R14119 n1_m1_201600_504000 n1_m1_206400_504000 5.356235
R14120 n1_m1_206400_504000 n1_m1_211200_504000 5.356235
R14121 n1_m1_211200_504000 n1_m1_216000_504000 5.356235
R14122 n1_m1_216000_504000 n1_m1_220800_504000 5.356235
R14123 n1_m1_220800_504000 n1_m1_225600_504000 5.356235
R14124 n1_m1_225600_504000 n1_m1_228000_504000 2.678118
R14125 n1_m1_230400_504000 n1_m1_228000_504000 2.678118
R14126 n1_m1_230400_504000 n1_m1_235200_504000 5.356235
R14127 n1_m1_235200_504000 n1_m1_240000_504000 5.356235
R14128 n1_m1_240000_504000 n1_m1_244800_504000 5.356235
R14129 n1_m1_244800_504000 n1_m1_249600_504000 5.356235
R14130 n1_m1_249600_504000 n1_m1_254400_504000 5.356235
R14131 n1_m1_254400_504000 n1_m1_256000_504000 1.785412
R14132 n1_m1_259200_504000 n1_m1_256000_504000 3.570824
R14133 n1_m1_259200_504000 n1_m1_264000_504000 5.356235
R14134 n1_m1_264000_504000 n1_m1_268800_504000 5.356235
R14135 n1_m1_268800_504000 n1_m1_273600_504000 5.356235
R14136 n1_m1_273600_504000 n1_m1_278400_504000 5.356235
R14137 n1_m1_278400_504000 n1_m1_283200_504000 5.356235
R14138 n1_m1_283200_504000 n1_m1_284000_504000 0.892706
R14139 n1_m1_288000_504000 n1_m1_284000_504000 4.463529
R14140 n1_m1_288000_504000 n1_m1_292800_504000 5.356235
R14141 n1_m1_292800_504000 n1_m1_297600_504000 5.356235
R14142 n1_m1_297600_504000 n1_m1_302400_504000 5.356235
R14143 n1_m1_302400_504000 n1_m1_307200_504000 5.356235
R14144 n1_m1_307200_504000 n1_m1_312000_504000 5.356235
R14145 n1_m1_312000_504000 n1_m1_316800_504000 5.356235
R14146 n1_m1_316800_504000 n1_m1_321600_504000 5.356235
R14147 n1_m1_321600_504000 n1_m1_326400_504000 5.356235
R14148 n1_m1_326400_504000 n1_m1_331200_504000 5.356235
R14149 n1_m1_331200_504000 n1_m1_336000_504000 5.356235
R14150 n1_m1_336000_504000 n1_m1_340000_504000 4.463529
R14151 n1_m1_340800_504000 n1_m1_340000_504000 0.892706
R14152 n1_m1_340800_504000 n1_m1_345600_504000 5.356235
R14153 n1_m1_345600_504000 n1_m1_350400_504000 5.356235
R14154 n1_m1_350400_504000 n1_m1_355200_504000 5.356235
R14155 n1_m1_355200_504000 n1_m1_360000_504000 5.356235
R14156 n1_m1_360000_504000 n1_m1_364800_504000 5.356235
R14157 n1_m1_364800_504000 n1_m1_368000_504000 3.570824
R14158 n1_m1_369600_504000 n1_m1_368000_504000 1.785412
R14159 n1_m1_369600_504000 n1_m1_374400_504000 5.356235
R14160 n1_m1_374400_504000 n1_m1_379200_504000 5.356235
R14161 n1_m1_379200_504000 n1_m1_384000_504000 5.356235
R14162 n1_m1_384000_504000 n1_m1_388800_504000 5.356235
R14163 n1_m1_388800_504000 n1_m1_393600_504000 5.356235
R14164 n1_m1_393600_504000 n1_m1_396000_504000 2.678118
R14165 n1_m1_398400_504000 n1_m1_396000_504000 2.678118
R14166 n1_m1_398400_504000 n1_m1_403200_504000 5.356235
R14167 n1_m1_403200_504000 n1_m1_408000_504000 5.356235
R14168 n1_m1_408000_504000 n1_m1_412800_504000 5.356235
R14169 n1_m1_412800_504000 n1_m1_417600_504000 5.356235
R14170 n1_m1_417600_504000 n1_m1_422400_504000 5.356235
R14171 n1_m1_422400_504000 n1_m1_424000_504000 1.785412
R14172 n1_m1_427200_504000 n1_m1_424000_504000 3.570824
R14173 n1_m1_427200_504000 n1_m1_432000_504000 5.356235
R14174 n1_m1_432000_504000 n1_m1_436800_504000 5.356235
R14175 n1_m1_436800_504000 n1_m1_441600_504000 5.356235
R14176 n1_m1_441600_504000 n1_m1_446400_504000 5.356235
R14177 n1_m1_446400_504000 n1_m1_451200_504000 5.356235
R14178 n1_m1_451200_504000 n1_m1_452000_504000 0.892706
R14179 n1_m1_456000_504000 n1_m1_452000_504000 4.463529
R14180 n1_m1_456000_504000 n1_m1_460800_504000 5.356235
R14181 n1_m1_460800_504000 n1_m1_465600_504000 5.356235
R14182 n1_m1_465600_504000 n1_m1_470400_504000 5.356235
R14183 n1_m1_470400_504000 n1_m1_475200_504000 5.356235
R14184 n1_m1_475200_504000 n1_m1_480000_504000 5.356235
R14185 n1_m1_480000_504000 n1_m1_484800_504000 5.356235
R14186 n1_m1_484800_504000 n1_m1_489600_504000 5.356235
R14187 n1_m1_489600_504000 n1_m1_494400_504000 5.356235
R14188 n1_m1_494400_504000 n1_m1_499200_504000 5.356235
R14189 n1_m1_499200_504000 n1_m1_504000_504000 5.356235
R14190 n1_m1_504000_504000 n1_m1_508000_504000 4.463529
R14191 n1_m1_508800_504000 n1_m1_508000_504000 0.892706
R14192 n1_m1_508800_504000 n1_m1_513600_504000 5.356235
R14193 n1_m1_513600_504000 n1_m1_518400_504000 5.356235
R14194 n1_m1_518400_504000 n1_m1_523200_504000 5.356235
R14195 n1_m1_523200_504000 n1_m1_528000_504000 5.356235
R14196 n1_m1_528000_504000 n1_m1_532800_504000 5.356235
R14197 n1_m1_532800_504000 n1_m1_536000_504000 3.570824
R14198 n1_m1_537600_504000 n1_m1_536000_504000 1.785412
R14199 n1_m1_537600_504000 n1_m1_542400_504000 5.356235
R14200 n1_m1_542400_504000 n1_m1_547200_504000 5.356235
R14201 n1_m1_547200_504000 n1_m1_552000_504000 5.356235
R14202 n1_m1_552000_504000 n1_m1_556800_504000 5.356235
R14203 n1_m1_556800_504000 n1_m1_561600_504000 5.356235
R14204 n1_m1_0_508800 n1_m1_4000_508800 4.463529
R14205 n1_m1_4800_508800 n1_m1_4000_508800 0.892706
R14206 n1_m1_4800_508800 n1_m1_9600_508800 5.356235
R14207 n1_m1_9600_508800 n1_m1_14400_508800 5.356235
R14208 n1_m1_14400_508800 n1_m1_19200_508800 5.356235
R14209 n1_m1_19200_508800 n1_m1_24000_508800 5.356235
R14210 n1_m1_24000_508800 n1_m1_28800_508800 5.356235
R14211 n1_m1_28800_508800 n1_m1_32000_508800 3.570824
R14212 n1_m1_33600_508800 n1_m1_32000_508800 1.785412
R14213 n1_m1_33600_508800 n1_m1_38400_508800 5.356235
R14214 n1_m1_38400_508800 n1_m1_43200_508800 5.356235
R14215 n1_m1_43200_508800 n1_m1_48000_508800 5.356235
R14216 n1_m1_48000_508800 n1_m1_52800_508800 5.356235
R14217 n1_m1_52800_508800 n1_m1_57600_508800 5.356235
R14218 n1_m1_57600_508800 n1_m1_60000_508800 2.678118
R14219 n1_m1_62400_508800 n1_m1_60000_508800 2.678118
R14220 n1_m1_62400_508800 n1_m1_67200_508800 5.356235
R14221 n1_m1_67200_508800 n1_m1_72000_508800 5.356235
R14222 n1_m1_72000_508800 n1_m1_76800_508800 5.356235
R14223 n1_m1_76800_508800 n1_m1_81600_508800 5.356235
R14224 n1_m1_81600_508800 n1_m1_86400_508800 5.356235
R14225 n1_m1_86400_508800 n1_m1_88000_508800 1.785412
R14226 n1_m1_91200_508800 n1_m1_88000_508800 3.570824
R14227 n1_m1_91200_508800 n1_m1_96000_508800 5.356235
R14228 n1_m1_96000_508800 n1_m1_100800_508800 5.356235
R14229 n1_m1_100800_508800 n1_m1_105600_508800 5.356235
R14230 n1_m1_105600_508800 n1_m1_110400_508800 5.356235
R14231 n1_m1_110400_508800 n1_m1_115200_508800 5.356235
R14232 n1_m1_115200_508800 n1_m1_116000_508800 0.892706
R14233 n1_m1_120000_508800 n1_m1_116000_508800 4.463529
R14234 n1_m1_120000_508800 n1_m1_124800_508800 5.356235
R14235 n1_m1_124800_508800 n1_m1_129600_508800 5.356235
R14236 n1_m1_129600_508800 n1_m1_134400_508800 5.356235
R14237 n1_m1_134400_508800 n1_m1_139200_508800 5.356235
R14238 n1_m1_139200_508800 n1_m1_144000_508800 5.356235
R14239 n1_m1_144000_508800 n1_m1_148800_508800 5.356235
R14240 n1_m1_148800_508800 n1_m1_153600_508800 5.356235
R14241 n1_m1_153600_508800 n1_m1_158400_508800 5.356235
R14242 n1_m1_158400_508800 n1_m1_163200_508800 5.356235
R14243 n1_m1_163200_508800 n1_m1_168000_508800 5.356235
R14244 n1_m1_168000_508800 n1_m1_172000_508800 4.463529
R14245 n1_m1_172800_508800 n1_m1_172000_508800 0.892706
R14246 n1_m1_172800_508800 n1_m1_177600_508800 5.356235
R14247 n1_m1_177600_508800 n1_m1_182400_508800 5.356235
R14248 n1_m1_182400_508800 n1_m1_187200_508800 5.356235
R14249 n1_m1_187200_508800 n1_m1_192000_508800 5.356235
R14250 n1_m1_192000_508800 n1_m1_196800_508800 5.356235
R14251 n1_m1_196800_508800 n1_m1_200000_508800 3.570824
R14252 n1_m1_201600_508800 n1_m1_200000_508800 1.785412
R14253 n1_m1_201600_508800 n1_m1_206400_508800 5.356235
R14254 n1_m1_206400_508800 n1_m1_211200_508800 5.356235
R14255 n1_m1_211200_508800 n1_m1_216000_508800 5.356235
R14256 n1_m1_216000_508800 n1_m1_220800_508800 5.356235
R14257 n1_m1_220800_508800 n1_m1_225600_508800 5.356235
R14258 n1_m1_225600_508800 n1_m1_228000_508800 2.678118
R14259 n1_m1_230400_508800 n1_m1_228000_508800 2.678118
R14260 n1_m1_230400_508800 n1_m1_235200_508800 5.356235
R14261 n1_m1_235200_508800 n1_m1_240000_508800 5.356235
R14262 n1_m1_240000_508800 n1_m1_244800_508800 5.356235
R14263 n1_m1_244800_508800 n1_m1_249600_508800 5.356235
R14264 n1_m1_249600_508800 n1_m1_254400_508800 5.356235
R14265 n1_m1_254400_508800 n1_m1_256000_508800 1.785412
R14266 n1_m1_259200_508800 n1_m1_256000_508800 3.570824
R14267 n1_m1_259200_508800 n1_m1_264000_508800 5.356235
R14268 n1_m1_264000_508800 n1_m1_268800_508800 5.356235
R14269 n1_m1_268800_508800 n1_m1_273600_508800 5.356235
R14270 n1_m1_273600_508800 n1_m1_278400_508800 5.356235
R14271 n1_m1_278400_508800 n1_m1_283200_508800 5.356235
R14272 n1_m1_283200_508800 n1_m1_284000_508800 0.892706
R14273 n1_m1_288000_508800 n1_m1_284000_508800 4.463529
R14274 n1_m1_288000_508800 n1_m1_292800_508800 5.356235
R14275 n1_m1_292800_508800 n1_m1_297600_508800 5.356235
R14276 n1_m1_297600_508800 n1_m1_302400_508800 5.356235
R14277 n1_m1_302400_508800 n1_m1_307200_508800 5.356235
R14278 n1_m1_307200_508800 n1_m1_312000_508800 5.356235
R14279 n1_m1_312000_508800 n1_m1_316800_508800 5.356235
R14280 n1_m1_316800_508800 n1_m1_321600_508800 5.356235
R14281 n1_m1_321600_508800 n1_m1_326400_508800 5.356235
R14282 n1_m1_326400_508800 n1_m1_331200_508800 5.356235
R14283 n1_m1_331200_508800 n1_m1_336000_508800 5.356235
R14284 n1_m1_336000_508800 n1_m1_340000_508800 4.463529
R14285 n1_m1_340800_508800 n1_m1_340000_508800 0.892706
R14286 n1_m1_340800_508800 n1_m1_345600_508800 5.356235
R14287 n1_m1_345600_508800 n1_m1_350400_508800 5.356235
R14288 n1_m1_350400_508800 n1_m1_355200_508800 5.356235
R14289 n1_m1_355200_508800 n1_m1_360000_508800 5.356235
R14290 n1_m1_360000_508800 n1_m1_364800_508800 5.356235
R14291 n1_m1_364800_508800 n1_m1_368000_508800 3.570824
R14292 n1_m1_369600_508800 n1_m1_368000_508800 1.785412
R14293 n1_m1_369600_508800 n1_m1_374400_508800 5.356235
R14294 n1_m1_374400_508800 n1_m1_379200_508800 5.356235
R14295 n1_m1_379200_508800 n1_m1_384000_508800 5.356235
R14296 n1_m1_384000_508800 n1_m1_388800_508800 5.356235
R14297 n1_m1_388800_508800 n1_m1_393600_508800 5.356235
R14298 n1_m1_393600_508800 n1_m1_396000_508800 2.678118
R14299 n1_m1_398400_508800 n1_m1_396000_508800 2.678118
R14300 n1_m1_398400_508800 n1_m1_403200_508800 5.356235
R14301 n1_m1_403200_508800 n1_m1_408000_508800 5.356235
R14302 n1_m1_408000_508800 n1_m1_412800_508800 5.356235
R14303 n1_m1_412800_508800 n1_m1_417600_508800 5.356235
R14304 n1_m1_417600_508800 n1_m1_422400_508800 5.356235
R14305 n1_m1_422400_508800 n1_m1_424000_508800 1.785412
R14306 n1_m1_427200_508800 n1_m1_424000_508800 3.570824
R14307 n1_m1_427200_508800 n1_m1_432000_508800 5.356235
R14308 n1_m1_432000_508800 n1_m1_436800_508800 5.356235
R14309 n1_m1_436800_508800 n1_m1_441600_508800 5.356235
R14310 n1_m1_441600_508800 n1_m1_446400_508800 5.356235
R14311 n1_m1_446400_508800 n1_m1_451200_508800 5.356235
R14312 n1_m1_451200_508800 n1_m1_452000_508800 0.892706
R14313 n1_m1_456000_508800 n1_m1_452000_508800 4.463529
R14314 n1_m1_456000_508800 n1_m1_460800_508800 5.356235
R14315 n1_m1_460800_508800 n1_m1_465600_508800 5.356235
R14316 n1_m1_465600_508800 n1_m1_470400_508800 5.356235
R14317 n1_m1_470400_508800 n1_m1_475200_508800 5.356235
R14318 n1_m1_475200_508800 n1_m1_480000_508800 5.356235
R14319 n1_m1_480000_508800 n1_m1_484800_508800 5.356235
R14320 n1_m1_484800_508800 n1_m1_489600_508800 5.356235
R14321 n1_m1_489600_508800 n1_m1_494400_508800 5.356235
R14322 n1_m1_494400_508800 n1_m1_499200_508800 5.356235
R14323 n1_m1_499200_508800 n1_m1_504000_508800 5.356235
R14324 n1_m1_504000_508800 n1_m1_508000_508800 4.463529
R14325 n1_m1_508800_508800 n1_m1_508000_508800 0.892706
R14326 n1_m1_508800_508800 n1_m1_513600_508800 5.356235
R14327 n1_m1_513600_508800 n1_m1_518400_508800 5.356235
R14328 n1_m1_518400_508800 n1_m1_523200_508800 5.356235
R14329 n1_m1_523200_508800 n1_m1_528000_508800 5.356235
R14330 n1_m1_528000_508800 n1_m1_532800_508800 5.356235
R14331 n1_m1_532800_508800 n1_m1_536000_508800 3.570824
R14332 n1_m1_537600_508800 n1_m1_536000_508800 1.785412
R14333 n1_m1_537600_508800 n1_m1_542400_508800 5.356235
R14334 n1_m1_542400_508800 n1_m1_547200_508800 5.356235
R14335 n1_m1_547200_508800 n1_m1_552000_508800 5.356235
R14336 n1_m1_552000_508800 n1_m1_556800_508800 5.356235
R14337 n1_m1_556800_508800 n1_m1_561600_508800 5.356235
R14338 n1_m1_0_513600 n1_m1_4000_513600 4.463529
R14339 n1_m1_4800_513600 n1_m1_4000_513600 0.892706
R14340 n1_m1_4800_513600 n1_m1_9600_513600 5.356235
R14341 n1_m1_9600_513600 n1_m1_14400_513600 5.356235
R14342 n1_m1_14400_513600 n1_m1_19200_513600 5.356235
R14343 n1_m1_19200_513600 n1_m1_24000_513600 5.356235
R14344 n1_m1_24000_513600 n1_m1_28800_513600 5.356235
R14345 n1_m1_28800_513600 n1_m1_32000_513600 3.570824
R14346 n1_m1_33600_513600 n1_m1_32000_513600 1.785412
R14347 n1_m1_33600_513600 n1_m1_38400_513600 5.356235
R14348 n1_m1_38400_513600 n1_m1_43200_513600 5.356235
R14349 n1_m1_43200_513600 n1_m1_48000_513600 5.356235
R14350 n1_m1_48000_513600 n1_m1_52800_513600 5.356235
R14351 n1_m1_52800_513600 n1_m1_57600_513600 5.356235
R14352 n1_m1_57600_513600 n1_m1_60000_513600 2.678118
R14353 n1_m1_62400_513600 n1_m1_60000_513600 2.678118
R14354 n1_m1_62400_513600 n1_m1_67200_513600 5.356235
R14355 n1_m1_67200_513600 n1_m1_72000_513600 5.356235
R14356 n1_m1_72000_513600 n1_m1_76800_513600 5.356235
R14357 n1_m1_76800_513600 n1_m1_81600_513600 5.356235
R14358 n1_m1_81600_513600 n1_m1_86400_513600 5.356235
R14359 n1_m1_86400_513600 n1_m1_88000_513600 1.785412
R14360 n1_m1_91200_513600 n1_m1_88000_513600 3.570824
R14361 n1_m1_91200_513600 n1_m1_96000_513600 5.356235
R14362 n1_m1_96000_513600 n1_m1_100800_513600 5.356235
R14363 n1_m1_100800_513600 n1_m1_105600_513600 5.356235
R14364 n1_m1_105600_513600 n1_m1_110400_513600 5.356235
R14365 n1_m1_110400_513600 n1_m1_115200_513600 5.356235
R14366 n1_m1_115200_513600 n1_m1_116000_513600 0.892706
R14367 n1_m1_120000_513600 n1_m1_116000_513600 4.463529
R14368 n1_m1_120000_513600 n1_m1_124800_513600 5.356235
R14369 n1_m1_124800_513600 n1_m1_129600_513600 5.356235
R14370 n1_m1_129600_513600 n1_m1_134400_513600 5.356235
R14371 n1_m1_134400_513600 n1_m1_139200_513600 5.356235
R14372 n1_m1_139200_513600 n1_m1_144000_513600 5.356235
R14373 n1_m1_144000_513600 n1_m1_148800_513600 5.356235
R14374 n1_m1_148800_513600 n1_m1_153600_513600 5.356235
R14375 n1_m1_153600_513600 n1_m1_158400_513600 5.356235
R14376 n1_m1_158400_513600 n1_m1_163200_513600 5.356235
R14377 n1_m1_163200_513600 n1_m1_168000_513600 5.356235
R14378 n1_m1_168000_513600 n1_m1_172000_513600 4.463529
R14379 n1_m1_172800_513600 n1_m1_172000_513600 0.892706
R14380 n1_m1_172800_513600 n1_m1_177600_513600 5.356235
R14381 n1_m1_177600_513600 n1_m1_182400_513600 5.356235
R14382 n1_m1_182400_513600 n1_m1_187200_513600 5.356235
R14383 n1_m1_187200_513600 n1_m1_192000_513600 5.356235
R14384 n1_m1_192000_513600 n1_m1_196800_513600 5.356235
R14385 n1_m1_196800_513600 n1_m1_200000_513600 3.570824
R14386 n1_m1_201600_513600 n1_m1_200000_513600 1.785412
R14387 n1_m1_201600_513600 n1_m1_206400_513600 5.356235
R14388 n1_m1_206400_513600 n1_m1_211200_513600 5.356235
R14389 n1_m1_211200_513600 n1_m1_216000_513600 5.356235
R14390 n1_m1_216000_513600 n1_m1_220800_513600 5.356235
R14391 n1_m1_220800_513600 n1_m1_225600_513600 5.356235
R14392 n1_m1_225600_513600 n1_m1_228000_513600 2.678118
R14393 n1_m1_230400_513600 n1_m1_228000_513600 2.678118
R14394 n1_m1_230400_513600 n1_m1_235200_513600 5.356235
R14395 n1_m1_235200_513600 n1_m1_240000_513600 5.356235
R14396 n1_m1_240000_513600 n1_m1_244800_513600 5.356235
R14397 n1_m1_244800_513600 n1_m1_249600_513600 5.356235
R14398 n1_m1_249600_513600 n1_m1_254400_513600 5.356235
R14399 n1_m1_254400_513600 n1_m1_256000_513600 1.785412
R14400 n1_m1_259200_513600 n1_m1_256000_513600 3.570824
R14401 n1_m1_259200_513600 n1_m1_264000_513600 5.356235
R14402 n1_m1_264000_513600 n1_m1_268800_513600 5.356235
R14403 n1_m1_268800_513600 n1_m1_273600_513600 5.356235
R14404 n1_m1_273600_513600 n1_m1_278400_513600 5.356235
R14405 n1_m1_278400_513600 n1_m1_283200_513600 5.356235
R14406 n1_m1_283200_513600 n1_m1_284000_513600 0.892706
R14407 n1_m1_288000_513600 n1_m1_284000_513600 4.463529
R14408 n1_m1_288000_513600 n1_m1_292800_513600 5.356235
R14409 n1_m1_292800_513600 n1_m1_297600_513600 5.356235
R14410 n1_m1_297600_513600 n1_m1_302400_513600 5.356235
R14411 n1_m1_302400_513600 n1_m1_307200_513600 5.356235
R14412 n1_m1_307200_513600 n1_m1_312000_513600 5.356235
R14413 n1_m1_312000_513600 n1_m1_316800_513600 5.356235
R14414 n1_m1_316800_513600 n1_m1_321600_513600 5.356235
R14415 n1_m1_321600_513600 n1_m1_326400_513600 5.356235
R14416 n1_m1_326400_513600 n1_m1_331200_513600 5.356235
R14417 n1_m1_331200_513600 n1_m1_336000_513600 5.356235
R14418 n1_m1_336000_513600 n1_m1_340000_513600 4.463529
R14419 n1_m1_340800_513600 n1_m1_340000_513600 0.892706
R14420 n1_m1_340800_513600 n1_m1_345600_513600 5.356235
R14421 n1_m1_345600_513600 n1_m1_350400_513600 5.356235
R14422 n1_m1_350400_513600 n1_m1_355200_513600 5.356235
R14423 n1_m1_355200_513600 n1_m1_360000_513600 5.356235
R14424 n1_m1_360000_513600 n1_m1_364800_513600 5.356235
R14425 n1_m1_364800_513600 n1_m1_368000_513600 3.570824
R14426 n1_m1_369600_513600 n1_m1_368000_513600 1.785412
R14427 n1_m1_369600_513600 n1_m1_374400_513600 5.356235
R14428 n1_m1_374400_513600 n1_m1_379200_513600 5.356235
R14429 n1_m1_379200_513600 n1_m1_384000_513600 5.356235
R14430 n1_m1_384000_513600 n1_m1_388800_513600 5.356235
R14431 n1_m1_388800_513600 n1_m1_393600_513600 5.356235
R14432 n1_m1_393600_513600 n1_m1_396000_513600 2.678118
R14433 n1_m1_398400_513600 n1_m1_396000_513600 2.678118
R14434 n1_m1_398400_513600 n1_m1_403200_513600 5.356235
R14435 n1_m1_403200_513600 n1_m1_408000_513600 5.356235
R14436 n1_m1_408000_513600 n1_m1_412800_513600 5.356235
R14437 n1_m1_412800_513600 n1_m1_417600_513600 5.356235
R14438 n1_m1_417600_513600 n1_m1_422400_513600 5.356235
R14439 n1_m1_422400_513600 n1_m1_424000_513600 1.785412
R14440 n1_m1_427200_513600 n1_m1_424000_513600 3.570824
R14441 n1_m1_427200_513600 n1_m1_432000_513600 5.356235
R14442 n1_m1_432000_513600 n1_m1_436800_513600 5.356235
R14443 n1_m1_436800_513600 n1_m1_441600_513600 5.356235
R14444 n1_m1_441600_513600 n1_m1_446400_513600 5.356235
R14445 n1_m1_446400_513600 n1_m1_451200_513600 5.356235
R14446 n1_m1_451200_513600 n1_m1_452000_513600 0.892706
R14447 n1_m1_456000_513600 n1_m1_452000_513600 4.463529
R14448 n1_m1_456000_513600 n1_m1_460800_513600 5.356235
R14449 n1_m1_460800_513600 n1_m1_465600_513600 5.356235
R14450 n1_m1_465600_513600 n1_m1_470400_513600 5.356235
R14451 n1_m1_470400_513600 n1_m1_475200_513600 5.356235
R14452 n1_m1_475200_513600 n1_m1_480000_513600 5.356235
R14453 n1_m1_480000_513600 n1_m1_484800_513600 5.356235
R14454 n1_m1_484800_513600 n1_m1_489600_513600 5.356235
R14455 n1_m1_489600_513600 n1_m1_494400_513600 5.356235
R14456 n1_m1_494400_513600 n1_m1_499200_513600 5.356235
R14457 n1_m1_499200_513600 n1_m1_504000_513600 5.356235
R14458 n1_m1_504000_513600 n1_m1_508000_513600 4.463529
R14459 n1_m1_508800_513600 n1_m1_508000_513600 0.892706
R14460 n1_m1_508800_513600 n1_m1_513600_513600 5.356235
R14461 n1_m1_513600_513600 n1_m1_518400_513600 5.356235
R14462 n1_m1_518400_513600 n1_m1_523200_513600 5.356235
R14463 n1_m1_523200_513600 n1_m1_528000_513600 5.356235
R14464 n1_m1_528000_513600 n1_m1_532800_513600 5.356235
R14465 n1_m1_532800_513600 n1_m1_536000_513600 3.570824
R14466 n1_m1_537600_513600 n1_m1_536000_513600 1.785412
R14467 n1_m1_537600_513600 n1_m1_542400_513600 5.356235
R14468 n1_m1_542400_513600 n1_m1_547200_513600 5.356235
R14469 n1_m1_547200_513600 n1_m1_552000_513600 5.356235
R14470 n1_m1_552000_513600 n1_m1_556800_513600 5.356235
R14471 n1_m1_556800_513600 n1_m1_561600_513600 5.356235
R14472 n1_m1_0_518400 n1_m1_4000_518400 4.463529
R14473 n1_m1_4800_518400 n1_m1_4000_518400 0.892706
R14474 n1_m1_4800_518400 n1_m1_9600_518400 5.356235
R14475 n1_m1_9600_518400 n1_m1_14400_518400 5.356235
R14476 n1_m1_14400_518400 n1_m1_19200_518400 5.356235
R14477 n1_m1_19200_518400 n1_m1_24000_518400 5.356235
R14478 n1_m1_24000_518400 n1_m1_28800_518400 5.356235
R14479 n1_m1_28800_518400 n1_m1_32000_518400 3.570824
R14480 n1_m1_33600_518400 n1_m1_32000_518400 1.785412
R14481 n1_m1_33600_518400 n1_m1_38400_518400 5.356235
R14482 n1_m1_38400_518400 n1_m1_43200_518400 5.356235
R14483 n1_m1_43200_518400 n1_m1_48000_518400 5.356235
R14484 n1_m1_48000_518400 n1_m1_52800_518400 5.356235
R14485 n1_m1_52800_518400 n1_m1_57600_518400 5.356235
R14486 n1_m1_57600_518400 n1_m1_60000_518400 2.678118
R14487 n1_m1_62400_518400 n1_m1_60000_518400 2.678118
R14488 n1_m1_62400_518400 n1_m1_67200_518400 5.356235
R14489 n1_m1_67200_518400 n1_m1_72000_518400 5.356235
R14490 n1_m1_72000_518400 n1_m1_76800_518400 5.356235
R14491 n1_m1_76800_518400 n1_m1_81600_518400 5.356235
R14492 n1_m1_81600_518400 n1_m1_86400_518400 5.356235
R14493 n1_m1_86400_518400 n1_m1_88000_518400 1.785412
R14494 n1_m1_91200_518400 n1_m1_88000_518400 3.570824
R14495 n1_m1_91200_518400 n1_m1_96000_518400 5.356235
R14496 n1_m1_96000_518400 n1_m1_100800_518400 5.356235
R14497 n1_m1_100800_518400 n1_m1_105600_518400 5.356235
R14498 n1_m1_105600_518400 n1_m1_110400_518400 5.356235
R14499 n1_m1_110400_518400 n1_m1_115200_518400 5.356235
R14500 n1_m1_115200_518400 n1_m1_116000_518400 0.892706
R14501 n1_m1_120000_518400 n1_m1_116000_518400 4.463529
R14502 n1_m1_120000_518400 n1_m1_124800_518400 5.356235
R14503 n1_m1_124800_518400 n1_m1_129600_518400 5.356235
R14504 n1_m1_129600_518400 n1_m1_134400_518400 5.356235
R14505 n1_m1_134400_518400 n1_m1_139200_518400 5.356235
R14506 n1_m1_139200_518400 n1_m1_144000_518400 5.356235
R14507 n1_m1_144000_518400 n1_m1_148800_518400 5.356235
R14508 n1_m1_148800_518400 n1_m1_153600_518400 5.356235
R14509 n1_m1_153600_518400 n1_m1_158400_518400 5.356235
R14510 n1_m1_158400_518400 n1_m1_163200_518400 5.356235
R14511 n1_m1_163200_518400 n1_m1_168000_518400 5.356235
R14512 n1_m1_168000_518400 n1_m1_172000_518400 4.463529
R14513 n1_m1_172800_518400 n1_m1_172000_518400 0.892706
R14514 n1_m1_172800_518400 n1_m1_177600_518400 5.356235
R14515 n1_m1_177600_518400 n1_m1_182400_518400 5.356235
R14516 n1_m1_182400_518400 n1_m1_187200_518400 5.356235
R14517 n1_m1_187200_518400 n1_m1_192000_518400 5.356235
R14518 n1_m1_192000_518400 n1_m1_196800_518400 5.356235
R14519 n1_m1_196800_518400 n1_m1_200000_518400 3.570824
R14520 n1_m1_201600_518400 n1_m1_200000_518400 1.785412
R14521 n1_m1_201600_518400 n1_m1_206400_518400 5.356235
R14522 n1_m1_206400_518400 n1_m1_211200_518400 5.356235
R14523 n1_m1_211200_518400 n1_m1_216000_518400 5.356235
R14524 n1_m1_216000_518400 n1_m1_220800_518400 5.356235
R14525 n1_m1_220800_518400 n1_m1_225600_518400 5.356235
R14526 n1_m1_225600_518400 n1_m1_228000_518400 2.678118
R14527 n1_m1_230400_518400 n1_m1_228000_518400 2.678118
R14528 n1_m1_230400_518400 n1_m1_235200_518400 5.356235
R14529 n1_m1_235200_518400 n1_m1_240000_518400 5.356235
R14530 n1_m1_240000_518400 n1_m1_244800_518400 5.356235
R14531 n1_m1_244800_518400 n1_m1_249600_518400 5.356235
R14532 n1_m1_249600_518400 n1_m1_254400_518400 5.356235
R14533 n1_m1_254400_518400 n1_m1_256000_518400 1.785412
R14534 n1_m1_259200_518400 n1_m1_256000_518400 3.570824
R14535 n1_m1_259200_518400 n1_m1_264000_518400 5.356235
R14536 n1_m1_264000_518400 n1_m1_268800_518400 5.356235
R14537 n1_m1_268800_518400 n1_m1_273600_518400 5.356235
R14538 n1_m1_273600_518400 n1_m1_278400_518400 5.356235
R14539 n1_m1_278400_518400 n1_m1_283200_518400 5.356235
R14540 n1_m1_283200_518400 n1_m1_284000_518400 0.892706
R14541 n1_m1_288000_518400 n1_m1_284000_518400 4.463529
R14542 n1_m1_288000_518400 n1_m1_292800_518400 5.356235
R14543 n1_m1_292800_518400 n1_m1_297600_518400 5.356235
R14544 n1_m1_297600_518400 n1_m1_302400_518400 5.356235
R14545 n1_m1_302400_518400 n1_m1_307200_518400 5.356235
R14546 n1_m1_307200_518400 n1_m1_312000_518400 5.356235
R14547 n1_m1_312000_518400 n1_m1_316800_518400 5.356235
R14548 n1_m1_316800_518400 n1_m1_321600_518400 5.356235
R14549 n1_m1_321600_518400 n1_m1_326400_518400 5.356235
R14550 n1_m1_326400_518400 n1_m1_331200_518400 5.356235
R14551 n1_m1_331200_518400 n1_m1_336000_518400 5.356235
R14552 n1_m1_336000_518400 n1_m1_340000_518400 4.463529
R14553 n1_m1_340800_518400 n1_m1_340000_518400 0.892706
R14554 n1_m1_340800_518400 n1_m1_345600_518400 5.356235
R14555 n1_m1_345600_518400 n1_m1_350400_518400 5.356235
R14556 n1_m1_350400_518400 n1_m1_355200_518400 5.356235
R14557 n1_m1_355200_518400 n1_m1_360000_518400 5.356235
R14558 n1_m1_360000_518400 n1_m1_364800_518400 5.356235
R14559 n1_m1_364800_518400 n1_m1_368000_518400 3.570824
R14560 n1_m1_369600_518400 n1_m1_368000_518400 1.785412
R14561 n1_m1_369600_518400 n1_m1_374400_518400 5.356235
R14562 n1_m1_374400_518400 n1_m1_379200_518400 5.356235
R14563 n1_m1_379200_518400 n1_m1_384000_518400 5.356235
R14564 n1_m1_384000_518400 n1_m1_388800_518400 5.356235
R14565 n1_m1_388800_518400 n1_m1_393600_518400 5.356235
R14566 n1_m1_393600_518400 n1_m1_396000_518400 2.678118
R14567 n1_m1_398400_518400 n1_m1_396000_518400 2.678118
R14568 n1_m1_398400_518400 n1_m1_403200_518400 5.356235
R14569 n1_m1_403200_518400 n1_m1_408000_518400 5.356235
R14570 n1_m1_408000_518400 n1_m1_412800_518400 5.356235
R14571 n1_m1_412800_518400 n1_m1_417600_518400 5.356235
R14572 n1_m1_417600_518400 n1_m1_422400_518400 5.356235
R14573 n1_m1_422400_518400 n1_m1_424000_518400 1.785412
R14574 n1_m1_427200_518400 n1_m1_424000_518400 3.570824
R14575 n1_m1_427200_518400 n1_m1_432000_518400 5.356235
R14576 n1_m1_432000_518400 n1_m1_436800_518400 5.356235
R14577 n1_m1_436800_518400 n1_m1_441600_518400 5.356235
R14578 n1_m1_441600_518400 n1_m1_446400_518400 5.356235
R14579 n1_m1_446400_518400 n1_m1_451200_518400 5.356235
R14580 n1_m1_451200_518400 n1_m1_452000_518400 0.892706
R14581 n1_m1_456000_518400 n1_m1_452000_518400 4.463529
R14582 n1_m1_456000_518400 n1_m1_460800_518400 5.356235
R14583 n1_m1_460800_518400 n1_m1_465600_518400 5.356235
R14584 n1_m1_465600_518400 n1_m1_470400_518400 5.356235
R14585 n1_m1_470400_518400 n1_m1_475200_518400 5.356235
R14586 n1_m1_475200_518400 n1_m1_480000_518400 5.356235
R14587 n1_m1_480000_518400 n1_m1_484800_518400 5.356235
R14588 n1_m1_484800_518400 n1_m1_489600_518400 5.356235
R14589 n1_m1_489600_518400 n1_m1_494400_518400 5.356235
R14590 n1_m1_494400_518400 n1_m1_499200_518400 5.356235
R14591 n1_m1_499200_518400 n1_m1_504000_518400 5.356235
R14592 n1_m1_504000_518400 n1_m1_508000_518400 4.463529
R14593 n1_m1_508800_518400 n1_m1_508000_518400 0.892706
R14594 n1_m1_508800_518400 n1_m1_513600_518400 5.356235
R14595 n1_m1_513600_518400 n1_m1_518400_518400 5.356235
R14596 n1_m1_518400_518400 n1_m1_523200_518400 5.356235
R14597 n1_m1_523200_518400 n1_m1_528000_518400 5.356235
R14598 n1_m1_528000_518400 n1_m1_532800_518400 5.356235
R14599 n1_m1_532800_518400 n1_m1_536000_518400 3.570824
R14600 n1_m1_537600_518400 n1_m1_536000_518400 1.785412
R14601 n1_m1_537600_518400 n1_m1_542400_518400 5.356235
R14602 n1_m1_542400_518400 n1_m1_547200_518400 5.356235
R14603 n1_m1_547200_518400 n1_m1_552000_518400 5.356235
R14604 n1_m1_552000_518400 n1_m1_556800_518400 5.356235
R14605 n1_m1_556800_518400 n1_m1_561600_518400 5.356235
R14606 n1_m1_0_523200 n1_m1_4000_523200 4.463529
R14607 n1_m1_4800_523200 n1_m1_4000_523200 0.892706
R14608 n1_m1_4800_523200 n1_m1_9600_523200 5.356235
R14609 n1_m1_9600_523200 n1_m1_14400_523200 5.356235
R14610 n1_m1_14400_523200 n1_m1_19200_523200 5.356235
R14611 n1_m1_19200_523200 n1_m1_24000_523200 5.356235
R14612 n1_m1_24000_523200 n1_m1_28800_523200 5.356235
R14613 n1_m1_28800_523200 n1_m1_32000_523200 3.570824
R14614 n1_m1_33600_523200 n1_m1_32000_523200 1.785412
R14615 n1_m1_33600_523200 n1_m1_38400_523200 5.356235
R14616 n1_m1_38400_523200 n1_m1_43200_523200 5.356235
R14617 n1_m1_43200_523200 n1_m1_48000_523200 5.356235
R14618 n1_m1_48000_523200 n1_m1_52800_523200 5.356235
R14619 n1_m1_52800_523200 n1_m1_57600_523200 5.356235
R14620 n1_m1_57600_523200 n1_m1_60000_523200 2.678118
R14621 n1_m1_62400_523200 n1_m1_60000_523200 2.678118
R14622 n1_m1_62400_523200 n1_m1_67200_523200 5.356235
R14623 n1_m1_67200_523200 n1_m1_72000_523200 5.356235
R14624 n1_m1_72000_523200 n1_m1_76800_523200 5.356235
R14625 n1_m1_76800_523200 n1_m1_81600_523200 5.356235
R14626 n1_m1_81600_523200 n1_m1_86400_523200 5.356235
R14627 n1_m1_86400_523200 n1_m1_88000_523200 1.785412
R14628 n1_m1_91200_523200 n1_m1_88000_523200 3.570824
R14629 n1_m1_91200_523200 n1_m1_96000_523200 5.356235
R14630 n1_m1_96000_523200 n1_m1_100800_523200 5.356235
R14631 n1_m1_100800_523200 n1_m1_105600_523200 5.356235
R14632 n1_m1_105600_523200 n1_m1_110400_523200 5.356235
R14633 n1_m1_110400_523200 n1_m1_115200_523200 5.356235
R14634 n1_m1_115200_523200 n1_m1_116000_523200 0.892706
R14635 n1_m1_120000_523200 n1_m1_116000_523200 4.463529
R14636 n1_m1_120000_523200 n1_m1_124800_523200 5.356235
R14637 n1_m1_124800_523200 n1_m1_129600_523200 5.356235
R14638 n1_m1_129600_523200 n1_m1_134400_523200 5.356235
R14639 n1_m1_134400_523200 n1_m1_139200_523200 5.356235
R14640 n1_m1_139200_523200 n1_m1_144000_523200 5.356235
R14641 n1_m1_144000_523200 n1_m1_148800_523200 5.356235
R14642 n1_m1_148800_523200 n1_m1_153600_523200 5.356235
R14643 n1_m1_153600_523200 n1_m1_158400_523200 5.356235
R14644 n1_m1_158400_523200 n1_m1_163200_523200 5.356235
R14645 n1_m1_163200_523200 n1_m1_168000_523200 5.356235
R14646 n1_m1_168000_523200 n1_m1_172000_523200 4.463529
R14647 n1_m1_172800_523200 n1_m1_172000_523200 0.892706
R14648 n1_m1_172800_523200 n1_m1_177600_523200 5.356235
R14649 n1_m1_177600_523200 n1_m1_182400_523200 5.356235
R14650 n1_m1_182400_523200 n1_m1_187200_523200 5.356235
R14651 n1_m1_187200_523200 n1_m1_192000_523200 5.356235
R14652 n1_m1_192000_523200 n1_m1_196800_523200 5.356235
R14653 n1_m1_196800_523200 n1_m1_200000_523200 3.570824
R14654 n1_m1_201600_523200 n1_m1_200000_523200 1.785412
R14655 n1_m1_201600_523200 n1_m1_206400_523200 5.356235
R14656 n1_m1_206400_523200 n1_m1_211200_523200 5.356235
R14657 n1_m1_211200_523200 n1_m1_216000_523200 5.356235
R14658 n1_m1_216000_523200 n1_m1_220800_523200 5.356235
R14659 n1_m1_220800_523200 n1_m1_225600_523200 5.356235
R14660 n1_m1_225600_523200 n1_m1_228000_523200 2.678118
R14661 n1_m1_230400_523200 n1_m1_228000_523200 2.678118
R14662 n1_m1_230400_523200 n1_m1_235200_523200 5.356235
R14663 n1_m1_235200_523200 n1_m1_240000_523200 5.356235
R14664 n1_m1_240000_523200 n1_m1_244800_523200 5.356235
R14665 n1_m1_244800_523200 n1_m1_249600_523200 5.356235
R14666 n1_m1_249600_523200 n1_m1_254400_523200 5.356235
R14667 n1_m1_254400_523200 n1_m1_256000_523200 1.785412
R14668 n1_m1_259200_523200 n1_m1_256000_523200 3.570824
R14669 n1_m1_259200_523200 n1_m1_264000_523200 5.356235
R14670 n1_m1_264000_523200 n1_m1_268800_523200 5.356235
R14671 n1_m1_268800_523200 n1_m1_273600_523200 5.356235
R14672 n1_m1_273600_523200 n1_m1_278400_523200 5.356235
R14673 n1_m1_278400_523200 n1_m1_283200_523200 5.356235
R14674 n1_m1_283200_523200 n1_m1_284000_523200 0.892706
R14675 n1_m1_288000_523200 n1_m1_284000_523200 4.463529
R14676 n1_m1_288000_523200 n1_m1_292800_523200 5.356235
R14677 n1_m1_292800_523200 n1_m1_297600_523200 5.356235
R14678 n1_m1_297600_523200 n1_m1_302400_523200 5.356235
R14679 n1_m1_302400_523200 n1_m1_307200_523200 5.356235
R14680 n1_m1_307200_523200 n1_m1_312000_523200 5.356235
R14681 n1_m1_312000_523200 n1_m1_316800_523200 5.356235
R14682 n1_m1_316800_523200 n1_m1_321600_523200 5.356235
R14683 n1_m1_321600_523200 n1_m1_326400_523200 5.356235
R14684 n1_m1_326400_523200 n1_m1_331200_523200 5.356235
R14685 n1_m1_331200_523200 n1_m1_336000_523200 5.356235
R14686 n1_m1_336000_523200 n1_m1_340000_523200 4.463529
R14687 n1_m1_340800_523200 n1_m1_340000_523200 0.892706
R14688 n1_m1_340800_523200 n1_m1_345600_523200 5.356235
R14689 n1_m1_345600_523200 n1_m1_350400_523200 5.356235
R14690 n1_m1_350400_523200 n1_m1_355200_523200 5.356235
R14691 n1_m1_355200_523200 n1_m1_360000_523200 5.356235
R14692 n1_m1_360000_523200 n1_m1_364800_523200 5.356235
R14693 n1_m1_364800_523200 n1_m1_368000_523200 3.570824
R14694 n1_m1_369600_523200 n1_m1_368000_523200 1.785412
R14695 n1_m1_369600_523200 n1_m1_374400_523200 5.356235
R14696 n1_m1_374400_523200 n1_m1_379200_523200 5.356235
R14697 n1_m1_379200_523200 n1_m1_384000_523200 5.356235
R14698 n1_m1_384000_523200 n1_m1_388800_523200 5.356235
R14699 n1_m1_388800_523200 n1_m1_393600_523200 5.356235
R14700 n1_m1_393600_523200 n1_m1_396000_523200 2.678118
R14701 n1_m1_398400_523200 n1_m1_396000_523200 2.678118
R14702 n1_m1_398400_523200 n1_m1_403200_523200 5.356235
R14703 n1_m1_403200_523200 n1_m1_408000_523200 5.356235
R14704 n1_m1_408000_523200 n1_m1_412800_523200 5.356235
R14705 n1_m1_412800_523200 n1_m1_417600_523200 5.356235
R14706 n1_m1_417600_523200 n1_m1_422400_523200 5.356235
R14707 n1_m1_422400_523200 n1_m1_424000_523200 1.785412
R14708 n1_m1_427200_523200 n1_m1_424000_523200 3.570824
R14709 n1_m1_427200_523200 n1_m1_432000_523200 5.356235
R14710 n1_m1_432000_523200 n1_m1_436800_523200 5.356235
R14711 n1_m1_436800_523200 n1_m1_441600_523200 5.356235
R14712 n1_m1_441600_523200 n1_m1_446400_523200 5.356235
R14713 n1_m1_446400_523200 n1_m1_451200_523200 5.356235
R14714 n1_m1_451200_523200 n1_m1_452000_523200 0.892706
R14715 n1_m1_456000_523200 n1_m1_452000_523200 4.463529
R14716 n1_m1_456000_523200 n1_m1_460800_523200 5.356235
R14717 n1_m1_460800_523200 n1_m1_465600_523200 5.356235
R14718 n1_m1_465600_523200 n1_m1_470400_523200 5.356235
R14719 n1_m1_470400_523200 n1_m1_475200_523200 5.356235
R14720 n1_m1_475200_523200 n1_m1_480000_523200 5.356235
R14721 n1_m1_480000_523200 n1_m1_484800_523200 5.356235
R14722 n1_m1_484800_523200 n1_m1_489600_523200 5.356235
R14723 n1_m1_489600_523200 n1_m1_494400_523200 5.356235
R14724 n1_m1_494400_523200 n1_m1_499200_523200 5.356235
R14725 n1_m1_499200_523200 n1_m1_504000_523200 5.356235
R14726 n1_m1_504000_523200 n1_m1_508000_523200 4.463529
R14727 n1_m1_508800_523200 n1_m1_508000_523200 0.892706
R14728 n1_m1_508800_523200 n1_m1_513600_523200 5.356235
R14729 n1_m1_513600_523200 n1_m1_518400_523200 5.356235
R14730 n1_m1_518400_523200 n1_m1_523200_523200 5.356235
R14731 n1_m1_523200_523200 n1_m1_528000_523200 5.356235
R14732 n1_m1_528000_523200 n1_m1_532800_523200 5.356235
R14733 n1_m1_532800_523200 n1_m1_536000_523200 3.570824
R14734 n1_m1_537600_523200 n1_m1_536000_523200 1.785412
R14735 n1_m1_537600_523200 n1_m1_542400_523200 5.356235
R14736 n1_m1_542400_523200 n1_m1_547200_523200 5.356235
R14737 n1_m1_547200_523200 n1_m1_552000_523200 5.356235
R14738 n1_m1_552000_523200 n1_m1_556800_523200 5.356235
R14739 n1_m1_556800_523200 n1_m1_561600_523200 5.356235
R14740 n1_m1_0_528000 n1_m1_4000_528000 4.463529
R14741 n1_m1_4800_528000 n1_m1_4000_528000 0.892706
R14742 n1_m1_4800_528000 n1_m1_9600_528000 5.356235
R14743 n1_m1_9600_528000 n1_m1_14400_528000 5.356235
R14744 n1_m1_14400_528000 n1_m1_19200_528000 5.356235
R14745 n1_m1_19200_528000 n1_m1_24000_528000 5.356235
R14746 n1_m1_24000_528000 n1_m1_28800_528000 5.356235
R14747 n1_m1_28800_528000 n1_m1_32000_528000 3.570824
R14748 n1_m1_33600_528000 n1_m1_32000_528000 1.785412
R14749 n1_m1_33600_528000 n1_m1_38400_528000 5.356235
R14750 n1_m1_38400_528000 n1_m1_43200_528000 5.356235
R14751 n1_m1_43200_528000 n1_m1_48000_528000 5.356235
R14752 n1_m1_48000_528000 n1_m1_52800_528000 5.356235
R14753 n1_m1_52800_528000 n1_m1_57600_528000 5.356235
R14754 n1_m1_57600_528000 n1_m1_60000_528000 2.678118
R14755 n1_m1_62400_528000 n1_m1_60000_528000 2.678118
R14756 n1_m1_62400_528000 n1_m1_67200_528000 5.356235
R14757 n1_m1_67200_528000 n1_m1_72000_528000 5.356235
R14758 n1_m1_72000_528000 n1_m1_76800_528000 5.356235
R14759 n1_m1_76800_528000 n1_m1_81600_528000 5.356235
R14760 n1_m1_81600_528000 n1_m1_86400_528000 5.356235
R14761 n1_m1_86400_528000 n1_m1_88000_528000 1.785412
R14762 n1_m1_91200_528000 n1_m1_88000_528000 3.570824
R14763 n1_m1_91200_528000 n1_m1_96000_528000 5.356235
R14764 n1_m1_96000_528000 n1_m1_100800_528000 5.356235
R14765 n1_m1_100800_528000 n1_m1_105600_528000 5.356235
R14766 n1_m1_105600_528000 n1_m1_110400_528000 5.356235
R14767 n1_m1_110400_528000 n1_m1_115200_528000 5.356235
R14768 n1_m1_115200_528000 n1_m1_116000_528000 0.892706
R14769 n1_m1_120000_528000 n1_m1_116000_528000 4.463529
R14770 n1_m1_120000_528000 n1_m1_124800_528000 5.356235
R14771 n1_m1_124800_528000 n1_m1_129600_528000 5.356235
R14772 n1_m1_129600_528000 n1_m1_134400_528000 5.356235
R14773 n1_m1_134400_528000 n1_m1_139200_528000 5.356235
R14774 n1_m1_139200_528000 n1_m1_144000_528000 5.356235
R14775 n1_m1_144000_528000 n1_m1_148800_528000 5.356235
R14776 n1_m1_148800_528000 n1_m1_153600_528000 5.356235
R14777 n1_m1_153600_528000 n1_m1_158400_528000 5.356235
R14778 n1_m1_158400_528000 n1_m1_163200_528000 5.356235
R14779 n1_m1_163200_528000 n1_m1_168000_528000 5.356235
R14780 n1_m1_168000_528000 n1_m1_172000_528000 4.463529
R14781 n1_m1_172800_528000 n1_m1_172000_528000 0.892706
R14782 n1_m1_172800_528000 n1_m1_177600_528000 5.356235
R14783 n1_m1_177600_528000 n1_m1_182400_528000 5.356235
R14784 n1_m1_182400_528000 n1_m1_187200_528000 5.356235
R14785 n1_m1_187200_528000 n1_m1_192000_528000 5.356235
R14786 n1_m1_192000_528000 n1_m1_196800_528000 5.356235
R14787 n1_m1_196800_528000 n1_m1_200000_528000 3.570824
R14788 n1_m1_201600_528000 n1_m1_200000_528000 1.785412
R14789 n1_m1_201600_528000 n1_m1_206400_528000 5.356235
R14790 n1_m1_206400_528000 n1_m1_211200_528000 5.356235
R14791 n1_m1_211200_528000 n1_m1_216000_528000 5.356235
R14792 n1_m1_216000_528000 n1_m1_220800_528000 5.356235
R14793 n1_m1_220800_528000 n1_m1_225600_528000 5.356235
R14794 n1_m1_225600_528000 n1_m1_228000_528000 2.678118
R14795 n1_m1_230400_528000 n1_m1_228000_528000 2.678118
R14796 n1_m1_230400_528000 n1_m1_235200_528000 5.356235
R14797 n1_m1_235200_528000 n1_m1_240000_528000 5.356235
R14798 n1_m1_240000_528000 n1_m1_244800_528000 5.356235
R14799 n1_m1_244800_528000 n1_m1_249600_528000 5.356235
R14800 n1_m1_249600_528000 n1_m1_254400_528000 5.356235
R14801 n1_m1_254400_528000 n1_m1_256000_528000 1.785412
R14802 n1_m1_259200_528000 n1_m1_256000_528000 3.570824
R14803 n1_m1_259200_528000 n1_m1_264000_528000 5.356235
R14804 n1_m1_264000_528000 n1_m1_268800_528000 5.356235
R14805 n1_m1_268800_528000 n1_m1_273600_528000 5.356235
R14806 n1_m1_273600_528000 n1_m1_278400_528000 5.356235
R14807 n1_m1_278400_528000 n1_m1_283200_528000 5.356235
R14808 n1_m1_283200_528000 n1_m1_284000_528000 0.892706
R14809 n1_m1_288000_528000 n1_m1_284000_528000 4.463529
R14810 n1_m1_288000_528000 n1_m1_292800_528000 5.356235
R14811 n1_m1_292800_528000 n1_m1_297600_528000 5.356235
R14812 n1_m1_297600_528000 n1_m1_302400_528000 5.356235
R14813 n1_m1_302400_528000 n1_m1_307200_528000 5.356235
R14814 n1_m1_307200_528000 n1_m1_312000_528000 5.356235
R14815 n1_m1_312000_528000 n1_m1_316800_528000 5.356235
R14816 n1_m1_316800_528000 n1_m1_321600_528000 5.356235
R14817 n1_m1_321600_528000 n1_m1_326400_528000 5.356235
R14818 n1_m1_326400_528000 n1_m1_331200_528000 5.356235
R14819 n1_m1_331200_528000 n1_m1_336000_528000 5.356235
R14820 n1_m1_336000_528000 n1_m1_340000_528000 4.463529
R14821 n1_m1_340800_528000 n1_m1_340000_528000 0.892706
R14822 n1_m1_340800_528000 n1_m1_345600_528000 5.356235
R14823 n1_m1_345600_528000 n1_m1_350400_528000 5.356235
R14824 n1_m1_350400_528000 n1_m1_355200_528000 5.356235
R14825 n1_m1_355200_528000 n1_m1_360000_528000 5.356235
R14826 n1_m1_360000_528000 n1_m1_364800_528000 5.356235
R14827 n1_m1_364800_528000 n1_m1_368000_528000 3.570824
R14828 n1_m1_369600_528000 n1_m1_368000_528000 1.785412
R14829 n1_m1_369600_528000 n1_m1_374400_528000 5.356235
R14830 n1_m1_374400_528000 n1_m1_379200_528000 5.356235
R14831 n1_m1_379200_528000 n1_m1_384000_528000 5.356235
R14832 n1_m1_384000_528000 n1_m1_388800_528000 5.356235
R14833 n1_m1_388800_528000 n1_m1_393600_528000 5.356235
R14834 n1_m1_393600_528000 n1_m1_396000_528000 2.678118
R14835 n1_m1_398400_528000 n1_m1_396000_528000 2.678118
R14836 n1_m1_398400_528000 n1_m1_403200_528000 5.356235
R14837 n1_m1_403200_528000 n1_m1_408000_528000 5.356235
R14838 n1_m1_408000_528000 n1_m1_412800_528000 5.356235
R14839 n1_m1_412800_528000 n1_m1_417600_528000 5.356235
R14840 n1_m1_417600_528000 n1_m1_422400_528000 5.356235
R14841 n1_m1_422400_528000 n1_m1_424000_528000 1.785412
R14842 n1_m1_427200_528000 n1_m1_424000_528000 3.570824
R14843 n1_m1_427200_528000 n1_m1_432000_528000 5.356235
R14844 n1_m1_432000_528000 n1_m1_436800_528000 5.356235
R14845 n1_m1_436800_528000 n1_m1_441600_528000 5.356235
R14846 n1_m1_441600_528000 n1_m1_446400_528000 5.356235
R14847 n1_m1_446400_528000 n1_m1_451200_528000 5.356235
R14848 n1_m1_451200_528000 n1_m1_452000_528000 0.892706
R14849 n1_m1_456000_528000 n1_m1_452000_528000 4.463529
R14850 n1_m1_456000_528000 n1_m1_460800_528000 5.356235
R14851 n1_m1_460800_528000 n1_m1_465600_528000 5.356235
R14852 n1_m1_465600_528000 n1_m1_470400_528000 5.356235
R14853 n1_m1_470400_528000 n1_m1_475200_528000 5.356235
R14854 n1_m1_475200_528000 n1_m1_480000_528000 5.356235
R14855 n1_m1_480000_528000 n1_m1_484800_528000 5.356235
R14856 n1_m1_484800_528000 n1_m1_489600_528000 5.356235
R14857 n1_m1_489600_528000 n1_m1_494400_528000 5.356235
R14858 n1_m1_494400_528000 n1_m1_499200_528000 5.356235
R14859 n1_m1_499200_528000 n1_m1_504000_528000 5.356235
R14860 n1_m1_504000_528000 n1_m1_508000_528000 4.463529
R14861 n1_m1_508800_528000 n1_m1_508000_528000 0.892706
R14862 n1_m1_508800_528000 n1_m1_513600_528000 5.356235
R14863 n1_m1_513600_528000 n1_m1_518400_528000 5.356235
R14864 n1_m1_518400_528000 n1_m1_523200_528000 5.356235
R14865 n1_m1_523200_528000 n1_m1_528000_528000 5.356235
R14866 n1_m1_528000_528000 n1_m1_532800_528000 5.356235
R14867 n1_m1_532800_528000 n1_m1_536000_528000 3.570824
R14868 n1_m1_537600_528000 n1_m1_536000_528000 1.785412
R14869 n1_m1_537600_528000 n1_m1_542400_528000 5.356235
R14870 n1_m1_542400_528000 n1_m1_547200_528000 5.356235
R14871 n1_m1_547200_528000 n1_m1_552000_528000 5.356235
R14872 n1_m1_552000_528000 n1_m1_556800_528000 5.356235
R14873 n1_m1_556800_528000 n1_m1_561600_528000 5.356235
R14874 n1_m1_0_532800 n1_m1_4000_532800 4.463529
R14875 n1_m1_4800_532800 n1_m1_4000_532800 0.892706
R14876 n1_m1_4800_532800 n1_m1_9600_532800 5.356235
R14877 n1_m1_9600_532800 n1_m1_14400_532800 5.356235
R14878 n1_m1_14400_532800 n1_m1_19200_532800 5.356235
R14879 n1_m1_19200_532800 n1_m1_24000_532800 5.356235
R14880 n1_m1_24000_532800 n1_m1_28800_532800 5.356235
R14881 n1_m1_28800_532800 n1_m1_32000_532800 3.570824
R14882 n1_m1_33600_532800 n1_m1_32000_532800 1.785412
R14883 n1_m1_33600_532800 n1_m1_38400_532800 5.356235
R14884 n1_m1_38400_532800 n1_m1_43200_532800 5.356235
R14885 n1_m1_43200_532800 n1_m1_48000_532800 5.356235
R14886 n1_m1_48000_532800 n1_m1_52800_532800 5.356235
R14887 n1_m1_52800_532800 n1_m1_57600_532800 5.356235
R14888 n1_m1_57600_532800 n1_m1_60000_532800 2.678118
R14889 n1_m1_62400_532800 n1_m1_60000_532800 2.678118
R14890 n1_m1_62400_532800 n1_m1_67200_532800 5.356235
R14891 n1_m1_67200_532800 n1_m1_72000_532800 5.356235
R14892 n1_m1_72000_532800 n1_m1_76800_532800 5.356235
R14893 n1_m1_76800_532800 n1_m1_81600_532800 5.356235
R14894 n1_m1_81600_532800 n1_m1_86400_532800 5.356235
R14895 n1_m1_86400_532800 n1_m1_88000_532800 1.785412
R14896 n1_m1_91200_532800 n1_m1_88000_532800 3.570824
R14897 n1_m1_91200_532800 n1_m1_96000_532800 5.356235
R14898 n1_m1_96000_532800 n1_m1_100800_532800 5.356235
R14899 n1_m1_100800_532800 n1_m1_105600_532800 5.356235
R14900 n1_m1_105600_532800 n1_m1_110400_532800 5.356235
R14901 n1_m1_110400_532800 n1_m1_115200_532800 5.356235
R14902 n1_m1_115200_532800 n1_m1_116000_532800 0.892706
R14903 n1_m1_120000_532800 n1_m1_116000_532800 4.463529
R14904 n1_m1_120000_532800 n1_m1_124800_532800 5.356235
R14905 n1_m1_124800_532800 n1_m1_129600_532800 5.356235
R14906 n1_m1_129600_532800 n1_m1_134400_532800 5.356235
R14907 n1_m1_134400_532800 n1_m1_139200_532800 5.356235
R14908 n1_m1_139200_532800 n1_m1_144000_532800 5.356235
R14909 n1_m1_144000_532800 n1_m1_148800_532800 5.356235
R14910 n1_m1_148800_532800 n1_m1_153600_532800 5.356235
R14911 n1_m1_153600_532800 n1_m1_158400_532800 5.356235
R14912 n1_m1_158400_532800 n1_m1_163200_532800 5.356235
R14913 n1_m1_163200_532800 n1_m1_168000_532800 5.356235
R14914 n1_m1_168000_532800 n1_m1_172000_532800 4.463529
R14915 n1_m1_172800_532800 n1_m1_172000_532800 0.892706
R14916 n1_m1_172800_532800 n1_m1_177600_532800 5.356235
R14917 n1_m1_177600_532800 n1_m1_182400_532800 5.356235
R14918 n1_m1_182400_532800 n1_m1_187200_532800 5.356235
R14919 n1_m1_187200_532800 n1_m1_192000_532800 5.356235
R14920 n1_m1_192000_532800 n1_m1_196800_532800 5.356235
R14921 n1_m1_196800_532800 n1_m1_200000_532800 3.570824
R14922 n1_m1_201600_532800 n1_m1_200000_532800 1.785412
R14923 n1_m1_201600_532800 n1_m1_206400_532800 5.356235
R14924 n1_m1_206400_532800 n1_m1_211200_532800 5.356235
R14925 n1_m1_211200_532800 n1_m1_216000_532800 5.356235
R14926 n1_m1_216000_532800 n1_m1_220800_532800 5.356235
R14927 n1_m1_220800_532800 n1_m1_225600_532800 5.356235
R14928 n1_m1_225600_532800 n1_m1_228000_532800 2.678118
R14929 n1_m1_230400_532800 n1_m1_228000_532800 2.678118
R14930 n1_m1_230400_532800 n1_m1_235200_532800 5.356235
R14931 n1_m1_235200_532800 n1_m1_240000_532800 5.356235
R14932 n1_m1_240000_532800 n1_m1_244800_532800 5.356235
R14933 n1_m1_244800_532800 n1_m1_249600_532800 5.356235
R14934 n1_m1_249600_532800 n1_m1_254400_532800 5.356235
R14935 n1_m1_254400_532800 n1_m1_256000_532800 1.785412
R14936 n1_m1_259200_532800 n1_m1_256000_532800 3.570824
R14937 n1_m1_259200_532800 n1_m1_264000_532800 5.356235
R14938 n1_m1_264000_532800 n1_m1_268800_532800 5.356235
R14939 n1_m1_268800_532800 n1_m1_273600_532800 5.356235
R14940 n1_m1_273600_532800 n1_m1_278400_532800 5.356235
R14941 n1_m1_278400_532800 n1_m1_283200_532800 5.356235
R14942 n1_m1_283200_532800 n1_m1_284000_532800 0.892706
R14943 n1_m1_288000_532800 n1_m1_284000_532800 4.463529
R14944 n1_m1_288000_532800 n1_m1_292800_532800 5.356235
R14945 n1_m1_292800_532800 n1_m1_297600_532800 5.356235
R14946 n1_m1_297600_532800 n1_m1_302400_532800 5.356235
R14947 n1_m1_302400_532800 n1_m1_307200_532800 5.356235
R14948 n1_m1_307200_532800 n1_m1_312000_532800 5.356235
R14949 n1_m1_312000_532800 n1_m1_316800_532800 5.356235
R14950 n1_m1_316800_532800 n1_m1_321600_532800 5.356235
R14951 n1_m1_321600_532800 n1_m1_326400_532800 5.356235
R14952 n1_m1_326400_532800 n1_m1_331200_532800 5.356235
R14953 n1_m1_331200_532800 n1_m1_336000_532800 5.356235
R14954 n1_m1_336000_532800 n1_m1_340000_532800 4.463529
R14955 n1_m1_340800_532800 n1_m1_340000_532800 0.892706
R14956 n1_m1_340800_532800 n1_m1_345600_532800 5.356235
R14957 n1_m1_345600_532800 n1_m1_350400_532800 5.356235
R14958 n1_m1_350400_532800 n1_m1_355200_532800 5.356235
R14959 n1_m1_355200_532800 n1_m1_360000_532800 5.356235
R14960 n1_m1_360000_532800 n1_m1_364800_532800 5.356235
R14961 n1_m1_364800_532800 n1_m1_368000_532800 3.570824
R14962 n1_m1_369600_532800 n1_m1_368000_532800 1.785412
R14963 n1_m1_369600_532800 n1_m1_374400_532800 5.356235
R14964 n1_m1_374400_532800 n1_m1_379200_532800 5.356235
R14965 n1_m1_379200_532800 n1_m1_384000_532800 5.356235
R14966 n1_m1_384000_532800 n1_m1_388800_532800 5.356235
R14967 n1_m1_388800_532800 n1_m1_393600_532800 5.356235
R14968 n1_m1_393600_532800 n1_m1_396000_532800 2.678118
R14969 n1_m1_398400_532800 n1_m1_396000_532800 2.678118
R14970 n1_m1_398400_532800 n1_m1_403200_532800 5.356235
R14971 n1_m1_403200_532800 n1_m1_408000_532800 5.356235
R14972 n1_m1_408000_532800 n1_m1_412800_532800 5.356235
R14973 n1_m1_412800_532800 n1_m1_417600_532800 5.356235
R14974 n1_m1_417600_532800 n1_m1_422400_532800 5.356235
R14975 n1_m1_422400_532800 n1_m1_424000_532800 1.785412
R14976 n1_m1_427200_532800 n1_m1_424000_532800 3.570824
R14977 n1_m1_427200_532800 n1_m1_432000_532800 5.356235
R14978 n1_m1_432000_532800 n1_m1_436800_532800 5.356235
R14979 n1_m1_436800_532800 n1_m1_441600_532800 5.356235
R14980 n1_m1_441600_532800 n1_m1_446400_532800 5.356235
R14981 n1_m1_446400_532800 n1_m1_451200_532800 5.356235
R14982 n1_m1_451200_532800 n1_m1_452000_532800 0.892706
R14983 n1_m1_456000_532800 n1_m1_452000_532800 4.463529
R14984 n1_m1_456000_532800 n1_m1_460800_532800 5.356235
R14985 n1_m1_460800_532800 n1_m1_465600_532800 5.356235
R14986 n1_m1_465600_532800 n1_m1_470400_532800 5.356235
R14987 n1_m1_470400_532800 n1_m1_475200_532800 5.356235
R14988 n1_m1_475200_532800 n1_m1_480000_532800 5.356235
R14989 n1_m1_480000_532800 n1_m1_484800_532800 5.356235
R14990 n1_m1_484800_532800 n1_m1_489600_532800 5.356235
R14991 n1_m1_489600_532800 n1_m1_494400_532800 5.356235
R14992 n1_m1_494400_532800 n1_m1_499200_532800 5.356235
R14993 n1_m1_499200_532800 n1_m1_504000_532800 5.356235
R14994 n1_m1_504000_532800 n1_m1_508000_532800 4.463529
R14995 n1_m1_508800_532800 n1_m1_508000_532800 0.892706
R14996 n1_m1_508800_532800 n1_m1_513600_532800 5.356235
R14997 n1_m1_513600_532800 n1_m1_518400_532800 5.356235
R14998 n1_m1_518400_532800 n1_m1_523200_532800 5.356235
R14999 n1_m1_523200_532800 n1_m1_528000_532800 5.356235
R15000 n1_m1_528000_532800 n1_m1_532800_532800 5.356235
R15001 n1_m1_532800_532800 n1_m1_536000_532800 3.570824
R15002 n1_m1_537600_532800 n1_m1_536000_532800 1.785412
R15003 n1_m1_537600_532800 n1_m1_542400_532800 5.356235
R15004 n1_m1_542400_532800 n1_m1_547200_532800 5.356235
R15005 n1_m1_547200_532800 n1_m1_552000_532800 5.356235
R15006 n1_m1_552000_532800 n1_m1_556800_532800 5.356235
R15007 n1_m1_556800_532800 n1_m1_561600_532800 5.356235
R15008 n1_m1_0_537600 n1_m1_4000_537600 4.463529
R15009 n1_m1_4800_537600 n1_m1_4000_537600 0.892706
R15010 n1_m1_4800_537600 n1_m1_9600_537600 5.356235
R15011 n1_m1_9600_537600 n1_m1_14400_537600 5.356235
R15012 n1_m1_14400_537600 n1_m1_19200_537600 5.356235
R15013 n1_m1_19200_537600 n1_m1_24000_537600 5.356235
R15014 n1_m1_24000_537600 n1_m1_28800_537600 5.356235
R15015 n1_m1_28800_537600 n1_m1_32000_537600 3.570824
R15016 n1_m1_33600_537600 n1_m1_32000_537600 1.785412
R15017 n1_m1_33600_537600 n1_m1_38400_537600 5.356235
R15018 n1_m1_38400_537600 n1_m1_43200_537600 5.356235
R15019 n1_m1_43200_537600 n1_m1_48000_537600 5.356235
R15020 n1_m1_48000_537600 n1_m1_52800_537600 5.356235
R15021 n1_m1_52800_537600 n1_m1_57600_537600 5.356235
R15022 n1_m1_57600_537600 n1_m1_60000_537600 2.678118
R15023 n1_m1_62400_537600 n1_m1_60000_537600 2.678118
R15024 n1_m1_62400_537600 n1_m1_67200_537600 5.356235
R15025 n1_m1_67200_537600 n1_m1_72000_537600 5.356235
R15026 n1_m1_72000_537600 n1_m1_76800_537600 5.356235
R15027 n1_m1_76800_537600 n1_m1_81600_537600 5.356235
R15028 n1_m1_81600_537600 n1_m1_86400_537600 5.356235
R15029 n1_m1_86400_537600 n1_m1_88000_537600 1.785412
R15030 n1_m1_91200_537600 n1_m1_88000_537600 3.570824
R15031 n1_m1_91200_537600 n1_m1_96000_537600 5.356235
R15032 n1_m1_96000_537600 n1_m1_100800_537600 5.356235
R15033 n1_m1_100800_537600 n1_m1_105600_537600 5.356235
R15034 n1_m1_105600_537600 n1_m1_110400_537600 5.356235
R15035 n1_m1_110400_537600 n1_m1_115200_537600 5.356235
R15036 n1_m1_115200_537600 n1_m1_116000_537600 0.892706
R15037 n1_m1_120000_537600 n1_m1_116000_537600 4.463529
R15038 n1_m1_120000_537600 n1_m1_124800_537600 5.356235
R15039 n1_m1_124800_537600 n1_m1_129600_537600 5.356235
R15040 n1_m1_129600_537600 n1_m1_134400_537600 5.356235
R15041 n1_m1_134400_537600 n1_m1_139200_537600 5.356235
R15042 n1_m1_139200_537600 n1_m1_144000_537600 5.356235
R15043 n1_m1_144000_537600 n1_m1_148800_537600 5.356235
R15044 n1_m1_148800_537600 n1_m1_153600_537600 5.356235
R15045 n1_m1_153600_537600 n1_m1_158400_537600 5.356235
R15046 n1_m1_158400_537600 n1_m1_163200_537600 5.356235
R15047 n1_m1_163200_537600 n1_m1_168000_537600 5.356235
R15048 n1_m1_168000_537600 n1_m1_172000_537600 4.463529
R15049 n1_m1_172800_537600 n1_m1_172000_537600 0.892706
R15050 n1_m1_172800_537600 n1_m1_177600_537600 5.356235
R15051 n1_m1_177600_537600 n1_m1_182400_537600 5.356235
R15052 n1_m1_182400_537600 n1_m1_187200_537600 5.356235
R15053 n1_m1_187200_537600 n1_m1_192000_537600 5.356235
R15054 n1_m1_192000_537600 n1_m1_196800_537600 5.356235
R15055 n1_m1_196800_537600 n1_m1_200000_537600 3.570824
R15056 n1_m1_201600_537600 n1_m1_200000_537600 1.785412
R15057 n1_m1_201600_537600 n1_m1_206400_537600 5.356235
R15058 n1_m1_206400_537600 n1_m1_211200_537600 5.356235
R15059 n1_m1_211200_537600 n1_m1_216000_537600 5.356235
R15060 n1_m1_216000_537600 n1_m1_220800_537600 5.356235
R15061 n1_m1_220800_537600 n1_m1_225600_537600 5.356235
R15062 n1_m1_225600_537600 n1_m1_228000_537600 2.678118
R15063 n1_m1_230400_537600 n1_m1_228000_537600 2.678118
R15064 n1_m1_230400_537600 n1_m1_235200_537600 5.356235
R15065 n1_m1_235200_537600 n1_m1_240000_537600 5.356235
R15066 n1_m1_240000_537600 n1_m1_244800_537600 5.356235
R15067 n1_m1_244800_537600 n1_m1_249600_537600 5.356235
R15068 n1_m1_249600_537600 n1_m1_254400_537600 5.356235
R15069 n1_m1_254400_537600 n1_m1_256000_537600 1.785412
R15070 n1_m1_259200_537600 n1_m1_256000_537600 3.570824
R15071 n1_m1_259200_537600 n1_m1_264000_537600 5.356235
R15072 n1_m1_264000_537600 n1_m1_268800_537600 5.356235
R15073 n1_m1_268800_537600 n1_m1_273600_537600 5.356235
R15074 n1_m1_273600_537600 n1_m1_278400_537600 5.356235
R15075 n1_m1_278400_537600 n1_m1_283200_537600 5.356235
R15076 n1_m1_283200_537600 n1_m1_284000_537600 0.892706
R15077 n1_m1_288000_537600 n1_m1_284000_537600 4.463529
R15078 n1_m1_288000_537600 n1_m1_292800_537600 5.356235
R15079 n1_m1_292800_537600 n1_m1_297600_537600 5.356235
R15080 n1_m1_297600_537600 n1_m1_302400_537600 5.356235
R15081 n1_m1_302400_537600 n1_m1_307200_537600 5.356235
R15082 n1_m1_307200_537600 n1_m1_312000_537600 5.356235
R15083 n1_m1_312000_537600 n1_m1_316800_537600 5.356235
R15084 n1_m1_316800_537600 n1_m1_321600_537600 5.356235
R15085 n1_m1_321600_537600 n1_m1_326400_537600 5.356235
R15086 n1_m1_326400_537600 n1_m1_331200_537600 5.356235
R15087 n1_m1_331200_537600 n1_m1_336000_537600 5.356235
R15088 n1_m1_336000_537600 n1_m1_340000_537600 4.463529
R15089 n1_m1_340800_537600 n1_m1_340000_537600 0.892706
R15090 n1_m1_340800_537600 n1_m1_345600_537600 5.356235
R15091 n1_m1_345600_537600 n1_m1_350400_537600 5.356235
R15092 n1_m1_350400_537600 n1_m1_355200_537600 5.356235
R15093 n1_m1_355200_537600 n1_m1_360000_537600 5.356235
R15094 n1_m1_360000_537600 n1_m1_364800_537600 5.356235
R15095 n1_m1_364800_537600 n1_m1_368000_537600 3.570824
R15096 n1_m1_369600_537600 n1_m1_368000_537600 1.785412
R15097 n1_m1_369600_537600 n1_m1_374400_537600 5.356235
R15098 n1_m1_374400_537600 n1_m1_379200_537600 5.356235
R15099 n1_m1_379200_537600 n1_m1_384000_537600 5.356235
R15100 n1_m1_384000_537600 n1_m1_388800_537600 5.356235
R15101 n1_m1_388800_537600 n1_m1_393600_537600 5.356235
R15102 n1_m1_393600_537600 n1_m1_396000_537600 2.678118
R15103 n1_m1_398400_537600 n1_m1_396000_537600 2.678118
R15104 n1_m1_398400_537600 n1_m1_403200_537600 5.356235
R15105 n1_m1_403200_537600 n1_m1_408000_537600 5.356235
R15106 n1_m1_408000_537600 n1_m1_412800_537600 5.356235
R15107 n1_m1_412800_537600 n1_m1_417600_537600 5.356235
R15108 n1_m1_417600_537600 n1_m1_422400_537600 5.356235
R15109 n1_m1_422400_537600 n1_m1_424000_537600 1.785412
R15110 n1_m1_427200_537600 n1_m1_424000_537600 3.570824
R15111 n1_m1_427200_537600 n1_m1_432000_537600 5.356235
R15112 n1_m1_432000_537600 n1_m1_436800_537600 5.356235
R15113 n1_m1_436800_537600 n1_m1_441600_537600 5.356235
R15114 n1_m1_441600_537600 n1_m1_446400_537600 5.356235
R15115 n1_m1_446400_537600 n1_m1_451200_537600 5.356235
R15116 n1_m1_451200_537600 n1_m1_452000_537600 0.892706
R15117 n1_m1_456000_537600 n1_m1_452000_537600 4.463529
R15118 n1_m1_456000_537600 n1_m1_460800_537600 5.356235
R15119 n1_m1_460800_537600 n1_m1_465600_537600 5.356235
R15120 n1_m1_465600_537600 n1_m1_470400_537600 5.356235
R15121 n1_m1_470400_537600 n1_m1_475200_537600 5.356235
R15122 n1_m1_475200_537600 n1_m1_480000_537600 5.356235
R15123 n1_m1_480000_537600 n1_m1_484800_537600 5.356235
R15124 n1_m1_484800_537600 n1_m1_489600_537600 5.356235
R15125 n1_m1_489600_537600 n1_m1_494400_537600 5.356235
R15126 n1_m1_494400_537600 n1_m1_499200_537600 5.356235
R15127 n1_m1_499200_537600 n1_m1_504000_537600 5.356235
R15128 n1_m1_504000_537600 n1_m1_508000_537600 4.463529
R15129 n1_m1_508800_537600 n1_m1_508000_537600 0.892706
R15130 n1_m1_508800_537600 n1_m1_513600_537600 5.356235
R15131 n1_m1_513600_537600 n1_m1_518400_537600 5.356235
R15132 n1_m1_518400_537600 n1_m1_523200_537600 5.356235
R15133 n1_m1_523200_537600 n1_m1_528000_537600 5.356235
R15134 n1_m1_528000_537600 n1_m1_532800_537600 5.356235
R15135 n1_m1_532800_537600 n1_m1_536000_537600 3.570824
R15136 n1_m1_537600_537600 n1_m1_536000_537600 1.785412
R15137 n1_m1_537600_537600 n1_m1_542400_537600 5.356235
R15138 n1_m1_542400_537600 n1_m1_547200_537600 5.356235
R15139 n1_m1_547200_537600 n1_m1_552000_537600 5.356235
R15140 n1_m1_552000_537600 n1_m1_556800_537600 5.356235
R15141 n1_m1_556800_537600 n1_m1_561600_537600 5.356235
R15142 n1_m1_0_542400 n1_m1_4000_542400 4.463529
R15143 n1_m1_4800_542400 n1_m1_4000_542400 0.892706
R15144 n1_m1_4800_542400 n1_m1_9600_542400 5.356235
R15145 n1_m1_9600_542400 n1_m1_14400_542400 5.356235
R15146 n1_m1_14400_542400 n1_m1_19200_542400 5.356235
R15147 n1_m1_19200_542400 n1_m1_24000_542400 5.356235
R15148 n1_m1_24000_542400 n1_m1_28800_542400 5.356235
R15149 n1_m1_28800_542400 n1_m1_32000_542400 3.570824
R15150 n1_m1_33600_542400 n1_m1_32000_542400 1.785412
R15151 n1_m1_33600_542400 n1_m1_38400_542400 5.356235
R15152 n1_m1_38400_542400 n1_m1_43200_542400 5.356235
R15153 n1_m1_43200_542400 n1_m1_48000_542400 5.356235
R15154 n1_m1_48000_542400 n1_m1_52800_542400 5.356235
R15155 n1_m1_52800_542400 n1_m1_57600_542400 5.356235
R15156 n1_m1_57600_542400 n1_m1_60000_542400 2.678118
R15157 n1_m1_62400_542400 n1_m1_60000_542400 2.678118
R15158 n1_m1_62400_542400 n1_m1_67200_542400 5.356235
R15159 n1_m1_67200_542400 n1_m1_72000_542400 5.356235
R15160 n1_m1_72000_542400 n1_m1_76800_542400 5.356235
R15161 n1_m1_76800_542400 n1_m1_81600_542400 5.356235
R15162 n1_m1_81600_542400 n1_m1_86400_542400 5.356235
R15163 n1_m1_86400_542400 n1_m1_88000_542400 1.785412
R15164 n1_m1_91200_542400 n1_m1_88000_542400 3.570824
R15165 n1_m1_91200_542400 n1_m1_96000_542400 5.356235
R15166 n1_m1_96000_542400 n1_m1_100800_542400 5.356235
R15167 n1_m1_100800_542400 n1_m1_105600_542400 5.356235
R15168 n1_m1_105600_542400 n1_m1_110400_542400 5.356235
R15169 n1_m1_110400_542400 n1_m1_115200_542400 5.356235
R15170 n1_m1_115200_542400 n1_m1_116000_542400 0.892706
R15171 n1_m1_120000_542400 n1_m1_116000_542400 4.463529
R15172 n1_m1_120000_542400 n1_m1_124800_542400 5.356235
R15173 n1_m1_124800_542400 n1_m1_129600_542400 5.356235
R15174 n1_m1_129600_542400 n1_m1_134400_542400 5.356235
R15175 n1_m1_134400_542400 n1_m1_139200_542400 5.356235
R15176 n1_m1_139200_542400 n1_m1_144000_542400 5.356235
R15177 n1_m1_144000_542400 n1_m1_148800_542400 5.356235
R15178 n1_m1_148800_542400 n1_m1_153600_542400 5.356235
R15179 n1_m1_153600_542400 n1_m1_158400_542400 5.356235
R15180 n1_m1_158400_542400 n1_m1_163200_542400 5.356235
R15181 n1_m1_163200_542400 n1_m1_168000_542400 5.356235
R15182 n1_m1_168000_542400 n1_m1_172000_542400 4.463529
R15183 n1_m1_172800_542400 n1_m1_172000_542400 0.892706
R15184 n1_m1_172800_542400 n1_m1_177600_542400 5.356235
R15185 n1_m1_177600_542400 n1_m1_182400_542400 5.356235
R15186 n1_m1_182400_542400 n1_m1_187200_542400 5.356235
R15187 n1_m1_187200_542400 n1_m1_192000_542400 5.356235
R15188 n1_m1_192000_542400 n1_m1_196800_542400 5.356235
R15189 n1_m1_196800_542400 n1_m1_200000_542400 3.570824
R15190 n1_m1_201600_542400 n1_m1_200000_542400 1.785412
R15191 n1_m1_201600_542400 n1_m1_206400_542400 5.356235
R15192 n1_m1_206400_542400 n1_m1_211200_542400 5.356235
R15193 n1_m1_211200_542400 n1_m1_216000_542400 5.356235
R15194 n1_m1_216000_542400 n1_m1_220800_542400 5.356235
R15195 n1_m1_220800_542400 n1_m1_225600_542400 5.356235
R15196 n1_m1_225600_542400 n1_m1_228000_542400 2.678118
R15197 n1_m1_230400_542400 n1_m1_228000_542400 2.678118
R15198 n1_m1_230400_542400 n1_m1_235200_542400 5.356235
R15199 n1_m1_235200_542400 n1_m1_240000_542400 5.356235
R15200 n1_m1_240000_542400 n1_m1_244800_542400 5.356235
R15201 n1_m1_244800_542400 n1_m1_249600_542400 5.356235
R15202 n1_m1_249600_542400 n1_m1_254400_542400 5.356235
R15203 n1_m1_254400_542400 n1_m1_256000_542400 1.785412
R15204 n1_m1_259200_542400 n1_m1_256000_542400 3.570824
R15205 n1_m1_259200_542400 n1_m1_264000_542400 5.356235
R15206 n1_m1_264000_542400 n1_m1_268800_542400 5.356235
R15207 n1_m1_268800_542400 n1_m1_273600_542400 5.356235
R15208 n1_m1_273600_542400 n1_m1_278400_542400 5.356235
R15209 n1_m1_278400_542400 n1_m1_283200_542400 5.356235
R15210 n1_m1_283200_542400 n1_m1_284000_542400 0.892706
R15211 n1_m1_288000_542400 n1_m1_284000_542400 4.463529
R15212 n1_m1_288000_542400 n1_m1_292800_542400 5.356235
R15213 n1_m1_292800_542400 n1_m1_297600_542400 5.356235
R15214 n1_m1_297600_542400 n1_m1_302400_542400 5.356235
R15215 n1_m1_302400_542400 n1_m1_307200_542400 5.356235
R15216 n1_m1_307200_542400 n1_m1_312000_542400 5.356235
R15217 n1_m1_312000_542400 n1_m1_316800_542400 5.356235
R15218 n1_m1_316800_542400 n1_m1_321600_542400 5.356235
R15219 n1_m1_321600_542400 n1_m1_326400_542400 5.356235
R15220 n1_m1_326400_542400 n1_m1_331200_542400 5.356235
R15221 n1_m1_331200_542400 n1_m1_336000_542400 5.356235
R15222 n1_m1_336000_542400 n1_m1_340000_542400 4.463529
R15223 n1_m1_340800_542400 n1_m1_340000_542400 0.892706
R15224 n1_m1_340800_542400 n1_m1_345600_542400 5.356235
R15225 n1_m1_345600_542400 n1_m1_350400_542400 5.356235
R15226 n1_m1_350400_542400 n1_m1_355200_542400 5.356235
R15227 n1_m1_355200_542400 n1_m1_360000_542400 5.356235
R15228 n1_m1_360000_542400 n1_m1_364800_542400 5.356235
R15229 n1_m1_364800_542400 n1_m1_368000_542400 3.570824
R15230 n1_m1_369600_542400 n1_m1_368000_542400 1.785412
R15231 n1_m1_369600_542400 n1_m1_374400_542400 5.356235
R15232 n1_m1_374400_542400 n1_m1_379200_542400 5.356235
R15233 n1_m1_379200_542400 n1_m1_384000_542400 5.356235
R15234 n1_m1_384000_542400 n1_m1_388800_542400 5.356235
R15235 n1_m1_388800_542400 n1_m1_393600_542400 5.356235
R15236 n1_m1_393600_542400 n1_m1_396000_542400 2.678118
R15237 n1_m1_398400_542400 n1_m1_396000_542400 2.678118
R15238 n1_m1_398400_542400 n1_m1_403200_542400 5.356235
R15239 n1_m1_403200_542400 n1_m1_408000_542400 5.356235
R15240 n1_m1_408000_542400 n1_m1_412800_542400 5.356235
R15241 n1_m1_412800_542400 n1_m1_417600_542400 5.356235
R15242 n1_m1_417600_542400 n1_m1_422400_542400 5.356235
R15243 n1_m1_422400_542400 n1_m1_424000_542400 1.785412
R15244 n1_m1_427200_542400 n1_m1_424000_542400 3.570824
R15245 n1_m1_427200_542400 n1_m1_432000_542400 5.356235
R15246 n1_m1_432000_542400 n1_m1_436800_542400 5.356235
R15247 n1_m1_436800_542400 n1_m1_441600_542400 5.356235
R15248 n1_m1_441600_542400 n1_m1_446400_542400 5.356235
R15249 n1_m1_446400_542400 n1_m1_451200_542400 5.356235
R15250 n1_m1_451200_542400 n1_m1_452000_542400 0.892706
R15251 n1_m1_456000_542400 n1_m1_452000_542400 4.463529
R15252 n1_m1_456000_542400 n1_m1_460800_542400 5.356235
R15253 n1_m1_460800_542400 n1_m1_465600_542400 5.356235
R15254 n1_m1_465600_542400 n1_m1_470400_542400 5.356235
R15255 n1_m1_470400_542400 n1_m1_475200_542400 5.356235
R15256 n1_m1_475200_542400 n1_m1_480000_542400 5.356235
R15257 n1_m1_480000_542400 n1_m1_484800_542400 5.356235
R15258 n1_m1_484800_542400 n1_m1_489600_542400 5.356235
R15259 n1_m1_489600_542400 n1_m1_494400_542400 5.356235
R15260 n1_m1_494400_542400 n1_m1_499200_542400 5.356235
R15261 n1_m1_499200_542400 n1_m1_504000_542400 5.356235
R15262 n1_m1_504000_542400 n1_m1_508000_542400 4.463529
R15263 n1_m1_508800_542400 n1_m1_508000_542400 0.892706
R15264 n1_m1_508800_542400 n1_m1_513600_542400 5.356235
R15265 n1_m1_513600_542400 n1_m1_518400_542400 5.356235
R15266 n1_m1_518400_542400 n1_m1_523200_542400 5.356235
R15267 n1_m1_523200_542400 n1_m1_528000_542400 5.356235
R15268 n1_m1_528000_542400 n1_m1_532800_542400 5.356235
R15269 n1_m1_532800_542400 n1_m1_536000_542400 3.570824
R15270 n1_m1_537600_542400 n1_m1_536000_542400 1.785412
R15271 n1_m1_537600_542400 n1_m1_542400_542400 5.356235
R15272 n1_m1_542400_542400 n1_m1_547200_542400 5.356235
R15273 n1_m1_547200_542400 n1_m1_552000_542400 5.356235
R15274 n1_m1_552000_542400 n1_m1_556800_542400 5.356235
R15275 n1_m1_556800_542400 n1_m1_561600_542400 5.356235
R15276 n1_m1_0_547200 n1_m1_4000_547200 4.463529
R15277 n1_m1_4800_547200 n1_m1_4000_547200 0.892706
R15278 n1_m1_4800_547200 n1_m1_9600_547200 5.356235
R15279 n1_m1_9600_547200 n1_m1_14400_547200 5.356235
R15280 n1_m1_14400_547200 n1_m1_19200_547200 5.356235
R15281 n1_m1_19200_547200 n1_m1_24000_547200 5.356235
R15282 n1_m1_24000_547200 n1_m1_28800_547200 5.356235
R15283 n1_m1_28800_547200 n1_m1_32000_547200 3.570824
R15284 n1_m1_33600_547200 n1_m1_32000_547200 1.785412
R15285 n1_m1_33600_547200 n1_m1_38400_547200 5.356235
R15286 n1_m1_38400_547200 n1_m1_43200_547200 5.356235
R15287 n1_m1_43200_547200 n1_m1_48000_547200 5.356235
R15288 n1_m1_48000_547200 n1_m1_52800_547200 5.356235
R15289 n1_m1_52800_547200 n1_m1_57600_547200 5.356235
R15290 n1_m1_57600_547200 n1_m1_60000_547200 2.678118
R15291 n1_m1_62400_547200 n1_m1_60000_547200 2.678118
R15292 n1_m1_62400_547200 n1_m1_67200_547200 5.356235
R15293 n1_m1_67200_547200 n1_m1_72000_547200 5.356235
R15294 n1_m1_72000_547200 n1_m1_76800_547200 5.356235
R15295 n1_m1_76800_547200 n1_m1_81600_547200 5.356235
R15296 n1_m1_81600_547200 n1_m1_86400_547200 5.356235
R15297 n1_m1_86400_547200 n1_m1_88000_547200 1.785412
R15298 n1_m1_91200_547200 n1_m1_88000_547200 3.570824
R15299 n1_m1_91200_547200 n1_m1_96000_547200 5.356235
R15300 n1_m1_96000_547200 n1_m1_100800_547200 5.356235
R15301 n1_m1_100800_547200 n1_m1_105600_547200 5.356235
R15302 n1_m1_105600_547200 n1_m1_110400_547200 5.356235
R15303 n1_m1_110400_547200 n1_m1_115200_547200 5.356235
R15304 n1_m1_115200_547200 n1_m1_116000_547200 0.892706
R15305 n1_m1_120000_547200 n1_m1_116000_547200 4.463529
R15306 n1_m1_120000_547200 n1_m1_124800_547200 5.356235
R15307 n1_m1_124800_547200 n1_m1_129600_547200 5.356235
R15308 n1_m1_129600_547200 n1_m1_134400_547200 5.356235
R15309 n1_m1_134400_547200 n1_m1_139200_547200 5.356235
R15310 n1_m1_139200_547200 n1_m1_144000_547200 5.356235
R15311 n1_m1_144000_547200 n1_m1_148800_547200 5.356235
R15312 n1_m1_148800_547200 n1_m1_153600_547200 5.356235
R15313 n1_m1_153600_547200 n1_m1_158400_547200 5.356235
R15314 n1_m1_158400_547200 n1_m1_163200_547200 5.356235
R15315 n1_m1_163200_547200 n1_m1_168000_547200 5.356235
R15316 n1_m1_168000_547200 n1_m1_172000_547200 4.463529
R15317 n1_m1_172800_547200 n1_m1_172000_547200 0.892706
R15318 n1_m1_172800_547200 n1_m1_177600_547200 5.356235
R15319 n1_m1_177600_547200 n1_m1_182400_547200 5.356235
R15320 n1_m1_182400_547200 n1_m1_187200_547200 5.356235
R15321 n1_m1_187200_547200 n1_m1_192000_547200 5.356235
R15322 n1_m1_192000_547200 n1_m1_196800_547200 5.356235
R15323 n1_m1_196800_547200 n1_m1_200000_547200 3.570824
R15324 n1_m1_201600_547200 n1_m1_200000_547200 1.785412
R15325 n1_m1_201600_547200 n1_m1_206400_547200 5.356235
R15326 n1_m1_206400_547200 n1_m1_211200_547200 5.356235
R15327 n1_m1_211200_547200 n1_m1_216000_547200 5.356235
R15328 n1_m1_216000_547200 n1_m1_220800_547200 5.356235
R15329 n1_m1_220800_547200 n1_m1_225600_547200 5.356235
R15330 n1_m1_225600_547200 n1_m1_228000_547200 2.678118
R15331 n1_m1_230400_547200 n1_m1_228000_547200 2.678118
R15332 n1_m1_230400_547200 n1_m1_235200_547200 5.356235
R15333 n1_m1_235200_547200 n1_m1_240000_547200 5.356235
R15334 n1_m1_240000_547200 n1_m1_244800_547200 5.356235
R15335 n1_m1_244800_547200 n1_m1_249600_547200 5.356235
R15336 n1_m1_249600_547200 n1_m1_254400_547200 5.356235
R15337 n1_m1_254400_547200 n1_m1_256000_547200 1.785412
R15338 n1_m1_259200_547200 n1_m1_256000_547200 3.570824
R15339 n1_m1_259200_547200 n1_m1_264000_547200 5.356235
R15340 n1_m1_264000_547200 n1_m1_268800_547200 5.356235
R15341 n1_m1_268800_547200 n1_m1_273600_547200 5.356235
R15342 n1_m1_273600_547200 n1_m1_278400_547200 5.356235
R15343 n1_m1_278400_547200 n1_m1_283200_547200 5.356235
R15344 n1_m1_283200_547200 n1_m1_284000_547200 0.892706
R15345 n1_m1_288000_547200 n1_m1_284000_547200 4.463529
R15346 n1_m1_288000_547200 n1_m1_292800_547200 5.356235
R15347 n1_m1_292800_547200 n1_m1_297600_547200 5.356235
R15348 n1_m1_297600_547200 n1_m1_302400_547200 5.356235
R15349 n1_m1_302400_547200 n1_m1_307200_547200 5.356235
R15350 n1_m1_307200_547200 n1_m1_312000_547200 5.356235
R15351 n1_m1_312000_547200 n1_m1_316800_547200 5.356235
R15352 n1_m1_316800_547200 n1_m1_321600_547200 5.356235
R15353 n1_m1_321600_547200 n1_m1_326400_547200 5.356235
R15354 n1_m1_326400_547200 n1_m1_331200_547200 5.356235
R15355 n1_m1_331200_547200 n1_m1_336000_547200 5.356235
R15356 n1_m1_336000_547200 n1_m1_340000_547200 4.463529
R15357 n1_m1_340800_547200 n1_m1_340000_547200 0.892706
R15358 n1_m1_340800_547200 n1_m1_345600_547200 5.356235
R15359 n1_m1_345600_547200 n1_m1_350400_547200 5.356235
R15360 n1_m1_350400_547200 n1_m1_355200_547200 5.356235
R15361 n1_m1_355200_547200 n1_m1_360000_547200 5.356235
R15362 n1_m1_360000_547200 n1_m1_364800_547200 5.356235
R15363 n1_m1_364800_547200 n1_m1_368000_547200 3.570824
R15364 n1_m1_369600_547200 n1_m1_368000_547200 1.785412
R15365 n1_m1_369600_547200 n1_m1_374400_547200 5.356235
R15366 n1_m1_374400_547200 n1_m1_379200_547200 5.356235
R15367 n1_m1_379200_547200 n1_m1_384000_547200 5.356235
R15368 n1_m1_384000_547200 n1_m1_388800_547200 5.356235
R15369 n1_m1_388800_547200 n1_m1_393600_547200 5.356235
R15370 n1_m1_393600_547200 n1_m1_396000_547200 2.678118
R15371 n1_m1_398400_547200 n1_m1_396000_547200 2.678118
R15372 n1_m1_398400_547200 n1_m1_403200_547200 5.356235
R15373 n1_m1_403200_547200 n1_m1_408000_547200 5.356235
R15374 n1_m1_408000_547200 n1_m1_412800_547200 5.356235
R15375 n1_m1_412800_547200 n1_m1_417600_547200 5.356235
R15376 n1_m1_417600_547200 n1_m1_422400_547200 5.356235
R15377 n1_m1_422400_547200 n1_m1_424000_547200 1.785412
R15378 n1_m1_427200_547200 n1_m1_424000_547200 3.570824
R15379 n1_m1_427200_547200 n1_m1_432000_547200 5.356235
R15380 n1_m1_432000_547200 n1_m1_436800_547200 5.356235
R15381 n1_m1_436800_547200 n1_m1_441600_547200 5.356235
R15382 n1_m1_441600_547200 n1_m1_446400_547200 5.356235
R15383 n1_m1_446400_547200 n1_m1_451200_547200 5.356235
R15384 n1_m1_451200_547200 n1_m1_452000_547200 0.892706
R15385 n1_m1_456000_547200 n1_m1_452000_547200 4.463529
R15386 n1_m1_456000_547200 n1_m1_460800_547200 5.356235
R15387 n1_m1_460800_547200 n1_m1_465600_547200 5.356235
R15388 n1_m1_465600_547200 n1_m1_470400_547200 5.356235
R15389 n1_m1_470400_547200 n1_m1_475200_547200 5.356235
R15390 n1_m1_475200_547200 n1_m1_480000_547200 5.356235
R15391 n1_m1_480000_547200 n1_m1_484800_547200 5.356235
R15392 n1_m1_484800_547200 n1_m1_489600_547200 5.356235
R15393 n1_m1_489600_547200 n1_m1_494400_547200 5.356235
R15394 n1_m1_494400_547200 n1_m1_499200_547200 5.356235
R15395 n1_m1_499200_547200 n1_m1_504000_547200 5.356235
R15396 n1_m1_504000_547200 n1_m1_508000_547200 4.463529
R15397 n1_m1_508800_547200 n1_m1_508000_547200 0.892706
R15398 n1_m1_508800_547200 n1_m1_513600_547200 5.356235
R15399 n1_m1_513600_547200 n1_m1_518400_547200 5.356235
R15400 n1_m1_518400_547200 n1_m1_523200_547200 5.356235
R15401 n1_m1_523200_547200 n1_m1_528000_547200 5.356235
R15402 n1_m1_528000_547200 n1_m1_532800_547200 5.356235
R15403 n1_m1_532800_547200 n1_m1_536000_547200 3.570824
R15404 n1_m1_537600_547200 n1_m1_536000_547200 1.785412
R15405 n1_m1_537600_547200 n1_m1_542400_547200 5.356235
R15406 n1_m1_542400_547200 n1_m1_547200_547200 5.356235
R15407 n1_m1_547200_547200 n1_m1_552000_547200 5.356235
R15408 n1_m1_552000_547200 n1_m1_556800_547200 5.356235
R15409 n1_m1_556800_547200 n1_m1_561600_547200 5.356235
R15410 n1_m1_0_552000 n1_m1_4000_552000 4.463529
R15411 n1_m1_4800_552000 n1_m1_4000_552000 0.892706
R15412 n1_m1_4800_552000 n1_m1_9600_552000 5.356235
R15413 n1_m1_9600_552000 n1_m1_14400_552000 5.356235
R15414 n1_m1_14400_552000 n1_m1_19200_552000 5.356235
R15415 n1_m1_19200_552000 n1_m1_24000_552000 5.356235
R15416 n1_m1_24000_552000 n1_m1_28800_552000 5.356235
R15417 n1_m1_28800_552000 n1_m1_32000_552000 3.570824
R15418 n1_m1_33600_552000 n1_m1_32000_552000 1.785412
R15419 n1_m1_33600_552000 n1_m1_38400_552000 5.356235
R15420 n1_m1_38400_552000 n1_m1_43200_552000 5.356235
R15421 n1_m1_43200_552000 n1_m1_48000_552000 5.356235
R15422 n1_m1_48000_552000 n1_m1_52800_552000 5.356235
R15423 n1_m1_52800_552000 n1_m1_57600_552000 5.356235
R15424 n1_m1_57600_552000 n1_m1_60000_552000 2.678118
R15425 n1_m1_62400_552000 n1_m1_60000_552000 2.678118
R15426 n1_m1_62400_552000 n1_m1_67200_552000 5.356235
R15427 n1_m1_67200_552000 n1_m1_72000_552000 5.356235
R15428 n1_m1_72000_552000 n1_m1_76800_552000 5.356235
R15429 n1_m1_76800_552000 n1_m1_81600_552000 5.356235
R15430 n1_m1_81600_552000 n1_m1_86400_552000 5.356235
R15431 n1_m1_86400_552000 n1_m1_88000_552000 1.785412
R15432 n1_m1_91200_552000 n1_m1_88000_552000 3.570824
R15433 n1_m1_91200_552000 n1_m1_96000_552000 5.356235
R15434 n1_m1_96000_552000 n1_m1_100800_552000 5.356235
R15435 n1_m1_100800_552000 n1_m1_105600_552000 5.356235
R15436 n1_m1_105600_552000 n1_m1_110400_552000 5.356235
R15437 n1_m1_110400_552000 n1_m1_115200_552000 5.356235
R15438 n1_m1_115200_552000 n1_m1_116000_552000 0.892706
R15439 n1_m1_120000_552000 n1_m1_116000_552000 4.463529
R15440 n1_m1_120000_552000 n1_m1_124800_552000 5.356235
R15441 n1_m1_124800_552000 n1_m1_129600_552000 5.356235
R15442 n1_m1_129600_552000 n1_m1_134400_552000 5.356235
R15443 n1_m1_134400_552000 n1_m1_139200_552000 5.356235
R15444 n1_m1_139200_552000 n1_m1_144000_552000 5.356235
R15445 n1_m1_144000_552000 n1_m1_148800_552000 5.356235
R15446 n1_m1_148800_552000 n1_m1_153600_552000 5.356235
R15447 n1_m1_153600_552000 n1_m1_158400_552000 5.356235
R15448 n1_m1_158400_552000 n1_m1_163200_552000 5.356235
R15449 n1_m1_163200_552000 n1_m1_168000_552000 5.356235
R15450 n1_m1_168000_552000 n1_m1_172000_552000 4.463529
R15451 n1_m1_172800_552000 n1_m1_172000_552000 0.892706
R15452 n1_m1_172800_552000 n1_m1_177600_552000 5.356235
R15453 n1_m1_177600_552000 n1_m1_182400_552000 5.356235
R15454 n1_m1_182400_552000 n1_m1_187200_552000 5.356235
R15455 n1_m1_187200_552000 n1_m1_192000_552000 5.356235
R15456 n1_m1_192000_552000 n1_m1_196800_552000 5.356235
R15457 n1_m1_196800_552000 n1_m1_200000_552000 3.570824
R15458 n1_m1_201600_552000 n1_m1_200000_552000 1.785412
R15459 n1_m1_201600_552000 n1_m1_206400_552000 5.356235
R15460 n1_m1_206400_552000 n1_m1_211200_552000 5.356235
R15461 n1_m1_211200_552000 n1_m1_216000_552000 5.356235
R15462 n1_m1_216000_552000 n1_m1_220800_552000 5.356235
R15463 n1_m1_220800_552000 n1_m1_225600_552000 5.356235
R15464 n1_m1_225600_552000 n1_m1_228000_552000 2.678118
R15465 n1_m1_230400_552000 n1_m1_228000_552000 2.678118
R15466 n1_m1_230400_552000 n1_m1_235200_552000 5.356235
R15467 n1_m1_235200_552000 n1_m1_240000_552000 5.356235
R15468 n1_m1_240000_552000 n1_m1_244800_552000 5.356235
R15469 n1_m1_244800_552000 n1_m1_249600_552000 5.356235
R15470 n1_m1_249600_552000 n1_m1_254400_552000 5.356235
R15471 n1_m1_254400_552000 n1_m1_256000_552000 1.785412
R15472 n1_m1_259200_552000 n1_m1_256000_552000 3.570824
R15473 n1_m1_259200_552000 n1_m1_264000_552000 5.356235
R15474 n1_m1_264000_552000 n1_m1_268800_552000 5.356235
R15475 n1_m1_268800_552000 n1_m1_273600_552000 5.356235
R15476 n1_m1_273600_552000 n1_m1_278400_552000 5.356235
R15477 n1_m1_278400_552000 n1_m1_283200_552000 5.356235
R15478 n1_m1_283200_552000 n1_m1_284000_552000 0.892706
R15479 n1_m1_288000_552000 n1_m1_284000_552000 4.463529
R15480 n1_m1_288000_552000 n1_m1_292800_552000 5.356235
R15481 n1_m1_292800_552000 n1_m1_297600_552000 5.356235
R15482 n1_m1_297600_552000 n1_m1_302400_552000 5.356235
R15483 n1_m1_302400_552000 n1_m1_307200_552000 5.356235
R15484 n1_m1_307200_552000 n1_m1_312000_552000 5.356235
R15485 n1_m1_312000_552000 n1_m1_316800_552000 5.356235
R15486 n1_m1_316800_552000 n1_m1_321600_552000 5.356235
R15487 n1_m1_321600_552000 n1_m1_326400_552000 5.356235
R15488 n1_m1_326400_552000 n1_m1_331200_552000 5.356235
R15489 n1_m1_331200_552000 n1_m1_336000_552000 5.356235
R15490 n1_m1_336000_552000 n1_m1_340000_552000 4.463529
R15491 n1_m1_340800_552000 n1_m1_340000_552000 0.892706
R15492 n1_m1_340800_552000 n1_m1_345600_552000 5.356235
R15493 n1_m1_345600_552000 n1_m1_350400_552000 5.356235
R15494 n1_m1_350400_552000 n1_m1_355200_552000 5.356235
R15495 n1_m1_355200_552000 n1_m1_360000_552000 5.356235
R15496 n1_m1_360000_552000 n1_m1_364800_552000 5.356235
R15497 n1_m1_364800_552000 n1_m1_368000_552000 3.570824
R15498 n1_m1_369600_552000 n1_m1_368000_552000 1.785412
R15499 n1_m1_369600_552000 n1_m1_374400_552000 5.356235
R15500 n1_m1_374400_552000 n1_m1_379200_552000 5.356235
R15501 n1_m1_379200_552000 n1_m1_384000_552000 5.356235
R15502 n1_m1_384000_552000 n1_m1_388800_552000 5.356235
R15503 n1_m1_388800_552000 n1_m1_393600_552000 5.356235
R15504 n1_m1_393600_552000 n1_m1_396000_552000 2.678118
R15505 n1_m1_398400_552000 n1_m1_396000_552000 2.678118
R15506 n1_m1_398400_552000 n1_m1_403200_552000 5.356235
R15507 n1_m1_403200_552000 n1_m1_408000_552000 5.356235
R15508 n1_m1_408000_552000 n1_m1_412800_552000 5.356235
R15509 n1_m1_412800_552000 n1_m1_417600_552000 5.356235
R15510 n1_m1_417600_552000 n1_m1_422400_552000 5.356235
R15511 n1_m1_422400_552000 n1_m1_424000_552000 1.785412
R15512 n1_m1_427200_552000 n1_m1_424000_552000 3.570824
R15513 n1_m1_427200_552000 n1_m1_432000_552000 5.356235
R15514 n1_m1_432000_552000 n1_m1_436800_552000 5.356235
R15515 n1_m1_436800_552000 n1_m1_441600_552000 5.356235
R15516 n1_m1_441600_552000 n1_m1_446400_552000 5.356235
R15517 n1_m1_446400_552000 n1_m1_451200_552000 5.356235
R15518 n1_m1_451200_552000 n1_m1_452000_552000 0.892706
R15519 n1_m1_456000_552000 n1_m1_452000_552000 4.463529
R15520 n1_m1_456000_552000 n1_m1_460800_552000 5.356235
R15521 n1_m1_460800_552000 n1_m1_465600_552000 5.356235
R15522 n1_m1_465600_552000 n1_m1_470400_552000 5.356235
R15523 n1_m1_470400_552000 n1_m1_475200_552000 5.356235
R15524 n1_m1_475200_552000 n1_m1_480000_552000 5.356235
R15525 n1_m1_480000_552000 n1_m1_484800_552000 5.356235
R15526 n1_m1_484800_552000 n1_m1_489600_552000 5.356235
R15527 n1_m1_489600_552000 n1_m1_494400_552000 5.356235
R15528 n1_m1_494400_552000 n1_m1_499200_552000 5.356235
R15529 n1_m1_499200_552000 n1_m1_504000_552000 5.356235
R15530 n1_m1_504000_552000 n1_m1_508000_552000 4.463529
R15531 n1_m1_508800_552000 n1_m1_508000_552000 0.892706
R15532 n1_m1_508800_552000 n1_m1_513600_552000 5.356235
R15533 n1_m1_513600_552000 n1_m1_518400_552000 5.356235
R15534 n1_m1_518400_552000 n1_m1_523200_552000 5.356235
R15535 n1_m1_523200_552000 n1_m1_528000_552000 5.356235
R15536 n1_m1_528000_552000 n1_m1_532800_552000 5.356235
R15537 n1_m1_532800_552000 n1_m1_536000_552000 3.570824
R15538 n1_m1_537600_552000 n1_m1_536000_552000 1.785412
R15539 n1_m1_537600_552000 n1_m1_542400_552000 5.356235
R15540 n1_m1_542400_552000 n1_m1_547200_552000 5.356235
R15541 n1_m1_547200_552000 n1_m1_552000_552000 5.356235
R15542 n1_m1_552000_552000 n1_m1_556800_552000 5.356235
R15543 n1_m1_556800_552000 n1_m1_561600_552000 5.356235
R15544 n1_m1_0_556800 n1_m1_4000_556800 4.463529
R15545 n1_m1_4800_556800 n1_m1_4000_556800 0.892706
R15546 n1_m1_4800_556800 n1_m1_9600_556800 5.356235
R15547 n1_m1_9600_556800 n1_m1_14400_556800 5.356235
R15548 n1_m1_14400_556800 n1_m1_19200_556800 5.356235
R15549 n1_m1_19200_556800 n1_m1_24000_556800 5.356235
R15550 n1_m1_24000_556800 n1_m1_28800_556800 5.356235
R15551 n1_m1_28800_556800 n1_m1_32000_556800 3.570824
R15552 n1_m1_33600_556800 n1_m1_32000_556800 1.785412
R15553 n1_m1_33600_556800 n1_m1_38400_556800 5.356235
R15554 n1_m1_38400_556800 n1_m1_43200_556800 5.356235
R15555 n1_m1_43200_556800 n1_m1_48000_556800 5.356235
R15556 n1_m1_48000_556800 n1_m1_52800_556800 5.356235
R15557 n1_m1_52800_556800 n1_m1_57600_556800 5.356235
R15558 n1_m1_57600_556800 n1_m1_60000_556800 2.678118
R15559 n1_m1_62400_556800 n1_m1_60000_556800 2.678118
R15560 n1_m1_62400_556800 n1_m1_67200_556800 5.356235
R15561 n1_m1_67200_556800 n1_m1_72000_556800 5.356235
R15562 n1_m1_72000_556800 n1_m1_76800_556800 5.356235
R15563 n1_m1_76800_556800 n1_m1_81600_556800 5.356235
R15564 n1_m1_81600_556800 n1_m1_86400_556800 5.356235
R15565 n1_m1_86400_556800 n1_m1_88000_556800 1.785412
R15566 n1_m1_91200_556800 n1_m1_88000_556800 3.570824
R15567 n1_m1_91200_556800 n1_m1_96000_556800 5.356235
R15568 n1_m1_96000_556800 n1_m1_100800_556800 5.356235
R15569 n1_m1_100800_556800 n1_m1_105600_556800 5.356235
R15570 n1_m1_105600_556800 n1_m1_110400_556800 5.356235
R15571 n1_m1_110400_556800 n1_m1_115200_556800 5.356235
R15572 n1_m1_115200_556800 n1_m1_116000_556800 0.892706
R15573 n1_m1_120000_556800 n1_m1_116000_556800 4.463529
R15574 n1_m1_120000_556800 n1_m1_124800_556800 5.356235
R15575 n1_m1_124800_556800 n1_m1_129600_556800 5.356235
R15576 n1_m1_129600_556800 n1_m1_134400_556800 5.356235
R15577 n1_m1_134400_556800 n1_m1_139200_556800 5.356235
R15578 n1_m1_139200_556800 n1_m1_144000_556800 5.356235
R15579 n1_m1_144000_556800 n1_m1_148800_556800 5.356235
R15580 n1_m1_148800_556800 n1_m1_153600_556800 5.356235
R15581 n1_m1_153600_556800 n1_m1_158400_556800 5.356235
R15582 n1_m1_158400_556800 n1_m1_163200_556800 5.356235
R15583 n1_m1_163200_556800 n1_m1_168000_556800 5.356235
R15584 n1_m1_168000_556800 n1_m1_172000_556800 4.463529
R15585 n1_m1_172800_556800 n1_m1_172000_556800 0.892706
R15586 n1_m1_172800_556800 n1_m1_177600_556800 5.356235
R15587 n1_m1_177600_556800 n1_m1_182400_556800 5.356235
R15588 n1_m1_182400_556800 n1_m1_187200_556800 5.356235
R15589 n1_m1_187200_556800 n1_m1_192000_556800 5.356235
R15590 n1_m1_192000_556800 n1_m1_196800_556800 5.356235
R15591 n1_m1_196800_556800 n1_m1_200000_556800 3.570824
R15592 n1_m1_201600_556800 n1_m1_200000_556800 1.785412
R15593 n1_m1_201600_556800 n1_m1_206400_556800 5.356235
R15594 n1_m1_206400_556800 n1_m1_211200_556800 5.356235
R15595 n1_m1_211200_556800 n1_m1_216000_556800 5.356235
R15596 n1_m1_216000_556800 n1_m1_220800_556800 5.356235
R15597 n1_m1_220800_556800 n1_m1_225600_556800 5.356235
R15598 n1_m1_225600_556800 n1_m1_228000_556800 2.678118
R15599 n1_m1_230400_556800 n1_m1_228000_556800 2.678118
R15600 n1_m1_230400_556800 n1_m1_235200_556800 5.356235
R15601 n1_m1_235200_556800 n1_m1_240000_556800 5.356235
R15602 n1_m1_240000_556800 n1_m1_244800_556800 5.356235
R15603 n1_m1_244800_556800 n1_m1_249600_556800 5.356235
R15604 n1_m1_249600_556800 n1_m1_254400_556800 5.356235
R15605 n1_m1_254400_556800 n1_m1_256000_556800 1.785412
R15606 n1_m1_259200_556800 n1_m1_256000_556800 3.570824
R15607 n1_m1_259200_556800 n1_m1_264000_556800 5.356235
R15608 n1_m1_264000_556800 n1_m1_268800_556800 5.356235
R15609 n1_m1_268800_556800 n1_m1_273600_556800 5.356235
R15610 n1_m1_273600_556800 n1_m1_278400_556800 5.356235
R15611 n1_m1_278400_556800 n1_m1_283200_556800 5.356235
R15612 n1_m1_283200_556800 n1_m1_284000_556800 0.892706
R15613 n1_m1_288000_556800 n1_m1_284000_556800 4.463529
R15614 n1_m1_288000_556800 n1_m1_292800_556800 5.356235
R15615 n1_m1_292800_556800 n1_m1_297600_556800 5.356235
R15616 n1_m1_297600_556800 n1_m1_302400_556800 5.356235
R15617 n1_m1_302400_556800 n1_m1_307200_556800 5.356235
R15618 n1_m1_307200_556800 n1_m1_312000_556800 5.356235
R15619 n1_m1_312000_556800 n1_m1_316800_556800 5.356235
R15620 n1_m1_316800_556800 n1_m1_321600_556800 5.356235
R15621 n1_m1_321600_556800 n1_m1_326400_556800 5.356235
R15622 n1_m1_326400_556800 n1_m1_331200_556800 5.356235
R15623 n1_m1_331200_556800 n1_m1_336000_556800 5.356235
R15624 n1_m1_336000_556800 n1_m1_340000_556800 4.463529
R15625 n1_m1_340800_556800 n1_m1_340000_556800 0.892706
R15626 n1_m1_340800_556800 n1_m1_345600_556800 5.356235
R15627 n1_m1_345600_556800 n1_m1_350400_556800 5.356235
R15628 n1_m1_350400_556800 n1_m1_355200_556800 5.356235
R15629 n1_m1_355200_556800 n1_m1_360000_556800 5.356235
R15630 n1_m1_360000_556800 n1_m1_364800_556800 5.356235
R15631 n1_m1_364800_556800 n1_m1_368000_556800 3.570824
R15632 n1_m1_369600_556800 n1_m1_368000_556800 1.785412
R15633 n1_m1_369600_556800 n1_m1_374400_556800 5.356235
R15634 n1_m1_374400_556800 n1_m1_379200_556800 5.356235
R15635 n1_m1_379200_556800 n1_m1_384000_556800 5.356235
R15636 n1_m1_384000_556800 n1_m1_388800_556800 5.356235
R15637 n1_m1_388800_556800 n1_m1_393600_556800 5.356235
R15638 n1_m1_393600_556800 n1_m1_396000_556800 2.678118
R15639 n1_m1_398400_556800 n1_m1_396000_556800 2.678118
R15640 n1_m1_398400_556800 n1_m1_403200_556800 5.356235
R15641 n1_m1_403200_556800 n1_m1_408000_556800 5.356235
R15642 n1_m1_408000_556800 n1_m1_412800_556800 5.356235
R15643 n1_m1_412800_556800 n1_m1_417600_556800 5.356235
R15644 n1_m1_417600_556800 n1_m1_422400_556800 5.356235
R15645 n1_m1_422400_556800 n1_m1_424000_556800 1.785412
R15646 n1_m1_427200_556800 n1_m1_424000_556800 3.570824
R15647 n1_m1_427200_556800 n1_m1_432000_556800 5.356235
R15648 n1_m1_432000_556800 n1_m1_436800_556800 5.356235
R15649 n1_m1_436800_556800 n1_m1_441600_556800 5.356235
R15650 n1_m1_441600_556800 n1_m1_446400_556800 5.356235
R15651 n1_m1_446400_556800 n1_m1_451200_556800 5.356235
R15652 n1_m1_451200_556800 n1_m1_452000_556800 0.892706
R15653 n1_m1_456000_556800 n1_m1_452000_556800 4.463529
R15654 n1_m1_456000_556800 n1_m1_460800_556800 5.356235
R15655 n1_m1_460800_556800 n1_m1_465600_556800 5.356235
R15656 n1_m1_465600_556800 n1_m1_470400_556800 5.356235
R15657 n1_m1_470400_556800 n1_m1_475200_556800 5.356235
R15658 n1_m1_475200_556800 n1_m1_480000_556800 5.356235
R15659 n1_m1_480000_556800 n1_m1_484800_556800 5.356235
R15660 n1_m1_484800_556800 n1_m1_489600_556800 5.356235
R15661 n1_m1_489600_556800 n1_m1_494400_556800 5.356235
R15662 n1_m1_494400_556800 n1_m1_499200_556800 5.356235
R15663 n1_m1_499200_556800 n1_m1_504000_556800 5.356235
R15664 n1_m1_504000_556800 n1_m1_508000_556800 4.463529
R15665 n1_m1_508800_556800 n1_m1_508000_556800 0.892706
R15666 n1_m1_508800_556800 n1_m1_513600_556800 5.356235
R15667 n1_m1_513600_556800 n1_m1_518400_556800 5.356235
R15668 n1_m1_518400_556800 n1_m1_523200_556800 5.356235
R15669 n1_m1_523200_556800 n1_m1_528000_556800 5.356235
R15670 n1_m1_528000_556800 n1_m1_532800_556800 5.356235
R15671 n1_m1_532800_556800 n1_m1_536000_556800 3.570824
R15672 n1_m1_537600_556800 n1_m1_536000_556800 1.785412
R15673 n1_m1_537600_556800 n1_m1_542400_556800 5.356235
R15674 n1_m1_542400_556800 n1_m1_547200_556800 5.356235
R15675 n1_m1_547200_556800 n1_m1_552000_556800 5.356235
R15676 n1_m1_552000_556800 n1_m1_556800_556800 5.356235
R15677 n1_m1_556800_556800 n1_m1_561600_556800 5.356235
R15678 n1_m1_0_561600 n1_m1_4000_561600 4.463529
R15679 n1_m1_4800_561600 n1_m1_4000_561600 0.892706
R15680 n1_m1_4800_561600 n1_m1_9600_561600 5.356235
R15681 n1_m1_9600_561600 n1_m1_14400_561600 5.356235
R15682 n1_m1_14400_561600 n1_m1_19200_561600 5.356235
R15683 n1_m1_19200_561600 n1_m1_24000_561600 5.356235
R15684 n1_m1_24000_561600 n1_m1_28800_561600 5.356235
R15685 n1_m1_28800_561600 n1_m1_32000_561600 3.570824
R15686 n1_m1_33600_561600 n1_m1_32000_561600 1.785412
R15687 n1_m1_33600_561600 n1_m1_38400_561600 5.356235
R15688 n1_m1_38400_561600 n1_m1_43200_561600 5.356235
R15689 n1_m1_43200_561600 n1_m1_48000_561600 5.356235
R15690 n1_m1_48000_561600 n1_m1_52800_561600 5.356235
R15691 n1_m1_52800_561600 n1_m1_57600_561600 5.356235
R15692 n1_m1_57600_561600 n1_m1_60000_561600 2.678118
R15693 n1_m1_62400_561600 n1_m1_60000_561600 2.678118
R15694 n1_m1_62400_561600 n1_m1_67200_561600 5.356235
R15695 n1_m1_67200_561600 n1_m1_72000_561600 5.356235
R15696 n1_m1_72000_561600 n1_m1_76800_561600 5.356235
R15697 n1_m1_76800_561600 n1_m1_81600_561600 5.356235
R15698 n1_m1_81600_561600 n1_m1_86400_561600 5.356235
R15699 n1_m1_86400_561600 n1_m1_88000_561600 1.785412
R15700 n1_m1_91200_561600 n1_m1_88000_561600 3.570824
R15701 n1_m1_91200_561600 n1_m1_96000_561600 5.356235
R15702 n1_m1_96000_561600 n1_m1_100800_561600 5.356235
R15703 n1_m1_100800_561600 n1_m1_105600_561600 5.356235
R15704 n1_m1_105600_561600 n1_m1_110400_561600 5.356235
R15705 n1_m1_110400_561600 n1_m1_115200_561600 5.356235
R15706 n1_m1_115200_561600 n1_m1_116000_561600 0.892706
R15707 n1_m1_120000_561600 n1_m1_116000_561600 4.463529
R15708 n1_m1_120000_561600 n1_m1_124800_561600 5.356235
R15709 n1_m1_124800_561600 n1_m1_129600_561600 5.356235
R15710 n1_m1_129600_561600 n1_m1_134400_561600 5.356235
R15711 n1_m1_134400_561600 n1_m1_139200_561600 5.356235
R15712 n1_m1_139200_561600 n1_m1_144000_561600 5.356235
R15713 n1_m1_144000_561600 n1_m1_148800_561600 5.356235
R15714 n1_m1_148800_561600 n1_m1_153600_561600 5.356235
R15715 n1_m1_153600_561600 n1_m1_158400_561600 5.356235
R15716 n1_m1_158400_561600 n1_m1_163200_561600 5.356235
R15717 n1_m1_163200_561600 n1_m1_168000_561600 5.356235
R15718 n1_m1_168000_561600 n1_m1_172000_561600 4.463529
R15719 n1_m1_172800_561600 n1_m1_172000_561600 0.892706
R15720 n1_m1_172800_561600 n1_m1_177600_561600 5.356235
R15721 n1_m1_177600_561600 n1_m1_182400_561600 5.356235
R15722 n1_m1_182400_561600 n1_m1_187200_561600 5.356235
R15723 n1_m1_187200_561600 n1_m1_192000_561600 5.356235
R15724 n1_m1_192000_561600 n1_m1_196800_561600 5.356235
R15725 n1_m1_196800_561600 n1_m1_200000_561600 3.570824
R15726 n1_m1_201600_561600 n1_m1_200000_561600 1.785412
R15727 n1_m1_201600_561600 n1_m1_206400_561600 5.356235
R15728 n1_m1_206400_561600 n1_m1_211200_561600 5.356235
R15729 n1_m1_211200_561600 n1_m1_216000_561600 5.356235
R15730 n1_m1_216000_561600 n1_m1_220800_561600 5.356235
R15731 n1_m1_220800_561600 n1_m1_225600_561600 5.356235
R15732 n1_m1_225600_561600 n1_m1_228000_561600 2.678118
R15733 n1_m1_230400_561600 n1_m1_228000_561600 2.678118
R15734 n1_m1_230400_561600 n1_m1_235200_561600 5.356235
R15735 n1_m1_235200_561600 n1_m1_240000_561600 5.356235
R15736 n1_m1_240000_561600 n1_m1_244800_561600 5.356235
R15737 n1_m1_244800_561600 n1_m1_249600_561600 5.356235
R15738 n1_m1_249600_561600 n1_m1_254400_561600 5.356235
R15739 n1_m1_254400_561600 n1_m1_256000_561600 1.785412
R15740 n1_m1_259200_561600 n1_m1_256000_561600 3.570824
R15741 n1_m1_259200_561600 n1_m1_264000_561600 5.356235
R15742 n1_m1_264000_561600 n1_m1_268800_561600 5.356235
R15743 n1_m1_268800_561600 n1_m1_273600_561600 5.356235
R15744 n1_m1_273600_561600 n1_m1_278400_561600 5.356235
R15745 n1_m1_278400_561600 n1_m1_283200_561600 5.356235
R15746 n1_m1_283200_561600 n1_m1_284000_561600 0.892706
R15747 n1_m1_288000_561600 n1_m1_284000_561600 4.463529
R15748 n1_m1_288000_561600 n1_m1_292800_561600 5.356235
R15749 n1_m1_292800_561600 n1_m1_297600_561600 5.356235
R15750 n1_m1_297600_561600 n1_m1_302400_561600 5.356235
R15751 n1_m1_302400_561600 n1_m1_307200_561600 5.356235
R15752 n1_m1_307200_561600 n1_m1_312000_561600 5.356235
R15753 n1_m1_312000_561600 n1_m1_316800_561600 5.356235
R15754 n1_m1_316800_561600 n1_m1_321600_561600 5.356235
R15755 n1_m1_321600_561600 n1_m1_326400_561600 5.356235
R15756 n1_m1_326400_561600 n1_m1_331200_561600 5.356235
R15757 n1_m1_331200_561600 n1_m1_336000_561600 5.356235
R15758 n1_m1_336000_561600 n1_m1_340000_561600 4.463529
R15759 n1_m1_340800_561600 n1_m1_340000_561600 0.892706
R15760 n1_m1_340800_561600 n1_m1_345600_561600 5.356235
R15761 n1_m1_345600_561600 n1_m1_350400_561600 5.356235
R15762 n1_m1_350400_561600 n1_m1_355200_561600 5.356235
R15763 n1_m1_355200_561600 n1_m1_360000_561600 5.356235
R15764 n1_m1_360000_561600 n1_m1_364800_561600 5.356235
R15765 n1_m1_364800_561600 n1_m1_368000_561600 3.570824
R15766 n1_m1_369600_561600 n1_m1_368000_561600 1.785412
R15767 n1_m1_369600_561600 n1_m1_374400_561600 5.356235
R15768 n1_m1_374400_561600 n1_m1_379200_561600 5.356235
R15769 n1_m1_379200_561600 n1_m1_384000_561600 5.356235
R15770 n1_m1_384000_561600 n1_m1_388800_561600 5.356235
R15771 n1_m1_388800_561600 n1_m1_393600_561600 5.356235
R15772 n1_m1_393600_561600 n1_m1_396000_561600 2.678118
R15773 n1_m1_398400_561600 n1_m1_396000_561600 2.678118
R15774 n1_m1_398400_561600 n1_m1_403200_561600 5.356235
R15775 n1_m1_403200_561600 n1_m1_408000_561600 5.356235
R15776 n1_m1_408000_561600 n1_m1_412800_561600 5.356235
R15777 n1_m1_412800_561600 n1_m1_417600_561600 5.356235
R15778 n1_m1_417600_561600 n1_m1_422400_561600 5.356235
R15779 n1_m1_422400_561600 n1_m1_424000_561600 1.785412
R15780 n1_m1_427200_561600 n1_m1_424000_561600 3.570824
R15781 n1_m1_427200_561600 n1_m1_432000_561600 5.356235
R15782 n1_m1_432000_561600 n1_m1_436800_561600 5.356235
R15783 n1_m1_436800_561600 n1_m1_441600_561600 5.356235
R15784 n1_m1_441600_561600 n1_m1_446400_561600 5.356235
R15785 n1_m1_446400_561600 n1_m1_451200_561600 5.356235
R15786 n1_m1_451200_561600 n1_m1_452000_561600 0.892706
R15787 n1_m1_456000_561600 n1_m1_452000_561600 4.463529
R15788 n1_m1_456000_561600 n1_m1_460800_561600 5.356235
R15789 n1_m1_460800_561600 n1_m1_465600_561600 5.356235
R15790 n1_m1_465600_561600 n1_m1_470400_561600 5.356235
R15791 n1_m1_470400_561600 n1_m1_475200_561600 5.356235
R15792 n1_m1_475200_561600 n1_m1_480000_561600 5.356235
R15793 n1_m1_480000_561600 n1_m1_484800_561600 5.356235
R15794 n1_m1_484800_561600 n1_m1_489600_561600 5.356235
R15795 n1_m1_489600_561600 n1_m1_494400_561600 5.356235
R15796 n1_m1_494400_561600 n1_m1_499200_561600 5.356235
R15797 n1_m1_499200_561600 n1_m1_504000_561600 5.356235
R15798 n1_m1_504000_561600 n1_m1_508000_561600 4.463529
R15799 n1_m1_508800_561600 n1_m1_508000_561600 0.892706
R15800 n1_m1_508800_561600 n1_m1_513600_561600 5.356235
R15801 n1_m1_513600_561600 n1_m1_518400_561600 5.356235
R15802 n1_m1_518400_561600 n1_m1_523200_561600 5.356235
R15803 n1_m1_523200_561600 n1_m1_528000_561600 5.356235
R15804 n1_m1_528000_561600 n1_m1_532800_561600 5.356235
R15805 n1_m1_532800_561600 n1_m1_536000_561600 3.570824
R15806 n1_m1_537600_561600 n1_m1_536000_561600 1.785412
R15807 n1_m1_537600_561600 n1_m1_542400_561600 5.356235
R15808 n1_m1_542400_561600 n1_m1_547200_561600 5.356235
R15809 n1_m1_547200_561600 n1_m1_552000_561600 5.356235
R15810 n1_m1_552000_561600 n1_m1_556800_561600 5.356235
R15811 n1_m1_556800_561600 n1_m1_561600_561600 5.356235
R15812 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R15813 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R15814 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R15815 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R15816 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R15817 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R15818 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R15819 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R15820 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R15821 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R15822 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R15823 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R15824 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R15825 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R15826 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R15827 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R15828 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R15829 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R15830 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R15831 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R15832 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R15833 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R15834 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R15835 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R15836 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R15837 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R15838 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R15839 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R15840 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R15841 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R15842 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R15843 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R15844 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R15845 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R15846 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R15847 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R15848 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R15849 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R15850 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R15851 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R15852 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R15853 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R15854 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R15855 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R15856 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R15857 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R15858 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R15859 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R15860 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R15861 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R15862 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R15863 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R15864 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R15865 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R15866 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R15867 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R15868 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R15869 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R15870 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R15871 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R15872 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R15873 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R15874 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R15875 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R15876 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R15877 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R15878 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R15879 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R15880 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R15881 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R15882 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R15883 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R15884 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R15885 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R15886 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R15887 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R15888 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R15889 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R15890 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R15891 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R15892 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R15893 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R15894 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R15895 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R15896 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R15897 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R15898 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R15899 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R15900 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R15901 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R15902 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R15903 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R15904 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R15905 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R15906 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R15907 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R15908 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R15909 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R15910 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R15911 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R15912 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R15913 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R15914 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R15915 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R15916 n1_m4_4000_470400 n1_m4_4000_475200 1.400000
R15917 n1_m4_4000_475200 n1_m4_4000_480000 1.400000
R15918 n1_m4_4000_480000 n1_m4_4000_484000 1.166667
R15919 n1_m4_4000_484800 n1_m4_4000_484000 0.233333
R15920 n1_m4_4000_484800 n1_m4_4000_489600 1.400000
R15921 n1_m4_4000_489600 n1_m4_4000_494400 1.400000
R15922 n1_m4_4000_494400 n1_m4_4000_499200 1.400000
R15923 n1_m4_4000_499200 n1_m4_4000_504000 1.400000
R15924 n1_m4_4000_504000 n1_m4_4000_508800 1.400000
R15925 n1_m4_4000_508800 n1_m4_4000_513600 1.400000
R15926 n1_m4_4000_513600 n1_m4_4000_518400 1.400000
R15927 n1_m4_4000_518400 n1_m4_4000_523200 1.400000
R15928 n1_m4_4000_523200 n1_m4_4000_528000 1.400000
R15929 n1_m4_4000_528000 n1_m4_4000_532800 1.400000
R15930 n1_m4_4000_532800 n1_m4_4000_537600 1.400000
R15931 n1_m4_4000_537600 n1_m4_4000_542400 1.400000
R15932 n1_m4_4000_542400 n1_m4_4000_547200 1.400000
R15933 n1_m4_4000_547200 n1_m4_4000_552000 1.400000
R15934 n1_m4_4000_552000 n1_m4_4000_556800 1.400000
R15935 n1_m4_4000_556800 n1_m4_4000_561600 1.400000
R15936 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R15937 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R15938 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R15939 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R15940 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R15941 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R15942 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R15943 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R15944 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R15945 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R15946 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R15947 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R15948 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R15949 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R15950 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R15951 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R15952 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R15953 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R15954 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R15955 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R15956 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R15957 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R15958 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R15959 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R15960 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R15961 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R15962 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R15963 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R15964 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R15965 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R15966 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R15967 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R15968 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R15969 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R15970 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R15971 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R15972 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R15973 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R15974 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R15975 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R15976 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R15977 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R15978 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R15979 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R15980 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R15981 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R15982 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R15983 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R15984 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R15985 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R15986 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R15987 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R15988 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R15989 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R15990 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R15991 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R15992 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R15993 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R15994 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R15995 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R15996 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R15997 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R15998 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R15999 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R16000 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R16001 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R16002 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R16003 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R16004 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R16005 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R16006 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R16007 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R16008 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R16009 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R16010 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R16011 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R16012 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R16013 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R16014 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R16015 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R16016 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R16017 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R16018 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R16019 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R16020 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R16021 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R16022 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R16023 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R16024 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R16025 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R16026 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R16027 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R16028 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R16029 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R16030 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R16031 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R16032 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R16033 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R16034 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R16035 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R16036 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R16037 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R16038 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R16039 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R16040 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R16041 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R16042 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R16043 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R16044 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R16045 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R16046 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R16047 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R16048 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R16049 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R16050 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R16051 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R16052 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R16053 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R16054 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R16055 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R16056 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R16057 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R16058 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R16059 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R16060 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R16061 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R16062 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R16063 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R16064 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R16065 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R16066 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R16067 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R16068 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R16069 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R16070 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R16071 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R16072 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R16073 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R16074 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R16075 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R16076 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R16077 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R16078 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R16079 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R16080 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R16081 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R16082 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R16083 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R16084 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R16085 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R16086 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R16087 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R16088 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R16089 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R16090 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R16091 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R16092 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R16093 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R16094 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R16095 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R16096 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R16097 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R16098 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R16099 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R16100 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R16101 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R16102 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R16103 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R16104 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R16105 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R16106 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R16107 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R16108 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R16109 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R16110 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R16111 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R16112 n1_m4_116000_196800 n1_m4_116000_201600 1.400000
R16113 n1_m4_116000_201600 n1_m4_116000_206400 1.400000
R16114 n1_m4_116000_206400 n1_m4_116000_211200 1.400000
R16115 n1_m4_116000_211200 n1_m4_116000_216000 1.400000
R16116 n1_m4_116000_216000 n1_m4_116000_220800 1.400000
R16117 n1_m4_116000_220800 n1_m4_116000_225600 1.400000
R16118 n1_m4_116000_225600 n1_m4_116000_230400 1.400000
R16119 n1_m4_116000_230400 n1_m4_116000_235200 1.400000
R16120 n1_m4_116000_235200 n1_m4_116000_240000 1.400000
R16121 n1_m4_116000_240000 n1_m4_116000_244000 1.166667
R16122 n1_m4_116000_244800 n1_m4_116000_244000 0.233333
R16123 n1_m4_116000_244800 n1_m4_116000_249600 1.400000
R16124 n1_m4_116000_249600 n1_m4_116000_254400 1.400000
R16125 n1_m4_116000_254400 n1_m4_116000_259200 1.400000
R16126 n1_m4_116000_259200 n1_m4_116000_264000 1.400000
R16127 n1_m4_116000_264000 n1_m4_116000_268800 1.400000
R16128 n1_m4_116000_268800 n1_m4_116000_273600 1.400000
R16129 n1_m4_116000_273600 n1_m4_116000_278400 1.400000
R16130 n1_m4_116000_278400 n1_m4_116000_283200 1.400000
R16131 n1_m4_116000_283200 n1_m4_116000_288000 1.400000
R16132 n1_m4_116000_288000 n1_m4_116000_292800 1.400000
R16133 n1_m4_116000_292800 n1_m4_116000_297600 1.400000
R16134 n1_m4_116000_297600 n1_m4_116000_302400 1.400000
R16135 n1_m4_116000_302400 n1_m4_116000_307200 1.400000
R16136 n1_m4_116000_307200 n1_m4_116000_312000 1.400000
R16137 n1_m4_116000_312000 n1_m4_116000_316800 1.400000
R16138 n1_m4_116000_316800 n1_m4_116000_321600 1.400000
R16139 n1_m4_116000_321600 n1_m4_116000_324000 0.700000
R16140 n1_m4_116000_326400 n1_m4_116000_324000 0.700000
R16141 n1_m4_116000_326400 n1_m4_116000_331200 1.400000
R16142 n1_m4_116000_331200 n1_m4_116000_336000 1.400000
R16143 n1_m4_116000_336000 n1_m4_116000_340800 1.400000
R16144 n1_m4_116000_340800 n1_m4_116000_345600 1.400000
R16145 n1_m4_116000_345600 n1_m4_116000_350400 1.400000
R16146 n1_m4_116000_350400 n1_m4_116000_355200 1.400000
R16147 n1_m4_116000_355200 n1_m4_116000_360000 1.400000
R16148 n1_m4_116000_360000 n1_m4_116000_364800 1.400000
R16149 n1_m4_116000_364800 n1_m4_116000_369600 1.400000
R16150 n1_m4_116000_369600 n1_m4_116000_374400 1.400000
R16151 n1_m4_116000_374400 n1_m4_116000_379200 1.400000
R16152 n1_m4_116000_379200 n1_m4_116000_384000 1.400000
R16153 n1_m4_116000_384000 n1_m4_116000_388800 1.400000
R16154 n1_m4_116000_388800 n1_m4_116000_393600 1.400000
R16155 n1_m4_116000_393600 n1_m4_116000_398400 1.400000
R16156 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R16157 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R16158 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R16159 n1_m4_116000_408000 n1_m4_116000_412800 1.400000
R16160 n1_m4_116000_412800 n1_m4_116000_417600 1.400000
R16161 n1_m4_116000_417600 n1_m4_116000_422400 1.400000
R16162 n1_m4_116000_422400 n1_m4_116000_427200 1.400000
R16163 n1_m4_116000_427200 n1_m4_116000_432000 1.400000
R16164 n1_m4_116000_432000 n1_m4_116000_436800 1.400000
R16165 n1_m4_116000_436800 n1_m4_116000_441600 1.400000
R16166 n1_m4_116000_441600 n1_m4_116000_446400 1.400000
R16167 n1_m4_116000_446400 n1_m4_116000_451200 1.400000
R16168 n1_m4_116000_451200 n1_m4_116000_456000 1.400000
R16169 n1_m4_116000_456000 n1_m4_116000_460800 1.400000
R16170 n1_m4_116000_460800 n1_m4_116000_465600 1.400000
R16171 n1_m4_116000_465600 n1_m4_116000_470400 1.400000
R16172 n1_m4_116000_470400 n1_m4_116000_475200 1.400000
R16173 n1_m4_116000_475200 n1_m4_116000_480000 1.400000
R16174 n1_m4_116000_480000 n1_m4_116000_484000 1.166667
R16175 n1_m4_116000_484800 n1_m4_116000_484000 0.233333
R16176 n1_m4_116000_484800 n1_m4_116000_489600 1.400000
R16177 n1_m4_116000_489600 n1_m4_116000_494400 1.400000
R16178 n1_m4_116000_494400 n1_m4_116000_499200 1.400000
R16179 n1_m4_116000_499200 n1_m4_116000_504000 1.400000
R16180 n1_m4_116000_504000 n1_m4_116000_508800 1.400000
R16181 n1_m4_116000_508800 n1_m4_116000_513600 1.400000
R16182 n1_m4_116000_513600 n1_m4_116000_518400 1.400000
R16183 n1_m4_116000_518400 n1_m4_116000_523200 1.400000
R16184 n1_m4_116000_523200 n1_m4_116000_528000 1.400000
R16185 n1_m4_116000_528000 n1_m4_116000_532800 1.400000
R16186 n1_m4_116000_532800 n1_m4_116000_537600 1.400000
R16187 n1_m4_116000_537600 n1_m4_116000_542400 1.400000
R16188 n1_m4_116000_542400 n1_m4_116000_547200 1.400000
R16189 n1_m4_116000_547200 n1_m4_116000_552000 1.400000
R16190 n1_m4_116000_552000 n1_m4_116000_556800 1.400000
R16191 n1_m4_116000_556800 n1_m4_116000_561600 1.400000
R16192 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R16193 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R16194 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R16195 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R16196 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R16197 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R16198 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R16199 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R16200 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R16201 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R16202 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R16203 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R16204 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R16205 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R16206 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R16207 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R16208 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R16209 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R16210 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R16211 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R16212 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R16213 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R16214 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R16215 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R16216 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R16217 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R16218 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R16219 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R16220 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R16221 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R16222 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R16223 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R16224 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R16225 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R16226 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R16227 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R16228 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R16229 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R16230 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R16231 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R16232 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R16233 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R16234 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R16235 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R16236 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R16237 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R16238 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R16239 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R16240 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R16241 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R16242 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R16243 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R16244 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R16245 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R16246 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R16247 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R16248 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R16249 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R16250 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R16251 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R16252 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R16253 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R16254 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R16255 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R16256 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R16257 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R16258 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R16259 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R16260 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R16261 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R16262 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R16263 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R16264 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R16265 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R16266 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R16267 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R16268 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R16269 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R16270 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R16271 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R16272 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R16273 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R16274 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R16275 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R16276 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R16277 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R16278 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R16279 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R16280 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R16281 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R16282 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R16283 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R16284 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R16285 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R16286 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R16287 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R16288 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R16289 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R16290 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R16291 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R16292 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R16293 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R16294 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R16295 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R16296 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R16297 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R16298 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R16299 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R16300 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R16301 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R16302 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R16303 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R16304 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R16305 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R16306 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R16307 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R16308 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R16309 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R16310 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R16311 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R16312 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R16313 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R16314 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R16315 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R16316 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R16317 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R16318 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R16319 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R16320 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R16321 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R16322 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R16323 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R16324 n1_m4_228000_0 n1_m4_228000_4000 1.166667
R16325 n1_m4_228000_4800 n1_m4_228000_4000 0.233333
R16326 n1_m4_228000_4800 n1_m4_228000_9600 1.400000
R16327 n1_m4_228000_9600 n1_m4_228000_14400 1.400000
R16328 n1_m4_228000_14400 n1_m4_228000_19200 1.400000
R16329 n1_m4_228000_19200 n1_m4_228000_24000 1.400000
R16330 n1_m4_228000_24000 n1_m4_228000_28800 1.400000
R16331 n1_m4_228000_28800 n1_m4_228000_33600 1.400000
R16332 n1_m4_228000_33600 n1_m4_228000_38400 1.400000
R16333 n1_m4_228000_38400 n1_m4_228000_43200 1.400000
R16334 n1_m4_228000_43200 n1_m4_228000_48000 1.400000
R16335 n1_m4_228000_48000 n1_m4_228000_52800 1.400000
R16336 n1_m4_228000_52800 n1_m4_228000_57600 1.400000
R16337 n1_m4_228000_57600 n1_m4_228000_62400 1.400000
R16338 n1_m4_228000_62400 n1_m4_228000_67200 1.400000
R16339 n1_m4_228000_67200 n1_m4_228000_72000 1.400000
R16340 n1_m4_228000_72000 n1_m4_228000_76800 1.400000
R16341 n1_m4_228000_76800 n1_m4_228000_81600 1.400000
R16342 n1_m4_228000_81600 n1_m4_228000_84000 0.700000
R16343 n1_m4_228000_86400 n1_m4_228000_84000 0.700000
R16344 n1_m4_228000_86400 n1_m4_228000_91200 1.400000
R16345 n1_m4_228000_91200 n1_m4_228000_96000 1.400000
R16346 n1_m4_228000_96000 n1_m4_228000_100800 1.400000
R16347 n1_m4_228000_100800 n1_m4_228000_105600 1.400000
R16348 n1_m4_228000_105600 n1_m4_228000_110400 1.400000
R16349 n1_m4_228000_110400 n1_m4_228000_115200 1.400000
R16350 n1_m4_228000_115200 n1_m4_228000_120000 1.400000
R16351 n1_m4_228000_120000 n1_m4_228000_124800 1.400000
R16352 n1_m4_228000_124800 n1_m4_228000_129600 1.400000
R16353 n1_m4_228000_129600 n1_m4_228000_134400 1.400000
R16354 n1_m4_228000_134400 n1_m4_228000_139200 1.400000
R16355 n1_m4_228000_139200 n1_m4_228000_144000 1.400000
R16356 n1_m4_228000_144000 n1_m4_228000_148800 1.400000
R16357 n1_m4_228000_148800 n1_m4_228000_153600 1.400000
R16358 n1_m4_228000_153600 n1_m4_228000_158400 1.400000
R16359 n1_m4_228000_158400 n1_m4_228000_163200 1.400000
R16360 n1_m4_228000_163200 n1_m4_228000_164000 0.233333
R16361 n1_m4_228000_168000 n1_m4_228000_164000 1.166667
R16362 n1_m4_228000_168000 n1_m4_228000_172800 1.400000
R16363 n1_m4_228000_172800 n1_m4_228000_177600 1.400000
R16364 n1_m4_228000_177600 n1_m4_228000_182400 1.400000
R16365 n1_m4_228000_182400 n1_m4_228000_187200 1.400000
R16366 n1_m4_228000_187200 n1_m4_228000_192000 1.400000
R16367 n1_m4_228000_192000 n1_m4_228000_196800 1.400000
R16368 n1_m4_256000_0 n1_m4_256000_4000 1.166667
R16369 n1_m4_256000_4800 n1_m4_256000_4000 0.233333
R16370 n1_m4_256000_4800 n1_m4_256000_9600 1.400000
R16371 n1_m4_256000_9600 n1_m4_256000_14400 1.400000
R16372 n1_m4_256000_14400 n1_m4_256000_19200 1.400000
R16373 n1_m4_256000_19200 n1_m4_256000_24000 1.400000
R16374 n1_m4_256000_24000 n1_m4_256000_28800 1.400000
R16375 n1_m4_256000_28800 n1_m4_256000_33600 1.400000
R16376 n1_m4_256000_33600 n1_m4_256000_38400 1.400000
R16377 n1_m4_256000_38400 n1_m4_256000_43200 1.400000
R16378 n1_m4_256000_43200 n1_m4_256000_48000 1.400000
R16379 n1_m4_256000_48000 n1_m4_256000_52800 1.400000
R16380 n1_m4_256000_52800 n1_m4_256000_57600 1.400000
R16381 n1_m4_256000_57600 n1_m4_256000_62400 1.400000
R16382 n1_m4_256000_62400 n1_m4_256000_67200 1.400000
R16383 n1_m4_256000_67200 n1_m4_256000_72000 1.400000
R16384 n1_m4_256000_72000 n1_m4_256000_76800 1.400000
R16385 n1_m4_256000_76800 n1_m4_256000_81600 1.400000
R16386 n1_m4_256000_81600 n1_m4_256000_84000 0.700000
R16387 n1_m4_256000_86400 n1_m4_256000_84000 0.700000
R16388 n1_m4_256000_86400 n1_m4_256000_91200 1.400000
R16389 n1_m4_256000_91200 n1_m4_256000_96000 1.400000
R16390 n1_m4_256000_96000 n1_m4_256000_100800 1.400000
R16391 n1_m4_256000_100800 n1_m4_256000_105600 1.400000
R16392 n1_m4_256000_105600 n1_m4_256000_110400 1.400000
R16393 n1_m4_256000_110400 n1_m4_256000_115200 1.400000
R16394 n1_m4_256000_115200 n1_m4_256000_120000 1.400000
R16395 n1_m4_256000_120000 n1_m4_256000_124800 1.400000
R16396 n1_m4_256000_124800 n1_m4_256000_129600 1.400000
R16397 n1_m4_256000_129600 n1_m4_256000_134400 1.400000
R16398 n1_m4_256000_134400 n1_m4_256000_139200 1.400000
R16399 n1_m4_256000_139200 n1_m4_256000_144000 1.400000
R16400 n1_m4_256000_144000 n1_m4_256000_148800 1.400000
R16401 n1_m4_256000_148800 n1_m4_256000_153600 1.400000
R16402 n1_m4_256000_153600 n1_m4_256000_158400 1.400000
R16403 n1_m4_256000_158400 n1_m4_256000_163200 1.400000
R16404 n1_m4_256000_163200 n1_m4_256000_164000 0.233333
R16405 n1_m4_256000_168000 n1_m4_256000_164000 1.166667
R16406 n1_m4_256000_168000 n1_m4_256000_172800 1.400000
R16407 n1_m4_256000_172800 n1_m4_256000_177600 1.400000
R16408 n1_m4_256000_177600 n1_m4_256000_182400 1.400000
R16409 n1_m4_256000_182400 n1_m4_256000_187200 1.400000
R16410 n1_m4_256000_187200 n1_m4_256000_192000 1.400000
R16411 n1_m4_256000_192000 n1_m4_256000_196800 1.400000
R16412 n1_m4_284000_0 n1_m4_284000_4000 1.166667
R16413 n1_m4_284000_4800 n1_m4_284000_4000 0.233333
R16414 n1_m4_284000_4800 n1_m4_284000_9600 1.400000
R16415 n1_m4_284000_9600 n1_m4_284000_14400 1.400000
R16416 n1_m4_284000_14400 n1_m4_284000_19200 1.400000
R16417 n1_m4_284000_19200 n1_m4_284000_24000 1.400000
R16418 n1_m4_284000_24000 n1_m4_284000_28800 1.400000
R16419 n1_m4_284000_28800 n1_m4_284000_33600 1.400000
R16420 n1_m4_284000_33600 n1_m4_284000_38400 1.400000
R16421 n1_m4_284000_38400 n1_m4_284000_43200 1.400000
R16422 n1_m4_284000_43200 n1_m4_284000_48000 1.400000
R16423 n1_m4_284000_48000 n1_m4_284000_52800 1.400000
R16424 n1_m4_284000_52800 n1_m4_284000_57600 1.400000
R16425 n1_m4_284000_57600 n1_m4_284000_62400 1.400000
R16426 n1_m4_284000_62400 n1_m4_284000_67200 1.400000
R16427 n1_m4_284000_67200 n1_m4_284000_72000 1.400000
R16428 n1_m4_284000_72000 n1_m4_284000_76800 1.400000
R16429 n1_m4_284000_76800 n1_m4_284000_81600 1.400000
R16430 n1_m4_284000_81600 n1_m4_284000_84000 0.700000
R16431 n1_m4_284000_86400 n1_m4_284000_84000 0.700000
R16432 n1_m4_284000_86400 n1_m4_284000_91200 1.400000
R16433 n1_m4_284000_91200 n1_m4_284000_96000 1.400000
R16434 n1_m4_284000_96000 n1_m4_284000_100800 1.400000
R16435 n1_m4_284000_100800 n1_m4_284000_105600 1.400000
R16436 n1_m4_284000_105600 n1_m4_284000_110400 1.400000
R16437 n1_m4_284000_110400 n1_m4_284000_115200 1.400000
R16438 n1_m4_284000_115200 n1_m4_284000_120000 1.400000
R16439 n1_m4_284000_120000 n1_m4_284000_124800 1.400000
R16440 n1_m4_284000_124800 n1_m4_284000_129600 1.400000
R16441 n1_m4_284000_129600 n1_m4_284000_134400 1.400000
R16442 n1_m4_284000_134400 n1_m4_284000_139200 1.400000
R16443 n1_m4_284000_139200 n1_m4_284000_144000 1.400000
R16444 n1_m4_284000_144000 n1_m4_284000_148800 1.400000
R16445 n1_m4_284000_148800 n1_m4_284000_153600 1.400000
R16446 n1_m4_284000_153600 n1_m4_284000_158400 1.400000
R16447 n1_m4_284000_158400 n1_m4_284000_163200 1.400000
R16448 n1_m4_284000_163200 n1_m4_284000_164000 0.233333
R16449 n1_m4_284000_168000 n1_m4_284000_164000 1.166667
R16450 n1_m4_284000_168000 n1_m4_284000_172800 1.400000
R16451 n1_m4_284000_172800 n1_m4_284000_177600 1.400000
R16452 n1_m4_284000_177600 n1_m4_284000_182400 1.400000
R16453 n1_m4_284000_182400 n1_m4_284000_187200 1.400000
R16454 n1_m4_284000_187200 n1_m4_284000_192000 1.400000
R16455 n1_m4_284000_192000 n1_m4_284000_196800 1.400000
R16456 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R16457 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R16458 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R16459 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R16460 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R16461 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R16462 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R16463 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R16464 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R16465 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R16466 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R16467 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R16468 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R16469 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R16470 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R16471 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R16472 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R16473 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R16474 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R16475 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R16476 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R16477 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R16478 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R16479 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R16480 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R16481 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R16482 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R16483 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R16484 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R16485 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R16486 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R16487 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R16488 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R16489 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R16490 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R16491 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R16492 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R16493 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R16494 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R16495 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R16496 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R16497 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R16498 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R16499 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R16500 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R16501 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R16502 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R16503 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R16504 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R16505 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R16506 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R16507 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R16508 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R16509 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R16510 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R16511 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R16512 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R16513 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R16514 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R16515 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R16516 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R16517 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R16518 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R16519 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R16520 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R16521 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R16522 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R16523 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R16524 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R16525 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R16526 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R16527 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R16528 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R16529 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R16530 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R16531 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R16532 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R16533 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R16534 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R16535 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R16536 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R16537 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R16538 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R16539 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R16540 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R16541 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R16542 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R16543 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R16544 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R16545 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R16546 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R16547 n1_m4_312000_408000 n1_m4_312000_412800 1.400000
R16548 n1_m4_312000_412800 n1_m4_312000_417600 1.400000
R16549 n1_m4_312000_417600 n1_m4_312000_422400 1.400000
R16550 n1_m4_312000_422400 n1_m4_312000_427200 1.400000
R16551 n1_m4_312000_427200 n1_m4_312000_432000 1.400000
R16552 n1_m4_312000_432000 n1_m4_312000_436800 1.400000
R16553 n1_m4_312000_436800 n1_m4_312000_441600 1.400000
R16554 n1_m4_312000_441600 n1_m4_312000_446400 1.400000
R16555 n1_m4_312000_446400 n1_m4_312000_451200 1.400000
R16556 n1_m4_312000_451200 n1_m4_312000_456000 1.400000
R16557 n1_m4_312000_456000 n1_m4_312000_460800 1.400000
R16558 n1_m4_312000_460800 n1_m4_312000_465600 1.400000
R16559 n1_m4_312000_465600 n1_m4_312000_470400 1.400000
R16560 n1_m4_312000_470400 n1_m4_312000_475200 1.400000
R16561 n1_m4_312000_475200 n1_m4_312000_480000 1.400000
R16562 n1_m4_312000_480000 n1_m4_312000_484000 1.166667
R16563 n1_m4_312000_484800 n1_m4_312000_484000 0.233333
R16564 n1_m4_312000_484800 n1_m4_312000_489600 1.400000
R16565 n1_m4_312000_489600 n1_m4_312000_494400 1.400000
R16566 n1_m4_312000_494400 n1_m4_312000_499200 1.400000
R16567 n1_m4_312000_499200 n1_m4_312000_504000 1.400000
R16568 n1_m4_312000_504000 n1_m4_312000_508800 1.400000
R16569 n1_m4_312000_508800 n1_m4_312000_513600 1.400000
R16570 n1_m4_312000_513600 n1_m4_312000_518400 1.400000
R16571 n1_m4_312000_518400 n1_m4_312000_523200 1.400000
R16572 n1_m4_312000_523200 n1_m4_312000_528000 1.400000
R16573 n1_m4_312000_528000 n1_m4_312000_532800 1.400000
R16574 n1_m4_312000_532800 n1_m4_312000_537600 1.400000
R16575 n1_m4_312000_537600 n1_m4_312000_542400 1.400000
R16576 n1_m4_312000_542400 n1_m4_312000_547200 1.400000
R16577 n1_m4_312000_547200 n1_m4_312000_552000 1.400000
R16578 n1_m4_312000_552000 n1_m4_312000_556800 1.400000
R16579 n1_m4_312000_556800 n1_m4_312000_561600 1.400000
R16580 n1_m4_340000_0 n1_m4_340000_4000 1.166667
R16581 n1_m4_340000_4800 n1_m4_340000_4000 0.233333
R16582 n1_m4_340000_4800 n1_m4_340000_9600 1.400000
R16583 n1_m4_340000_9600 n1_m4_340000_14400 1.400000
R16584 n1_m4_340000_14400 n1_m4_340000_19200 1.400000
R16585 n1_m4_340000_19200 n1_m4_340000_24000 1.400000
R16586 n1_m4_340000_24000 n1_m4_340000_28800 1.400000
R16587 n1_m4_340000_28800 n1_m4_340000_33600 1.400000
R16588 n1_m4_340000_33600 n1_m4_340000_38400 1.400000
R16589 n1_m4_340000_38400 n1_m4_340000_43200 1.400000
R16590 n1_m4_340000_43200 n1_m4_340000_48000 1.400000
R16591 n1_m4_340000_48000 n1_m4_340000_52800 1.400000
R16592 n1_m4_340000_52800 n1_m4_340000_57600 1.400000
R16593 n1_m4_340000_57600 n1_m4_340000_62400 1.400000
R16594 n1_m4_340000_62400 n1_m4_340000_67200 1.400000
R16595 n1_m4_340000_67200 n1_m4_340000_72000 1.400000
R16596 n1_m4_340000_72000 n1_m4_340000_76800 1.400000
R16597 n1_m4_340000_76800 n1_m4_340000_81600 1.400000
R16598 n1_m4_340000_81600 n1_m4_340000_84000 0.700000
R16599 n1_m4_340000_86400 n1_m4_340000_84000 0.700000
R16600 n1_m4_340000_86400 n1_m4_340000_91200 1.400000
R16601 n1_m4_340000_91200 n1_m4_340000_96000 1.400000
R16602 n1_m4_340000_96000 n1_m4_340000_100800 1.400000
R16603 n1_m4_340000_100800 n1_m4_340000_105600 1.400000
R16604 n1_m4_340000_105600 n1_m4_340000_110400 1.400000
R16605 n1_m4_340000_110400 n1_m4_340000_115200 1.400000
R16606 n1_m4_340000_115200 n1_m4_340000_120000 1.400000
R16607 n1_m4_340000_120000 n1_m4_340000_124800 1.400000
R16608 n1_m4_340000_124800 n1_m4_340000_129600 1.400000
R16609 n1_m4_340000_129600 n1_m4_340000_134400 1.400000
R16610 n1_m4_340000_134400 n1_m4_340000_139200 1.400000
R16611 n1_m4_340000_139200 n1_m4_340000_144000 1.400000
R16612 n1_m4_340000_144000 n1_m4_340000_148800 1.400000
R16613 n1_m4_340000_148800 n1_m4_340000_153600 1.400000
R16614 n1_m4_340000_153600 n1_m4_340000_158400 1.400000
R16615 n1_m4_340000_158400 n1_m4_340000_163200 1.400000
R16616 n1_m4_340000_163200 n1_m4_340000_164000 0.233333
R16617 n1_m4_340000_168000 n1_m4_340000_164000 1.166667
R16618 n1_m4_340000_168000 n1_m4_340000_172800 1.400000
R16619 n1_m4_340000_172800 n1_m4_340000_177600 1.400000
R16620 n1_m4_340000_177600 n1_m4_340000_182400 1.400000
R16621 n1_m4_340000_182400 n1_m4_340000_187200 1.400000
R16622 n1_m4_340000_187200 n1_m4_340000_192000 1.400000
R16623 n1_m4_340000_192000 n1_m4_340000_196800 1.400000
R16624 n1_m4_368000_0 n1_m4_368000_4000 1.166667
R16625 n1_m4_368000_4800 n1_m4_368000_4000 0.233333
R16626 n1_m4_368000_4800 n1_m4_368000_9600 1.400000
R16627 n1_m4_368000_9600 n1_m4_368000_14400 1.400000
R16628 n1_m4_368000_14400 n1_m4_368000_19200 1.400000
R16629 n1_m4_368000_19200 n1_m4_368000_24000 1.400000
R16630 n1_m4_368000_24000 n1_m4_368000_28800 1.400000
R16631 n1_m4_368000_28800 n1_m4_368000_33600 1.400000
R16632 n1_m4_368000_33600 n1_m4_368000_38400 1.400000
R16633 n1_m4_368000_38400 n1_m4_368000_43200 1.400000
R16634 n1_m4_368000_43200 n1_m4_368000_48000 1.400000
R16635 n1_m4_368000_48000 n1_m4_368000_52800 1.400000
R16636 n1_m4_368000_52800 n1_m4_368000_57600 1.400000
R16637 n1_m4_368000_57600 n1_m4_368000_62400 1.400000
R16638 n1_m4_368000_62400 n1_m4_368000_67200 1.400000
R16639 n1_m4_368000_67200 n1_m4_368000_72000 1.400000
R16640 n1_m4_368000_72000 n1_m4_368000_76800 1.400000
R16641 n1_m4_368000_76800 n1_m4_368000_81600 1.400000
R16642 n1_m4_368000_81600 n1_m4_368000_84000 0.700000
R16643 n1_m4_368000_86400 n1_m4_368000_84000 0.700000
R16644 n1_m4_368000_86400 n1_m4_368000_91200 1.400000
R16645 n1_m4_368000_91200 n1_m4_368000_96000 1.400000
R16646 n1_m4_368000_96000 n1_m4_368000_100800 1.400000
R16647 n1_m4_368000_100800 n1_m4_368000_105600 1.400000
R16648 n1_m4_368000_105600 n1_m4_368000_110400 1.400000
R16649 n1_m4_368000_110400 n1_m4_368000_115200 1.400000
R16650 n1_m4_368000_115200 n1_m4_368000_120000 1.400000
R16651 n1_m4_368000_120000 n1_m4_368000_124800 1.400000
R16652 n1_m4_368000_124800 n1_m4_368000_129600 1.400000
R16653 n1_m4_368000_129600 n1_m4_368000_134400 1.400000
R16654 n1_m4_368000_134400 n1_m4_368000_139200 1.400000
R16655 n1_m4_368000_139200 n1_m4_368000_144000 1.400000
R16656 n1_m4_368000_144000 n1_m4_368000_148800 1.400000
R16657 n1_m4_368000_148800 n1_m4_368000_153600 1.400000
R16658 n1_m4_368000_153600 n1_m4_368000_158400 1.400000
R16659 n1_m4_368000_158400 n1_m4_368000_163200 1.400000
R16660 n1_m4_368000_163200 n1_m4_368000_164000 0.233333
R16661 n1_m4_368000_168000 n1_m4_368000_164000 1.166667
R16662 n1_m4_368000_168000 n1_m4_368000_172800 1.400000
R16663 n1_m4_368000_172800 n1_m4_368000_177600 1.400000
R16664 n1_m4_368000_177600 n1_m4_368000_182400 1.400000
R16665 n1_m4_368000_182400 n1_m4_368000_187200 1.400000
R16666 n1_m4_368000_187200 n1_m4_368000_192000 1.400000
R16667 n1_m4_368000_192000 n1_m4_368000_196800 1.400000
R16668 n1_m4_396000_0 n1_m4_396000_4000 1.166667
R16669 n1_m4_396000_4800 n1_m4_396000_4000 0.233333
R16670 n1_m4_396000_4800 n1_m4_396000_9600 1.400000
R16671 n1_m4_396000_9600 n1_m4_396000_14400 1.400000
R16672 n1_m4_396000_14400 n1_m4_396000_19200 1.400000
R16673 n1_m4_396000_19200 n1_m4_396000_24000 1.400000
R16674 n1_m4_396000_24000 n1_m4_396000_28800 1.400000
R16675 n1_m4_396000_28800 n1_m4_396000_33600 1.400000
R16676 n1_m4_396000_33600 n1_m4_396000_38400 1.400000
R16677 n1_m4_396000_38400 n1_m4_396000_43200 1.400000
R16678 n1_m4_396000_43200 n1_m4_396000_48000 1.400000
R16679 n1_m4_396000_48000 n1_m4_396000_52800 1.400000
R16680 n1_m4_396000_52800 n1_m4_396000_57600 1.400000
R16681 n1_m4_396000_57600 n1_m4_396000_62400 1.400000
R16682 n1_m4_396000_62400 n1_m4_396000_67200 1.400000
R16683 n1_m4_396000_67200 n1_m4_396000_72000 1.400000
R16684 n1_m4_396000_72000 n1_m4_396000_76800 1.400000
R16685 n1_m4_396000_76800 n1_m4_396000_81600 1.400000
R16686 n1_m4_396000_81600 n1_m4_396000_84000 0.700000
R16687 n1_m4_396000_86400 n1_m4_396000_84000 0.700000
R16688 n1_m4_396000_86400 n1_m4_396000_91200 1.400000
R16689 n1_m4_396000_91200 n1_m4_396000_96000 1.400000
R16690 n1_m4_396000_96000 n1_m4_396000_100800 1.400000
R16691 n1_m4_396000_100800 n1_m4_396000_105600 1.400000
R16692 n1_m4_396000_105600 n1_m4_396000_110400 1.400000
R16693 n1_m4_396000_110400 n1_m4_396000_115200 1.400000
R16694 n1_m4_396000_115200 n1_m4_396000_120000 1.400000
R16695 n1_m4_396000_120000 n1_m4_396000_124800 1.400000
R16696 n1_m4_396000_124800 n1_m4_396000_129600 1.400000
R16697 n1_m4_396000_129600 n1_m4_396000_134400 1.400000
R16698 n1_m4_396000_134400 n1_m4_396000_139200 1.400000
R16699 n1_m4_396000_139200 n1_m4_396000_144000 1.400000
R16700 n1_m4_396000_144000 n1_m4_396000_148800 1.400000
R16701 n1_m4_396000_148800 n1_m4_396000_153600 1.400000
R16702 n1_m4_396000_153600 n1_m4_396000_158400 1.400000
R16703 n1_m4_396000_158400 n1_m4_396000_163200 1.400000
R16704 n1_m4_396000_163200 n1_m4_396000_164000 0.233333
R16705 n1_m4_396000_168000 n1_m4_396000_164000 1.166667
R16706 n1_m4_396000_168000 n1_m4_396000_172800 1.400000
R16707 n1_m4_396000_172800 n1_m4_396000_177600 1.400000
R16708 n1_m4_396000_177600 n1_m4_396000_182400 1.400000
R16709 n1_m4_396000_182400 n1_m4_396000_187200 1.400000
R16710 n1_m4_396000_187200 n1_m4_396000_192000 1.400000
R16711 n1_m4_396000_192000 n1_m4_396000_196800 1.400000
R16712 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R16713 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R16714 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R16715 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R16716 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R16717 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R16718 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R16719 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R16720 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R16721 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R16722 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R16723 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R16724 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R16725 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R16726 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R16727 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R16728 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R16729 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R16730 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R16731 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R16732 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R16733 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R16734 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R16735 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R16736 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R16737 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R16738 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R16739 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R16740 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R16741 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R16742 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R16743 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R16744 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R16745 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R16746 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R16747 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R16748 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R16749 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R16750 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R16751 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R16752 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R16753 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R16754 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R16755 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R16756 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R16757 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R16758 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R16759 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R16760 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R16761 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R16762 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R16763 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R16764 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R16765 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R16766 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R16767 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R16768 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R16769 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R16770 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R16771 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R16772 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R16773 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R16774 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R16775 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R16776 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R16777 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R16778 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R16779 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R16780 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R16781 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R16782 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R16783 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R16784 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R16785 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R16786 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R16787 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R16788 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R16789 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R16790 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R16791 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R16792 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R16793 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R16794 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R16795 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R16796 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R16797 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R16798 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R16799 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R16800 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R16801 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R16802 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R16803 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R16804 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R16805 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R16806 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R16807 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R16808 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R16809 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R16810 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R16811 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R16812 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R16813 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R16814 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R16815 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R16816 n1_m4_424000_470400 n1_m4_424000_475200 1.400000
R16817 n1_m4_424000_475200 n1_m4_424000_480000 1.400000
R16818 n1_m4_424000_480000 n1_m4_424000_484000 1.166667
R16819 n1_m4_424000_484800 n1_m4_424000_484000 0.233333
R16820 n1_m4_424000_484800 n1_m4_424000_489600 1.400000
R16821 n1_m4_424000_489600 n1_m4_424000_494400 1.400000
R16822 n1_m4_424000_494400 n1_m4_424000_499200 1.400000
R16823 n1_m4_424000_499200 n1_m4_424000_504000 1.400000
R16824 n1_m4_424000_504000 n1_m4_424000_508800 1.400000
R16825 n1_m4_424000_508800 n1_m4_424000_513600 1.400000
R16826 n1_m4_424000_513600 n1_m4_424000_518400 1.400000
R16827 n1_m4_424000_518400 n1_m4_424000_523200 1.400000
R16828 n1_m4_424000_523200 n1_m4_424000_528000 1.400000
R16829 n1_m4_424000_528000 n1_m4_424000_532800 1.400000
R16830 n1_m4_424000_532800 n1_m4_424000_537600 1.400000
R16831 n1_m4_424000_537600 n1_m4_424000_542400 1.400000
R16832 n1_m4_424000_542400 n1_m4_424000_547200 1.400000
R16833 n1_m4_424000_547200 n1_m4_424000_552000 1.400000
R16834 n1_m4_424000_552000 n1_m4_424000_556800 1.400000
R16835 n1_m4_424000_556800 n1_m4_424000_561600 1.400000
R16836 n1_m4_452000_196800 n1_m4_452000_201600 1.400000
R16837 n1_m4_452000_201600 n1_m4_452000_206400 1.400000
R16838 n1_m4_452000_206400 n1_m4_452000_211200 1.400000
R16839 n1_m4_452000_211200 n1_m4_452000_216000 1.400000
R16840 n1_m4_452000_216000 n1_m4_452000_220800 1.400000
R16841 n1_m4_452000_220800 n1_m4_452000_225600 1.400000
R16842 n1_m4_452000_225600 n1_m4_452000_230400 1.400000
R16843 n1_m4_452000_230400 n1_m4_452000_235200 1.400000
R16844 n1_m4_452000_235200 n1_m4_452000_240000 1.400000
R16845 n1_m4_452000_240000 n1_m4_452000_244000 1.166667
R16846 n1_m4_452000_244800 n1_m4_452000_244000 0.233333
R16847 n1_m4_452000_244800 n1_m4_452000_249600 1.400000
R16848 n1_m4_452000_249600 n1_m4_452000_254400 1.400000
R16849 n1_m4_452000_254400 n1_m4_452000_259200 1.400000
R16850 n1_m4_452000_259200 n1_m4_452000_264000 1.400000
R16851 n1_m4_452000_264000 n1_m4_452000_268800 1.400000
R16852 n1_m4_452000_268800 n1_m4_452000_273600 1.400000
R16853 n1_m4_452000_273600 n1_m4_452000_278400 1.400000
R16854 n1_m4_452000_278400 n1_m4_452000_283200 1.400000
R16855 n1_m4_452000_283200 n1_m4_452000_288000 1.400000
R16856 n1_m4_452000_288000 n1_m4_452000_292800 1.400000
R16857 n1_m4_452000_292800 n1_m4_452000_297600 1.400000
R16858 n1_m4_452000_297600 n1_m4_452000_302400 1.400000
R16859 n1_m4_452000_302400 n1_m4_452000_307200 1.400000
R16860 n1_m4_452000_307200 n1_m4_452000_312000 1.400000
R16861 n1_m4_452000_312000 n1_m4_452000_316800 1.400000
R16862 n1_m4_452000_316800 n1_m4_452000_321600 1.400000
R16863 n1_m4_452000_321600 n1_m4_452000_324000 0.700000
R16864 n1_m4_452000_326400 n1_m4_452000_324000 0.700000
R16865 n1_m4_452000_326400 n1_m4_452000_331200 1.400000
R16866 n1_m4_452000_331200 n1_m4_452000_336000 1.400000
R16867 n1_m4_452000_336000 n1_m4_452000_340800 1.400000
R16868 n1_m4_452000_340800 n1_m4_452000_345600 1.400000
R16869 n1_m4_452000_345600 n1_m4_452000_350400 1.400000
R16870 n1_m4_452000_350400 n1_m4_452000_355200 1.400000
R16871 n1_m4_452000_355200 n1_m4_452000_360000 1.400000
R16872 n1_m4_452000_360000 n1_m4_452000_364800 1.400000
R16873 n1_m4_452000_364800 n1_m4_452000_369600 1.400000
R16874 n1_m4_452000_369600 n1_m4_452000_374400 1.400000
R16875 n1_m4_452000_374400 n1_m4_452000_379200 1.400000
R16876 n1_m4_452000_379200 n1_m4_452000_384000 1.400000
R16877 n1_m4_452000_384000 n1_m4_452000_388800 1.400000
R16878 n1_m4_452000_388800 n1_m4_452000_393600 1.400000
R16879 n1_m4_452000_393600 n1_m4_452000_398400 1.400000
R16880 n1_m4_480000_0 n1_m4_480000_4000 1.166667
R16881 n1_m4_480000_4800 n1_m4_480000_4000 0.233333
R16882 n1_m4_480000_4800 n1_m4_480000_9600 1.400000
R16883 n1_m4_480000_9600 n1_m4_480000_14400 1.400000
R16884 n1_m4_480000_14400 n1_m4_480000_19200 1.400000
R16885 n1_m4_480000_19200 n1_m4_480000_24000 1.400000
R16886 n1_m4_480000_24000 n1_m4_480000_28800 1.400000
R16887 n1_m4_480000_28800 n1_m4_480000_33600 1.400000
R16888 n1_m4_480000_33600 n1_m4_480000_38400 1.400000
R16889 n1_m4_480000_38400 n1_m4_480000_43200 1.400000
R16890 n1_m4_480000_43200 n1_m4_480000_48000 1.400000
R16891 n1_m4_480000_48000 n1_m4_480000_52800 1.400000
R16892 n1_m4_480000_52800 n1_m4_480000_57600 1.400000
R16893 n1_m4_480000_57600 n1_m4_480000_62400 1.400000
R16894 n1_m4_480000_62400 n1_m4_480000_67200 1.400000
R16895 n1_m4_480000_67200 n1_m4_480000_72000 1.400000
R16896 n1_m4_480000_72000 n1_m4_480000_76800 1.400000
R16897 n1_m4_480000_76800 n1_m4_480000_81600 1.400000
R16898 n1_m4_480000_81600 n1_m4_480000_84000 0.700000
R16899 n1_m4_480000_86400 n1_m4_480000_84000 0.700000
R16900 n1_m4_480000_86400 n1_m4_480000_91200 1.400000
R16901 n1_m4_480000_91200 n1_m4_480000_96000 1.400000
R16902 n1_m4_480000_96000 n1_m4_480000_100800 1.400000
R16903 n1_m4_480000_100800 n1_m4_480000_105600 1.400000
R16904 n1_m4_480000_105600 n1_m4_480000_110400 1.400000
R16905 n1_m4_480000_110400 n1_m4_480000_115200 1.400000
R16906 n1_m4_480000_115200 n1_m4_480000_120000 1.400000
R16907 n1_m4_480000_120000 n1_m4_480000_124800 1.400000
R16908 n1_m4_480000_124800 n1_m4_480000_129600 1.400000
R16909 n1_m4_480000_129600 n1_m4_480000_134400 1.400000
R16910 n1_m4_480000_134400 n1_m4_480000_139200 1.400000
R16911 n1_m4_480000_139200 n1_m4_480000_144000 1.400000
R16912 n1_m4_480000_144000 n1_m4_480000_148800 1.400000
R16913 n1_m4_480000_148800 n1_m4_480000_153600 1.400000
R16914 n1_m4_480000_153600 n1_m4_480000_158400 1.400000
R16915 n1_m4_480000_158400 n1_m4_480000_163200 1.400000
R16916 n1_m4_480000_163200 n1_m4_480000_164000 0.233333
R16917 n1_m4_480000_168000 n1_m4_480000_164000 1.166667
R16918 n1_m4_480000_168000 n1_m4_480000_172800 1.400000
R16919 n1_m4_480000_172800 n1_m4_480000_177600 1.400000
R16920 n1_m4_480000_177600 n1_m4_480000_182400 1.400000
R16921 n1_m4_480000_182400 n1_m4_480000_187200 1.400000
R16922 n1_m4_480000_187200 n1_m4_480000_192000 1.400000
R16923 n1_m4_480000_192000 n1_m4_480000_196800 1.400000
R16924 n1_m4_480000_196800 n1_m4_480000_201600 1.400000
R16925 n1_m4_480000_201600 n1_m4_480000_206400 1.400000
R16926 n1_m4_480000_206400 n1_m4_480000_211200 1.400000
R16927 n1_m4_480000_211200 n1_m4_480000_216000 1.400000
R16928 n1_m4_480000_216000 n1_m4_480000_220800 1.400000
R16929 n1_m4_480000_220800 n1_m4_480000_225600 1.400000
R16930 n1_m4_480000_225600 n1_m4_480000_230400 1.400000
R16931 n1_m4_480000_230400 n1_m4_480000_235200 1.400000
R16932 n1_m4_480000_235200 n1_m4_480000_240000 1.400000
R16933 n1_m4_480000_240000 n1_m4_480000_244000 1.166667
R16934 n1_m4_480000_244800 n1_m4_480000_244000 0.233333
R16935 n1_m4_480000_244800 n1_m4_480000_249600 1.400000
R16936 n1_m4_480000_249600 n1_m4_480000_254400 1.400000
R16937 n1_m4_480000_254400 n1_m4_480000_259200 1.400000
R16938 n1_m4_480000_259200 n1_m4_480000_264000 1.400000
R16939 n1_m4_480000_264000 n1_m4_480000_268800 1.400000
R16940 n1_m4_480000_268800 n1_m4_480000_273600 1.400000
R16941 n1_m4_480000_273600 n1_m4_480000_278400 1.400000
R16942 n1_m4_480000_278400 n1_m4_480000_283200 1.400000
R16943 n1_m4_480000_283200 n1_m4_480000_288000 1.400000
R16944 n1_m4_480000_288000 n1_m4_480000_292800 1.400000
R16945 n1_m4_480000_292800 n1_m4_480000_297600 1.400000
R16946 n1_m4_480000_297600 n1_m4_480000_302400 1.400000
R16947 n1_m4_480000_302400 n1_m4_480000_307200 1.400000
R16948 n1_m4_480000_307200 n1_m4_480000_312000 1.400000
R16949 n1_m4_480000_312000 n1_m4_480000_316800 1.400000
R16950 n1_m4_480000_316800 n1_m4_480000_321600 1.400000
R16951 n1_m4_480000_321600 n1_m4_480000_324000 0.700000
R16952 n1_m4_480000_326400 n1_m4_480000_324000 0.700000
R16953 n1_m4_480000_326400 n1_m4_480000_331200 1.400000
R16954 n1_m4_480000_331200 n1_m4_480000_336000 1.400000
R16955 n1_m4_480000_336000 n1_m4_480000_340800 1.400000
R16956 n1_m4_480000_340800 n1_m4_480000_345600 1.400000
R16957 n1_m4_480000_345600 n1_m4_480000_350400 1.400000
R16958 n1_m4_480000_350400 n1_m4_480000_355200 1.400000
R16959 n1_m4_480000_355200 n1_m4_480000_360000 1.400000
R16960 n1_m4_480000_360000 n1_m4_480000_364800 1.400000
R16961 n1_m4_480000_364800 n1_m4_480000_369600 1.400000
R16962 n1_m4_480000_369600 n1_m4_480000_374400 1.400000
R16963 n1_m4_480000_374400 n1_m4_480000_379200 1.400000
R16964 n1_m4_480000_379200 n1_m4_480000_384000 1.400000
R16965 n1_m4_480000_384000 n1_m4_480000_388800 1.400000
R16966 n1_m4_480000_388800 n1_m4_480000_393600 1.400000
R16967 n1_m4_480000_393600 n1_m4_480000_398400 1.400000
R16968 n1_m4_508000_196800 n1_m4_508000_201600 1.400000
R16969 n1_m4_508000_201600 n1_m4_508000_206400 1.400000
R16970 n1_m4_508000_206400 n1_m4_508000_211200 1.400000
R16971 n1_m4_508000_211200 n1_m4_508000_216000 1.400000
R16972 n1_m4_508000_216000 n1_m4_508000_220800 1.400000
R16973 n1_m4_508000_220800 n1_m4_508000_225600 1.400000
R16974 n1_m4_508000_225600 n1_m4_508000_230400 1.400000
R16975 n1_m4_508000_230400 n1_m4_508000_235200 1.400000
R16976 n1_m4_508000_235200 n1_m4_508000_240000 1.400000
R16977 n1_m4_508000_240000 n1_m4_508000_244000 1.166667
R16978 n1_m4_508000_244800 n1_m4_508000_244000 0.233333
R16979 n1_m4_508000_244800 n1_m4_508000_249600 1.400000
R16980 n1_m4_508000_249600 n1_m4_508000_254400 1.400000
R16981 n1_m4_508000_254400 n1_m4_508000_259200 1.400000
R16982 n1_m4_508000_259200 n1_m4_508000_264000 1.400000
R16983 n1_m4_508000_264000 n1_m4_508000_268800 1.400000
R16984 n1_m4_508000_268800 n1_m4_508000_273600 1.400000
R16985 n1_m4_508000_273600 n1_m4_508000_278400 1.400000
R16986 n1_m4_508000_278400 n1_m4_508000_283200 1.400000
R16987 n1_m4_508000_283200 n1_m4_508000_288000 1.400000
R16988 n1_m4_508000_288000 n1_m4_508000_292800 1.400000
R16989 n1_m4_508000_292800 n1_m4_508000_297600 1.400000
R16990 n1_m4_508000_297600 n1_m4_508000_302400 1.400000
R16991 n1_m4_508000_302400 n1_m4_508000_307200 1.400000
R16992 n1_m4_508000_307200 n1_m4_508000_312000 1.400000
R16993 n1_m4_508000_312000 n1_m4_508000_316800 1.400000
R16994 n1_m4_508000_316800 n1_m4_508000_321600 1.400000
R16995 n1_m4_508000_321600 n1_m4_508000_324000 0.700000
R16996 n1_m4_508000_326400 n1_m4_508000_324000 0.700000
R16997 n1_m4_508000_326400 n1_m4_508000_331200 1.400000
R16998 n1_m4_508000_331200 n1_m4_508000_336000 1.400000
R16999 n1_m4_508000_336000 n1_m4_508000_340800 1.400000
R17000 n1_m4_508000_340800 n1_m4_508000_345600 1.400000
R17001 n1_m4_508000_345600 n1_m4_508000_350400 1.400000
R17002 n1_m4_508000_350400 n1_m4_508000_355200 1.400000
R17003 n1_m4_508000_355200 n1_m4_508000_360000 1.400000
R17004 n1_m4_508000_360000 n1_m4_508000_364800 1.400000
R17005 n1_m4_508000_364800 n1_m4_508000_369600 1.400000
R17006 n1_m4_508000_369600 n1_m4_508000_374400 1.400000
R17007 n1_m4_508000_374400 n1_m4_508000_379200 1.400000
R17008 n1_m4_508000_379200 n1_m4_508000_384000 1.400000
R17009 n1_m4_508000_384000 n1_m4_508000_388800 1.400000
R17010 n1_m4_508000_388800 n1_m4_508000_393600 1.400000
R17011 n1_m4_508000_393600 n1_m4_508000_398400 1.400000
R17012 n1_m4_508000_398400 n1_m4_508000_403200 1.400000
R17013 n1_m4_508000_403200 n1_m4_508000_404000 0.233333
R17014 n1_m4_508000_408000 n1_m4_508000_404000 1.166667
R17015 n1_m4_508000_408000 n1_m4_508000_412800 1.400000
R17016 n1_m4_508000_412800 n1_m4_508000_417600 1.400000
R17017 n1_m4_508000_417600 n1_m4_508000_422400 1.400000
R17018 n1_m4_508000_422400 n1_m4_508000_427200 1.400000
R17019 n1_m4_508000_427200 n1_m4_508000_432000 1.400000
R17020 n1_m4_508000_432000 n1_m4_508000_436800 1.400000
R17021 n1_m4_508000_436800 n1_m4_508000_441600 1.400000
R17022 n1_m4_508000_441600 n1_m4_508000_446400 1.400000
R17023 n1_m4_508000_446400 n1_m4_508000_451200 1.400000
R17024 n1_m4_508000_451200 n1_m4_508000_456000 1.400000
R17025 n1_m4_508000_456000 n1_m4_508000_460800 1.400000
R17026 n1_m4_508000_460800 n1_m4_508000_465600 1.400000
R17027 n1_m4_508000_465600 n1_m4_508000_470400 1.400000
R17028 n1_m4_508000_470400 n1_m4_508000_475200 1.400000
R17029 n1_m4_508000_475200 n1_m4_508000_480000 1.400000
R17030 n1_m4_508000_480000 n1_m4_508000_484000 1.166667
R17031 n1_m4_508000_484800 n1_m4_508000_484000 0.233333
R17032 n1_m4_508000_484800 n1_m4_508000_489600 1.400000
R17033 n1_m4_508000_489600 n1_m4_508000_494400 1.400000
R17034 n1_m4_508000_494400 n1_m4_508000_499200 1.400000
R17035 n1_m4_508000_499200 n1_m4_508000_504000 1.400000
R17036 n1_m4_508000_504000 n1_m4_508000_508800 1.400000
R17037 n1_m4_508000_508800 n1_m4_508000_513600 1.400000
R17038 n1_m4_508000_513600 n1_m4_508000_518400 1.400000
R17039 n1_m4_508000_518400 n1_m4_508000_523200 1.400000
R17040 n1_m4_508000_523200 n1_m4_508000_528000 1.400000
R17041 n1_m4_508000_528000 n1_m4_508000_532800 1.400000
R17042 n1_m4_508000_532800 n1_m4_508000_537600 1.400000
R17043 n1_m4_508000_537600 n1_m4_508000_542400 1.400000
R17044 n1_m4_508000_542400 n1_m4_508000_547200 1.400000
R17045 n1_m4_508000_547200 n1_m4_508000_552000 1.400000
R17046 n1_m4_508000_552000 n1_m4_508000_556800 1.400000
R17047 n1_m4_508000_556800 n1_m4_508000_561600 1.400000
R17048 n1_m4_536000_0 n1_m4_536000_4000 1.166667
R17049 n1_m4_536000_4800 n1_m4_536000_4000 0.233333
R17050 n1_m4_536000_4800 n1_m4_536000_9600 1.400000
R17051 n1_m4_536000_9600 n1_m4_536000_14400 1.400000
R17052 n1_m4_536000_14400 n1_m4_536000_19200 1.400000
R17053 n1_m4_536000_19200 n1_m4_536000_24000 1.400000
R17054 n1_m4_536000_24000 n1_m4_536000_28800 1.400000
R17055 n1_m4_536000_28800 n1_m4_536000_33600 1.400000
R17056 n1_m4_536000_33600 n1_m4_536000_38400 1.400000
R17057 n1_m4_536000_38400 n1_m4_536000_43200 1.400000
R17058 n1_m4_536000_43200 n1_m4_536000_48000 1.400000
R17059 n1_m4_536000_48000 n1_m4_536000_52800 1.400000
R17060 n1_m4_536000_52800 n1_m4_536000_57600 1.400000
R17061 n1_m4_536000_57600 n1_m4_536000_62400 1.400000
R17062 n1_m4_536000_62400 n1_m4_536000_67200 1.400000
R17063 n1_m4_536000_67200 n1_m4_536000_72000 1.400000
R17064 n1_m4_536000_72000 n1_m4_536000_76800 1.400000
R17065 n1_m4_536000_76800 n1_m4_536000_81600 1.400000
R17066 n1_m4_536000_81600 n1_m4_536000_84000 0.700000
R17067 n1_m4_536000_86400 n1_m4_536000_84000 0.700000
R17068 n1_m4_536000_86400 n1_m4_536000_91200 1.400000
R17069 n1_m4_536000_91200 n1_m4_536000_96000 1.400000
R17070 n1_m4_536000_96000 n1_m4_536000_100800 1.400000
R17071 n1_m4_536000_100800 n1_m4_536000_105600 1.400000
R17072 n1_m4_536000_105600 n1_m4_536000_110400 1.400000
R17073 n1_m4_536000_110400 n1_m4_536000_115200 1.400000
R17074 n1_m4_536000_115200 n1_m4_536000_120000 1.400000
R17075 n1_m4_536000_120000 n1_m4_536000_124800 1.400000
R17076 n1_m4_536000_124800 n1_m4_536000_129600 1.400000
R17077 n1_m4_536000_129600 n1_m4_536000_134400 1.400000
R17078 n1_m4_536000_134400 n1_m4_536000_139200 1.400000
R17079 n1_m4_536000_139200 n1_m4_536000_144000 1.400000
R17080 n1_m4_536000_144000 n1_m4_536000_148800 1.400000
R17081 n1_m4_536000_148800 n1_m4_536000_153600 1.400000
R17082 n1_m4_536000_153600 n1_m4_536000_158400 1.400000
R17083 n1_m4_536000_158400 n1_m4_536000_163200 1.400000
R17084 n1_m4_536000_163200 n1_m4_536000_164000 0.233333
R17085 n1_m4_536000_168000 n1_m4_536000_164000 1.166667
R17086 n1_m4_536000_168000 n1_m4_536000_172800 1.400000
R17087 n1_m4_536000_172800 n1_m4_536000_177600 1.400000
R17088 n1_m4_536000_177600 n1_m4_536000_182400 1.400000
R17089 n1_m4_536000_182400 n1_m4_536000_187200 1.400000
R17090 n1_m4_536000_187200 n1_m4_536000_192000 1.400000
R17091 n1_m4_536000_192000 n1_m4_536000_196800 1.400000
R17092 n1_m4_536000_196800 n1_m4_536000_201600 1.400000
R17093 n1_m4_536000_201600 n1_m4_536000_206400 1.400000
R17094 n1_m4_536000_206400 n1_m4_536000_211200 1.400000
R17095 n1_m4_536000_211200 n1_m4_536000_216000 1.400000
R17096 n1_m4_536000_216000 n1_m4_536000_220800 1.400000
R17097 n1_m4_536000_220800 n1_m4_536000_225600 1.400000
R17098 n1_m4_536000_225600 n1_m4_536000_230400 1.400000
R17099 n1_m4_536000_230400 n1_m4_536000_235200 1.400000
R17100 n1_m4_536000_235200 n1_m4_536000_240000 1.400000
R17101 n1_m4_536000_240000 n1_m4_536000_244000 1.166667
R17102 n1_m4_536000_244800 n1_m4_536000_244000 0.233333
R17103 n1_m4_536000_244800 n1_m4_536000_249600 1.400000
R17104 n1_m4_536000_249600 n1_m4_536000_254400 1.400000
R17105 n1_m4_536000_254400 n1_m4_536000_259200 1.400000
R17106 n1_m4_536000_259200 n1_m4_536000_264000 1.400000
R17107 n1_m4_536000_264000 n1_m4_536000_268800 1.400000
R17108 n1_m4_536000_268800 n1_m4_536000_273600 1.400000
R17109 n1_m4_536000_273600 n1_m4_536000_278400 1.400000
R17110 n1_m4_536000_278400 n1_m4_536000_283200 1.400000
R17111 n1_m4_536000_283200 n1_m4_536000_288000 1.400000
R17112 n1_m4_536000_288000 n1_m4_536000_292800 1.400000
R17113 n1_m4_536000_292800 n1_m4_536000_297600 1.400000
R17114 n1_m4_536000_297600 n1_m4_536000_302400 1.400000
R17115 n1_m4_536000_302400 n1_m4_536000_307200 1.400000
R17116 n1_m4_536000_307200 n1_m4_536000_312000 1.400000
R17117 n1_m4_536000_312000 n1_m4_536000_316800 1.400000
R17118 n1_m4_536000_316800 n1_m4_536000_321600 1.400000
R17119 n1_m4_536000_321600 n1_m4_536000_324000 0.700000
R17120 n1_m4_536000_326400 n1_m4_536000_324000 0.700000
R17121 n1_m4_536000_326400 n1_m4_536000_331200 1.400000
R17122 n1_m4_536000_331200 n1_m4_536000_336000 1.400000
R17123 n1_m4_536000_336000 n1_m4_536000_340800 1.400000
R17124 n1_m4_536000_340800 n1_m4_536000_345600 1.400000
R17125 n1_m4_536000_345600 n1_m4_536000_350400 1.400000
R17126 n1_m4_536000_350400 n1_m4_536000_355200 1.400000
R17127 n1_m4_536000_355200 n1_m4_536000_360000 1.400000
R17128 n1_m4_536000_360000 n1_m4_536000_364800 1.400000
R17129 n1_m4_536000_364800 n1_m4_536000_369600 1.400000
R17130 n1_m4_536000_369600 n1_m4_536000_374400 1.400000
R17131 n1_m4_536000_374400 n1_m4_536000_379200 1.400000
R17132 n1_m4_536000_379200 n1_m4_536000_384000 1.400000
R17133 n1_m4_536000_384000 n1_m4_536000_388800 1.400000
R17134 n1_m4_536000_388800 n1_m4_536000_393600 1.400000
R17135 n1_m4_536000_393600 n1_m4_536000_398400 1.400000
R17136 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R17137 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R17138 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R17139 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R17140 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R17141 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R17142 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R17143 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R17144 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R17145 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R17146 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R17147 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R17148 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R17149 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R17150 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R17151 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R17152 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R17153 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R17154 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R17155 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R17156 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R17157 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R17158 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R17159 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R17160 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R17161 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R17162 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R17163 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R17164 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R17165 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R17166 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R17167 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R17168 n1_m7_452000_4000 n1_m7_474400_4000 0.594240
R17169 n1_m7_480000_4000 n1_m7_474400_4000 0.148560
R17170 n1_m7_480000_4000 n1_m7_496800_4000 0.445680
R17171 n1_m7_508000_4000 n1_m7_496800_4000 0.297120
R17172 n1_m7_508000_4000 n1_m7_519200_4000 0.297120
R17173 n1_m7_536000_4000 n1_m7_519200_4000 0.445680
R17174 n1_m7_536000_4000 n1_m7_541600_4000 0.148560
R17175 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R17176 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R17177 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R17178 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R17179 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R17180 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R17181 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R17182 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R17183 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R17184 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R17185 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R17186 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R17187 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R17188 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R17189 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R17190 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R17191 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R17192 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R17193 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R17194 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R17195 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R17196 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R17197 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R17198 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R17199 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R17200 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R17201 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R17202 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R17203 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R17204 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R17205 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R17206 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R17207 n1_m7_452000_84000 n1_m7_474400_84000 0.594240
R17208 n1_m7_480000_84000 n1_m7_474400_84000 0.148560
R17209 n1_m7_480000_84000 n1_m7_496800_84000 0.445680
R17210 n1_m7_508000_84000 n1_m7_496800_84000 0.297120
R17211 n1_m7_508000_84000 n1_m7_519200_84000 0.297120
R17212 n1_m7_536000_84000 n1_m7_519200_84000 0.445680
R17213 n1_m7_536000_84000 n1_m7_541600_84000 0.148560
R17214 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R17215 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R17216 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R17217 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R17218 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R17219 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R17220 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R17221 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R17222 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R17223 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R17224 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R17225 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R17226 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R17227 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R17228 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R17229 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R17230 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R17231 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R17232 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R17233 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R17234 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R17235 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R17236 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R17237 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R17238 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R17239 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R17240 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R17241 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R17242 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R17243 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R17244 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R17245 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R17246 n1_m7_452000_164000 n1_m7_474400_164000 0.594240
R17247 n1_m7_480000_164000 n1_m7_474400_164000 0.148560
R17248 n1_m7_480000_164000 n1_m7_496800_164000 0.445680
R17249 n1_m7_508000_164000 n1_m7_496800_164000 0.297120
R17250 n1_m7_508000_164000 n1_m7_519200_164000 0.297120
R17251 n1_m7_536000_164000 n1_m7_519200_164000 0.445680
R17252 n1_m7_536000_164000 n1_m7_541600_164000 0.148560
R17253 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R17254 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R17255 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R17256 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R17257 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R17258 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R17259 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R17260 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R17261 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R17262 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R17263 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R17264 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R17265 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R17266 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R17267 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R17268 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R17269 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R17270 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R17271 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R17272 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R17273 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R17274 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R17275 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R17276 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R17277 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R17278 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R17279 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R17280 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R17281 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R17282 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R17283 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R17284 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R17285 n1_m7_452000_244000 n1_m7_474400_244000 0.594240
R17286 n1_m7_480000_244000 n1_m7_474400_244000 0.148560
R17287 n1_m7_480000_244000 n1_m7_496800_244000 0.445680
R17288 n1_m7_508000_244000 n1_m7_496800_244000 0.297120
R17289 n1_m7_508000_244000 n1_m7_519200_244000 0.297120
R17290 n1_m7_536000_244000 n1_m7_519200_244000 0.445680
R17291 n1_m7_536000_244000 n1_m7_541600_244000 0.148560
R17292 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R17293 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R17294 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R17295 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R17296 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R17297 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R17298 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R17299 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R17300 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R17301 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R17302 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R17303 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R17304 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R17305 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R17306 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R17307 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R17308 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R17309 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R17310 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R17311 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R17312 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R17313 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R17314 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R17315 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R17316 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R17317 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R17318 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R17319 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R17320 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R17321 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R17322 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R17323 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R17324 n1_m7_452000_324000 n1_m7_474400_324000 0.594240
R17325 n1_m7_480000_324000 n1_m7_474400_324000 0.148560
R17326 n1_m7_480000_324000 n1_m7_496800_324000 0.445680
R17327 n1_m7_508000_324000 n1_m7_496800_324000 0.297120
R17328 n1_m7_508000_324000 n1_m7_519200_324000 0.297120
R17329 n1_m7_536000_324000 n1_m7_519200_324000 0.445680
R17330 n1_m7_536000_324000 n1_m7_541600_324000 0.148560
R17331 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R17332 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R17333 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R17334 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R17335 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R17336 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R17337 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R17338 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R17339 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R17340 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R17341 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R17342 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R17343 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R17344 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R17345 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R17346 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R17347 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R17348 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R17349 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R17350 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R17351 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R17352 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R17353 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R17354 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R17355 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R17356 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R17357 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R17358 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R17359 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R17360 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R17361 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R17362 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R17363 n1_m7_452000_404000 n1_m7_474400_404000 0.594240
R17364 n1_m7_480000_404000 n1_m7_474400_404000 0.148560
R17365 n1_m7_480000_404000 n1_m7_496800_404000 0.445680
R17366 n1_m7_508000_404000 n1_m7_496800_404000 0.297120
R17367 n1_m7_508000_404000 n1_m7_519200_404000 0.297120
R17368 n1_m7_536000_404000 n1_m7_519200_404000 0.445680
R17369 n1_m7_536000_404000 n1_m7_541600_404000 0.148560
R17370 n1_m7_4000_484000 n1_m7_26400_484000 0.594240
R17371 n1_m7_32000_484000 n1_m7_26400_484000 0.148560
R17372 n1_m7_32000_484000 n1_m7_48800_484000 0.445680
R17373 n1_m7_60000_484000 n1_m7_48800_484000 0.297120
R17374 n1_m7_60000_484000 n1_m7_71200_484000 0.297120
R17375 n1_m7_88000_484000 n1_m7_71200_484000 0.445680
R17376 n1_m7_88000_484000 n1_m7_93600_484000 0.148560
R17377 n1_m7_116000_484000 n1_m7_93600_484000 0.594240
R17378 n1_m7_116000_484000 n1_m7_138400_484000 0.594240
R17379 n1_m7_144000_484000 n1_m7_138400_484000 0.148560
R17380 n1_m7_144000_484000 n1_m7_160800_484000 0.445680
R17381 n1_m7_172000_484000 n1_m7_160800_484000 0.297120
R17382 n1_m7_172000_484000 n1_m7_183200_484000 0.297120
R17383 n1_m7_200000_484000 n1_m7_183200_484000 0.445680
R17384 n1_m7_200000_484000 n1_m7_205600_484000 0.148560
R17385 n1_m7_228000_484000 n1_m7_205600_484000 0.594240
R17386 n1_m7_228000_484000 n1_m7_250400_484000 0.594240
R17387 n1_m7_256000_484000 n1_m7_250400_484000 0.148560
R17388 n1_m7_256000_484000 n1_m7_272800_484000 0.445680
R17389 n1_m7_284000_484000 n1_m7_272800_484000 0.297120
R17390 n1_m7_284000_484000 n1_m7_295200_484000 0.297120
R17391 n1_m7_312000_484000 n1_m7_295200_484000 0.445680
R17392 n1_m7_312000_484000 n1_m7_317600_484000 0.148560
R17393 n1_m7_340000_484000 n1_m7_317600_484000 0.594240
R17394 n1_m7_340000_484000 n1_m7_362400_484000 0.594240
R17395 n1_m7_368000_484000 n1_m7_362400_484000 0.148560
R17396 n1_m7_368000_484000 n1_m7_384800_484000 0.445680
R17397 n1_m7_396000_484000 n1_m7_384800_484000 0.297120
R17398 n1_m7_396000_484000 n1_m7_407200_484000 0.297120
R17399 n1_m7_424000_484000 n1_m7_407200_484000 0.445680
R17400 n1_m7_424000_484000 n1_m7_429600_484000 0.148560
R17401 n1_m7_452000_484000 n1_m7_429600_484000 0.594240
R17402 n1_m7_452000_484000 n1_m7_474400_484000 0.594240
R17403 n1_m7_480000_484000 n1_m7_474400_484000 0.148560
R17404 n1_m7_480000_484000 n1_m7_496800_484000 0.445680
R17405 n1_m7_508000_484000 n1_m7_496800_484000 0.297120
R17406 n1_m7_508000_484000 n1_m7_519200_484000 0.297120
R17407 n1_m7_536000_484000 n1_m7_519200_484000 0.445680
R17408 n1_m7_536000_484000 n1_m7_541600_484000 0.148560
R17409 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R17410 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R17411 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R17412 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R17413 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R17414 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R17415 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R17416 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R17417 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R17418 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R17419 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R17420 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R17421 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R17422 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R17423 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R17424 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R17425 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R17426 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R17427 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R17428 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R17429 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R17430 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R17431 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R17432 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R17433 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R17434 n1_m8_4000_452000 n1_m8_4000_474400 0.120000
R17435 n1_m8_4000_484000 n1_m8_4000_474400 0.051429
R17436 n1_m8_4000_484000 n1_m8_4000_496800 0.068571
R17437 n1_m8_4000_496800 n1_m8_4000_519200 0.120000
R17438 n1_m8_4000_519200 n1_m8_4000_541600 0.120000
R17439 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R17440 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R17441 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R17442 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R17443 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R17444 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R17445 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R17446 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R17447 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R17448 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R17449 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R17450 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R17451 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R17452 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R17453 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R17454 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R17455 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R17456 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R17457 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R17458 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R17459 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R17460 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R17461 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R17462 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R17463 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R17464 n1_m8_26400_452000 n1_m8_26400_474400 0.120000
R17465 n1_m8_26400_484000 n1_m8_26400_474400 0.051429
R17466 n1_m8_26400_484000 n1_m8_26400_496800 0.068571
R17467 n1_m8_26400_496800 n1_m8_26400_519200 0.120000
R17468 n1_m8_26400_519200 n1_m8_26400_541600 0.120000
R17469 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R17470 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R17471 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R17472 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R17473 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R17474 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R17475 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R17476 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R17477 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R17478 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R17479 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R17480 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R17481 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R17482 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R17483 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R17484 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R17485 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R17486 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R17487 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R17488 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R17489 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R17490 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R17491 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R17492 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R17493 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R17494 n1_m8_48800_452000 n1_m8_48800_474400 0.120000
R17495 n1_m8_48800_484000 n1_m8_48800_474400 0.051429
R17496 n1_m8_48800_484000 n1_m8_48800_496800 0.068571
R17497 n1_m8_48800_496800 n1_m8_48800_519200 0.120000
R17498 n1_m8_48800_519200 n1_m8_48800_541600 0.120000
R17499 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R17500 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R17501 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R17502 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R17503 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R17504 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R17505 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R17506 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R17507 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R17508 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R17509 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R17510 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R17511 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R17512 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R17513 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R17514 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R17515 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R17516 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R17517 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R17518 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R17519 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R17520 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R17521 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R17522 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R17523 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R17524 n1_m8_71200_452000 n1_m8_71200_474400 0.120000
R17525 n1_m8_71200_484000 n1_m8_71200_474400 0.051429
R17526 n1_m8_71200_484000 n1_m8_71200_496800 0.068571
R17527 n1_m8_71200_496800 n1_m8_71200_519200 0.120000
R17528 n1_m8_71200_519200 n1_m8_71200_541600 0.120000
R17529 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R17530 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R17531 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R17532 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R17533 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R17534 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R17535 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R17536 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R17537 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R17538 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R17539 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R17540 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R17541 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R17542 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R17543 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R17544 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R17545 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R17546 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R17547 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R17548 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R17549 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R17550 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R17551 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R17552 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R17553 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R17554 n1_m8_93600_452000 n1_m8_93600_474400 0.120000
R17555 n1_m8_93600_484000 n1_m8_93600_474400 0.051429
R17556 n1_m8_93600_484000 n1_m8_93600_496800 0.068571
R17557 n1_m8_93600_496800 n1_m8_93600_519200 0.120000
R17558 n1_m8_93600_519200 n1_m8_93600_541600 0.120000
R17559 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R17560 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R17561 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R17562 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R17563 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R17564 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R17565 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R17566 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R17567 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R17568 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R17569 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R17570 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R17571 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R17572 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R17573 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R17574 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R17575 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R17576 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R17577 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R17578 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R17579 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R17580 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R17581 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R17582 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R17583 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R17584 n1_m8_116000_452000 n1_m8_116000_474400 0.120000
R17585 n1_m8_116000_484000 n1_m8_116000_474400 0.051429
R17586 n1_m8_116000_484000 n1_m8_116000_496800 0.068571
R17587 n1_m8_116000_496800 n1_m8_116000_519200 0.120000
R17588 n1_m8_116000_519200 n1_m8_116000_541600 0.120000
R17589 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R17590 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R17591 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R17592 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R17593 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R17594 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R17595 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R17596 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R17597 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R17598 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R17599 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R17600 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R17601 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R17602 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R17603 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R17604 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R17605 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R17606 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R17607 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R17608 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R17609 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R17610 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R17611 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R17612 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R17613 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R17614 n1_m8_138400_452000 n1_m8_138400_474400 0.120000
R17615 n1_m8_138400_484000 n1_m8_138400_474400 0.051429
R17616 n1_m8_138400_484000 n1_m8_138400_496800 0.068571
R17617 n1_m8_138400_496800 n1_m8_138400_519200 0.120000
R17618 n1_m8_138400_519200 n1_m8_138400_541600 0.120000
R17619 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R17620 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R17621 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R17622 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R17623 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R17624 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R17625 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R17626 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R17627 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R17628 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R17629 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R17630 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R17631 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R17632 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R17633 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R17634 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R17635 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R17636 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R17637 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R17638 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R17639 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R17640 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R17641 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R17642 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R17643 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R17644 n1_m8_160800_452000 n1_m8_160800_474400 0.120000
R17645 n1_m8_160800_484000 n1_m8_160800_474400 0.051429
R17646 n1_m8_160800_484000 n1_m8_160800_496800 0.068571
R17647 n1_m8_160800_496800 n1_m8_160800_519200 0.120000
R17648 n1_m8_160800_519200 n1_m8_160800_541600 0.120000
R17649 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R17650 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R17651 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R17652 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R17653 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R17654 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R17655 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R17656 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R17657 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R17658 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R17659 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R17660 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R17661 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R17662 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R17663 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R17664 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R17665 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R17666 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R17667 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R17668 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R17669 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R17670 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R17671 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R17672 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R17673 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R17674 n1_m8_183200_452000 n1_m8_183200_474400 0.120000
R17675 n1_m8_183200_484000 n1_m8_183200_474400 0.051429
R17676 n1_m8_183200_484000 n1_m8_183200_496800 0.068571
R17677 n1_m8_183200_496800 n1_m8_183200_519200 0.120000
R17678 n1_m8_183200_519200 n1_m8_183200_541600 0.120000
R17679 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R17680 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R17681 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R17682 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R17683 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R17684 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R17685 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R17686 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R17687 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R17688 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R17689 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R17690 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R17691 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R17692 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R17693 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R17694 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R17695 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R17696 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R17697 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R17698 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R17699 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R17700 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R17701 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R17702 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R17703 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R17704 n1_m8_205600_452000 n1_m8_205600_474400 0.120000
R17705 n1_m8_205600_484000 n1_m8_205600_474400 0.051429
R17706 n1_m8_205600_484000 n1_m8_205600_496800 0.068571
R17707 n1_m8_205600_496800 n1_m8_205600_519200 0.120000
R17708 n1_m8_205600_519200 n1_m8_205600_541600 0.120000
R17709 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R17710 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R17711 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R17712 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R17713 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R17714 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R17715 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R17716 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R17717 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R17718 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R17719 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R17720 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R17721 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R17722 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R17723 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R17724 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R17725 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R17726 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R17727 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R17728 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R17729 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R17730 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R17731 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R17732 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R17733 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R17734 n1_m8_228000_452000 n1_m8_228000_474400 0.120000
R17735 n1_m8_228000_484000 n1_m8_228000_474400 0.051429
R17736 n1_m8_228000_484000 n1_m8_228000_496800 0.068571
R17737 n1_m8_228000_496800 n1_m8_228000_519200 0.120000
R17738 n1_m8_228000_519200 n1_m8_228000_541600 0.120000
R17739 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R17740 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R17741 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R17742 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R17743 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R17744 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R17745 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R17746 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R17747 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R17748 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R17749 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R17750 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R17751 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R17752 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R17753 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R17754 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R17755 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R17756 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R17757 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R17758 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R17759 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R17760 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R17761 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R17762 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R17763 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R17764 n1_m8_250400_452000 n1_m8_250400_474400 0.120000
R17765 n1_m8_250400_484000 n1_m8_250400_474400 0.051429
R17766 n1_m8_250400_484000 n1_m8_250400_496800 0.068571
R17767 n1_m8_250400_496800 n1_m8_250400_519200 0.120000
R17768 n1_m8_250400_519200 n1_m8_250400_541600 0.120000
R17769 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R17770 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R17771 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R17772 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R17773 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R17774 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R17775 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R17776 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R17777 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R17778 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R17779 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R17780 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R17781 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R17782 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R17783 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R17784 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R17785 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R17786 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R17787 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R17788 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R17789 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R17790 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R17791 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R17792 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R17793 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R17794 n1_m8_272800_452000 n1_m8_272800_474400 0.120000
R17795 n1_m8_272800_484000 n1_m8_272800_474400 0.051429
R17796 n1_m8_272800_484000 n1_m8_272800_496800 0.068571
R17797 n1_m8_272800_496800 n1_m8_272800_519200 0.120000
R17798 n1_m8_272800_519200 n1_m8_272800_541600 0.120000
R17799 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R17800 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R17801 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R17802 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R17803 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R17804 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R17805 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R17806 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R17807 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R17808 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R17809 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R17810 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R17811 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R17812 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R17813 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R17814 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R17815 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R17816 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R17817 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R17818 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R17819 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R17820 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R17821 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R17822 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R17823 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R17824 n1_m8_295200_452000 n1_m8_295200_474400 0.120000
R17825 n1_m8_295200_484000 n1_m8_295200_474400 0.051429
R17826 n1_m8_295200_484000 n1_m8_295200_496800 0.068571
R17827 n1_m8_295200_496800 n1_m8_295200_519200 0.120000
R17828 n1_m8_295200_519200 n1_m8_295200_541600 0.120000
R17829 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R17830 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R17831 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R17832 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R17833 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R17834 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R17835 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R17836 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R17837 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R17838 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R17839 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R17840 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R17841 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R17842 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R17843 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R17844 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R17845 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R17846 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R17847 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R17848 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R17849 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R17850 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R17851 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R17852 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R17853 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R17854 n1_m8_317600_452000 n1_m8_317600_474400 0.120000
R17855 n1_m8_317600_484000 n1_m8_317600_474400 0.051429
R17856 n1_m8_317600_484000 n1_m8_317600_496800 0.068571
R17857 n1_m8_317600_496800 n1_m8_317600_519200 0.120000
R17858 n1_m8_317600_519200 n1_m8_317600_541600 0.120000
R17859 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R17860 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R17861 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R17862 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R17863 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R17864 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R17865 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R17866 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R17867 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R17868 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R17869 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R17870 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R17871 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R17872 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R17873 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R17874 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R17875 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R17876 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R17877 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R17878 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R17879 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R17880 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R17881 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R17882 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R17883 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R17884 n1_m8_340000_452000 n1_m8_340000_474400 0.120000
R17885 n1_m8_340000_484000 n1_m8_340000_474400 0.051429
R17886 n1_m8_340000_484000 n1_m8_340000_496800 0.068571
R17887 n1_m8_340000_496800 n1_m8_340000_519200 0.120000
R17888 n1_m8_340000_519200 n1_m8_340000_541600 0.120000
R17889 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R17890 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R17891 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R17892 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R17893 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R17894 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R17895 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R17896 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R17897 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R17898 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R17899 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R17900 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R17901 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R17902 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R17903 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R17904 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R17905 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R17906 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R17907 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R17908 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R17909 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R17910 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R17911 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R17912 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R17913 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R17914 n1_m8_362400_452000 n1_m8_362400_474400 0.120000
R17915 n1_m8_362400_484000 n1_m8_362400_474400 0.051429
R17916 n1_m8_362400_484000 n1_m8_362400_496800 0.068571
R17917 n1_m8_362400_496800 n1_m8_362400_519200 0.120000
R17918 n1_m8_362400_519200 n1_m8_362400_541600 0.120000
R17919 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R17920 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R17921 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R17922 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R17923 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R17924 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R17925 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R17926 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R17927 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R17928 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R17929 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R17930 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R17931 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R17932 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R17933 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R17934 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R17935 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R17936 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R17937 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R17938 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R17939 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R17940 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R17941 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R17942 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R17943 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R17944 n1_m8_384800_452000 n1_m8_384800_474400 0.120000
R17945 n1_m8_384800_484000 n1_m8_384800_474400 0.051429
R17946 n1_m8_384800_484000 n1_m8_384800_496800 0.068571
R17947 n1_m8_384800_496800 n1_m8_384800_519200 0.120000
R17948 n1_m8_384800_519200 n1_m8_384800_541600 0.120000
R17949 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R17950 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R17951 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R17952 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R17953 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R17954 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R17955 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R17956 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R17957 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R17958 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R17959 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R17960 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R17961 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R17962 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R17963 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R17964 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R17965 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R17966 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R17967 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R17968 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R17969 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R17970 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R17971 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R17972 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R17973 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R17974 n1_m8_407200_452000 n1_m8_407200_474400 0.120000
R17975 n1_m8_407200_484000 n1_m8_407200_474400 0.051429
R17976 n1_m8_407200_484000 n1_m8_407200_496800 0.068571
R17977 n1_m8_407200_496800 n1_m8_407200_519200 0.120000
R17978 n1_m8_407200_519200 n1_m8_407200_541600 0.120000
R17979 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R17980 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R17981 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R17982 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R17983 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R17984 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R17985 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R17986 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R17987 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R17988 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R17989 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R17990 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R17991 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R17992 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R17993 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R17994 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R17995 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R17996 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R17997 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R17998 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R17999 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R18000 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R18001 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R18002 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R18003 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R18004 n1_m8_429600_452000 n1_m8_429600_474400 0.120000
R18005 n1_m8_429600_484000 n1_m8_429600_474400 0.051429
R18006 n1_m8_429600_484000 n1_m8_429600_496800 0.068571
R18007 n1_m8_429600_496800 n1_m8_429600_519200 0.120000
R18008 n1_m8_429600_519200 n1_m8_429600_541600 0.120000
R18009 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R18010 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R18011 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R18012 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R18013 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R18014 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R18015 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R18016 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R18017 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R18018 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R18019 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R18020 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R18021 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R18022 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R18023 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R18024 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R18025 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R18026 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R18027 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R18028 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R18029 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R18030 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R18031 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R18032 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R18033 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R18034 n1_m8_452000_452000 n1_m8_452000_474400 0.120000
R18035 n1_m8_452000_484000 n1_m8_452000_474400 0.051429
R18036 n1_m8_452000_484000 n1_m8_452000_496800 0.068571
R18037 n1_m8_452000_496800 n1_m8_452000_519200 0.120000
R18038 n1_m8_452000_519200 n1_m8_452000_541600 0.120000
R18039 n1_m8_474400_4000 n1_m8_474400_26400 0.120000
R18040 n1_m8_474400_26400 n1_m8_474400_48800 0.120000
R18041 n1_m8_474400_48800 n1_m8_474400_71200 0.120000
R18042 n1_m8_474400_84000 n1_m8_474400_71200 0.068571
R18043 n1_m8_474400_84000 n1_m8_474400_93600 0.051429
R18044 n1_m8_474400_93600 n1_m8_474400_116000 0.120000
R18045 n1_m8_474400_116000 n1_m8_474400_138400 0.120000
R18046 n1_m8_474400_138400 n1_m8_474400_160800 0.120000
R18047 n1_m8_474400_164000 n1_m8_474400_160800 0.017143
R18048 n1_m8_474400_164000 n1_m8_474400_183200 0.102857
R18049 n1_m8_474400_183200 n1_m8_474400_205600 0.120000
R18050 n1_m8_474400_205600 n1_m8_474400_228000 0.120000
R18051 n1_m8_474400_244000 n1_m8_474400_228000 0.085714
R18052 n1_m8_474400_244000 n1_m8_474400_250400 0.034286
R18053 n1_m8_474400_250400 n1_m8_474400_272800 0.120000
R18054 n1_m8_474400_272800 n1_m8_474400_295200 0.120000
R18055 n1_m8_474400_295200 n1_m8_474400_317600 0.120000
R18056 n1_m8_474400_324000 n1_m8_474400_317600 0.034286
R18057 n1_m8_474400_324000 n1_m8_474400_340000 0.085714
R18058 n1_m8_474400_340000 n1_m8_474400_362400 0.120000
R18059 n1_m8_474400_362400 n1_m8_474400_384800 0.120000
R18060 n1_m8_474400_404000 n1_m8_474400_384800 0.102857
R18061 n1_m8_474400_404000 n1_m8_474400_407200 0.017143
R18062 n1_m8_474400_407200 n1_m8_474400_429600 0.120000
R18063 n1_m8_474400_429600 n1_m8_474400_452000 0.120000
R18064 n1_m8_474400_452000 n1_m8_474400_474400 0.120000
R18065 n1_m8_474400_484000 n1_m8_474400_474400 0.051429
R18066 n1_m8_474400_484000 n1_m8_474400_496800 0.068571
R18067 n1_m8_474400_496800 n1_m8_474400_519200 0.120000
R18068 n1_m8_474400_519200 n1_m8_474400_541600 0.120000
R18069 n1_m8_496800_4000 n1_m8_496800_26400 0.120000
R18070 n1_m8_496800_26400 n1_m8_496800_48800 0.120000
R18071 n1_m8_496800_48800 n1_m8_496800_71200 0.120000
R18072 n1_m8_496800_84000 n1_m8_496800_71200 0.068571
R18073 n1_m8_496800_84000 n1_m8_496800_93600 0.051429
R18074 n1_m8_496800_93600 n1_m8_496800_116000 0.120000
R18075 n1_m8_496800_116000 n1_m8_496800_138400 0.120000
R18076 n1_m8_496800_138400 n1_m8_496800_160800 0.120000
R18077 n1_m8_496800_164000 n1_m8_496800_160800 0.017143
R18078 n1_m8_496800_164000 n1_m8_496800_183200 0.102857
R18079 n1_m8_496800_183200 n1_m8_496800_205600 0.120000
R18080 n1_m8_496800_205600 n1_m8_496800_228000 0.120000
R18081 n1_m8_496800_244000 n1_m8_496800_228000 0.085714
R18082 n1_m8_496800_244000 n1_m8_496800_250400 0.034286
R18083 n1_m8_496800_250400 n1_m8_496800_272800 0.120000
R18084 n1_m8_496800_272800 n1_m8_496800_295200 0.120000
R18085 n1_m8_496800_295200 n1_m8_496800_317600 0.120000
R18086 n1_m8_496800_324000 n1_m8_496800_317600 0.034286
R18087 n1_m8_496800_324000 n1_m8_496800_340000 0.085714
R18088 n1_m8_496800_340000 n1_m8_496800_362400 0.120000
R18089 n1_m8_496800_362400 n1_m8_496800_384800 0.120000
R18090 n1_m8_496800_404000 n1_m8_496800_384800 0.102857
R18091 n1_m8_496800_404000 n1_m8_496800_407200 0.017143
R18092 n1_m8_496800_407200 n1_m8_496800_429600 0.120000
R18093 n1_m8_496800_429600 n1_m8_496800_452000 0.120000
R18094 n1_m8_496800_452000 n1_m8_496800_474400 0.120000
R18095 n1_m8_496800_484000 n1_m8_496800_474400 0.051429
R18096 n1_m8_496800_484000 n1_m8_496800_496800 0.068571
R18097 n1_m8_496800_496800 n1_m8_496800_519200 0.120000
R18098 n1_m8_496800_519200 n1_m8_496800_541600 0.120000
R18099 n1_m8_519200_4000 n1_m8_519200_26400 0.120000
R18100 n1_m8_519200_26400 n1_m8_519200_48800 0.120000
R18101 n1_m8_519200_48800 n1_m8_519200_71200 0.120000
R18102 n1_m8_519200_84000 n1_m8_519200_71200 0.068571
R18103 n1_m8_519200_84000 n1_m8_519200_93600 0.051429
R18104 n1_m8_519200_93600 n1_m8_519200_116000 0.120000
R18105 n1_m8_519200_116000 n1_m8_519200_138400 0.120000
R18106 n1_m8_519200_138400 n1_m8_519200_160800 0.120000
R18107 n1_m8_519200_164000 n1_m8_519200_160800 0.017143
R18108 n1_m8_519200_164000 n1_m8_519200_183200 0.102857
R18109 n1_m8_519200_183200 n1_m8_519200_205600 0.120000
R18110 n1_m8_519200_205600 n1_m8_519200_228000 0.120000
R18111 n1_m8_519200_244000 n1_m8_519200_228000 0.085714
R18112 n1_m8_519200_244000 n1_m8_519200_250400 0.034286
R18113 n1_m8_519200_250400 n1_m8_519200_272800 0.120000
R18114 n1_m8_519200_272800 n1_m8_519200_295200 0.120000
R18115 n1_m8_519200_295200 n1_m8_519200_317600 0.120000
R18116 n1_m8_519200_324000 n1_m8_519200_317600 0.034286
R18117 n1_m8_519200_324000 n1_m8_519200_340000 0.085714
R18118 n1_m8_519200_340000 n1_m8_519200_362400 0.120000
R18119 n1_m8_519200_362400 n1_m8_519200_384800 0.120000
R18120 n1_m8_519200_404000 n1_m8_519200_384800 0.102857
R18121 n1_m8_519200_404000 n1_m8_519200_407200 0.017143
R18122 n1_m8_519200_407200 n1_m8_519200_429600 0.120000
R18123 n1_m8_519200_429600 n1_m8_519200_452000 0.120000
R18124 n1_m8_519200_452000 n1_m8_519200_474400 0.120000
R18125 n1_m8_519200_484000 n1_m8_519200_474400 0.051429
R18126 n1_m8_519200_484000 n1_m8_519200_496800 0.068571
R18127 n1_m8_519200_496800 n1_m8_519200_519200 0.120000
R18128 n1_m8_519200_519200 n1_m8_519200_541600 0.120000
R18129 n1_m8_541600_4000 n1_m8_541600_26400 0.120000
R18130 n1_m8_541600_26400 n1_m8_541600_48800 0.120000
R18131 n1_m8_541600_48800 n1_m8_541600_71200 0.120000
R18132 n1_m8_541600_84000 n1_m8_541600_71200 0.068571
R18133 n1_m8_541600_84000 n1_m8_541600_93600 0.051429
R18134 n1_m8_541600_93600 n1_m8_541600_116000 0.120000
R18135 n1_m8_541600_116000 n1_m8_541600_138400 0.120000
R18136 n1_m8_541600_138400 n1_m8_541600_160800 0.120000
R18137 n1_m8_541600_164000 n1_m8_541600_160800 0.017143
R18138 n1_m8_541600_164000 n1_m8_541600_183200 0.102857
R18139 n1_m8_541600_183200 n1_m8_541600_205600 0.120000
R18140 n1_m8_541600_205600 n1_m8_541600_228000 0.120000
R18141 n1_m8_541600_244000 n1_m8_541600_228000 0.085714
R18142 n1_m8_541600_244000 n1_m8_541600_250400 0.034286
R18143 n1_m8_541600_250400 n1_m8_541600_272800 0.120000
R18144 n1_m8_541600_272800 n1_m8_541600_295200 0.120000
R18145 n1_m8_541600_295200 n1_m8_541600_317600 0.120000
R18146 n1_m8_541600_324000 n1_m8_541600_317600 0.034286
R18147 n1_m8_541600_324000 n1_m8_541600_340000 0.085714
R18148 n1_m8_541600_340000 n1_m8_541600_362400 0.120000
R18149 n1_m8_541600_362400 n1_m8_541600_384800 0.120000
R18150 n1_m8_541600_404000 n1_m8_541600_384800 0.102857
R18151 n1_m8_541600_404000 n1_m8_541600_407200 0.017143
R18152 n1_m8_541600_407200 n1_m8_541600_429600 0.120000
R18153 n1_m8_541600_429600 n1_m8_541600_452000 0.120000
R18154 n1_m8_541600_452000 n1_m8_541600_474400 0.120000
R18155 n1_m8_541600_484000 n1_m8_541600_474400 0.051429
R18156 n1_m8_541600_484000 n1_m8_541600_496800 0.068571
R18157 n1_m8_541600_496800 n1_m8_541600_519200 0.120000
R18158 n1_m8_541600_519200 n1_m8_541600_541600 0.120000
R18159 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R18160 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R18161 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R18162 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R18163 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R18164 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R18165 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R18166 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R18167 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R18168 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R18169 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R18170 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R18171 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R18172 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R18173 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R18174 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R18175 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R18176 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R18177 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R18178 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R18179 n1_m9_452000_4000 n1_m9_474400_4000 0.096000
R18180 n1_m9_474400_4000 n1_m9_496800_4000 0.096000
R18181 n1_m9_496800_4000 n1_m9_519200_4000 0.096000
R18182 n1_m9_519200_4000 n1_m9_541600_4000 0.096000
R18183 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R18184 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R18185 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R18186 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R18187 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R18188 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R18189 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R18190 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R18191 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R18192 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R18193 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R18194 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R18195 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R18196 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R18197 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R18198 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R18199 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R18200 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R18201 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R18202 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R18203 n1_m9_452000_26400 n1_m9_474400_26400 0.096000
R18204 n1_m9_474400_26400 n1_m9_496800_26400 0.096000
R18205 n1_m9_496800_26400 n1_m9_519200_26400 0.096000
R18206 n1_m9_519200_26400 n1_m9_541600_26400 0.096000
R18207 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R18208 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R18209 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R18210 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R18211 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R18212 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R18213 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R18214 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R18215 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R18216 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R18217 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R18218 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R18219 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R18220 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R18221 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R18222 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R18223 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R18224 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R18225 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R18226 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R18227 n1_m9_452000_48800 n1_m9_474400_48800 0.096000
R18228 n1_m9_474400_48800 n1_m9_496800_48800 0.096000
R18229 n1_m9_496800_48800 n1_m9_519200_48800 0.096000
R18230 n1_m9_519200_48800 n1_m9_541600_48800 0.096000
R18231 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R18232 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R18233 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R18234 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R18235 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R18236 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R18237 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R18238 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R18239 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R18240 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R18241 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R18242 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R18243 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R18244 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R18245 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R18246 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R18247 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R18248 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R18249 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R18250 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R18251 n1_m9_452000_71200 n1_m9_474400_71200 0.096000
R18252 n1_m9_474400_71200 n1_m9_496800_71200 0.096000
R18253 n1_m9_496800_71200 n1_m9_519200_71200 0.096000
R18254 n1_m9_519200_71200 n1_m9_541600_71200 0.096000
R18255 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R18256 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R18257 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R18258 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R18259 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R18260 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R18261 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R18262 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R18263 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R18264 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R18265 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R18266 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R18267 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R18268 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R18269 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R18270 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R18271 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R18272 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R18273 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R18274 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R18275 n1_m9_452000_93600 n1_m9_474400_93600 0.096000
R18276 n1_m9_474400_93600 n1_m9_496800_93600 0.096000
R18277 n1_m9_496800_93600 n1_m9_519200_93600 0.096000
R18278 n1_m9_519200_93600 n1_m9_541600_93600 0.096000
R18279 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R18280 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R18281 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R18282 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R18283 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R18284 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R18285 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R18286 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R18287 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R18288 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R18289 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R18290 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R18291 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R18292 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R18293 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R18294 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R18295 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R18296 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R18297 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R18298 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R18299 n1_m9_452000_116000 n1_m9_474400_116000 0.096000
R18300 n1_m9_474400_116000 n1_m9_496800_116000 0.096000
R18301 n1_m9_496800_116000 n1_m9_519200_116000 0.096000
R18302 n1_m9_519200_116000 n1_m9_541600_116000 0.096000
R18303 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R18304 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R18305 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R18306 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R18307 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R18308 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R18309 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R18310 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R18311 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R18312 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R18313 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R18314 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R18315 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R18316 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R18317 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R18318 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R18319 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R18320 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R18321 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R18322 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R18323 n1_m9_452000_138400 n1_m9_474400_138400 0.096000
R18324 n1_m9_474400_138400 n1_m9_496800_138400 0.096000
R18325 n1_m9_496800_138400 n1_m9_519200_138400 0.096000
R18326 n1_m9_519200_138400 n1_m9_541600_138400 0.096000
R18327 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R18328 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R18329 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R18330 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R18331 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R18332 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R18333 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R18334 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R18335 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R18336 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R18337 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R18338 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R18339 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R18340 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R18341 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R18342 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R18343 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R18344 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R18345 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R18346 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R18347 n1_m9_452000_160800 n1_m9_474400_160800 0.096000
R18348 n1_m9_474400_160800 n1_m9_496800_160800 0.096000
R18349 n1_m9_496800_160800 n1_m9_519200_160800 0.096000
R18350 n1_m9_519200_160800 n1_m9_541600_160800 0.096000
R18351 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R18352 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R18353 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R18354 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R18355 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R18356 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R18357 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R18358 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R18359 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R18360 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R18361 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R18362 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R18363 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R18364 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R18365 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R18366 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R18367 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R18368 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R18369 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R18370 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R18371 n1_m9_452000_183200 n1_m9_474400_183200 0.096000
R18372 n1_m9_474400_183200 n1_m9_496800_183200 0.096000
R18373 n1_m9_496800_183200 n1_m9_519200_183200 0.096000
R18374 n1_m9_519200_183200 n1_m9_541600_183200 0.096000
R18375 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R18376 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R18377 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R18378 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R18379 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R18380 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R18381 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R18382 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R18383 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R18384 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R18385 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R18386 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R18387 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R18388 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R18389 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R18390 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R18391 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R18392 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R18393 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R18394 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R18395 n1_m9_452000_205600 n1_m9_474400_205600 0.096000
R18396 n1_m9_474400_205600 n1_m9_496800_205600 0.096000
R18397 n1_m9_496800_205600 n1_m9_519200_205600 0.096000
R18398 n1_m9_519200_205600 n1_m9_541600_205600 0.096000
R18399 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R18400 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R18401 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R18402 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R18403 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R18404 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R18405 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R18406 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R18407 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R18408 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R18409 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R18410 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R18411 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R18412 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R18413 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R18414 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R18415 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R18416 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R18417 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R18418 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R18419 n1_m9_452000_228000 n1_m9_474400_228000 0.096000
R18420 n1_m9_474400_228000 n1_m9_496800_228000 0.096000
R18421 n1_m9_496800_228000 n1_m9_519200_228000 0.096000
R18422 n1_m9_519200_228000 n1_m9_541600_228000 0.096000
R18423 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R18424 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R18425 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R18426 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R18427 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R18428 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R18429 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R18430 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R18431 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R18432 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R18433 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R18434 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R18435 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R18436 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R18437 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R18438 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R18439 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R18440 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R18441 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R18442 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R18443 n1_m9_452000_250400 n1_m9_474400_250400 0.096000
R18444 n1_m9_474400_250400 n1_m9_496800_250400 0.096000
R18445 n1_m9_496800_250400 n1_m9_519200_250400 0.096000
R18446 n1_m9_519200_250400 n1_m9_541600_250400 0.096000
R18447 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R18448 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R18449 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R18450 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R18451 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R18452 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R18453 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R18454 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R18455 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R18456 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R18457 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R18458 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R18459 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R18460 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R18461 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R18462 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R18463 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R18464 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R18465 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R18466 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R18467 n1_m9_452000_272800 n1_m9_474400_272800 0.096000
R18468 n1_m9_474400_272800 n1_m9_496800_272800 0.096000
R18469 n1_m9_496800_272800 n1_m9_519200_272800 0.096000
R18470 n1_m9_519200_272800 n1_m9_541600_272800 0.096000
R18471 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R18472 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R18473 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R18474 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R18475 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R18476 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R18477 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R18478 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R18479 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R18480 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R18481 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R18482 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R18483 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R18484 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R18485 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R18486 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R18487 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R18488 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R18489 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R18490 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R18491 n1_m9_452000_295200 n1_m9_474400_295200 0.096000
R18492 n1_m9_474400_295200 n1_m9_496800_295200 0.096000
R18493 n1_m9_496800_295200 n1_m9_519200_295200 0.096000
R18494 n1_m9_519200_295200 n1_m9_541600_295200 0.096000
R18495 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R18496 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R18497 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R18498 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R18499 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R18500 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R18501 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R18502 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R18503 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R18504 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R18505 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R18506 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R18507 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R18508 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R18509 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R18510 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R18511 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R18512 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R18513 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R18514 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R18515 n1_m9_452000_317600 n1_m9_474400_317600 0.096000
R18516 n1_m9_474400_317600 n1_m9_496800_317600 0.096000
R18517 n1_m9_496800_317600 n1_m9_519200_317600 0.096000
R18518 n1_m9_519200_317600 n1_m9_541600_317600 0.096000
R18519 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R18520 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R18521 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R18522 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R18523 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R18524 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R18525 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R18526 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R18527 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R18528 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R18529 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R18530 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R18531 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R18532 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R18533 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R18534 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R18535 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R18536 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R18537 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R18538 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R18539 n1_m9_452000_340000 n1_m9_474400_340000 0.096000
R18540 n1_m9_474400_340000 n1_m9_496800_340000 0.096000
R18541 n1_m9_496800_340000 n1_m9_519200_340000 0.096000
R18542 n1_m9_519200_340000 n1_m9_541600_340000 0.096000
R18543 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R18544 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R18545 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R18546 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R18547 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R18548 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R18549 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R18550 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R18551 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R18552 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R18553 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R18554 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R18555 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R18556 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R18557 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R18558 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R18559 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R18560 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R18561 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R18562 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R18563 n1_m9_452000_362400 n1_m9_474400_362400 0.096000
R18564 n1_m9_474400_362400 n1_m9_496800_362400 0.096000
R18565 n1_m9_496800_362400 n1_m9_519200_362400 0.096000
R18566 n1_m9_519200_362400 n1_m9_541600_362400 0.096000
R18567 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R18568 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R18569 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R18570 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R18571 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R18572 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R18573 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R18574 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R18575 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R18576 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R18577 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R18578 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R18579 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R18580 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R18581 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R18582 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R18583 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R18584 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R18585 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R18586 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R18587 n1_m9_452000_384800 n1_m9_474400_384800 0.096000
R18588 n1_m9_474400_384800 n1_m9_496800_384800 0.096000
R18589 n1_m9_496800_384800 n1_m9_519200_384800 0.096000
R18590 n1_m9_519200_384800 n1_m9_541600_384800 0.096000
R18591 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R18592 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R18593 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R18594 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R18595 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R18596 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R18597 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R18598 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R18599 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R18600 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R18601 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R18602 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R18603 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R18604 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R18605 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R18606 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R18607 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R18608 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R18609 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R18610 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R18611 n1_m9_452000_407200 n1_m9_474400_407200 0.096000
R18612 n1_m9_474400_407200 n1_m9_496800_407200 0.096000
R18613 n1_m9_496800_407200 n1_m9_519200_407200 0.096000
R18614 n1_m9_519200_407200 n1_m9_541600_407200 0.096000
R18615 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R18616 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R18617 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R18618 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R18619 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R18620 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R18621 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R18622 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R18623 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R18624 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R18625 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R18626 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R18627 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R18628 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R18629 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R18630 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R18631 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R18632 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R18633 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R18634 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R18635 n1_m9_452000_429600 n1_m9_474400_429600 0.096000
R18636 n1_m9_474400_429600 n1_m9_496800_429600 0.096000
R18637 n1_m9_496800_429600 n1_m9_519200_429600 0.096000
R18638 n1_m9_519200_429600 n1_m9_541600_429600 0.096000
R18639 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R18640 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R18641 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R18642 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R18643 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R18644 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R18645 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R18646 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R18647 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R18648 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R18649 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R18650 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R18651 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R18652 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R18653 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R18654 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R18655 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R18656 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R18657 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R18658 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R18659 n1_m9_452000_452000 n1_m9_474400_452000 0.096000
R18660 n1_m9_474400_452000 n1_m9_496800_452000 0.096000
R18661 n1_m9_496800_452000 n1_m9_519200_452000 0.096000
R18662 n1_m9_519200_452000 n1_m9_541600_452000 0.096000
R18663 n1_m9_4000_474400 n1_m9_26400_474400 0.096000
R18664 n1_m9_26400_474400 n1_m9_48800_474400 0.096000
R18665 n1_m9_48800_474400 n1_m9_71200_474400 0.096000
R18666 n1_m9_71200_474400 n1_m9_93600_474400 0.096000
R18667 n1_m9_93600_474400 n1_m9_116000_474400 0.096000
R18668 n1_m9_116000_474400 n1_m9_138400_474400 0.096000
R18669 n1_m9_138400_474400 n1_m9_160800_474400 0.096000
R18670 n1_m9_160800_474400 n1_m9_183200_474400 0.096000
R18671 n1_m9_183200_474400 n1_m9_205600_474400 0.096000
R18672 n1_m9_205600_474400 n1_m9_228000_474400 0.096000
R18673 n1_m9_228000_474400 n1_m9_250400_474400 0.096000
R18674 n1_m9_250400_474400 n1_m9_272800_474400 0.096000
R18675 n1_m9_272800_474400 n1_m9_295200_474400 0.096000
R18676 n1_m9_295200_474400 n1_m9_317600_474400 0.096000
R18677 n1_m9_317600_474400 n1_m9_340000_474400 0.096000
R18678 n1_m9_340000_474400 n1_m9_362400_474400 0.096000
R18679 n1_m9_362400_474400 n1_m9_384800_474400 0.096000
R18680 n1_m9_384800_474400 n1_m9_407200_474400 0.096000
R18681 n1_m9_407200_474400 n1_m9_429600_474400 0.096000
R18682 n1_m9_429600_474400 n1_m9_452000_474400 0.096000
R18683 n1_m9_452000_474400 n1_m9_474400_474400 0.096000
R18684 n1_m9_474400_474400 n1_m9_496800_474400 0.096000
R18685 n1_m9_496800_474400 n1_m9_519200_474400 0.096000
R18686 n1_m9_519200_474400 n1_m9_541600_474400 0.096000
R18687 n1_m9_4000_496800 n1_m9_26400_496800 0.096000
R18688 n1_m9_26400_496800 n1_m9_48800_496800 0.096000
R18689 n1_m9_48800_496800 n1_m9_71200_496800 0.096000
R18690 n1_m9_71200_496800 n1_m9_93600_496800 0.096000
R18691 n1_m9_93600_496800 n1_m9_116000_496800 0.096000
R18692 n1_m9_116000_496800 n1_m9_138400_496800 0.096000
R18693 n1_m9_138400_496800 n1_m9_160800_496800 0.096000
R18694 n1_m9_160800_496800 n1_m9_183200_496800 0.096000
R18695 n1_m9_183200_496800 n1_m9_205600_496800 0.096000
R18696 n1_m9_205600_496800 n1_m9_228000_496800 0.096000
R18697 n1_m9_228000_496800 n1_m9_250400_496800 0.096000
R18698 n1_m9_250400_496800 n1_m9_272800_496800 0.096000
R18699 n1_m9_272800_496800 n1_m9_295200_496800 0.096000
R18700 n1_m9_295200_496800 n1_m9_317600_496800 0.096000
R18701 n1_m9_317600_496800 n1_m9_340000_496800 0.096000
R18702 n1_m9_340000_496800 n1_m9_362400_496800 0.096000
R18703 n1_m9_362400_496800 n1_m9_384800_496800 0.096000
R18704 n1_m9_384800_496800 n1_m9_407200_496800 0.096000
R18705 n1_m9_407200_496800 n1_m9_429600_496800 0.096000
R18706 n1_m9_429600_496800 n1_m9_452000_496800 0.096000
R18707 n1_m9_452000_496800 n1_m9_474400_496800 0.096000
R18708 n1_m9_474400_496800 n1_m9_496800_496800 0.096000
R18709 n1_m9_496800_496800 n1_m9_519200_496800 0.096000
R18710 n1_m9_519200_496800 n1_m9_541600_496800 0.096000
R18711 n1_m9_4000_519200 n1_m9_26400_519200 0.096000
R18712 n1_m9_26400_519200 n1_m9_48800_519200 0.096000
R18713 n1_m9_48800_519200 n1_m9_71200_519200 0.096000
R18714 n1_m9_71200_519200 n1_m9_93600_519200 0.096000
R18715 n1_m9_93600_519200 n1_m9_116000_519200 0.096000
R18716 n1_m9_116000_519200 n1_m9_138400_519200 0.096000
R18717 n1_m9_138400_519200 n1_m9_160800_519200 0.096000
R18718 n1_m9_160800_519200 n1_m9_183200_519200 0.096000
R18719 n1_m9_183200_519200 n1_m9_205600_519200 0.096000
R18720 n1_m9_205600_519200 n1_m9_228000_519200 0.096000
R18721 n1_m9_228000_519200 n1_m9_250400_519200 0.096000
R18722 n1_m9_250400_519200 n1_m9_272800_519200 0.096000
R18723 n1_m9_272800_519200 n1_m9_295200_519200 0.096000
R18724 n1_m9_295200_519200 n1_m9_317600_519200 0.096000
R18725 n1_m9_317600_519200 n1_m9_340000_519200 0.096000
R18726 n1_m9_340000_519200 n1_m9_362400_519200 0.096000
R18727 n1_m9_362400_519200 n1_m9_384800_519200 0.096000
R18728 n1_m9_384800_519200 n1_m9_407200_519200 0.096000
R18729 n1_m9_407200_519200 n1_m9_429600_519200 0.096000
R18730 n1_m9_429600_519200 n1_m9_452000_519200 0.096000
R18731 n1_m9_452000_519200 n1_m9_474400_519200 0.096000
R18732 n1_m9_474400_519200 n1_m9_496800_519200 0.096000
R18733 n1_m9_496800_519200 n1_m9_519200_519200 0.096000
R18734 n1_m9_519200_519200 n1_m9_541600_519200 0.096000
R18735 n1_m9_4000_541600 n1_m9_26400_541600 0.096000
R18736 n1_m9_26400_541600 n1_m9_48800_541600 0.096000
R18737 n1_m9_48800_541600 n1_m9_71200_541600 0.096000
R18738 n1_m9_71200_541600 n1_m9_93600_541600 0.096000
R18739 n1_m9_93600_541600 n1_m9_116000_541600 0.096000
R18740 n1_m9_116000_541600 n1_m9_138400_541600 0.096000
R18741 n1_m9_138400_541600 n1_m9_160800_541600 0.096000
R18742 n1_m9_160800_541600 n1_m9_183200_541600 0.096000
R18743 n1_m9_183200_541600 n1_m9_205600_541600 0.096000
R18744 n1_m9_205600_541600 n1_m9_228000_541600 0.096000
R18745 n1_m9_228000_541600 n1_m9_250400_541600 0.096000
R18746 n1_m9_250400_541600 n1_m9_272800_541600 0.096000
R18747 n1_m9_272800_541600 n1_m9_295200_541600 0.096000
R18748 n1_m9_295200_541600 n1_m9_317600_541600 0.096000
R18749 n1_m9_317600_541600 n1_m9_340000_541600 0.096000
R18750 n1_m9_340000_541600 n1_m9_362400_541600 0.096000
R18751 n1_m9_362400_541600 n1_m9_384800_541600 0.096000
R18752 n1_m9_384800_541600 n1_m9_407200_541600 0.096000
R18753 n1_m9_407200_541600 n1_m9_429600_541600 0.096000
R18754 n1_m9_429600_541600 n1_m9_452000_541600 0.096000
R18755 n1_m9_452000_541600 n1_m9_474400_541600 0.096000
R18756 n1_m9_474400_541600 n1_m9_496800_541600 0.096000
R18757 n1_m9_496800_541600 n1_m9_519200_541600 0.096000
R18758 n1_m9_519200_541600 n1_m9_541600_541600 0.096000
R18759 n1_m1_4000_0 n1_m4_4000_0 15.000000
R18760 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R18761 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R18762 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R18763 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R18764 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R18765 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R18766 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R18767 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R18768 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R18769 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R18770 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R18771 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R18772 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R18773 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R18774 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R18775 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R18776 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R18777 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R18778 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R18779 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R18780 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R18781 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R18782 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R18783 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R18784 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R18785 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R18786 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R18787 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R18788 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R18789 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R18790 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R18791 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R18792 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R18793 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R18794 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R18795 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R18796 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R18797 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R18798 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R18799 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R18800 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R18801 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R18802 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R18803 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R18804 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R18805 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R18806 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R18807 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R18808 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R18809 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R18810 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R18811 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R18812 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R18813 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R18814 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R18815 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R18816 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R18817 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R18818 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R18819 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R18820 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R18821 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R18822 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R18823 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R18824 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R18825 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R18826 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R18827 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R18828 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R18829 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R18830 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R18831 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R18832 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R18833 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R18834 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R18835 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R18836 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R18837 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R18838 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R18839 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R18840 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R18841 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R18842 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R18843 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R18844 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R18845 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R18846 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R18847 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R18848 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R18849 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R18850 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R18851 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R18852 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R18853 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R18854 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R18855 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R18856 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R18857 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R18858 n1_m1_4000_475200 n1_m4_4000_475200 15.000000
R18859 n1_m1_4000_480000 n1_m4_4000_480000 15.000000
R18860 n1_m1_4000_484800 n1_m4_4000_484800 15.000000
R18861 n1_m1_4000_489600 n1_m4_4000_489600 15.000000
R18862 n1_m1_4000_494400 n1_m4_4000_494400 15.000000
R18863 n1_m1_4000_499200 n1_m4_4000_499200 15.000000
R18864 n1_m1_4000_504000 n1_m4_4000_504000 15.000000
R18865 n1_m1_4000_508800 n1_m4_4000_508800 15.000000
R18866 n1_m1_4000_513600 n1_m4_4000_513600 15.000000
R18867 n1_m1_4000_518400 n1_m4_4000_518400 15.000000
R18868 n1_m1_4000_523200 n1_m4_4000_523200 15.000000
R18869 n1_m1_4000_528000 n1_m4_4000_528000 15.000000
R18870 n1_m1_4000_532800 n1_m4_4000_532800 15.000000
R18871 n1_m1_4000_537600 n1_m4_4000_537600 15.000000
R18872 n1_m1_4000_542400 n1_m4_4000_542400 15.000000
R18873 n1_m1_4000_547200 n1_m4_4000_547200 15.000000
R18874 n1_m1_4000_552000 n1_m4_4000_552000 15.000000
R18875 n1_m1_4000_556800 n1_m4_4000_556800 15.000000
R18876 n1_m1_4000_561600 n1_m4_4000_561600 15.000000
R18877 n1_m1_32000_0 n1_m4_32000_0 15.000000
R18878 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R18879 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R18880 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R18881 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R18882 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R18883 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R18884 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R18885 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R18886 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R18887 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R18888 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R18889 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R18890 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R18891 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R18892 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R18893 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R18894 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R18895 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R18896 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R18897 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R18898 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R18899 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R18900 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R18901 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R18902 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R18903 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R18904 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R18905 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R18906 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R18907 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R18908 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R18909 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R18910 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R18911 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R18912 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R18913 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R18914 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R18915 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R18916 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R18917 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R18918 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R18919 n1_m1_60000_0 n1_m4_60000_0 15.000000
R18920 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R18921 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R18922 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R18923 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R18924 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R18925 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R18926 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R18927 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R18928 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R18929 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R18930 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R18931 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R18932 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R18933 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R18934 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R18935 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R18936 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R18937 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R18938 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R18939 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R18940 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R18941 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R18942 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R18943 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R18944 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R18945 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R18946 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R18947 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R18948 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R18949 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R18950 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R18951 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R18952 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R18953 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R18954 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R18955 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R18956 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R18957 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R18958 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R18959 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R18960 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R18961 n1_m1_88000_0 n1_m4_88000_0 15.000000
R18962 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R18963 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R18964 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R18965 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R18966 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R18967 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R18968 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R18969 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R18970 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R18971 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R18972 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R18973 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R18974 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R18975 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R18976 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R18977 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R18978 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R18979 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R18980 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R18981 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R18982 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R18983 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R18984 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R18985 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R18986 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R18987 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R18988 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R18989 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R18990 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R18991 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R18992 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R18993 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R18994 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R18995 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R18996 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R18997 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R18998 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R18999 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R19000 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R19001 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R19002 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R19003 n1_m1_116000_0 n1_m4_116000_0 15.000000
R19004 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R19005 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R19006 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R19007 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R19008 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R19009 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R19010 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R19011 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R19012 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R19013 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R19014 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R19015 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R19016 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R19017 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R19018 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R19019 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R19020 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R19021 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R19022 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R19023 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R19024 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R19025 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R19026 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R19027 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R19028 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R19029 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R19030 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R19031 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R19032 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R19033 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R19034 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R19035 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R19036 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R19037 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R19038 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R19039 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R19040 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R19041 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R19042 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R19043 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R19044 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R19045 n1_m1_116000_201600 n1_m4_116000_201600 15.000000
R19046 n1_m1_116000_206400 n1_m4_116000_206400 15.000000
R19047 n1_m1_116000_211200 n1_m4_116000_211200 15.000000
R19048 n1_m1_116000_216000 n1_m4_116000_216000 15.000000
R19049 n1_m1_116000_220800 n1_m4_116000_220800 15.000000
R19050 n1_m1_116000_225600 n1_m4_116000_225600 15.000000
R19051 n1_m1_116000_230400 n1_m4_116000_230400 15.000000
R19052 n1_m1_116000_235200 n1_m4_116000_235200 15.000000
R19053 n1_m1_116000_240000 n1_m4_116000_240000 15.000000
R19054 n1_m1_116000_244800 n1_m4_116000_244800 15.000000
R19055 n1_m1_116000_249600 n1_m4_116000_249600 15.000000
R19056 n1_m1_116000_254400 n1_m4_116000_254400 15.000000
R19057 n1_m1_116000_259200 n1_m4_116000_259200 15.000000
R19058 n1_m1_116000_264000 n1_m4_116000_264000 15.000000
R19059 n1_m1_116000_268800 n1_m4_116000_268800 15.000000
R19060 n1_m1_116000_273600 n1_m4_116000_273600 15.000000
R19061 n1_m1_116000_278400 n1_m4_116000_278400 15.000000
R19062 n1_m1_116000_283200 n1_m4_116000_283200 15.000000
R19063 n1_m1_116000_288000 n1_m4_116000_288000 15.000000
R19064 n1_m1_116000_292800 n1_m4_116000_292800 15.000000
R19065 n1_m1_116000_297600 n1_m4_116000_297600 15.000000
R19066 n1_m1_116000_302400 n1_m4_116000_302400 15.000000
R19067 n1_m1_116000_307200 n1_m4_116000_307200 15.000000
R19068 n1_m1_116000_312000 n1_m4_116000_312000 15.000000
R19069 n1_m1_116000_316800 n1_m4_116000_316800 15.000000
R19070 n1_m1_116000_321600 n1_m4_116000_321600 15.000000
R19071 n1_m1_116000_326400 n1_m4_116000_326400 15.000000
R19072 n1_m1_116000_331200 n1_m4_116000_331200 15.000000
R19073 n1_m1_116000_336000 n1_m4_116000_336000 15.000000
R19074 n1_m1_116000_340800 n1_m4_116000_340800 15.000000
R19075 n1_m1_116000_345600 n1_m4_116000_345600 15.000000
R19076 n1_m1_116000_350400 n1_m4_116000_350400 15.000000
R19077 n1_m1_116000_355200 n1_m4_116000_355200 15.000000
R19078 n1_m1_116000_360000 n1_m4_116000_360000 15.000000
R19079 n1_m1_116000_364800 n1_m4_116000_364800 15.000000
R19080 n1_m1_116000_369600 n1_m4_116000_369600 15.000000
R19081 n1_m1_116000_374400 n1_m4_116000_374400 15.000000
R19082 n1_m1_116000_379200 n1_m4_116000_379200 15.000000
R19083 n1_m1_116000_384000 n1_m4_116000_384000 15.000000
R19084 n1_m1_116000_388800 n1_m4_116000_388800 15.000000
R19085 n1_m1_116000_393600 n1_m4_116000_393600 15.000000
R19086 n1_m1_116000_398400 n1_m4_116000_398400 15.000000
R19087 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R19088 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R19089 n1_m1_116000_412800 n1_m4_116000_412800 15.000000
R19090 n1_m1_116000_417600 n1_m4_116000_417600 15.000000
R19091 n1_m1_116000_422400 n1_m4_116000_422400 15.000000
R19092 n1_m1_116000_427200 n1_m4_116000_427200 15.000000
R19093 n1_m1_116000_432000 n1_m4_116000_432000 15.000000
R19094 n1_m1_116000_436800 n1_m4_116000_436800 15.000000
R19095 n1_m1_116000_441600 n1_m4_116000_441600 15.000000
R19096 n1_m1_116000_446400 n1_m4_116000_446400 15.000000
R19097 n1_m1_116000_451200 n1_m4_116000_451200 15.000000
R19098 n1_m1_116000_456000 n1_m4_116000_456000 15.000000
R19099 n1_m1_116000_460800 n1_m4_116000_460800 15.000000
R19100 n1_m1_116000_465600 n1_m4_116000_465600 15.000000
R19101 n1_m1_116000_470400 n1_m4_116000_470400 15.000000
R19102 n1_m1_116000_475200 n1_m4_116000_475200 15.000000
R19103 n1_m1_116000_480000 n1_m4_116000_480000 15.000000
R19104 n1_m1_116000_484800 n1_m4_116000_484800 15.000000
R19105 n1_m1_116000_489600 n1_m4_116000_489600 15.000000
R19106 n1_m1_116000_494400 n1_m4_116000_494400 15.000000
R19107 n1_m1_116000_499200 n1_m4_116000_499200 15.000000
R19108 n1_m1_116000_504000 n1_m4_116000_504000 15.000000
R19109 n1_m1_116000_508800 n1_m4_116000_508800 15.000000
R19110 n1_m1_116000_513600 n1_m4_116000_513600 15.000000
R19111 n1_m1_116000_518400 n1_m4_116000_518400 15.000000
R19112 n1_m1_116000_523200 n1_m4_116000_523200 15.000000
R19113 n1_m1_116000_528000 n1_m4_116000_528000 15.000000
R19114 n1_m1_116000_532800 n1_m4_116000_532800 15.000000
R19115 n1_m1_116000_537600 n1_m4_116000_537600 15.000000
R19116 n1_m1_116000_542400 n1_m4_116000_542400 15.000000
R19117 n1_m1_116000_547200 n1_m4_116000_547200 15.000000
R19118 n1_m1_116000_552000 n1_m4_116000_552000 15.000000
R19119 n1_m1_116000_556800 n1_m4_116000_556800 15.000000
R19120 n1_m1_116000_561600 n1_m4_116000_561600 15.000000
R19121 n1_m1_144000_0 n1_m4_144000_0 15.000000
R19122 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R19123 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R19124 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R19125 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R19126 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R19127 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R19128 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R19129 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R19130 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R19131 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R19132 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R19133 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R19134 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R19135 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R19136 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R19137 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R19138 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R19139 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R19140 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R19141 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R19142 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R19143 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R19144 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R19145 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R19146 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R19147 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R19148 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R19149 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R19150 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R19151 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R19152 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R19153 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R19154 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R19155 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R19156 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R19157 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R19158 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R19159 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R19160 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R19161 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R19162 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R19163 n1_m1_172000_0 n1_m4_172000_0 15.000000
R19164 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R19165 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R19166 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R19167 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R19168 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R19169 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R19170 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R19171 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R19172 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R19173 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R19174 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R19175 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R19176 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R19177 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R19178 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R19179 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R19180 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R19181 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R19182 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R19183 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R19184 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R19185 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R19186 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R19187 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R19188 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R19189 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R19190 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R19191 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R19192 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R19193 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R19194 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R19195 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R19196 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R19197 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R19198 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R19199 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R19200 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R19201 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R19202 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R19203 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R19204 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R19205 n1_m1_200000_0 n1_m4_200000_0 15.000000
R19206 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R19207 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R19208 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R19209 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R19210 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R19211 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R19212 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R19213 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R19214 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R19215 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R19216 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R19217 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R19218 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R19219 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R19220 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R19221 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R19222 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R19223 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R19224 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R19225 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R19226 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R19227 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R19228 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R19229 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R19230 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R19231 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R19232 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R19233 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R19234 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R19235 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R19236 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R19237 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R19238 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R19239 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R19240 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R19241 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R19242 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R19243 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R19244 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R19245 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R19246 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R19247 n1_m1_228000_0 n1_m4_228000_0 15.000000
R19248 n1_m1_228000_4800 n1_m4_228000_4800 15.000000
R19249 n1_m1_228000_9600 n1_m4_228000_9600 15.000000
R19250 n1_m1_228000_14400 n1_m4_228000_14400 15.000000
R19251 n1_m1_228000_19200 n1_m4_228000_19200 15.000000
R19252 n1_m1_228000_24000 n1_m4_228000_24000 15.000000
R19253 n1_m1_228000_28800 n1_m4_228000_28800 15.000000
R19254 n1_m1_228000_33600 n1_m4_228000_33600 15.000000
R19255 n1_m1_228000_38400 n1_m4_228000_38400 15.000000
R19256 n1_m1_228000_43200 n1_m4_228000_43200 15.000000
R19257 n1_m1_228000_48000 n1_m4_228000_48000 15.000000
R19258 n1_m1_228000_52800 n1_m4_228000_52800 15.000000
R19259 n1_m1_228000_57600 n1_m4_228000_57600 15.000000
R19260 n1_m1_228000_62400 n1_m4_228000_62400 15.000000
R19261 n1_m1_228000_67200 n1_m4_228000_67200 15.000000
R19262 n1_m1_228000_72000 n1_m4_228000_72000 15.000000
R19263 n1_m1_228000_76800 n1_m4_228000_76800 15.000000
R19264 n1_m1_228000_81600 n1_m4_228000_81600 15.000000
R19265 n1_m1_228000_86400 n1_m4_228000_86400 15.000000
R19266 n1_m1_228000_91200 n1_m4_228000_91200 15.000000
R19267 n1_m1_228000_96000 n1_m4_228000_96000 15.000000
R19268 n1_m1_228000_100800 n1_m4_228000_100800 15.000000
R19269 n1_m1_228000_105600 n1_m4_228000_105600 15.000000
R19270 n1_m1_228000_110400 n1_m4_228000_110400 15.000000
R19271 n1_m1_228000_115200 n1_m4_228000_115200 15.000000
R19272 n1_m1_228000_120000 n1_m4_228000_120000 15.000000
R19273 n1_m1_228000_124800 n1_m4_228000_124800 15.000000
R19274 n1_m1_228000_129600 n1_m4_228000_129600 15.000000
R19275 n1_m1_228000_134400 n1_m4_228000_134400 15.000000
R19276 n1_m1_228000_139200 n1_m4_228000_139200 15.000000
R19277 n1_m1_228000_144000 n1_m4_228000_144000 15.000000
R19278 n1_m1_228000_148800 n1_m4_228000_148800 15.000000
R19279 n1_m1_228000_153600 n1_m4_228000_153600 15.000000
R19280 n1_m1_228000_158400 n1_m4_228000_158400 15.000000
R19281 n1_m1_228000_163200 n1_m4_228000_163200 15.000000
R19282 n1_m1_228000_168000 n1_m4_228000_168000 15.000000
R19283 n1_m1_228000_172800 n1_m4_228000_172800 15.000000
R19284 n1_m1_228000_177600 n1_m4_228000_177600 15.000000
R19285 n1_m1_228000_182400 n1_m4_228000_182400 15.000000
R19286 n1_m1_228000_187200 n1_m4_228000_187200 15.000000
R19287 n1_m1_228000_192000 n1_m4_228000_192000 15.000000
R19288 n1_m1_228000_196800 n1_m4_228000_196800 15.000000
R19289 n1_m1_256000_0 n1_m4_256000_0 15.000000
R19290 n1_m1_256000_4800 n1_m4_256000_4800 15.000000
R19291 n1_m1_256000_9600 n1_m4_256000_9600 15.000000
R19292 n1_m1_256000_14400 n1_m4_256000_14400 15.000000
R19293 n1_m1_256000_19200 n1_m4_256000_19200 15.000000
R19294 n1_m1_256000_24000 n1_m4_256000_24000 15.000000
R19295 n1_m1_256000_28800 n1_m4_256000_28800 15.000000
R19296 n1_m1_256000_33600 n1_m4_256000_33600 15.000000
R19297 n1_m1_256000_38400 n1_m4_256000_38400 15.000000
R19298 n1_m1_256000_43200 n1_m4_256000_43200 15.000000
R19299 n1_m1_256000_48000 n1_m4_256000_48000 15.000000
R19300 n1_m1_256000_52800 n1_m4_256000_52800 15.000000
R19301 n1_m1_256000_57600 n1_m4_256000_57600 15.000000
R19302 n1_m1_256000_62400 n1_m4_256000_62400 15.000000
R19303 n1_m1_256000_67200 n1_m4_256000_67200 15.000000
R19304 n1_m1_256000_72000 n1_m4_256000_72000 15.000000
R19305 n1_m1_256000_76800 n1_m4_256000_76800 15.000000
R19306 n1_m1_256000_81600 n1_m4_256000_81600 15.000000
R19307 n1_m1_256000_86400 n1_m4_256000_86400 15.000000
R19308 n1_m1_256000_91200 n1_m4_256000_91200 15.000000
R19309 n1_m1_256000_96000 n1_m4_256000_96000 15.000000
R19310 n1_m1_256000_100800 n1_m4_256000_100800 15.000000
R19311 n1_m1_256000_105600 n1_m4_256000_105600 15.000000
R19312 n1_m1_256000_110400 n1_m4_256000_110400 15.000000
R19313 n1_m1_256000_115200 n1_m4_256000_115200 15.000000
R19314 n1_m1_256000_120000 n1_m4_256000_120000 15.000000
R19315 n1_m1_256000_124800 n1_m4_256000_124800 15.000000
R19316 n1_m1_256000_129600 n1_m4_256000_129600 15.000000
R19317 n1_m1_256000_134400 n1_m4_256000_134400 15.000000
R19318 n1_m1_256000_139200 n1_m4_256000_139200 15.000000
R19319 n1_m1_256000_144000 n1_m4_256000_144000 15.000000
R19320 n1_m1_256000_148800 n1_m4_256000_148800 15.000000
R19321 n1_m1_256000_153600 n1_m4_256000_153600 15.000000
R19322 n1_m1_256000_158400 n1_m4_256000_158400 15.000000
R19323 n1_m1_256000_163200 n1_m4_256000_163200 15.000000
R19324 n1_m1_256000_168000 n1_m4_256000_168000 15.000000
R19325 n1_m1_256000_172800 n1_m4_256000_172800 15.000000
R19326 n1_m1_256000_177600 n1_m4_256000_177600 15.000000
R19327 n1_m1_256000_182400 n1_m4_256000_182400 15.000000
R19328 n1_m1_256000_187200 n1_m4_256000_187200 15.000000
R19329 n1_m1_256000_192000 n1_m4_256000_192000 15.000000
R19330 n1_m1_256000_196800 n1_m4_256000_196800 15.000000
R19331 n1_m1_284000_0 n1_m4_284000_0 15.000000
R19332 n1_m1_284000_4800 n1_m4_284000_4800 15.000000
R19333 n1_m1_284000_9600 n1_m4_284000_9600 15.000000
R19334 n1_m1_284000_14400 n1_m4_284000_14400 15.000000
R19335 n1_m1_284000_19200 n1_m4_284000_19200 15.000000
R19336 n1_m1_284000_24000 n1_m4_284000_24000 15.000000
R19337 n1_m1_284000_28800 n1_m4_284000_28800 15.000000
R19338 n1_m1_284000_33600 n1_m4_284000_33600 15.000000
R19339 n1_m1_284000_38400 n1_m4_284000_38400 15.000000
R19340 n1_m1_284000_43200 n1_m4_284000_43200 15.000000
R19341 n1_m1_284000_48000 n1_m4_284000_48000 15.000000
R19342 n1_m1_284000_52800 n1_m4_284000_52800 15.000000
R19343 n1_m1_284000_57600 n1_m4_284000_57600 15.000000
R19344 n1_m1_284000_62400 n1_m4_284000_62400 15.000000
R19345 n1_m1_284000_67200 n1_m4_284000_67200 15.000000
R19346 n1_m1_284000_72000 n1_m4_284000_72000 15.000000
R19347 n1_m1_284000_76800 n1_m4_284000_76800 15.000000
R19348 n1_m1_284000_81600 n1_m4_284000_81600 15.000000
R19349 n1_m1_284000_86400 n1_m4_284000_86400 15.000000
R19350 n1_m1_284000_91200 n1_m4_284000_91200 15.000000
R19351 n1_m1_284000_96000 n1_m4_284000_96000 15.000000
R19352 n1_m1_284000_100800 n1_m4_284000_100800 15.000000
R19353 n1_m1_284000_105600 n1_m4_284000_105600 15.000000
R19354 n1_m1_284000_110400 n1_m4_284000_110400 15.000000
R19355 n1_m1_284000_115200 n1_m4_284000_115200 15.000000
R19356 n1_m1_284000_120000 n1_m4_284000_120000 15.000000
R19357 n1_m1_284000_124800 n1_m4_284000_124800 15.000000
R19358 n1_m1_284000_129600 n1_m4_284000_129600 15.000000
R19359 n1_m1_284000_134400 n1_m4_284000_134400 15.000000
R19360 n1_m1_284000_139200 n1_m4_284000_139200 15.000000
R19361 n1_m1_284000_144000 n1_m4_284000_144000 15.000000
R19362 n1_m1_284000_148800 n1_m4_284000_148800 15.000000
R19363 n1_m1_284000_153600 n1_m4_284000_153600 15.000000
R19364 n1_m1_284000_158400 n1_m4_284000_158400 15.000000
R19365 n1_m1_284000_163200 n1_m4_284000_163200 15.000000
R19366 n1_m1_284000_168000 n1_m4_284000_168000 15.000000
R19367 n1_m1_284000_172800 n1_m4_284000_172800 15.000000
R19368 n1_m1_284000_177600 n1_m4_284000_177600 15.000000
R19369 n1_m1_284000_182400 n1_m4_284000_182400 15.000000
R19370 n1_m1_284000_187200 n1_m4_284000_187200 15.000000
R19371 n1_m1_284000_192000 n1_m4_284000_192000 15.000000
R19372 n1_m1_284000_196800 n1_m4_284000_196800 15.000000
R19373 n1_m1_312000_0 n1_m4_312000_0 15.000000
R19374 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R19375 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R19376 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R19377 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R19378 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R19379 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R19380 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R19381 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R19382 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R19383 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R19384 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R19385 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R19386 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R19387 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R19388 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R19389 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R19390 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R19391 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R19392 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R19393 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R19394 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R19395 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R19396 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R19397 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R19398 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R19399 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R19400 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R19401 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R19402 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R19403 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R19404 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R19405 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R19406 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R19407 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R19408 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R19409 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R19410 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R19411 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R19412 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R19413 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R19414 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R19415 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R19416 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R19417 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R19418 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R19419 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R19420 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R19421 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R19422 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R19423 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R19424 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R19425 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R19426 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R19427 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R19428 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R19429 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R19430 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R19431 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R19432 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R19433 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R19434 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R19435 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R19436 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R19437 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R19438 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R19439 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R19440 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R19441 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R19442 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R19443 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R19444 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R19445 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R19446 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R19447 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R19448 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R19449 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R19450 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R19451 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R19452 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R19453 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R19454 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R19455 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R19456 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R19457 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R19458 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R19459 n1_m1_312000_412800 n1_m4_312000_412800 15.000000
R19460 n1_m1_312000_417600 n1_m4_312000_417600 15.000000
R19461 n1_m1_312000_422400 n1_m4_312000_422400 15.000000
R19462 n1_m1_312000_427200 n1_m4_312000_427200 15.000000
R19463 n1_m1_312000_432000 n1_m4_312000_432000 15.000000
R19464 n1_m1_312000_436800 n1_m4_312000_436800 15.000000
R19465 n1_m1_312000_441600 n1_m4_312000_441600 15.000000
R19466 n1_m1_312000_446400 n1_m4_312000_446400 15.000000
R19467 n1_m1_312000_451200 n1_m4_312000_451200 15.000000
R19468 n1_m1_312000_456000 n1_m4_312000_456000 15.000000
R19469 n1_m1_312000_460800 n1_m4_312000_460800 15.000000
R19470 n1_m1_312000_465600 n1_m4_312000_465600 15.000000
R19471 n1_m1_312000_470400 n1_m4_312000_470400 15.000000
R19472 n1_m1_312000_475200 n1_m4_312000_475200 15.000000
R19473 n1_m1_312000_480000 n1_m4_312000_480000 15.000000
R19474 n1_m1_312000_484800 n1_m4_312000_484800 15.000000
R19475 n1_m1_312000_489600 n1_m4_312000_489600 15.000000
R19476 n1_m1_312000_494400 n1_m4_312000_494400 15.000000
R19477 n1_m1_312000_499200 n1_m4_312000_499200 15.000000
R19478 n1_m1_312000_504000 n1_m4_312000_504000 15.000000
R19479 n1_m1_312000_508800 n1_m4_312000_508800 15.000000
R19480 n1_m1_312000_513600 n1_m4_312000_513600 15.000000
R19481 n1_m1_312000_518400 n1_m4_312000_518400 15.000000
R19482 n1_m1_312000_523200 n1_m4_312000_523200 15.000000
R19483 n1_m1_312000_528000 n1_m4_312000_528000 15.000000
R19484 n1_m1_312000_532800 n1_m4_312000_532800 15.000000
R19485 n1_m1_312000_537600 n1_m4_312000_537600 15.000000
R19486 n1_m1_312000_542400 n1_m4_312000_542400 15.000000
R19487 n1_m1_312000_547200 n1_m4_312000_547200 15.000000
R19488 n1_m1_312000_552000 n1_m4_312000_552000 15.000000
R19489 n1_m1_312000_556800 n1_m4_312000_556800 15.000000
R19490 n1_m1_312000_561600 n1_m4_312000_561600 15.000000
R19491 n1_m1_340000_0 n1_m4_340000_0 15.000000
R19492 n1_m1_340000_4800 n1_m4_340000_4800 15.000000
R19493 n1_m1_340000_9600 n1_m4_340000_9600 15.000000
R19494 n1_m1_340000_14400 n1_m4_340000_14400 15.000000
R19495 n1_m1_340000_19200 n1_m4_340000_19200 15.000000
R19496 n1_m1_340000_24000 n1_m4_340000_24000 15.000000
R19497 n1_m1_340000_28800 n1_m4_340000_28800 15.000000
R19498 n1_m1_340000_33600 n1_m4_340000_33600 15.000000
R19499 n1_m1_340000_38400 n1_m4_340000_38400 15.000000
R19500 n1_m1_340000_43200 n1_m4_340000_43200 15.000000
R19501 n1_m1_340000_48000 n1_m4_340000_48000 15.000000
R19502 n1_m1_340000_52800 n1_m4_340000_52800 15.000000
R19503 n1_m1_340000_57600 n1_m4_340000_57600 15.000000
R19504 n1_m1_340000_62400 n1_m4_340000_62400 15.000000
R19505 n1_m1_340000_67200 n1_m4_340000_67200 15.000000
R19506 n1_m1_340000_72000 n1_m4_340000_72000 15.000000
R19507 n1_m1_340000_76800 n1_m4_340000_76800 15.000000
R19508 n1_m1_340000_81600 n1_m4_340000_81600 15.000000
R19509 n1_m1_340000_86400 n1_m4_340000_86400 15.000000
R19510 n1_m1_340000_91200 n1_m4_340000_91200 15.000000
R19511 n1_m1_340000_96000 n1_m4_340000_96000 15.000000
R19512 n1_m1_340000_100800 n1_m4_340000_100800 15.000000
R19513 n1_m1_340000_105600 n1_m4_340000_105600 15.000000
R19514 n1_m1_340000_110400 n1_m4_340000_110400 15.000000
R19515 n1_m1_340000_115200 n1_m4_340000_115200 15.000000
R19516 n1_m1_340000_120000 n1_m4_340000_120000 15.000000
R19517 n1_m1_340000_124800 n1_m4_340000_124800 15.000000
R19518 n1_m1_340000_129600 n1_m4_340000_129600 15.000000
R19519 n1_m1_340000_134400 n1_m4_340000_134400 15.000000
R19520 n1_m1_340000_139200 n1_m4_340000_139200 15.000000
R19521 n1_m1_340000_144000 n1_m4_340000_144000 15.000000
R19522 n1_m1_340000_148800 n1_m4_340000_148800 15.000000
R19523 n1_m1_340000_153600 n1_m4_340000_153600 15.000000
R19524 n1_m1_340000_158400 n1_m4_340000_158400 15.000000
R19525 n1_m1_340000_163200 n1_m4_340000_163200 15.000000
R19526 n1_m1_340000_168000 n1_m4_340000_168000 15.000000
R19527 n1_m1_340000_172800 n1_m4_340000_172800 15.000000
R19528 n1_m1_340000_177600 n1_m4_340000_177600 15.000000
R19529 n1_m1_340000_182400 n1_m4_340000_182400 15.000000
R19530 n1_m1_340000_187200 n1_m4_340000_187200 15.000000
R19531 n1_m1_340000_192000 n1_m4_340000_192000 15.000000
R19532 n1_m1_340000_196800 n1_m4_340000_196800 15.000000
R19533 n1_m1_368000_0 n1_m4_368000_0 15.000000
R19534 n1_m1_368000_4800 n1_m4_368000_4800 15.000000
R19535 n1_m1_368000_9600 n1_m4_368000_9600 15.000000
R19536 n1_m1_368000_14400 n1_m4_368000_14400 15.000000
R19537 n1_m1_368000_19200 n1_m4_368000_19200 15.000000
R19538 n1_m1_368000_24000 n1_m4_368000_24000 15.000000
R19539 n1_m1_368000_28800 n1_m4_368000_28800 15.000000
R19540 n1_m1_368000_33600 n1_m4_368000_33600 15.000000
R19541 n1_m1_368000_38400 n1_m4_368000_38400 15.000000
R19542 n1_m1_368000_43200 n1_m4_368000_43200 15.000000
R19543 n1_m1_368000_48000 n1_m4_368000_48000 15.000000
R19544 n1_m1_368000_52800 n1_m4_368000_52800 15.000000
R19545 n1_m1_368000_57600 n1_m4_368000_57600 15.000000
R19546 n1_m1_368000_62400 n1_m4_368000_62400 15.000000
R19547 n1_m1_368000_67200 n1_m4_368000_67200 15.000000
R19548 n1_m1_368000_72000 n1_m4_368000_72000 15.000000
R19549 n1_m1_368000_76800 n1_m4_368000_76800 15.000000
R19550 n1_m1_368000_81600 n1_m4_368000_81600 15.000000
R19551 n1_m1_368000_86400 n1_m4_368000_86400 15.000000
R19552 n1_m1_368000_91200 n1_m4_368000_91200 15.000000
R19553 n1_m1_368000_96000 n1_m4_368000_96000 15.000000
R19554 n1_m1_368000_100800 n1_m4_368000_100800 15.000000
R19555 n1_m1_368000_105600 n1_m4_368000_105600 15.000000
R19556 n1_m1_368000_110400 n1_m4_368000_110400 15.000000
R19557 n1_m1_368000_115200 n1_m4_368000_115200 15.000000
R19558 n1_m1_368000_120000 n1_m4_368000_120000 15.000000
R19559 n1_m1_368000_124800 n1_m4_368000_124800 15.000000
R19560 n1_m1_368000_129600 n1_m4_368000_129600 15.000000
R19561 n1_m1_368000_134400 n1_m4_368000_134400 15.000000
R19562 n1_m1_368000_139200 n1_m4_368000_139200 15.000000
R19563 n1_m1_368000_144000 n1_m4_368000_144000 15.000000
R19564 n1_m1_368000_148800 n1_m4_368000_148800 15.000000
R19565 n1_m1_368000_153600 n1_m4_368000_153600 15.000000
R19566 n1_m1_368000_158400 n1_m4_368000_158400 15.000000
R19567 n1_m1_368000_163200 n1_m4_368000_163200 15.000000
R19568 n1_m1_368000_168000 n1_m4_368000_168000 15.000000
R19569 n1_m1_368000_172800 n1_m4_368000_172800 15.000000
R19570 n1_m1_368000_177600 n1_m4_368000_177600 15.000000
R19571 n1_m1_368000_182400 n1_m4_368000_182400 15.000000
R19572 n1_m1_368000_187200 n1_m4_368000_187200 15.000000
R19573 n1_m1_368000_192000 n1_m4_368000_192000 15.000000
R19574 n1_m1_368000_196800 n1_m4_368000_196800 15.000000
R19575 n1_m1_396000_0 n1_m4_396000_0 15.000000
R19576 n1_m1_396000_4800 n1_m4_396000_4800 15.000000
R19577 n1_m1_396000_9600 n1_m4_396000_9600 15.000000
R19578 n1_m1_396000_14400 n1_m4_396000_14400 15.000000
R19579 n1_m1_396000_19200 n1_m4_396000_19200 15.000000
R19580 n1_m1_396000_24000 n1_m4_396000_24000 15.000000
R19581 n1_m1_396000_28800 n1_m4_396000_28800 15.000000
R19582 n1_m1_396000_33600 n1_m4_396000_33600 15.000000
R19583 n1_m1_396000_38400 n1_m4_396000_38400 15.000000
R19584 n1_m1_396000_43200 n1_m4_396000_43200 15.000000
R19585 n1_m1_396000_48000 n1_m4_396000_48000 15.000000
R19586 n1_m1_396000_52800 n1_m4_396000_52800 15.000000
R19587 n1_m1_396000_57600 n1_m4_396000_57600 15.000000
R19588 n1_m1_396000_62400 n1_m4_396000_62400 15.000000
R19589 n1_m1_396000_67200 n1_m4_396000_67200 15.000000
R19590 n1_m1_396000_72000 n1_m4_396000_72000 15.000000
R19591 n1_m1_396000_76800 n1_m4_396000_76800 15.000000
R19592 n1_m1_396000_81600 n1_m4_396000_81600 15.000000
R19593 n1_m1_396000_86400 n1_m4_396000_86400 15.000000
R19594 n1_m1_396000_91200 n1_m4_396000_91200 15.000000
R19595 n1_m1_396000_96000 n1_m4_396000_96000 15.000000
R19596 n1_m1_396000_100800 n1_m4_396000_100800 15.000000
R19597 n1_m1_396000_105600 n1_m4_396000_105600 15.000000
R19598 n1_m1_396000_110400 n1_m4_396000_110400 15.000000
R19599 n1_m1_396000_115200 n1_m4_396000_115200 15.000000
R19600 n1_m1_396000_120000 n1_m4_396000_120000 15.000000
R19601 n1_m1_396000_124800 n1_m4_396000_124800 15.000000
R19602 n1_m1_396000_129600 n1_m4_396000_129600 15.000000
R19603 n1_m1_396000_134400 n1_m4_396000_134400 15.000000
R19604 n1_m1_396000_139200 n1_m4_396000_139200 15.000000
R19605 n1_m1_396000_144000 n1_m4_396000_144000 15.000000
R19606 n1_m1_396000_148800 n1_m4_396000_148800 15.000000
R19607 n1_m1_396000_153600 n1_m4_396000_153600 15.000000
R19608 n1_m1_396000_158400 n1_m4_396000_158400 15.000000
R19609 n1_m1_396000_163200 n1_m4_396000_163200 15.000000
R19610 n1_m1_396000_168000 n1_m4_396000_168000 15.000000
R19611 n1_m1_396000_172800 n1_m4_396000_172800 15.000000
R19612 n1_m1_396000_177600 n1_m4_396000_177600 15.000000
R19613 n1_m1_396000_182400 n1_m4_396000_182400 15.000000
R19614 n1_m1_396000_187200 n1_m4_396000_187200 15.000000
R19615 n1_m1_396000_192000 n1_m4_396000_192000 15.000000
R19616 n1_m1_396000_196800 n1_m4_396000_196800 15.000000
R19617 n1_m1_424000_0 n1_m4_424000_0 15.000000
R19618 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R19619 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R19620 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R19621 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R19622 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R19623 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R19624 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R19625 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R19626 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R19627 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R19628 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R19629 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R19630 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R19631 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R19632 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R19633 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R19634 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R19635 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R19636 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R19637 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R19638 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R19639 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R19640 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R19641 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R19642 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R19643 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R19644 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R19645 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R19646 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R19647 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R19648 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R19649 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R19650 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R19651 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R19652 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R19653 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R19654 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R19655 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R19656 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R19657 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R19658 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R19659 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R19660 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R19661 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R19662 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R19663 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R19664 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R19665 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R19666 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R19667 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R19668 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R19669 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R19670 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R19671 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R19672 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R19673 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R19674 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R19675 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R19676 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R19677 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R19678 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R19679 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R19680 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R19681 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R19682 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R19683 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R19684 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R19685 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R19686 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R19687 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R19688 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R19689 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R19690 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R19691 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R19692 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R19693 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R19694 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R19695 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R19696 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R19697 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R19698 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R19699 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R19700 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R19701 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R19702 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R19703 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R19704 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R19705 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R19706 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R19707 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R19708 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R19709 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R19710 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R19711 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R19712 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R19713 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R19714 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R19715 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R19716 n1_m1_424000_475200 n1_m4_424000_475200 15.000000
R19717 n1_m1_424000_480000 n1_m4_424000_480000 15.000000
R19718 n1_m1_424000_484800 n1_m4_424000_484800 15.000000
R19719 n1_m1_424000_489600 n1_m4_424000_489600 15.000000
R19720 n1_m1_424000_494400 n1_m4_424000_494400 15.000000
R19721 n1_m1_424000_499200 n1_m4_424000_499200 15.000000
R19722 n1_m1_424000_504000 n1_m4_424000_504000 15.000000
R19723 n1_m1_424000_508800 n1_m4_424000_508800 15.000000
R19724 n1_m1_424000_513600 n1_m4_424000_513600 15.000000
R19725 n1_m1_424000_518400 n1_m4_424000_518400 15.000000
R19726 n1_m1_424000_523200 n1_m4_424000_523200 15.000000
R19727 n1_m1_424000_528000 n1_m4_424000_528000 15.000000
R19728 n1_m1_424000_532800 n1_m4_424000_532800 15.000000
R19729 n1_m1_424000_537600 n1_m4_424000_537600 15.000000
R19730 n1_m1_424000_542400 n1_m4_424000_542400 15.000000
R19731 n1_m1_424000_547200 n1_m4_424000_547200 15.000000
R19732 n1_m1_424000_552000 n1_m4_424000_552000 15.000000
R19733 n1_m1_424000_556800 n1_m4_424000_556800 15.000000
R19734 n1_m1_424000_561600 n1_m4_424000_561600 15.000000
R19735 n1_m1_452000_0 n1_m4_452000_0 15.000000
R19736 n1_m1_452000_201600 n1_m4_452000_201600 15.000000
R19737 n1_m1_452000_206400 n1_m4_452000_206400 15.000000
R19738 n1_m1_452000_211200 n1_m4_452000_211200 15.000000
R19739 n1_m1_452000_216000 n1_m4_452000_216000 15.000000
R19740 n1_m1_452000_220800 n1_m4_452000_220800 15.000000
R19741 n1_m1_452000_225600 n1_m4_452000_225600 15.000000
R19742 n1_m1_452000_230400 n1_m4_452000_230400 15.000000
R19743 n1_m1_452000_235200 n1_m4_452000_235200 15.000000
R19744 n1_m1_452000_240000 n1_m4_452000_240000 15.000000
R19745 n1_m1_452000_244800 n1_m4_452000_244800 15.000000
R19746 n1_m1_452000_249600 n1_m4_452000_249600 15.000000
R19747 n1_m1_452000_254400 n1_m4_452000_254400 15.000000
R19748 n1_m1_452000_259200 n1_m4_452000_259200 15.000000
R19749 n1_m1_452000_264000 n1_m4_452000_264000 15.000000
R19750 n1_m1_452000_268800 n1_m4_452000_268800 15.000000
R19751 n1_m1_452000_273600 n1_m4_452000_273600 15.000000
R19752 n1_m1_452000_278400 n1_m4_452000_278400 15.000000
R19753 n1_m1_452000_283200 n1_m4_452000_283200 15.000000
R19754 n1_m1_452000_288000 n1_m4_452000_288000 15.000000
R19755 n1_m1_452000_292800 n1_m4_452000_292800 15.000000
R19756 n1_m1_452000_297600 n1_m4_452000_297600 15.000000
R19757 n1_m1_452000_302400 n1_m4_452000_302400 15.000000
R19758 n1_m1_452000_307200 n1_m4_452000_307200 15.000000
R19759 n1_m1_452000_312000 n1_m4_452000_312000 15.000000
R19760 n1_m1_452000_316800 n1_m4_452000_316800 15.000000
R19761 n1_m1_452000_321600 n1_m4_452000_321600 15.000000
R19762 n1_m1_452000_326400 n1_m4_452000_326400 15.000000
R19763 n1_m1_452000_331200 n1_m4_452000_331200 15.000000
R19764 n1_m1_452000_336000 n1_m4_452000_336000 15.000000
R19765 n1_m1_452000_340800 n1_m4_452000_340800 15.000000
R19766 n1_m1_452000_345600 n1_m4_452000_345600 15.000000
R19767 n1_m1_452000_350400 n1_m4_452000_350400 15.000000
R19768 n1_m1_452000_355200 n1_m4_452000_355200 15.000000
R19769 n1_m1_452000_360000 n1_m4_452000_360000 15.000000
R19770 n1_m1_452000_364800 n1_m4_452000_364800 15.000000
R19771 n1_m1_452000_369600 n1_m4_452000_369600 15.000000
R19772 n1_m1_452000_374400 n1_m4_452000_374400 15.000000
R19773 n1_m1_452000_379200 n1_m4_452000_379200 15.000000
R19774 n1_m1_452000_384000 n1_m4_452000_384000 15.000000
R19775 n1_m1_452000_388800 n1_m4_452000_388800 15.000000
R19776 n1_m1_452000_393600 n1_m4_452000_393600 15.000000
R19777 n1_m1_452000_398400 n1_m4_452000_398400 15.000000
R19778 n1_m1_480000_0 n1_m4_480000_0 15.000000
R19779 n1_m1_480000_4800 n1_m4_480000_4800 15.000000
R19780 n1_m1_480000_9600 n1_m4_480000_9600 15.000000
R19781 n1_m1_480000_14400 n1_m4_480000_14400 15.000000
R19782 n1_m1_480000_19200 n1_m4_480000_19200 15.000000
R19783 n1_m1_480000_24000 n1_m4_480000_24000 15.000000
R19784 n1_m1_480000_28800 n1_m4_480000_28800 15.000000
R19785 n1_m1_480000_33600 n1_m4_480000_33600 15.000000
R19786 n1_m1_480000_38400 n1_m4_480000_38400 15.000000
R19787 n1_m1_480000_43200 n1_m4_480000_43200 15.000000
R19788 n1_m1_480000_48000 n1_m4_480000_48000 15.000000
R19789 n1_m1_480000_52800 n1_m4_480000_52800 15.000000
R19790 n1_m1_480000_57600 n1_m4_480000_57600 15.000000
R19791 n1_m1_480000_62400 n1_m4_480000_62400 15.000000
R19792 n1_m1_480000_67200 n1_m4_480000_67200 15.000000
R19793 n1_m1_480000_72000 n1_m4_480000_72000 15.000000
R19794 n1_m1_480000_76800 n1_m4_480000_76800 15.000000
R19795 n1_m1_480000_81600 n1_m4_480000_81600 15.000000
R19796 n1_m1_480000_86400 n1_m4_480000_86400 15.000000
R19797 n1_m1_480000_91200 n1_m4_480000_91200 15.000000
R19798 n1_m1_480000_96000 n1_m4_480000_96000 15.000000
R19799 n1_m1_480000_100800 n1_m4_480000_100800 15.000000
R19800 n1_m1_480000_105600 n1_m4_480000_105600 15.000000
R19801 n1_m1_480000_110400 n1_m4_480000_110400 15.000000
R19802 n1_m1_480000_115200 n1_m4_480000_115200 15.000000
R19803 n1_m1_480000_120000 n1_m4_480000_120000 15.000000
R19804 n1_m1_480000_124800 n1_m4_480000_124800 15.000000
R19805 n1_m1_480000_129600 n1_m4_480000_129600 15.000000
R19806 n1_m1_480000_134400 n1_m4_480000_134400 15.000000
R19807 n1_m1_480000_139200 n1_m4_480000_139200 15.000000
R19808 n1_m1_480000_144000 n1_m4_480000_144000 15.000000
R19809 n1_m1_480000_148800 n1_m4_480000_148800 15.000000
R19810 n1_m1_480000_153600 n1_m4_480000_153600 15.000000
R19811 n1_m1_480000_158400 n1_m4_480000_158400 15.000000
R19812 n1_m1_480000_163200 n1_m4_480000_163200 15.000000
R19813 n1_m1_480000_168000 n1_m4_480000_168000 15.000000
R19814 n1_m1_480000_172800 n1_m4_480000_172800 15.000000
R19815 n1_m1_480000_177600 n1_m4_480000_177600 15.000000
R19816 n1_m1_480000_182400 n1_m4_480000_182400 15.000000
R19817 n1_m1_480000_187200 n1_m4_480000_187200 15.000000
R19818 n1_m1_480000_192000 n1_m4_480000_192000 15.000000
R19819 n1_m1_480000_196800 n1_m4_480000_196800 15.000000
R19820 n1_m1_480000_201600 n1_m4_480000_201600 15.000000
R19821 n1_m1_480000_206400 n1_m4_480000_206400 15.000000
R19822 n1_m1_480000_211200 n1_m4_480000_211200 15.000000
R19823 n1_m1_480000_216000 n1_m4_480000_216000 15.000000
R19824 n1_m1_480000_220800 n1_m4_480000_220800 15.000000
R19825 n1_m1_480000_225600 n1_m4_480000_225600 15.000000
R19826 n1_m1_480000_230400 n1_m4_480000_230400 15.000000
R19827 n1_m1_480000_235200 n1_m4_480000_235200 15.000000
R19828 n1_m1_480000_240000 n1_m4_480000_240000 15.000000
R19829 n1_m1_480000_244800 n1_m4_480000_244800 15.000000
R19830 n1_m1_480000_249600 n1_m4_480000_249600 15.000000
R19831 n1_m1_480000_254400 n1_m4_480000_254400 15.000000
R19832 n1_m1_480000_259200 n1_m4_480000_259200 15.000000
R19833 n1_m1_480000_264000 n1_m4_480000_264000 15.000000
R19834 n1_m1_480000_268800 n1_m4_480000_268800 15.000000
R19835 n1_m1_480000_273600 n1_m4_480000_273600 15.000000
R19836 n1_m1_480000_278400 n1_m4_480000_278400 15.000000
R19837 n1_m1_480000_283200 n1_m4_480000_283200 15.000000
R19838 n1_m1_480000_288000 n1_m4_480000_288000 15.000000
R19839 n1_m1_480000_292800 n1_m4_480000_292800 15.000000
R19840 n1_m1_480000_297600 n1_m4_480000_297600 15.000000
R19841 n1_m1_480000_302400 n1_m4_480000_302400 15.000000
R19842 n1_m1_480000_307200 n1_m4_480000_307200 15.000000
R19843 n1_m1_480000_312000 n1_m4_480000_312000 15.000000
R19844 n1_m1_480000_316800 n1_m4_480000_316800 15.000000
R19845 n1_m1_480000_321600 n1_m4_480000_321600 15.000000
R19846 n1_m1_480000_326400 n1_m4_480000_326400 15.000000
R19847 n1_m1_480000_331200 n1_m4_480000_331200 15.000000
R19848 n1_m1_480000_336000 n1_m4_480000_336000 15.000000
R19849 n1_m1_480000_340800 n1_m4_480000_340800 15.000000
R19850 n1_m1_480000_345600 n1_m4_480000_345600 15.000000
R19851 n1_m1_480000_350400 n1_m4_480000_350400 15.000000
R19852 n1_m1_480000_355200 n1_m4_480000_355200 15.000000
R19853 n1_m1_480000_360000 n1_m4_480000_360000 15.000000
R19854 n1_m1_480000_364800 n1_m4_480000_364800 15.000000
R19855 n1_m1_480000_369600 n1_m4_480000_369600 15.000000
R19856 n1_m1_480000_374400 n1_m4_480000_374400 15.000000
R19857 n1_m1_480000_379200 n1_m4_480000_379200 15.000000
R19858 n1_m1_480000_384000 n1_m4_480000_384000 15.000000
R19859 n1_m1_480000_388800 n1_m4_480000_388800 15.000000
R19860 n1_m1_480000_393600 n1_m4_480000_393600 15.000000
R19861 n1_m1_480000_398400 n1_m4_480000_398400 15.000000
R19862 n1_m1_508000_0 n1_m4_508000_0 15.000000
R19863 n1_m1_508000_201600 n1_m4_508000_201600 15.000000
R19864 n1_m1_508000_206400 n1_m4_508000_206400 15.000000
R19865 n1_m1_508000_211200 n1_m4_508000_211200 15.000000
R19866 n1_m1_508000_216000 n1_m4_508000_216000 15.000000
R19867 n1_m1_508000_220800 n1_m4_508000_220800 15.000000
R19868 n1_m1_508000_225600 n1_m4_508000_225600 15.000000
R19869 n1_m1_508000_230400 n1_m4_508000_230400 15.000000
R19870 n1_m1_508000_235200 n1_m4_508000_235200 15.000000
R19871 n1_m1_508000_240000 n1_m4_508000_240000 15.000000
R19872 n1_m1_508000_244800 n1_m4_508000_244800 15.000000
R19873 n1_m1_508000_249600 n1_m4_508000_249600 15.000000
R19874 n1_m1_508000_254400 n1_m4_508000_254400 15.000000
R19875 n1_m1_508000_259200 n1_m4_508000_259200 15.000000
R19876 n1_m1_508000_264000 n1_m4_508000_264000 15.000000
R19877 n1_m1_508000_268800 n1_m4_508000_268800 15.000000
R19878 n1_m1_508000_273600 n1_m4_508000_273600 15.000000
R19879 n1_m1_508000_278400 n1_m4_508000_278400 15.000000
R19880 n1_m1_508000_283200 n1_m4_508000_283200 15.000000
R19881 n1_m1_508000_288000 n1_m4_508000_288000 15.000000
R19882 n1_m1_508000_292800 n1_m4_508000_292800 15.000000
R19883 n1_m1_508000_297600 n1_m4_508000_297600 15.000000
R19884 n1_m1_508000_302400 n1_m4_508000_302400 15.000000
R19885 n1_m1_508000_307200 n1_m4_508000_307200 15.000000
R19886 n1_m1_508000_312000 n1_m4_508000_312000 15.000000
R19887 n1_m1_508000_316800 n1_m4_508000_316800 15.000000
R19888 n1_m1_508000_321600 n1_m4_508000_321600 15.000000
R19889 n1_m1_508000_326400 n1_m4_508000_326400 15.000000
R19890 n1_m1_508000_331200 n1_m4_508000_331200 15.000000
R19891 n1_m1_508000_336000 n1_m4_508000_336000 15.000000
R19892 n1_m1_508000_340800 n1_m4_508000_340800 15.000000
R19893 n1_m1_508000_345600 n1_m4_508000_345600 15.000000
R19894 n1_m1_508000_350400 n1_m4_508000_350400 15.000000
R19895 n1_m1_508000_355200 n1_m4_508000_355200 15.000000
R19896 n1_m1_508000_360000 n1_m4_508000_360000 15.000000
R19897 n1_m1_508000_364800 n1_m4_508000_364800 15.000000
R19898 n1_m1_508000_369600 n1_m4_508000_369600 15.000000
R19899 n1_m1_508000_374400 n1_m4_508000_374400 15.000000
R19900 n1_m1_508000_379200 n1_m4_508000_379200 15.000000
R19901 n1_m1_508000_384000 n1_m4_508000_384000 15.000000
R19902 n1_m1_508000_388800 n1_m4_508000_388800 15.000000
R19903 n1_m1_508000_393600 n1_m4_508000_393600 15.000000
R19904 n1_m1_508000_398400 n1_m4_508000_398400 15.000000
R19905 n1_m1_508000_403200 n1_m4_508000_403200 15.000000
R19906 n1_m1_508000_408000 n1_m4_508000_408000 15.000000
R19907 n1_m1_508000_412800 n1_m4_508000_412800 15.000000
R19908 n1_m1_508000_417600 n1_m4_508000_417600 15.000000
R19909 n1_m1_508000_422400 n1_m4_508000_422400 15.000000
R19910 n1_m1_508000_427200 n1_m4_508000_427200 15.000000
R19911 n1_m1_508000_432000 n1_m4_508000_432000 15.000000
R19912 n1_m1_508000_436800 n1_m4_508000_436800 15.000000
R19913 n1_m1_508000_441600 n1_m4_508000_441600 15.000000
R19914 n1_m1_508000_446400 n1_m4_508000_446400 15.000000
R19915 n1_m1_508000_451200 n1_m4_508000_451200 15.000000
R19916 n1_m1_508000_456000 n1_m4_508000_456000 15.000000
R19917 n1_m1_508000_460800 n1_m4_508000_460800 15.000000
R19918 n1_m1_508000_465600 n1_m4_508000_465600 15.000000
R19919 n1_m1_508000_470400 n1_m4_508000_470400 15.000000
R19920 n1_m1_508000_475200 n1_m4_508000_475200 15.000000
R19921 n1_m1_508000_480000 n1_m4_508000_480000 15.000000
R19922 n1_m1_508000_484800 n1_m4_508000_484800 15.000000
R19923 n1_m1_508000_489600 n1_m4_508000_489600 15.000000
R19924 n1_m1_508000_494400 n1_m4_508000_494400 15.000000
R19925 n1_m1_508000_499200 n1_m4_508000_499200 15.000000
R19926 n1_m1_508000_504000 n1_m4_508000_504000 15.000000
R19927 n1_m1_508000_508800 n1_m4_508000_508800 15.000000
R19928 n1_m1_508000_513600 n1_m4_508000_513600 15.000000
R19929 n1_m1_508000_518400 n1_m4_508000_518400 15.000000
R19930 n1_m1_508000_523200 n1_m4_508000_523200 15.000000
R19931 n1_m1_508000_528000 n1_m4_508000_528000 15.000000
R19932 n1_m1_508000_532800 n1_m4_508000_532800 15.000000
R19933 n1_m1_508000_537600 n1_m4_508000_537600 15.000000
R19934 n1_m1_508000_542400 n1_m4_508000_542400 15.000000
R19935 n1_m1_508000_547200 n1_m4_508000_547200 15.000000
R19936 n1_m1_508000_552000 n1_m4_508000_552000 15.000000
R19937 n1_m1_508000_556800 n1_m4_508000_556800 15.000000
R19938 n1_m1_508000_561600 n1_m4_508000_561600 15.000000
R19939 n1_m1_536000_0 n1_m4_536000_0 15.000000
R19940 n1_m1_536000_4800 n1_m4_536000_4800 15.000000
R19941 n1_m1_536000_9600 n1_m4_536000_9600 15.000000
R19942 n1_m1_536000_14400 n1_m4_536000_14400 15.000000
R19943 n1_m1_536000_19200 n1_m4_536000_19200 15.000000
R19944 n1_m1_536000_24000 n1_m4_536000_24000 15.000000
R19945 n1_m1_536000_28800 n1_m4_536000_28800 15.000000
R19946 n1_m1_536000_33600 n1_m4_536000_33600 15.000000
R19947 n1_m1_536000_38400 n1_m4_536000_38400 15.000000
R19948 n1_m1_536000_43200 n1_m4_536000_43200 15.000000
R19949 n1_m1_536000_48000 n1_m4_536000_48000 15.000000
R19950 n1_m1_536000_52800 n1_m4_536000_52800 15.000000
R19951 n1_m1_536000_57600 n1_m4_536000_57600 15.000000
R19952 n1_m1_536000_62400 n1_m4_536000_62400 15.000000
R19953 n1_m1_536000_67200 n1_m4_536000_67200 15.000000
R19954 n1_m1_536000_72000 n1_m4_536000_72000 15.000000
R19955 n1_m1_536000_76800 n1_m4_536000_76800 15.000000
R19956 n1_m1_536000_81600 n1_m4_536000_81600 15.000000
R19957 n1_m1_536000_86400 n1_m4_536000_86400 15.000000
R19958 n1_m1_536000_91200 n1_m4_536000_91200 15.000000
R19959 n1_m1_536000_96000 n1_m4_536000_96000 15.000000
R19960 n1_m1_536000_100800 n1_m4_536000_100800 15.000000
R19961 n1_m1_536000_105600 n1_m4_536000_105600 15.000000
R19962 n1_m1_536000_110400 n1_m4_536000_110400 15.000000
R19963 n1_m1_536000_115200 n1_m4_536000_115200 15.000000
R19964 n1_m1_536000_120000 n1_m4_536000_120000 15.000000
R19965 n1_m1_536000_124800 n1_m4_536000_124800 15.000000
R19966 n1_m1_536000_129600 n1_m4_536000_129600 15.000000
R19967 n1_m1_536000_134400 n1_m4_536000_134400 15.000000
R19968 n1_m1_536000_139200 n1_m4_536000_139200 15.000000
R19969 n1_m1_536000_144000 n1_m4_536000_144000 15.000000
R19970 n1_m1_536000_148800 n1_m4_536000_148800 15.000000
R19971 n1_m1_536000_153600 n1_m4_536000_153600 15.000000
R19972 n1_m1_536000_158400 n1_m4_536000_158400 15.000000
R19973 n1_m1_536000_163200 n1_m4_536000_163200 15.000000
R19974 n1_m1_536000_168000 n1_m4_536000_168000 15.000000
R19975 n1_m1_536000_172800 n1_m4_536000_172800 15.000000
R19976 n1_m1_536000_177600 n1_m4_536000_177600 15.000000
R19977 n1_m1_536000_182400 n1_m4_536000_182400 15.000000
R19978 n1_m1_536000_187200 n1_m4_536000_187200 15.000000
R19979 n1_m1_536000_192000 n1_m4_536000_192000 15.000000
R19980 n1_m1_536000_196800 n1_m4_536000_196800 15.000000
R19981 n1_m1_536000_201600 n1_m4_536000_201600 15.000000
R19982 n1_m1_536000_206400 n1_m4_536000_206400 15.000000
R19983 n1_m1_536000_211200 n1_m4_536000_211200 15.000000
R19984 n1_m1_536000_216000 n1_m4_536000_216000 15.000000
R19985 n1_m1_536000_220800 n1_m4_536000_220800 15.000000
R19986 n1_m1_536000_225600 n1_m4_536000_225600 15.000000
R19987 n1_m1_536000_230400 n1_m4_536000_230400 15.000000
R19988 n1_m1_536000_235200 n1_m4_536000_235200 15.000000
R19989 n1_m1_536000_240000 n1_m4_536000_240000 15.000000
R19990 n1_m1_536000_244800 n1_m4_536000_244800 15.000000
R19991 n1_m1_536000_249600 n1_m4_536000_249600 15.000000
R19992 n1_m1_536000_254400 n1_m4_536000_254400 15.000000
R19993 n1_m1_536000_259200 n1_m4_536000_259200 15.000000
R19994 n1_m1_536000_264000 n1_m4_536000_264000 15.000000
R19995 n1_m1_536000_268800 n1_m4_536000_268800 15.000000
R19996 n1_m1_536000_273600 n1_m4_536000_273600 15.000000
R19997 n1_m1_536000_278400 n1_m4_536000_278400 15.000000
R19998 n1_m1_536000_283200 n1_m4_536000_283200 15.000000
R19999 n1_m1_536000_288000 n1_m4_536000_288000 15.000000
R20000 n1_m1_536000_292800 n1_m4_536000_292800 15.000000
R20001 n1_m1_536000_297600 n1_m4_536000_297600 15.000000
R20002 n1_m1_536000_302400 n1_m4_536000_302400 15.000000
R20003 n1_m1_536000_307200 n1_m4_536000_307200 15.000000
R20004 n1_m1_536000_312000 n1_m4_536000_312000 15.000000
R20005 n1_m1_536000_316800 n1_m4_536000_316800 15.000000
R20006 n1_m1_536000_321600 n1_m4_536000_321600 15.000000
R20007 n1_m1_536000_326400 n1_m4_536000_326400 15.000000
R20008 n1_m1_536000_331200 n1_m4_536000_331200 15.000000
R20009 n1_m1_536000_336000 n1_m4_536000_336000 15.000000
R20010 n1_m1_536000_340800 n1_m4_536000_340800 15.000000
R20011 n1_m1_536000_345600 n1_m4_536000_345600 15.000000
R20012 n1_m1_536000_350400 n1_m4_536000_350400 15.000000
R20013 n1_m1_536000_355200 n1_m4_536000_355200 15.000000
R20014 n1_m1_536000_360000 n1_m4_536000_360000 15.000000
R20015 n1_m1_536000_364800 n1_m4_536000_364800 15.000000
R20016 n1_m1_536000_369600 n1_m4_536000_369600 15.000000
R20017 n1_m1_536000_374400 n1_m4_536000_374400 15.000000
R20018 n1_m1_536000_379200 n1_m4_536000_379200 15.000000
R20019 n1_m1_536000_384000 n1_m4_536000_384000 15.000000
R20020 n1_m1_536000_388800 n1_m4_536000_388800 15.000000
R20021 n1_m1_536000_393600 n1_m4_536000_393600 15.000000
R20022 n1_m1_536000_398400 n1_m4_536000_398400 15.000000
R20023 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R20024 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R20025 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R20026 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R20027 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R20028 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R20029 n1_m4_4000_484000 n1_m7_4000_484000 9.000000
R20030 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R20031 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R20032 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R20033 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R20034 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R20035 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R20036 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R20037 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R20038 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R20039 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R20040 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R20041 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R20042 n1_m4_116000_244000 n1_m7_116000_244000 9.000000
R20043 n1_m4_116000_324000 n1_m7_116000_324000 9.000000
R20044 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R20045 n1_m4_116000_484000 n1_m7_116000_484000 9.000000
R20046 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R20047 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R20048 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R20049 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R20050 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R20051 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R20052 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R20053 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R20054 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R20055 n1_m4_228000_4000 n1_m7_228000_4000 9.000000
R20056 n1_m4_228000_84000 n1_m7_228000_84000 9.000000
R20057 n1_m4_228000_164000 n1_m7_228000_164000 9.000000
R20058 n1_m4_256000_4000 n1_m7_256000_4000 9.000000
R20059 n1_m4_256000_84000 n1_m7_256000_84000 9.000000
R20060 n1_m4_256000_164000 n1_m7_256000_164000 9.000000
R20061 n1_m4_284000_4000 n1_m7_284000_4000 9.000000
R20062 n1_m4_284000_84000 n1_m7_284000_84000 9.000000
R20063 n1_m4_284000_164000 n1_m7_284000_164000 9.000000
R20064 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R20065 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R20066 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R20067 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R20068 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R20069 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R20070 n1_m4_312000_484000 n1_m7_312000_484000 9.000000
R20071 n1_m4_340000_4000 n1_m7_340000_4000 9.000000
R20072 n1_m4_340000_84000 n1_m7_340000_84000 9.000000
R20073 n1_m4_340000_164000 n1_m7_340000_164000 9.000000
R20074 n1_m4_368000_4000 n1_m7_368000_4000 9.000000
R20075 n1_m4_368000_84000 n1_m7_368000_84000 9.000000
R20076 n1_m4_368000_164000 n1_m7_368000_164000 9.000000
R20077 n1_m4_396000_4000 n1_m7_396000_4000 9.000000
R20078 n1_m4_396000_84000 n1_m7_396000_84000 9.000000
R20079 n1_m4_396000_164000 n1_m7_396000_164000 9.000000
R20080 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R20081 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R20082 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R20083 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R20084 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R20085 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R20086 n1_m4_424000_484000 n1_m7_424000_484000 9.000000
R20087 n1_m4_452000_244000 n1_m7_452000_244000 9.000000
R20088 n1_m4_452000_324000 n1_m7_452000_324000 9.000000
R20089 n1_m4_480000_4000 n1_m7_480000_4000 9.000000
R20090 n1_m4_480000_84000 n1_m7_480000_84000 9.000000
R20091 n1_m4_480000_164000 n1_m7_480000_164000 9.000000
R20092 n1_m4_480000_244000 n1_m7_480000_244000 9.000000
R20093 n1_m4_480000_324000 n1_m7_480000_324000 9.000000
R20094 n1_m4_508000_244000 n1_m7_508000_244000 9.000000
R20095 n1_m4_508000_324000 n1_m7_508000_324000 9.000000
R20096 n1_m4_508000_404000 n1_m7_508000_404000 9.000000
R20097 n1_m4_508000_484000 n1_m7_508000_484000 9.000000
R20098 n1_m4_536000_4000 n1_m7_536000_4000 9.000000
R20099 n1_m4_536000_84000 n1_m7_536000_84000 9.000000
R20100 n1_m4_536000_164000 n1_m7_536000_164000 9.000000
R20101 n1_m4_536000_244000 n1_m7_536000_244000 9.000000
R20102 n1_m4_536000_324000 n1_m7_536000_324000 9.000000
R20103 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R20104 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R20105 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R20106 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R20107 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R20108 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R20109 n1_m7_4000_484000 n1_m8_4000_484000 1.000000
R20110 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R20111 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R20112 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R20113 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R20114 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R20115 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R20116 n1_m7_26400_484000 n1_m8_26400_484000 1.000000
R20117 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R20118 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R20119 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R20120 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R20121 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R20122 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R20123 n1_m7_48800_484000 n1_m8_48800_484000 1.000000
R20124 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R20125 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R20126 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R20127 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R20128 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R20129 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R20130 n1_m7_71200_484000 n1_m8_71200_484000 1.000000
R20131 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R20132 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R20133 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R20134 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R20135 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R20136 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R20137 n1_m7_93600_484000 n1_m8_93600_484000 1.000000
R20138 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R20139 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R20140 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R20141 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R20142 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R20143 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R20144 n1_m7_116000_484000 n1_m8_116000_484000 1.000000
R20145 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R20146 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R20147 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R20148 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R20149 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R20150 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R20151 n1_m7_138400_484000 n1_m8_138400_484000 1.000000
R20152 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R20153 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R20154 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R20155 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R20156 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R20157 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R20158 n1_m7_160800_484000 n1_m8_160800_484000 1.000000
R20159 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R20160 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R20161 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R20162 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R20163 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R20164 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R20165 n1_m7_183200_484000 n1_m8_183200_484000 1.000000
R20166 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R20167 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R20168 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R20169 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R20170 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R20171 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R20172 n1_m7_205600_484000 n1_m8_205600_484000 1.000000
R20173 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R20174 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R20175 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R20176 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R20177 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R20178 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R20179 n1_m7_228000_484000 n1_m8_228000_484000 1.000000
R20180 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R20181 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R20182 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R20183 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R20184 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R20185 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R20186 n1_m7_250400_484000 n1_m8_250400_484000 1.000000
R20187 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R20188 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R20189 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R20190 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R20191 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R20192 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R20193 n1_m7_272800_484000 n1_m8_272800_484000 1.000000
R20194 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R20195 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R20196 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R20197 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R20198 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R20199 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R20200 n1_m7_295200_484000 n1_m8_295200_484000 1.000000
R20201 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R20202 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R20203 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R20204 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R20205 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R20206 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R20207 n1_m7_317600_484000 n1_m8_317600_484000 1.000000
R20208 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R20209 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R20210 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R20211 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R20212 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R20213 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R20214 n1_m7_340000_484000 n1_m8_340000_484000 1.000000
R20215 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R20216 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R20217 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R20218 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R20219 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R20220 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R20221 n1_m7_362400_484000 n1_m8_362400_484000 1.000000
R20222 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R20223 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R20224 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R20225 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R20226 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R20227 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R20228 n1_m7_384800_484000 n1_m8_384800_484000 1.000000
R20229 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R20230 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R20231 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R20232 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R20233 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R20234 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R20235 n1_m7_407200_484000 n1_m8_407200_484000 1.000000
R20236 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R20237 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R20238 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R20239 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R20240 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R20241 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R20242 n1_m7_429600_484000 n1_m8_429600_484000 1.000000
R20243 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R20244 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R20245 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R20246 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R20247 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R20248 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R20249 n1_m7_452000_484000 n1_m8_452000_484000 1.000000
R20250 n1_m7_474400_4000 n1_m8_474400_4000 1.000000
R20251 n1_m7_474400_84000 n1_m8_474400_84000 1.000000
R20252 n1_m7_474400_164000 n1_m8_474400_164000 1.000000
R20253 n1_m7_474400_244000 n1_m8_474400_244000 1.000000
R20254 n1_m7_474400_324000 n1_m8_474400_324000 1.000000
R20255 n1_m7_474400_404000 n1_m8_474400_404000 1.000000
R20256 n1_m7_474400_484000 n1_m8_474400_484000 1.000000
R20257 n1_m7_496800_4000 n1_m8_496800_4000 1.000000
R20258 n1_m7_496800_84000 n1_m8_496800_84000 1.000000
R20259 n1_m7_496800_164000 n1_m8_496800_164000 1.000000
R20260 n1_m7_496800_244000 n1_m8_496800_244000 1.000000
R20261 n1_m7_496800_324000 n1_m8_496800_324000 1.000000
R20262 n1_m7_496800_404000 n1_m8_496800_404000 1.000000
R20263 n1_m7_496800_484000 n1_m8_496800_484000 1.000000
R20264 n1_m7_519200_4000 n1_m8_519200_4000 1.000000
R20265 n1_m7_519200_84000 n1_m8_519200_84000 1.000000
R20266 n1_m7_519200_164000 n1_m8_519200_164000 1.000000
R20267 n1_m7_519200_244000 n1_m8_519200_244000 1.000000
R20268 n1_m7_519200_324000 n1_m8_519200_324000 1.000000
R20269 n1_m7_519200_404000 n1_m8_519200_404000 1.000000
R20270 n1_m7_519200_484000 n1_m8_519200_484000 1.000000
R20271 n1_m7_541600_4000 n1_m8_541600_4000 1.000000
R20272 n1_m7_541600_84000 n1_m8_541600_84000 1.000000
R20273 n1_m7_541600_164000 n1_m8_541600_164000 1.000000
R20274 n1_m7_541600_244000 n1_m8_541600_244000 1.000000
R20275 n1_m7_541600_324000 n1_m8_541600_324000 1.000000
R20276 n1_m7_541600_404000 n1_m8_541600_404000 1.000000
R20277 n1_m7_541600_484000 n1_m8_541600_484000 1.000000
R20278 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R20279 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R20280 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R20281 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R20282 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R20283 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R20284 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R20285 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R20286 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R20287 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R20288 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R20289 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R20290 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R20291 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R20292 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R20293 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R20294 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R20295 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R20296 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R20297 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R20298 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R20299 n1_m8_4000_474400 n1_m9_4000_474400 1.000000
R20300 n1_m8_4000_496800 n1_m9_4000_496800 1.000000
R20301 n1_m8_4000_519200 n1_m9_4000_519200 1.000000
R20302 n1_m8_4000_541600 n1_m9_4000_541600 1.000000
R20303 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R20304 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R20305 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R20306 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R20307 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R20308 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R20309 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R20310 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R20311 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R20312 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R20313 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R20314 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R20315 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R20316 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R20317 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R20318 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R20319 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R20320 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R20321 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R20322 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R20323 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R20324 n1_m8_26400_474400 n1_m9_26400_474400 1.000000
R20325 n1_m8_26400_496800 n1_m9_26400_496800 1.000000
R20326 n1_m8_26400_519200 n1_m9_26400_519200 1.000000
R20327 n1_m8_26400_541600 n1_m9_26400_541600 1.000000
R20328 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R20329 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R20330 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R20331 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R20332 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R20333 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R20334 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R20335 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R20336 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R20337 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R20338 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R20339 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R20340 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R20341 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R20342 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R20343 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R20344 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R20345 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R20346 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R20347 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R20348 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R20349 n1_m8_48800_474400 n1_m9_48800_474400 1.000000
R20350 n1_m8_48800_496800 n1_m9_48800_496800 1.000000
R20351 n1_m8_48800_519200 n1_m9_48800_519200 1.000000
R20352 n1_m8_48800_541600 n1_m9_48800_541600 1.000000
R20353 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R20354 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R20355 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R20356 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R20357 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R20358 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R20359 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R20360 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R20361 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R20362 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R20363 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R20364 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R20365 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R20366 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R20367 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R20368 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R20369 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R20370 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R20371 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R20372 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R20373 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R20374 n1_m8_71200_474400 n1_m9_71200_474400 1.000000
R20375 n1_m8_71200_496800 n1_m9_71200_496800 1.000000
R20376 n1_m8_71200_519200 n1_m9_71200_519200 1.000000
R20377 n1_m8_71200_541600 n1_m9_71200_541600 1.000000
R20378 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R20379 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R20380 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R20381 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R20382 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R20383 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R20384 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R20385 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R20386 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R20387 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R20388 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R20389 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R20390 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R20391 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R20392 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R20393 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R20394 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R20395 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R20396 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R20397 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R20398 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R20399 n1_m8_93600_474400 n1_m9_93600_474400 1.000000
R20400 n1_m8_93600_496800 n1_m9_93600_496800 1.000000
R20401 n1_m8_93600_519200 n1_m9_93600_519200 1.000000
R20402 n1_m8_93600_541600 n1_m9_93600_541600 1.000000
R20403 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R20404 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R20405 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R20406 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R20407 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R20408 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R20409 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R20410 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R20411 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R20412 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R20413 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R20414 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R20415 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R20416 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R20417 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R20418 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R20419 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R20420 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R20421 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R20422 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R20423 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R20424 n1_m8_116000_474400 n1_m9_116000_474400 1.000000
R20425 n1_m8_116000_496800 n1_m9_116000_496800 1.000000
R20426 n1_m8_116000_519200 n1_m9_116000_519200 1.000000
R20427 n1_m8_116000_541600 n1_m9_116000_541600 1.000000
R20428 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R20429 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R20430 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R20431 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R20432 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R20433 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R20434 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R20435 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R20436 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R20437 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R20438 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R20439 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R20440 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R20441 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R20442 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R20443 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R20444 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R20445 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R20446 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R20447 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R20448 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R20449 n1_m8_138400_474400 n1_m9_138400_474400 1.000000
R20450 n1_m8_138400_496800 n1_m9_138400_496800 1.000000
R20451 n1_m8_138400_519200 n1_m9_138400_519200 1.000000
R20452 n1_m8_138400_541600 n1_m9_138400_541600 1.000000
R20453 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R20454 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R20455 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R20456 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R20457 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R20458 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R20459 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R20460 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R20461 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R20462 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R20463 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R20464 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R20465 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R20466 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R20467 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R20468 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R20469 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R20470 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R20471 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R20472 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R20473 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R20474 n1_m8_160800_474400 n1_m9_160800_474400 1.000000
R20475 n1_m8_160800_496800 n1_m9_160800_496800 1.000000
R20476 n1_m8_160800_519200 n1_m9_160800_519200 1.000000
R20477 n1_m8_160800_541600 n1_m9_160800_541600 1.000000
R20478 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R20479 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R20480 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R20481 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R20482 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R20483 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R20484 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R20485 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R20486 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R20487 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R20488 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R20489 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R20490 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R20491 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R20492 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R20493 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R20494 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R20495 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R20496 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R20497 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R20498 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R20499 n1_m8_183200_474400 n1_m9_183200_474400 1.000000
R20500 n1_m8_183200_496800 n1_m9_183200_496800 1.000000
R20501 n1_m8_183200_519200 n1_m9_183200_519200 1.000000
R20502 n1_m8_183200_541600 n1_m9_183200_541600 1.000000
R20503 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R20504 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R20505 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R20506 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R20507 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R20508 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R20509 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R20510 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R20511 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R20512 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R20513 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R20514 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R20515 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R20516 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R20517 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R20518 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R20519 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R20520 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R20521 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R20522 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R20523 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R20524 n1_m8_205600_474400 n1_m9_205600_474400 1.000000
R20525 n1_m8_205600_496800 n1_m9_205600_496800 1.000000
R20526 n1_m8_205600_519200 n1_m9_205600_519200 1.000000
R20527 n1_m8_205600_541600 n1_m9_205600_541600 1.000000
R20528 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R20529 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R20530 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R20531 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R20532 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R20533 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R20534 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R20535 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R20536 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R20537 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R20538 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R20539 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R20540 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R20541 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R20542 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R20543 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R20544 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R20545 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R20546 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R20547 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R20548 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R20549 n1_m8_228000_474400 n1_m9_228000_474400 1.000000
R20550 n1_m8_228000_496800 n1_m9_228000_496800 1.000000
R20551 n1_m8_228000_519200 n1_m9_228000_519200 1.000000
R20552 n1_m8_228000_541600 n1_m9_228000_541600 1.000000
R20553 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R20554 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R20555 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R20556 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R20557 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R20558 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R20559 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R20560 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R20561 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R20562 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R20563 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R20564 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R20565 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R20566 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R20567 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R20568 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R20569 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R20570 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R20571 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R20572 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R20573 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R20574 n1_m8_250400_474400 n1_m9_250400_474400 1.000000
R20575 n1_m8_250400_496800 n1_m9_250400_496800 1.000000
R20576 n1_m8_250400_519200 n1_m9_250400_519200 1.000000
R20577 n1_m8_250400_541600 n1_m9_250400_541600 1.000000
R20578 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R20579 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R20580 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R20581 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R20582 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R20583 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R20584 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R20585 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R20586 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R20587 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R20588 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R20589 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R20590 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R20591 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R20592 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R20593 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R20594 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R20595 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R20596 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R20597 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R20598 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R20599 n1_m8_272800_474400 n1_m9_272800_474400 1.000000
R20600 n1_m8_272800_496800 n1_m9_272800_496800 1.000000
R20601 n1_m8_272800_519200 n1_m9_272800_519200 1.000000
R20602 n1_m8_272800_541600 n1_m9_272800_541600 1.000000
R20603 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R20604 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R20605 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R20606 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R20607 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R20608 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R20609 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R20610 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R20611 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R20612 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R20613 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R20614 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R20615 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R20616 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R20617 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R20618 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R20619 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R20620 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R20621 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R20622 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R20623 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R20624 n1_m8_295200_474400 n1_m9_295200_474400 1.000000
R20625 n1_m8_295200_496800 n1_m9_295200_496800 1.000000
R20626 n1_m8_295200_519200 n1_m9_295200_519200 1.000000
R20627 n1_m8_295200_541600 n1_m9_295200_541600 1.000000
R20628 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R20629 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R20630 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R20631 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R20632 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R20633 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R20634 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R20635 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R20636 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R20637 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R20638 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R20639 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R20640 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R20641 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R20642 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R20643 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R20644 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R20645 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R20646 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R20647 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R20648 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R20649 n1_m8_317600_474400 n1_m9_317600_474400 1.000000
R20650 n1_m8_317600_496800 n1_m9_317600_496800 1.000000
R20651 n1_m8_317600_519200 n1_m9_317600_519200 1.000000
R20652 n1_m8_317600_541600 n1_m9_317600_541600 1.000000
R20653 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R20654 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R20655 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R20656 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R20657 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R20658 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R20659 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R20660 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R20661 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R20662 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R20663 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R20664 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R20665 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R20666 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R20667 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R20668 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R20669 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R20670 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R20671 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R20672 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R20673 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R20674 n1_m8_340000_474400 n1_m9_340000_474400 1.000000
R20675 n1_m8_340000_496800 n1_m9_340000_496800 1.000000
R20676 n1_m8_340000_519200 n1_m9_340000_519200 1.000000
R20677 n1_m8_340000_541600 n1_m9_340000_541600 1.000000
R20678 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R20679 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R20680 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R20681 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R20682 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R20683 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R20684 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R20685 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R20686 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R20687 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R20688 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R20689 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R20690 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R20691 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R20692 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R20693 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R20694 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R20695 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R20696 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R20697 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R20698 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R20699 n1_m8_362400_474400 n1_m9_362400_474400 1.000000
R20700 n1_m8_362400_496800 n1_m9_362400_496800 1.000000
R20701 n1_m8_362400_519200 n1_m9_362400_519200 1.000000
R20702 n1_m8_362400_541600 n1_m9_362400_541600 1.000000
R20703 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R20704 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R20705 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R20706 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R20707 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R20708 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R20709 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R20710 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R20711 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R20712 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R20713 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R20714 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R20715 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R20716 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R20717 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R20718 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R20719 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R20720 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R20721 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R20722 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R20723 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R20724 n1_m8_384800_474400 n1_m9_384800_474400 1.000000
R20725 n1_m8_384800_496800 n1_m9_384800_496800 1.000000
R20726 n1_m8_384800_519200 n1_m9_384800_519200 1.000000
R20727 n1_m8_384800_541600 n1_m9_384800_541600 1.000000
R20728 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R20729 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R20730 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R20731 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R20732 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R20733 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R20734 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R20735 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R20736 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R20737 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R20738 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R20739 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R20740 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R20741 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R20742 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R20743 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R20744 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R20745 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R20746 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R20747 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R20748 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R20749 n1_m8_407200_474400 n1_m9_407200_474400 1.000000
R20750 n1_m8_407200_496800 n1_m9_407200_496800 1.000000
R20751 n1_m8_407200_519200 n1_m9_407200_519200 1.000000
R20752 n1_m8_407200_541600 n1_m9_407200_541600 1.000000
R20753 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R20754 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R20755 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R20756 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R20757 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R20758 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R20759 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R20760 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R20761 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R20762 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R20763 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R20764 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R20765 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R20766 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R20767 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R20768 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R20769 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R20770 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R20771 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R20772 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R20773 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R20774 n1_m8_429600_474400 n1_m9_429600_474400 1.000000
R20775 n1_m8_429600_496800 n1_m9_429600_496800 1.000000
R20776 n1_m8_429600_519200 n1_m9_429600_519200 1.000000
R20777 n1_m8_429600_541600 n1_m9_429600_541600 1.000000
R20778 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R20779 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R20780 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R20781 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R20782 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R20783 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R20784 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R20785 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R20786 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R20787 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R20788 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R20789 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R20790 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R20791 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R20792 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R20793 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R20794 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R20795 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R20796 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R20797 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R20798 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
R20799 n1_m8_452000_474400 n1_m9_452000_474400 1.000000
R20800 n1_m8_452000_496800 n1_m9_452000_496800 1.000000
R20801 n1_m8_452000_519200 n1_m9_452000_519200 1.000000
R20802 n1_m8_452000_541600 n1_m9_452000_541600 1.000000
R20803 n1_m8_474400_4000 n1_m9_474400_4000 1.000000
R20804 n1_m8_474400_26400 n1_m9_474400_26400 1.000000
R20805 n1_m8_474400_48800 n1_m9_474400_48800 1.000000
R20806 n1_m8_474400_71200 n1_m9_474400_71200 1.000000
R20807 n1_m8_474400_93600 n1_m9_474400_93600 1.000000
R20808 n1_m8_474400_116000 n1_m9_474400_116000 1.000000
R20809 n1_m8_474400_138400 n1_m9_474400_138400 1.000000
R20810 n1_m8_474400_160800 n1_m9_474400_160800 1.000000
R20811 n1_m8_474400_183200 n1_m9_474400_183200 1.000000
R20812 n1_m8_474400_205600 n1_m9_474400_205600 1.000000
R20813 n1_m8_474400_228000 n1_m9_474400_228000 1.000000
R20814 n1_m8_474400_250400 n1_m9_474400_250400 1.000000
R20815 n1_m8_474400_272800 n1_m9_474400_272800 1.000000
R20816 n1_m8_474400_295200 n1_m9_474400_295200 1.000000
R20817 n1_m8_474400_317600 n1_m9_474400_317600 1.000000
R20818 n1_m8_474400_340000 n1_m9_474400_340000 1.000000
R20819 n1_m8_474400_362400 n1_m9_474400_362400 1.000000
R20820 n1_m8_474400_384800 n1_m9_474400_384800 1.000000
R20821 n1_m8_474400_407200 n1_m9_474400_407200 1.000000
R20822 n1_m8_474400_429600 n1_m9_474400_429600 1.000000
R20823 n1_m8_474400_452000 n1_m9_474400_452000 1.000000
R20824 n1_m8_474400_474400 n1_m9_474400_474400 1.000000
R20825 n1_m8_474400_496800 n1_m9_474400_496800 1.000000
R20826 n1_m8_474400_519200 n1_m9_474400_519200 1.000000
R20827 n1_m8_474400_541600 n1_m9_474400_541600 1.000000
R20828 n1_m8_496800_4000 n1_m9_496800_4000 1.000000
R20829 n1_m8_496800_26400 n1_m9_496800_26400 1.000000
R20830 n1_m8_496800_48800 n1_m9_496800_48800 1.000000
R20831 n1_m8_496800_71200 n1_m9_496800_71200 1.000000
R20832 n1_m8_496800_93600 n1_m9_496800_93600 1.000000
R20833 n1_m8_496800_116000 n1_m9_496800_116000 1.000000
R20834 n1_m8_496800_138400 n1_m9_496800_138400 1.000000
R20835 n1_m8_496800_160800 n1_m9_496800_160800 1.000000
R20836 n1_m8_496800_183200 n1_m9_496800_183200 1.000000
R20837 n1_m8_496800_205600 n1_m9_496800_205600 1.000000
R20838 n1_m8_496800_228000 n1_m9_496800_228000 1.000000
R20839 n1_m8_496800_250400 n1_m9_496800_250400 1.000000
R20840 n1_m8_496800_272800 n1_m9_496800_272800 1.000000
R20841 n1_m8_496800_295200 n1_m9_496800_295200 1.000000
R20842 n1_m8_496800_317600 n1_m9_496800_317600 1.000000
R20843 n1_m8_496800_340000 n1_m9_496800_340000 1.000000
R20844 n1_m8_496800_362400 n1_m9_496800_362400 1.000000
R20845 n1_m8_496800_384800 n1_m9_496800_384800 1.000000
R20846 n1_m8_496800_407200 n1_m9_496800_407200 1.000000
R20847 n1_m8_496800_429600 n1_m9_496800_429600 1.000000
R20848 n1_m8_496800_452000 n1_m9_496800_452000 1.000000
R20849 n1_m8_496800_474400 n1_m9_496800_474400 1.000000
R20850 n1_m8_496800_496800 n1_m9_496800_496800 1.000000
R20851 n1_m8_496800_519200 n1_m9_496800_519200 1.000000
R20852 n1_m8_496800_541600 n1_m9_496800_541600 1.000000
R20853 n1_m8_519200_4000 n1_m9_519200_4000 1.000000
R20854 n1_m8_519200_26400 n1_m9_519200_26400 1.000000
R20855 n1_m8_519200_48800 n1_m9_519200_48800 1.000000
R20856 n1_m8_519200_71200 n1_m9_519200_71200 1.000000
R20857 n1_m8_519200_93600 n1_m9_519200_93600 1.000000
R20858 n1_m8_519200_116000 n1_m9_519200_116000 1.000000
R20859 n1_m8_519200_138400 n1_m9_519200_138400 1.000000
R20860 n1_m8_519200_160800 n1_m9_519200_160800 1.000000
R20861 n1_m8_519200_183200 n1_m9_519200_183200 1.000000
R20862 n1_m8_519200_205600 n1_m9_519200_205600 1.000000
R20863 n1_m8_519200_228000 n1_m9_519200_228000 1.000000
R20864 n1_m8_519200_250400 n1_m9_519200_250400 1.000000
R20865 n1_m8_519200_272800 n1_m9_519200_272800 1.000000
R20866 n1_m8_519200_295200 n1_m9_519200_295200 1.000000
R20867 n1_m8_519200_317600 n1_m9_519200_317600 1.000000
R20868 n1_m8_519200_340000 n1_m9_519200_340000 1.000000
R20869 n1_m8_519200_362400 n1_m9_519200_362400 1.000000
R20870 n1_m8_519200_384800 n1_m9_519200_384800 1.000000
R20871 n1_m8_519200_407200 n1_m9_519200_407200 1.000000
R20872 n1_m8_519200_429600 n1_m9_519200_429600 1.000000
R20873 n1_m8_519200_452000 n1_m9_519200_452000 1.000000
R20874 n1_m8_519200_474400 n1_m9_519200_474400 1.000000
R20875 n1_m8_519200_496800 n1_m9_519200_496800 1.000000
R20876 n1_m8_519200_519200 n1_m9_519200_519200 1.000000
R20877 n1_m8_519200_541600 n1_m9_519200_541600 1.000000
R20878 n1_m8_541600_4000 n1_m9_541600_4000 1.000000
R20879 n1_m8_541600_26400 n1_m9_541600_26400 1.000000
R20880 n1_m8_541600_48800 n1_m9_541600_48800 1.000000
R20881 n1_m8_541600_71200 n1_m9_541600_71200 1.000000
R20882 n1_m8_541600_93600 n1_m9_541600_93600 1.000000
R20883 n1_m8_541600_116000 n1_m9_541600_116000 1.000000
R20884 n1_m8_541600_138400 n1_m9_541600_138400 1.000000
R20885 n1_m8_541600_160800 n1_m9_541600_160800 1.000000
R20886 n1_m8_541600_183200 n1_m9_541600_183200 1.000000
R20887 n1_m8_541600_205600 n1_m9_541600_205600 1.000000
R20888 n1_m8_541600_228000 n1_m9_541600_228000 1.000000
R20889 n1_m8_541600_250400 n1_m9_541600_250400 1.000000
R20890 n1_m8_541600_272800 n1_m9_541600_272800 1.000000
R20891 n1_m8_541600_295200 n1_m9_541600_295200 1.000000
R20892 n1_m8_541600_317600 n1_m9_541600_317600 1.000000
R20893 n1_m8_541600_340000 n1_m9_541600_340000 1.000000
R20894 n1_m8_541600_362400 n1_m9_541600_362400 1.000000
R20895 n1_m8_541600_384800 n1_m9_541600_384800 1.000000
R20896 n1_m8_541600_407200 n1_m9_541600_407200 1.000000
R20897 n1_m8_541600_429600 n1_m9_541600_429600 1.000000
R20898 n1_m8_541600_452000 n1_m9_541600_452000 1.000000
R20899 n1_m8_541600_474400 n1_m9_541600_474400 1.000000
R20900 n1_m8_541600_496800 n1_m9_541600_496800 1.000000
R20901 n1_m8_541600_519200 n1_m9_541600_519200 1.000000
R20902 n1_m8_541600_541600 n1_m9_541600_541600 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_541600_250400 0 1.100000
V2 n1_m9_250400_452000 0 1.100000
V3 n1_m9_340000_340000 0 1.100000
R20903 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R20904 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R20905 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R20906 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R20907 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R20908 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R20909 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R20910 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R20911 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R20912 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R20913 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R20914 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R20915 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R20916 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R20917 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R20918 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R20919 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R20920 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R20921 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R20922 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R20923 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R20924 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R20925 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R20926 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R20927 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R20928 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R20929 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R20930 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R20931 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R20932 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R20933 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R20934 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R20935 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R20936 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R20937 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R20938 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R20939 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R20940 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R20941 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R20942 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R20943 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R20944 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R20945 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R20946 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R20947 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R20948 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R20949 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R20950 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R20951 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R20952 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R20953 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R20954 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R20955 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R20956 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R20957 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R20958 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R20959 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R20960 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R20961 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R20962 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R20963 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R20964 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R20965 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R20966 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R20967 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R20968 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R20969 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R20970 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R20971 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R20972 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R20973 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R20974 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R20975 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R20976 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R20977 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R20978 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R20979 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R20980 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R20981 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R20982 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R20983 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R20984 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R20985 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R20986 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R20987 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R20988 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R20989 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R20990 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R20991 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R20992 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R20993 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R20994 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R20995 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R20996 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R20997 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R20998 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R20999 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R21000 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R21001 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R21002 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R21003 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R21004 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R21005 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R21006 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R21007 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R21008 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R21009 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R21010 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R21011 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R21012 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R21013 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R21014 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R21015 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R21016 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R21017 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R21018 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R21019 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R21020 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R21021 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R21022 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
R21023 n1_m4_200000_470400 n1_m4_200000_475200 1.400000
R21024 n1_m1_200000_475200 n1_m4_200000_475200 15.000000
R21025 n1_m4_200000_475200 n1_m4_200000_480000 1.400000
R21026 n1_m1_200000_480000 n1_m4_200000_480000 15.000000
R21027 n1_m4_200000_480000 n1_m4_200000_484000 1.166667
R21028 n1_m4_200000_484000 n1_m7_200000_484000 9.000000
R21029 n1_m4_200000_484800 n1_m4_200000_484000 0.233333
R21030 n1_m1_200000_484800 n1_m4_200000_484800 15.000000
R21031 n1_m4_200000_484800 n1_m4_200000_489600 1.400000
R21032 n1_m1_200000_489600 n1_m4_200000_489600 15.000000
R21033 n1_m4_200000_489600 n1_m4_200000_494400 1.400000
R21034 n1_m1_200000_494400 n1_m4_200000_494400 15.000000
R21035 n1_m4_200000_494400 n1_m4_200000_499200 1.400000
R21036 n1_m1_200000_499200 n1_m4_200000_499200 15.000000
R21037 n1_m4_200000_499200 n1_m4_200000_504000 1.400000
R21038 n1_m1_200000_504000 n1_m4_200000_504000 15.000000
R21039 n1_m4_200000_504000 n1_m4_200000_508800 1.400000
R21040 n1_m1_200000_508800 n1_m4_200000_508800 15.000000
R21041 n1_m4_200000_508800 n1_m4_200000_513600 1.400000
R21042 n1_m1_200000_513600 n1_m4_200000_513600 15.000000
R21043 n1_m4_200000_513600 n1_m4_200000_518400 1.400000
R21044 n1_m1_200000_518400 n1_m4_200000_518400 15.000000
R21045 n1_m4_200000_518400 n1_m4_200000_523200 1.400000
R21046 n1_m1_200000_523200 n1_m4_200000_523200 15.000000
R21047 n1_m4_200000_523200 n1_m4_200000_528000 1.400000
R21048 n1_m1_200000_528000 n1_m4_200000_528000 15.000000
R21049 n1_m4_200000_528000 n1_m4_200000_532800 1.400000
R21050 n1_m1_200000_532800 n1_m4_200000_532800 15.000000
R21051 n1_m4_200000_532800 n1_m4_200000_537600 1.400000
R21052 n1_m1_200000_537600 n1_m4_200000_537600 15.000000
R21053 n1_m4_200000_537600 n1_m4_200000_542400 1.400000
R21054 n1_m1_200000_542400 n1_m4_200000_542400 15.000000
R21055 n1_m4_200000_542400 n1_m4_200000_547200 1.400000
R21056 n1_m1_200000_547200 n1_m4_200000_547200 15.000000
R21057 n1_m4_200000_547200 n1_m4_200000_552000 1.400000
R21058 n1_m1_200000_552000 n1_m4_200000_552000 15.000000
R21059 n1_m4_200000_552000 n1_m4_200000_556800 1.400000
R21060 n1_m1_200000_556800 n1_m4_200000_556800 15.000000
R21061 n1_m4_200000_556800 n1_m4_200000_561600 1.400000
R21062 n1_m1_200000_561600 n1_m4_200000_561600 15.000000
I0 n1_m1_0_0 0 1.684153e-07
I1 n1_m1_0_4800 0 1.686847e-07
I2 n1_m1_0_9600 0 2.342876e-07
I3 n1_m1_0_14400 0 1.434958e-07
I4 n1_m1_0_19200 0 1.436664e-07
I5 n1_m1_0_24000 0 2.208124e-07
I6 n1_m1_0_28800 0 1.443493e-07
I7 n1_m1_0_33600 0 2.087828e-07
I8 n1_m1_0_38400 0 1.393127e-07
I9 n1_m1_0_43200 0 1.399040e-07
I10 n1_m1_0_48000 0 2.112707e-07
I11 n1_m1_0_52800 0 1.414416e-07
I12 n1_m1_0_57600 0 2.149795e-07
I13 n1_m1_0_62400 0 1.476944e-07
I14 n1_m1_0_67200 0 1.480196e-07
I15 n1_m1_0_72000 0 2.315168e-07
I16 n1_m1_0_76800 0 1.732760e-07
I17 n1_m1_0_81600 0 2.394253e-07
I18 n1_m1_0_86400 0 1.577968e-07
I19 n1_m1_0_91200 0 1.619675e-07
I20 n1_m1_0_96000 0 2.326301e-07
I21 n1_m1_0_100800 0 1.598361e-07
I22 n1_m1_0_105600 0 2.567061e-07
I23 n1_m1_0_110400 0 2.363120e-07
I24 n1_m1_0_115200 0 2.612109e-07
I25 n1_m1_0_120000 0 3.114327e-07
I26 n1_m1_0_124800 0 2.039040e-07
I27 n1_m1_0_129600 0 3.084425e-07
I28 n1_m1_0_134400 0 2.428833e-07
I29 n1_m1_0_139200 0 2.574120e-07
I30 n1_m1_0_144000 0 3.431798e-07
I31 n1_m1_0_148800 0 2.367070e-07
I32 n1_m1_0_153600 0 3.359979e-07
I33 n1_m1_0_158400 0 2.219075e-07
I34 n1_m1_0_163200 0 2.718397e-07
I35 n1_m1_0_168000 0 4.143849e-07
I36 n1_m1_0_172800 0 2.323370e-07
I37 n1_m1_0_177600 0 2.925920e-07
I38 n1_m1_0_182400 0 1.847449e-07
I39 n1_m1_0_187200 0 1.935015e-07
I40 n1_m1_0_192000 0 3.226337e-07
I41 n1_m1_0_196800 0 1.963006e-07
I42 n1_m1_0_201600 0 2.796608e-07
I43 n1_m1_0_206400 0 1.979793e-07
I44 n1_m1_0_211200 0 1.941879e-07
I45 n1_m1_0_216000 0 4.507530e-07
I46 n1_m1_0_220800 0 2.221790e-07
I47 n1_m1_0_225600 0 3.387559e-07
I48 n1_m1_0_230400 0 3.022357e-07
I49 n1_m1_0_235200 0 2.867421e-07
I50 n1_m1_0_240000 0 3.559415e-07
I51 n1_m1_0_244800 0 3.101346e-07
I52 n1_m1_0_249600 0 4.149060e-07
I53 n1_m1_0_254400 0 1.966894e-07
I54 n1_m1_0_259200 0 1.796842e-07
I55 n1_m1_0_264000 0 3.227056e-07
I56 n1_m1_0_268800 0 2.423719e-07
I57 n1_m1_0_273600 0 3.427946e-07
I58 n1_m1_0_278400 0 2.130531e-07
I59 n1_m1_0_283200 0 2.113673e-07
I60 n1_m1_0_288000 0 3.252118e-07
I61 n1_m1_0_292800 0 2.189478e-07
I62 n1_m1_0_297600 0 3.292193e-07
I63 n1_m1_0_302400 0 2.170458e-07
I64 n1_m1_0_307200 0 2.137292e-07
I65 n1_m1_0_312000 0 3.159129e-07
I66 n1_m1_0_316800 0 1.823684e-07
I67 n1_m1_0_321600 0 3.176069e-07
I68 n1_m1_0_326400 0 1.777797e-07
I69 n1_m1_0_331200 0 2.103829e-07
I70 n1_m1_0_336000 0 3.413610e-07
I71 n1_m1_0_340800 0 2.063595e-07
I72 n1_m1_0_345600 0 3.935201e-07
I73 n1_m1_0_350400 0 3.332790e-07
I74 n1_m1_0_355200 0 3.213515e-07
I75 n1_m1_0_360000 0 3.740407e-07
I76 n1_m1_0_364800 0 2.268150e-07
I77 n1_m1_0_369600 0 4.497326e-07
I78 n1_m1_0_374400 0 3.493113e-07
I79 n1_m1_0_379200 0 2.252817e-07
I80 n1_m1_0_384000 0 2.371175e-07
I81 n1_m1_0_388800 0 1.595887e-07
I82 n1_m1_0_393600 0 2.532031e-07
I83 n1_m1_0_398400 0 1.515735e-07
I84 n1_m1_0_403200 0 1.554275e-07
I85 n1_m1_0_408000 0 2.465546e-07
I86 n1_m1_0_412800 0 1.570342e-07
I87 n1_m1_0_417600 0 2.666783e-07
I88 n1_m1_0_422400 0 1.725794e-07
I89 n1_m1_0_427200 0 1.637397e-07
I90 n1_m1_0_432000 0 2.407176e-07
I91 n1_m1_0_436800 0 1.522440e-07
I92 n1_m1_0_441600 0 2.546927e-07
I93 n1_m1_0_446400 0 1.691616e-07
I94 n1_m1_0_451200 0 1.439403e-07
I95 n1_m1_0_456000 0 2.251897e-07
I96 n1_m1_0_460800 0 1.505028e-07
I97 n1_m1_0_465600 0 2.235221e-07
I98 n1_m1_0_470400 0 1.573936e-07
I99 n1_m1_0_475200 0 1.676783e-07
I100 n1_m1_0_480000 0 2.459610e-07
I101 n1_m1_0_484800 0 1.555601e-07
I102 n1_m1_0_489600 0 2.222476e-07
I103 n1_m1_0_494400 0 1.520084e-07
I104 n1_m1_0_499200 0 1.547455e-07
I105 n1_m1_0_504000 0 2.361141e-07
I106 n1_m1_0_508800 0 1.598903e-07
I107 n1_m1_0_513600 0 2.318871e-07
I108 n1_m1_0_518400 0 1.475440e-07
I109 n1_m1_0_523200 0 1.467537e-07
I110 n1_m1_0_528000 0 2.277761e-07
I111 n1_m1_0_532800 0 1.582892e-07
I112 n1_m1_0_537600 0 2.331684e-07
I113 n1_m1_0_542400 0 1.445063e-07
I114 n1_m1_0_547200 0 1.414213e-07
I115 n1_m1_0_552000 0 2.086442e-07
I116 n1_m1_0_556800 0 1.344892e-07
I117 n1_m1_0_561600 0 6.703403e-08
I118 n1_m1_4800_0 0 8.729435e-08
I119 n1_m1_4800_4800 0 8.877994e-08
I120 n1_m1_4800_9600 0 1.248634e-07
I121 n1_m1_4800_14400 0 7.719366e-08
I122 n1_m1_4800_19200 0 7.692822e-08
I123 n1_m1_4800_24000 0 1.139876e-07
I124 n1_m1_4800_28800 0 7.238427e-08
I125 n1_m1_4800_33600 0 1.025719e-07
I126 n1_m1_4800_38400 0 6.865395e-08
I127 n1_m1_4800_43200 0 6.995199e-08
I128 n1_m1_4800_48000 0 1.080520e-07
I129 n1_m1_4800_52800 0 7.357008e-08
I130 n1_m1_4800_57600 0 1.141079e-07
I131 n1_m1_4800_62400 0 7.690446e-08
I132 n1_m1_4800_67200 0 7.783491e-08
I133 n1_m1_4800_72000 0 1.291100e-07
I134 n1_m1_4800_76800 0 8.904419e-08
I135 n1_m1_4800_81600 0 1.166242e-07
I136 n1_m1_4800_86400 0 8.299090e-08
I137 n1_m1_4800_91200 0 9.382732e-08
I138 n1_m1_4800_96000 0 1.429804e-07
I139 n1_m1_4800_100800 0 1.037570e-07
I140 n1_m1_4800_105600 0 1.737677e-07
I141 n1_m1_4800_110400 0 1.781771e-07
I142 n1_m1_4800_115200 0 1.715145e-07
I143 n1_m1_4800_120000 0 1.850960e-07
I144 n1_m1_4800_124800 0 1.336514e-07
I145 n1_m1_4800_129600 0 2.257812e-07
I146 n1_m1_4800_134400 0 1.906618e-07
I147 n1_m1_4800_139200 0 2.070277e-07
I148 n1_m1_4800_144000 0 2.894899e-07
I149 n1_m1_4800_148800 0 2.000664e-07
I150 n1_m1_4800_153600 0 2.677628e-07
I151 n1_m1_4800_158400 0 1.651432e-07
I152 n1_m1_4800_163200 0 1.909380e-07
I153 n1_m1_4800_168000 0 3.144170e-07
I154 n1_m1_4800_172800 0 1.867862e-07
I155 n1_m1_4800_177600 0 1.927900e-07
I156 n1_m1_4800_182400 0 1.211484e-07
I157 n1_m1_4800_187200 0 1.378897e-07
I158 n1_m1_4800_192000 0 2.500639e-07
I159 n1_m1_4800_196800 0 1.456076e-07
I160 n1_m1_4800_201600 0 1.943683e-07
I161 n1_m1_4800_206400 0 1.379898e-07
I162 n1_m1_4800_211200 0 1.171624e-07
I163 n1_m1_4800_216000 0 3.530677e-07
I164 n1_m1_4800_220800 0 1.349518e-07
I165 n1_m1_4800_225600 0 2.409037e-07
I166 n1_m1_4800_230400 0 1.436551e-07
I167 n1_m1_4800_235200 0 1.325980e-07
I168 n1_m1_4800_240000 0 3.165715e-07
I169 n1_m1_4800_244800 0 2.158221e-07
I170 n1_m1_4800_249600 0 3.229844e-07
I171 n1_m1_4800_254400 0 1.806076e-07
I172 n1_m1_4800_259200 0 1.493878e-07
I173 n1_m1_4800_264000 0 2.527635e-07
I174 n1_m1_4800_268800 0 2.269191e-07
I175 n1_m1_4800_273600 0 2.928382e-07
I176 n1_m1_4800_278400 0 1.288914e-07
I177 n1_m1_4800_283200 0 1.575871e-07
I178 n1_m1_4800_288000 0 2.407944e-07
I179 n1_m1_4800_292800 0 1.688250e-07
I180 n1_m1_4800_297600 0 2.647052e-07
I181 n1_m1_4800_302400 0 1.797122e-07
I182 n1_m1_4800_307200 0 1.759578e-07
I183 n1_m1_4800_312000 0 2.460074e-07
I184 n1_m1_4800_316800 0 1.203232e-07
I185 n1_m1_4800_321600 0 2.924809e-07
I186 n1_m1_4800_326400 0 1.211973e-07
I187 n1_m1_4800_331200 0 1.627728e-07
I188 n1_m1_4800_336000 0 2.506575e-07
I189 n1_m1_4800_340800 0 1.625582e-07
I190 n1_m1_4800_345600 0 3.143875e-07
I191 n1_m1_4800_350400 0 2.319375e-07
I192 n1_m1_4800_355200 0 2.368907e-07
I193 n1_m1_4800_360000 0 2.966851e-07
I194 n1_m1_4800_364800 0 1.816708e-07
I195 n1_m1_4800_369600 0 3.351459e-07
I196 n1_m1_4800_374400 0 2.342567e-07
I197 n1_m1_4800_379200 0 1.631710e-07
I198 n1_m1_4800_384000 0 1.453128e-07
I199 n1_m1_4800_388800 0 9.280930e-08
I200 n1_m1_4800_393600 0 1.286825e-07
I201 n1_m1_4800_398400 0 8.780900e-08
I202 n1_m1_4800_403200 0 8.735232e-08
I203 n1_m1_4800_408000 0 1.353619e-07
I204 n1_m1_4800_412800 0 9.194439e-08
I205 n1_m1_4800_417600 0 1.238425e-07
I206 n1_m1_4800_422400 0 8.936600e-08
I207 n1_m1_4800_427200 0 1.029193e-07
I208 n1_m1_4800_432000 0 1.351487e-07
I209 n1_m1_4800_436800 0 8.815972e-08
I210 n1_m1_4800_441600 0 1.227011e-07
I211 n1_m1_4800_446400 0 8.179627e-08
I212 n1_m1_4800_451200 0 7.947486e-08
I213 n1_m1_4800_456000 0 1.102074e-07
I214 n1_m1_4800_460800 0 7.615037e-08
I215 n1_m1_4800_465600 0 1.146198e-07
I216 n1_m1_4800_470400 0 7.442401e-08
I217 n1_m1_4800_475200 0 7.984126e-08
I218 n1_m1_4800_480000 0 1.357420e-07
I219 n1_m1_4800_484800 0 8.467604e-08
I220 n1_m1_4800_489600 0 1.145361e-07
I221 n1_m1_4800_494400 0 7.994513e-08
I222 n1_m1_4800_499200 0 7.994513e-08
I223 n1_m1_4800_504000 0 1.199177e-07
I224 n1_m1_4800_508800 0 7.973887e-08
I225 n1_m1_4800_513600 0 1.154723e-07
I226 n1_m1_4800_518400 0 7.345789e-08
I227 n1_m1_4800_523200 0 7.296890e-08
I228 n1_m1_4800_528000 0 1.102544e-07
I229 n1_m1_4800_532800 0 7.700656e-08
I230 n1_m1_4800_537600 0 1.163347e-07
I231 n1_m1_4800_542400 0 7.328303e-08
I232 n1_m1_4800_547200 0 7.347867e-08
I233 n1_m1_4800_552000 0 1.106523e-07
I234 n1_m1_4800_556800 0 6.985843e-08
I235 n1_m1_4800_561600 0 3.448870e-08
I236 n1_m1_9600_0 0 2.527524e-07
I237 n1_m1_9600_4800 0 2.540896e-07
I238 n1_m1_9600_9600 0 3.676751e-07
I239 n1_m1_9600_14400 0 2.359344e-07
I240 n1_m1_9600_19200 0 2.368686e-07
I241 n1_m1_9600_24000 0 3.530865e-07
I242 n1_m1_9600_28800 0 2.221914e-07
I243 n1_m1_9600_33600 0 3.077158e-07
I244 n1_m1_9600_38400 0 2.059618e-07
I245 n1_m1_9600_43200 0 2.098560e-07
I246 n1_m1_9600_48000 0 3.231447e-07
I247 n1_m1_9600_52800 0 2.249887e-07
I248 n1_m1_9600_57600 0 3.436691e-07
I249 n1_m1_9600_62400 0 2.361406e-07
I250 n1_m1_9600_67200 0 2.356057e-07
I251 n1_m1_9600_72000 0 3.506554e-07
I252 n1_m1_9600_76800 0 2.508968e-07
I253 n1_m1_9600_81600 0 3.649060e-07
I254 n1_m1_9600_86400 0 3.000810e-07
I255 n1_m1_9600_91200 0 3.626179e-07
I256 n1_m1_9600_96000 0 4.734618e-07
I257 n1_m1_9600_100800 0 2.659274e-07
I258 n1_m1_9600_105600 0 7.051700e-07
I259 n1_m1_9600_110400 0 6.740706e-07
I260 n1_m1_9600_115200 0 6.283464e-07
I261 n1_m1_9600_120000 0 7.939197e-07
I262 n1_m1_9600_124800 0 6.269369e-07
I263 n1_m1_9600_129600 0 1.007869e-06
I264 n1_m1_9600_134400 0 7.435724e-07
I265 n1_m1_9600_139200 0 7.656307e-07
I266 n1_m1_9600_144000 0 1.078874e-06
I267 n1_m1_9600_148800 0 7.593342e-07
I268 n1_m1_9600_153600 0 9.892990e-07
I269 n1_m1_9600_158400 0 5.515173e-07
I270 n1_m1_9600_163200 0 5.577143e-07
I271 n1_m1_9600_168000 0 9.145134e-07
I272 n1_m1_9600_172800 0 6.440540e-07
I273 n1_m1_9600_177600 0 1.073826e-06
I274 n1_m1_9600_182400 0 7.094692e-07
I275 n1_m1_9600_187200 0 7.289905e-07
I276 n1_m1_9600_192000 0 1.262251e-06
I277 n1_m1_9600_196800 0 8.761828e-07
I278 n1_m1_9600_201600 0 1.357310e-06
I279 n1_m1_9600_206400 0 9.895596e-07
I280 n1_m1_9600_211200 0 8.224635e-07
I281 n1_m1_9600_216000 0 1.465269e-06
I282 n1_m1_9600_220800 0 7.630175e-07
I283 n1_m1_9600_225600 0 1.366126e-06
I284 n1_m1_9600_230400 0 8.121101e-07
I285 n1_m1_9600_235200 0 8.411959e-07
I286 n1_m1_9600_240000 0 1.633770e-06
I287 n1_m1_9600_244800 0 8.096736e-07
I288 n1_m1_9600_249600 0 9.515059e-07
I289 n1_m1_9600_254400 0 6.533588e-07
I290 n1_m1_9600_259200 0 7.156733e-07
I291 n1_m1_9600_264000 0 8.963904e-07
I292 n1_m1_9600_268800 0 6.455964e-07
I293 n1_m1_9600_273600 0 8.809403e-07
I294 n1_m1_9600_278400 0 3.538565e-07
I295 n1_m1_9600_283200 0 4.900146e-07
I296 n1_m1_9600_288000 0 6.929115e-07
I297 n1_m1_9600_292800 0 4.550551e-07
I298 n1_m1_9600_297600 0 7.131803e-07
I299 n1_m1_9600_302400 0 4.925173e-07
I300 n1_m1_9600_307200 0 4.962175e-07
I301 n1_m1_9600_312000 0 7.383575e-07
I302 n1_m1_9600_316800 0 4.603733e-07
I303 n1_m1_9600_321600 0 1.215804e-06
I304 n1_m1_9600_326400 0 8.234188e-07
I305 n1_m1_9600_331200 0 8.293946e-07
I306 n1_m1_9600_336000 0 1.371935e-06
I307 n1_m1_9600_340800 0 8.946203e-07
I308 n1_m1_9600_345600 0 1.231804e-06
I309 n1_m1_9600_350400 0 7.634461e-07
I310 n1_m1_9600_355200 0 7.360597e-07
I311 n1_m1_9600_360000 0 9.904513e-07
I312 n1_m1_9600_364800 0 6.129937e-07
I313 n1_m1_9600_369600 0 9.527834e-07
I314 n1_m1_9600_374400 0 5.995626e-07
I315 n1_m1_9600_379200 0 4.513762e-07
I316 n1_m1_9600_384000 0 4.659214e-07
I317 n1_m1_9600_388800 0 3.069490e-07
I318 n1_m1_9600_393600 0 3.543578e-07
I319 n1_m1_9600_398400 0 2.845255e-07
I320 n1_m1_9600_403200 0 2.730899e-07
I321 n1_m1_9600_408000 0 3.855023e-07
I322 n1_m1_9600_412800 0 2.992354e-07
I323 n1_m1_9600_417600 0 3.631794e-07
I324 n1_m1_9600_422400 0 3.072195e-07
I325 n1_m1_9600_427200 0 4.985405e-07
I326 n1_m1_9600_432000 0 4.845242e-07
I327 n1_m1_9600_436800 0 3.124372e-07
I328 n1_m1_9600_441600 0 3.595682e-07
I329 n1_m1_9600_446400 0 2.453377e-07
I330 n1_m1_9600_451200 0 2.526144e-07
I331 n1_m1_9600_456000 0 3.357180e-07
I332 n1_m1_9600_460800 0 2.371390e-07
I333 n1_m1_9600_465600 0 3.487300e-07
I334 n1_m1_9600_470400 0 2.262051e-07
I335 n1_m1_9600_475200 0 2.499943e-07
I336 n1_m1_9600_480000 0 5.070196e-07
I337 n1_m1_9600_484800 0 2.735437e-07
I338 n1_m1_9600_489600 0 3.446760e-07
I339 n1_m1_9600_494400 0 2.367296e-07
I340 n1_m1_9600_499200 0 2.367296e-07
I341 n1_m1_9600_504000 0 3.550944e-07
I342 n1_m1_9600_508800 0 2.311528e-07
I343 n1_m1_9600_513600 0 3.322843e-07
I344 n1_m1_9600_518400 0 2.125945e-07
I345 n1_m1_9600_523200 0 2.114122e-07
I346 n1_m1_9600_528000 0 3.230466e-07
I347 n1_m1_9600_532800 0 2.319041e-07
I348 n1_m1_9600_537600 0 3.499147e-07
I349 n1_m1_9600_542400 0 2.214020e-07
I350 n1_m1_9600_547200 0 2.262081e-07
I351 n1_m1_9600_552000 0 3.505079e-07
I352 n1_m1_9600_556800 0 2.222121e-07
I353 n1_m1_9600_561600 0 1.102008e-07
I354 n1_m1_14400_0 0 1.415120e-07
I355 n1_m1_14400_4800 0 1.452756e-07
I356 n1_m1_14400_9600 0 2.192423e-07
I357 n1_m1_14400_14400 0 1.470831e-07
I358 n1_m1_14400_19200 0 1.526201e-07
I359 n1_m1_14400_24000 0 2.343329e-07
I360 n1_m1_14400_28800 0 1.479681e-07
I361 n1_m1_14400_33600 0 2.060201e-07
I362 n1_m1_14400_38400 0 1.377906e-07
I363 n1_m1_14400_43200 0 1.399040e-07
I364 n1_m1_14400_48000 0 2.104293e-07
I365 n1_m1_14400_52800 0 1.444430e-07
I366 n1_m1_14400_57600 0 2.194751e-07
I367 n1_m1_14400_62400 0 1.506191e-07
I368 n1_m1_14400_67200 0 1.513489e-07
I369 n1_m1_14400_72000 0 2.415340e-07
I370 n1_m1_14400_76800 0 1.807905e-07
I371 n1_m1_14400_81600 0 2.498131e-07
I372 n1_m1_14400_86400 0 1.731777e-07
I373 n1_m1_14400_91200 0 1.807515e-07
I374 n1_m1_14400_96000 0 2.529265e-07
I375 n1_m1_14400_100800 0 1.603835e-07
I376 n1_m1_14400_105600 0 2.600017e-07
I377 n1_m1_14400_110400 0 2.063370e-07
I378 n1_m1_14400_115200 0 2.004761e-07
I379 n1_m1_14400_120000 0 3.120234e-07
I380 n1_m1_14400_124800 0 2.846651e-07
I381 n1_m1_14400_129600 0 4.018690e-07
I382 n1_m1_14400_134400 0 2.246934e-07
I383 n1_m1_14400_139200 0 2.535160e-07
I384 n1_m1_14400_144000 0 4.957529e-07
I385 n1_m1_14400_148800 0 3.849977e-07
I386 n1_m1_14400_153600 0 5.184661e-07
I387 n1_m1_14400_158400 0 2.473409e-07
I388 n1_m1_14400_163200 0 2.116612e-07
I389 n1_m1_14400_168000 0 3.129757e-07
I390 n1_m1_14400_172800 0 2.205857e-07
I391 n1_m1_14400_177600 0 3.550008e-07
I392 n1_m1_14400_182400 0 2.282868e-07
I393 n1_m1_14400_187200 0 2.138398e-07
I394 n1_m1_14400_192000 0 3.537717e-07
I395 n1_m1_14400_196800 0 3.663867e-07
I396 n1_m1_14400_201600 0 7.717144e-07
I397 n1_m1_14400_206400 0 6.625316e-07
I398 n1_m1_14400_211200 0 6.545623e-07
I399 n1_m1_14400_216000 0 6.212014e-07
I400 n1_m1_14400_220800 0 5.036150e-07
I401 n1_m1_14400_225600 0 9.230699e-07
I402 n1_m1_14400_230400 0 7.158703e-07
I403 n1_m1_14400_235200 0 8.168738e-07
I404 n1_m1_14400_240000 0 7.531896e-07
I405 n1_m1_14400_244800 0 3.521447e-07
I406 n1_m1_14400_249600 0 4.174900e-07
I407 n1_m1_14400_254400 0 2.486218e-07
I408 n1_m1_14400_259200 0 4.571821e-07
I409 n1_m1_14400_264000 0 4.923135e-07
I410 n1_m1_14400_268800 0 2.110382e-07
I411 n1_m1_14400_273600 0 3.503148e-07
I412 n1_m1_14400_278400 0 1.986794e-07
I413 n1_m1_14400_283200 0 2.294841e-07
I414 n1_m1_14400_288000 0 3.161527e-07
I415 n1_m1_14400_292800 0 1.872971e-07
I416 n1_m1_14400_297600 0 2.644751e-07
I417 n1_m1_14400_302400 0 1.759137e-07
I418 n1_m1_14400_307200 0 1.859603e-07
I419 n1_m1_14400_312000 0 3.239770e-07
I420 n1_m1_14400_316800 0 2.080977e-07
I421 n1_m1_14400_321600 0 5.054876e-07
I422 n1_m1_14400_326400 0 6.984396e-07
I423 n1_m1_14400_331200 0 4.475675e-07
I424 n1_m1_14400_336000 0 9.848646e-07
I425 n1_m1_14400_340800 0 6.691556e-07
I426 n1_m1_14400_345600 0 4.472066e-07
I427 n1_m1_14400_350400 0 3.143933e-07
I428 n1_m1_14400_355200 0 3.032943e-07
I429 n1_m1_14400_360000 0 4.026918e-07
I430 n1_m1_14400_364800 0 2.369175e-07
I431 n1_m1_14400_369600 0 3.136615e-07
I432 n1_m1_14400_374400 0 1.884782e-07
I433 n1_m1_14400_379200 0 1.767735e-07
I434 n1_m1_14400_384000 0 2.577258e-07
I435 n1_m1_14400_388800 0 1.650634e-07
I436 n1_m1_14400_393600 0 2.288590e-07
I437 n1_m1_14400_398400 0 1.636924e-07
I438 n1_m1_14400_403200 0 1.583377e-07
I439 n1_m1_14400_408000 0 2.272139e-07
I440 n1_m1_14400_412800 0 1.677871e-07
I441 n1_m1_14400_417600 0 2.926337e-07
I442 n1_m1_14400_422400 0 1.968955e-07
I443 n1_m1_14400_427200 0 2.792380e-07
I444 n1_m1_14400_432000 0 3.078906e-07
I445 n1_m1_14400_436800 0 1.774643e-07
I446 n1_m1_14400_441600 0 2.313469e-07
I447 n1_m1_14400_446400 0 1.576022e-07
I448 n1_m1_14400_451200 0 1.611689e-07
I449 n1_m1_14400_456000 0 2.252880e-07
I450 n1_m1_14400_460800 0 1.512388e-07
I451 n1_m1_14400_465600 0 2.313550e-07
I452 n1_m1_14400_470400 0 1.672908e-07
I453 n1_m1_14400_475200 0 2.003450e-07
I454 n1_m1_14400_480000 0 3.688564e-07
I455 n1_m1_14400_484800 0 1.838722e-07
I456 n1_m1_14400_489600 0 2.299773e-07
I457 n1_m1_14400_494400 0 1.458844e-07
I458 n1_m1_14400_499200 0 1.458844e-07
I459 n1_m1_14400_504000 0 2.188267e-07
I460 n1_m1_14400_508800 0 1.423236e-07
I461 n1_m1_14400_513600 0 2.103593e-07
I462 n1_m1_14400_518400 0 1.399449e-07
I463 n1_m1_14400_523200 0 1.401820e-07
I464 n1_m1_14400_528000 0 2.223593e-07
I465 n1_m1_14400_532800 0 1.601999e-07
I466 n1_m1_14400_537600 0 2.376641e-07
I467 n1_m1_14400_542400 0 1.529496e-07
I468 n1_m1_14400_547200 0 1.551108e-07
I469 n1_m1_14400_552000 0 2.387882e-07
I470 n1_m1_14400_556800 0 1.506895e-07
I471 n1_m1_14400_561600 0 7.443943e-08
I472 n1_m1_19200_0 0 1.372190e-07
I473 n1_m1_19200_4800 0 1.411605e-07
I474 n1_m1_19200_9600 0 2.131063e-07
I475 n1_m1_19200_14400 0 1.416213e-07
I476 n1_m1_19200_19200 0 1.466474e-07
I477 n1_m1_19200_24000 0 2.256103e-07
I478 n1_m1_19200_28800 0 1.441041e-07
I479 n1_m1_19200_33600 0 2.094493e-07
I480 n1_m1_19200_38400 0 1.396799e-07
I481 n1_m1_19200_43200 0 1.399040e-07
I482 n1_m1_19200_48000 0 2.098347e-07
I483 n1_m1_19200_52800 0 1.396153e-07
I484 n1_m1_19200_57600 0 2.096031e-07
I485 n1_m1_19200_62400 0 1.409391e-07
I486 n1_m1_19200_67200 0 1.452746e-07
I487 n1_m1_19200_72000 0 2.907489e-07
I488 n1_m1_19200_76800 0 2.359943e-07
I489 n1_m1_19200_81600 0 2.536362e-07
I490 n1_m1_19200_86400 0 1.506003e-07
I491 n1_m1_19200_91200 0 1.530316e-07
I492 n1_m1_19200_96000 0 2.376580e-07
I493 n1_m1_19200_100800 0 1.779656e-07
I494 n1_m1_19200_105600 0 2.361586e-07
I495 n1_m1_19200_110400 0 1.639987e-07
I496 n1_m1_19200_115200 0 1.628155e-07
I497 n1_m1_19200_120000 0 2.422808e-07
I498 n1_m1_19200_124800 0 1.832166e-07
I499 n1_m1_19200_129600 0 2.698337e-07
I500 n1_m1_19200_134400 0 1.691553e-07
I501 n1_m1_19200_139200 0 1.756530e-07
I502 n1_m1_19200_144000 0 2.944605e-07
I503 n1_m1_19200_148800 0 2.323267e-07
I504 n1_m1_19200_153600 0 3.438635e-07
I505 n1_m1_19200_158400 0 1.885756e-07
I506 n1_m1_19200_163200 0 1.674619e-07
I507 n1_m1_19200_168000 0 2.395876e-07
I508 n1_m1_19200_172800 0 1.684143e-07
I509 n1_m1_19200_177600 0 2.948420e-07
I510 n1_m1_19200_182400 0 1.978101e-07
I511 n1_m1_19200_187200 0 1.868659e-07
I512 n1_m1_19200_192000 0 3.035942e-07
I513 n1_m1_19200_196800 0 3.444609e-07
I514 n1_m1_19200_201600 0 7.267104e-07
I515 n1_m1_19200_206400 0 6.109671e-07
I516 n1_m1_19200_211200 0 6.964776e-07
I517 n1_m1_19200_216000 0 7.186182e-07
I518 n1_m1_19200_220800 0 6.531347e-07
I519 n1_m1_19200_225600 0 1.352494e-06
I520 n1_m1_19200_230400 0 9.797070e-07
I521 n1_m1_19200_235200 0 9.987067e-07
I522 n1_m1_19200_240000 0 8.142820e-07
I523 n1_m1_19200_244800 0 2.614216e-07
I524 n1_m1_19200_249600 0 3.354519e-07
I525 n1_m1_19200_254400 0 1.855787e-07
I526 n1_m1_19200_259200 0 3.306602e-07
I527 n1_m1_19200_264000 0 3.506831e-07
I528 n1_m1_19200_268800 0 1.785060e-07
I529 n1_m1_19200_273600 0 3.161217e-07
I530 n1_m1_19200_278400 0 1.798188e-07
I531 n1_m1_19200_283200 0 1.839603e-07
I532 n1_m1_19200_288000 0 2.769085e-07
I533 n1_m1_19200_292800 0 1.708732e-07
I534 n1_m1_19200_297600 0 2.303536e-07
I535 n1_m1_19200_302400 0 1.488658e-07
I536 n1_m1_19200_307200 0 1.654262e-07
I537 n1_m1_19200_312000 0 3.319724e-07
I538 n1_m1_19200_316800 0 2.500158e-07
I539 n1_m1_19200_321600 0 5.752607e-07
I540 n1_m1_19200_326400 0 6.738698e-07
I541 n1_m1_19200_331200 0 4.512544e-07
I542 n1_m1_19200_336000 0 1.004666e-06
I543 n1_m1_19200_340800 0 6.700417e-07
I544 n1_m1_19200_345600 0 4.021635e-07
I545 n1_m1_19200_350400 0 2.126753e-07
I546 n1_m1_19200_355200 0 1.870638e-07
I547 n1_m1_19200_360000 0 2.644094e-07
I548 n1_m1_19200_364800 0 1.668273e-07
I549 n1_m1_19200_369600 0 2.358264e-07
I550 n1_m1_19200_374400 0 1.512278e-07
I551 n1_m1_19200_379200 0 1.554787e-07
I552 n1_m1_19200_384000 0 2.362006e-07
I553 n1_m1_19200_388800 0 1.554099e-07
I554 n1_m1_19200_393600 0 2.440513e-07
I555 n1_m1_19200_398400 0 1.500283e-07
I556 n1_m1_19200_403200 0 1.472254e-07
I557 n1_m1_19200_408000 0 2.207539e-07
I558 n1_m1_19200_412800 0 1.552239e-07
I559 n1_m1_19200_417600 0 5.154139e-07
I560 n1_m1_19200_422400 0 1.992291e-07
I561 n1_m1_19200_427200 0 1.853764e-07
I562 n1_m1_19200_432000 0 2.860770e-07
I563 n1_m1_19200_436800 0 1.583844e-07
I564 n1_m1_19200_441600 0 2.421920e-07
I565 n1_m1_19200_446400 0 1.568914e-07
I566 n1_m1_19200_451200 0 1.474456e-07
I567 n1_m1_19200_456000 0 2.292364e-07
I568 n1_m1_19200_460800 0 1.486613e-07
I569 n1_m1_19200_465600 0 2.323910e-07
I570 n1_m1_19200_470400 0 1.961255e-07
I571 n1_m1_19200_475200 0 2.664904e-07
I572 n1_m1_19200_480000 0 3.190308e-07
I573 n1_m1_19200_484800 0 1.721208e-07
I574 n1_m1_19200_489600 0 2.347062e-07
I575 n1_m1_19200_494400 0 1.404789e-07
I576 n1_m1_19200_499200 0 1.404789e-07
I577 n1_m1_19200_504000 0 2.107184e-07
I578 n1_m1_19200_508800 0 1.401014e-07
I579 n1_m1_19200_513600 0 2.108621e-07
I580 n1_m1_19200_518400 0 1.409227e-07
I581 n1_m1_19200_523200 0 1.420048e-07
I582 n1_m1_19200_528000 0 2.292594e-07
I583 n1_m1_19200_532800 0 1.652780e-07
I584 n1_m1_19200_537600 0 2.427276e-07
I585 n1_m1_19200_542400 0 1.532282e-07
I586 n1_m1_19200_547200 0 1.553027e-07
I587 n1_m1_19200_552000 0 2.356909e-07
I588 n1_m1_19200_556800 0 1.459556e-07
I589 n1_m1_19200_561600 0 7.205316e-08
I590 n1_m1_24000_0 0 2.253616e-07
I591 n1_m1_24000_4800 0 2.294792e-07
I592 n1_m1_24000_9600 0 3.385293e-07
I593 n1_m1_24000_14400 0 2.107808e-07
I594 n1_m1_24000_19200 0 2.120657e-07
I595 n1_m1_24000_24000 0 3.255595e-07
I596 n1_m1_24000_28800 0 2.104373e-07
I597 n1_m1_24000_33600 0 3.147839e-07
I598 n1_m1_24000_38400 0 2.098560e-07
I599 n1_m1_24000_43200 0 2.098560e-07
I600 n1_m1_24000_48000 0 3.144189e-07
I601 n1_m1_24000_52800 0 2.048970e-07
I602 n1_m1_24000_57600 0 3.060041e-07
I603 n1_m1_24000_62400 0 2.072090e-07
I604 n1_m1_24000_67200 0 2.128932e-07
I605 n1_m1_24000_72000 0 3.933858e-07
I606 n1_m1_24000_76800 0 3.276387e-07
I607 n1_m1_24000_81600 0 3.948927e-07
I608 n1_m1_24000_86400 0 2.361918e-07
I609 n1_m1_24000_91200 0 2.324357e-07
I610 n1_m1_24000_96000 0 3.470934e-07
I611 n1_m1_24000_100800 0 2.611468e-07
I612 n1_m1_24000_105600 0 3.761518e-07
I613 n1_m1_24000_110400 0 2.585635e-07
I614 n1_m1_24000_115200 0 2.400338e-07
I615 n1_m1_24000_120000 0 3.404895e-07
I616 n1_m1_24000_124800 0 2.432877e-07
I617 n1_m1_24000_129600 0 3.668628e-07
I618 n1_m1_24000_134400 0 2.438452e-07
I619 n1_m1_24000_139200 0 2.493074e-07
I620 n1_m1_24000_144000 0 3.787987e-07
I621 n1_m1_24000_148800 0 2.647611e-07
I622 n1_m1_24000_153600 0 4.115528e-07
I623 n1_m1_24000_158400 0 2.612498e-07
I624 n1_m1_24000_163200 0 2.411812e-07
I625 n1_m1_24000_168000 0 3.472854e-07
I626 n1_m1_24000_172800 0 2.336195e-07
I627 n1_m1_24000_177600 0 3.677760e-07
I628 n1_m1_24000_182400 0 2.597186e-07
I629 n1_m1_24000_187200 0 2.613585e-07
I630 n1_m1_24000_192000 0 4.088170e-07
I631 n1_m1_24000_196800 0 3.482017e-07
I632 n1_m1_24000_201600 0 5.640794e-07
I633 n1_m1_24000_206400 0 4.113479e-07
I634 n1_m1_24000_211200 0 4.796035e-07
I635 n1_m1_24000_216000 0 8.647822e-07
I636 n1_m1_24000_220800 0 6.907642e-07
I637 n1_m1_24000_225600 0 1.820897e-06
I638 n1_m1_24000_230400 0 1.056031e-06
I639 n1_m1_24000_235200 0 8.887233e-07
I640 n1_m1_24000_240000 0 1.060283e-06
I641 n1_m1_24000_244800 0 2.671978e-07
I642 n1_m1_24000_249600 0 4.046281e-07
I643 n1_m1_24000_254400 0 2.604432e-07
I644 n1_m1_24000_259200 0 2.760880e-07
I645 n1_m1_24000_264000 0 3.730224e-07
I646 n1_m1_24000_268800 0 2.717544e-07
I647 n1_m1_24000_273600 0 4.817319e-07
I648 n1_m1_24000_278400 0 2.487616e-07
I649 n1_m1_24000_283200 0 2.496606e-07
I650 n1_m1_24000_288000 0 3.789329e-07
I651 n1_m1_24000_292800 0 2.410379e-07
I652 n1_m1_24000_297600 0 3.349106e-07
I653 n1_m1_24000_302400 0 2.219237e-07
I654 n1_m1_24000_307200 0 2.449701e-07
I655 n1_m1_24000_312000 0 4.703730e-07
I656 n1_m1_24000_316800 0 3.239174e-07
I657 n1_m1_24000_321600 0 8.964345e-07
I658 n1_m1_24000_326400 0 4.092462e-07
I659 n1_m1_24000_331200 0 3.975957e-07
I660 n1_m1_24000_336000 0 7.657214e-07
I661 n1_m1_24000_340800 0 4.774661e-07
I662 n1_m1_24000_345600 0 5.075495e-07
I663 n1_m1_24000_350400 0 2.563031e-07
I664 n1_m1_24000_355200 0 2.467614e-07
I665 n1_m1_24000_360000 0 3.511909e-07
I666 n1_m1_24000_364800 0 2.328529e-07
I667 n1_m1_24000_369600 0 3.396855e-07
I668 n1_m1_24000_374400 0 2.219662e-07
I669 n1_m1_24000_379200 0 2.311928e-07
I670 n1_m1_24000_384000 0 3.535109e-07
I671 n1_m1_24000_388800 0 2.240340e-07
I672 n1_m1_24000_393600 0 3.516916e-07
I673 n1_m1_24000_398400 0 2.149677e-07
I674 n1_m1_24000_403200 0 2.139733e-07
I675 n1_m1_24000_408000 0 3.257592e-07
I676 n1_m1_24000_412800 0 2.242456e-07
I677 n1_m1_24000_417600 0 7.842280e-07
I678 n1_m1_24000_422400 0 2.840064e-07
I679 n1_m1_24000_427200 0 2.392844e-07
I680 n1_m1_24000_432000 0 3.830566e-07
I681 n1_m1_24000_436800 0 2.213669e-07
I682 n1_m1_24000_441600 0 3.655997e-07
I683 n1_m1_24000_446400 0 2.435600e-07
I684 n1_m1_24000_451200 0 2.193821e-07
I685 n1_m1_24000_456000 0 3.385400e-07
I686 n1_m1_24000_460800 0 2.197958e-07
I687 n1_m1_24000_465600 0 3.432793e-07
I688 n1_m1_24000_470400 0 3.050880e-07
I689 n1_m1_24000_475200 0 3.626195e-07
I690 n1_m1_24000_480000 0 4.075805e-07
I691 n1_m1_24000_484800 0 2.408632e-07
I692 n1_m1_24000_489600 0 3.508745e-07
I693 n1_m1_24000_494400 0 2.126654e-07
I694 n1_m1_24000_499200 0 2.116006e-07
I695 n1_m1_24000_504000 0 3.147839e-07
I696 n1_m1_24000_508800 0 2.117006e-07
I697 n1_m1_24000_513600 0 3.257373e-07
I698 n1_m1_24000_518400 0 2.197163e-07
I699 n1_m1_24000_523200 0 2.263159e-07
I700 n1_m1_24000_528000 0 3.452013e-07
I701 n1_m1_24000_532800 0 2.459700e-07
I702 n1_m1_24000_537600 0 3.621236e-07
I703 n1_m1_24000_542400 0 2.298422e-07
I704 n1_m1_24000_547200 0 2.329540e-07
I705 n1_m1_24000_552000 0 3.529517e-07
I706 n1_m1_24000_556800 0 2.197256e-07
I707 n1_m1_24000_561600 0 1.086708e-07
I708 n1_m1_28800_0 0 1.554568e-07
I709 n1_m1_28800_4800 0 1.551426e-07
I710 n1_m1_28800_9600 0 2.226192e-07
I711 n1_m1_28800_14400 0 1.402757e-07
I712 n1_m1_28800_19200 0 1.408464e-07
I713 n1_m1_28800_24000 0 2.171032e-07
I714 n1_m1_28800_28800 0 1.413831e-07
I715 n1_m1_28800_33600 0 2.098560e-07
I716 n1_m1_28800_38400 0 1.399040e-07
I717 n1_m1_28800_43200 0 1.399040e-07
I718 n1_m1_28800_48000 0 2.098560e-07
I719 n1_m1_28800_52800 0 1.399336e-07
I720 n1_m1_28800_57600 0 2.116641e-07
I721 n1_m1_28800_62400 0 1.386878e-07
I722 n1_m1_28800_67200 0 1.415868e-07
I723 n1_m1_28800_72000 0 2.210472e-07
I724 n1_m1_28800_76800 0 1.643387e-07
I725 n1_m1_28800_81600 0 2.395046e-07
I726 n1_m1_28800_86400 0 1.556525e-07
I727 n1_m1_28800_91200 0 1.546572e-07
I728 n1_m1_28800_96000 0 2.190955e-07
I729 n1_m1_28800_100800 0 1.502438e-07
I730 n1_m1_28800_105600 0 2.338181e-07
I731 n1_m1_28800_110400 0 1.731353e-07
I732 n1_m1_28800_115200 0 1.636696e-07
I733 n1_m1_28800_120000 0 2.293357e-07
I734 n1_m1_28800_124800 0 1.527114e-07
I735 n1_m1_28800_129600 0 2.203729e-07
I736 n1_m1_28800_134400 0 1.451810e-07
I737 n1_m1_28800_139200 0 1.544397e-07
I738 n1_m1_28800_144000 0 2.363446e-07
I739 n1_m1_28800_148800 0 1.554568e-07
I740 n1_m1_28800_153600 0 2.451227e-07
I741 n1_m1_28800_158400 0 1.654370e-07
I742 n1_m1_28800_163200 0 1.557316e-07
I743 n1_m1_28800_168000 0 2.313300e-07
I744 n1_m1_28800_172800 0 1.583729e-07
I745 n1_m1_28800_177600 0 2.403866e-07
I746 n1_m1_28800_182400 0 1.695966e-07
I747 n1_m1_28800_187200 0 1.699953e-07
I748 n1_m1_28800_192000 0 2.609688e-07
I749 n1_m1_28800_196800 0 1.921409e-07
I750 n1_m1_28800_201600 0 2.853572e-07
I751 n1_m1_28800_206400 0 1.822629e-07
I752 n1_m1_28800_211200 0 1.913171e-07
I753 n1_m1_28800_216000 0 3.973443e-07
I754 n1_m1_28800_220800 0 2.947855e-07
I755 n1_m1_28800_225600 0 7.144047e-07
I756 n1_m1_28800_230400 0 4.154773e-07
I757 n1_m1_28800_235200 0 3.775811e-07
I758 n1_m1_28800_240000 0 4.906483e-07
I759 n1_m1_28800_244800 0 1.701937e-07
I760 n1_m1_28800_249600 0 2.502309e-07
I761 n1_m1_28800_254400 0 1.568238e-07
I762 n1_m1_28800_259200 0 1.538587e-07
I763 n1_m1_28800_264000 0 2.383854e-07
I764 n1_m1_28800_268800 0 1.662794e-07
I765 n1_m1_28800_273600 0 2.533835e-07
I766 n1_m1_28800_278400 0 1.637203e-07
I767 n1_m1_28800_283200 0 1.603316e-07
I768 n1_m1_28800_288000 0 2.292159e-07
I769 n1_m1_28800_292800 0 1.499844e-07
I770 n1_m1_28800_297600 0 2.252296e-07
I771 n1_m1_28800_302400 0 1.542822e-07
I772 n1_m1_28800_307200 0 1.597794e-07
I773 n1_m1_28800_312000 0 2.484344e-07
I774 n1_m1_28800_316800 0 1.915007e-07
I775 n1_m1_28800_321600 0 5.376064e-07
I776 n1_m1_28800_326400 0 1.962507e-07
I777 n1_m1_28800_331200 0 2.208856e-07
I778 n1_m1_28800_336000 0 3.305066e-07
I779 n1_m1_28800_340800 0 2.024678e-07
I780 n1_m1_28800_345600 0 3.126729e-07
I781 n1_m1_28800_350400 0 1.650416e-07
I782 n1_m1_28800_355200 0 1.556560e-07
I783 n1_m1_28800_360000 0 2.274944e-07
I784 n1_m1_28800_364800 0 1.600636e-07
I785 n1_m1_28800_369600 0 2.396348e-07
I786 n1_m1_28800_374400 0 1.476777e-07
I787 n1_m1_28800_379200 0 1.495131e-07
I788 n1_m1_28800_384000 0 2.341184e-07
I789 n1_m1_28800_388800 0 1.526445e-07
I790 n1_m1_28800_393600 0 2.049784e-07
I791 n1_m1_28800_398400 0 1.461630e-07
I792 n1_m1_28800_403200 0 1.475048e-07
I793 n1_m1_28800_408000 0 2.136629e-07
I794 n1_m1_28800_412800 0 1.493037e-07
I795 n1_m1_28800_417600 0 2.520665e-07
I796 n1_m1_28800_422400 0 1.576981e-07
I797 n1_m1_28800_427200 0 1.588713e-07
I798 n1_m1_28800_432000 0 2.316129e-07
I799 n1_m1_28800_436800 0 1.482109e-07
I800 n1_m1_28800_441600 0 2.254743e-07
I801 n1_m1_28800_446400 0 1.566432e-07
I802 n1_m1_28800_451200 0 1.497307e-07
I803 n1_m1_28800_456000 0 2.136229e-07
I804 n1_m1_28800_460800 0 1.427354e-07
I805 n1_m1_28800_465600 0 2.232228e-07
I806 n1_m1_28800_470400 0 1.625888e-07
I807 n1_m1_28800_475200 0 1.637226e-07
I808 n1_m1_28800_480000 0 2.337388e-07
I809 n1_m1_28800_484800 0 1.520239e-07
I810 n1_m1_28800_489600 0 2.279528e-07
I811 n1_m1_28800_494400 0 1.465661e-07
I812 n1_m1_28800_499200 0 1.440411e-07
I813 n1_m1_28800_504000 0 2.098560e-07
I814 n1_m1_28800_508800 0 1.428227e-07
I815 n1_m1_28800_513600 0 2.165240e-07
I816 n1_m1_28800_518400 0 1.447092e-07
I817 n1_m1_28800_523200 0 1.477822e-07
I818 n1_m1_28800_528000 0 2.200485e-07
I819 n1_m1_28800_532800 0 1.552622e-07
I820 n1_m1_28800_537600 0 2.330354e-07
I821 n1_m1_28800_542400 0 1.518989e-07
I822 n1_m1_28800_547200 0 1.553027e-07
I823 n1_m1_28800_552000 0 2.368039e-07
I824 n1_m1_28800_556800 0 1.515212e-07
I825 n1_m1_28800_561600 0 7.529826e-08
I826 n1_m1_33600_0 0 1.548225e-07
I827 n1_m1_33600_4800 0 1.515324e-07
I828 n1_m1_33600_9600 0 2.124042e-07
I829 n1_m1_33600_14400 0 1.407702e-07
I830 n1_m1_33600_19200 0 1.444441e-07
I831 n1_m1_33600_24000 0 2.215517e-07
I832 n1_m1_33600_28800 0 1.490080e-07
I833 n1_m1_33600_33600 0 2.135490e-07
I834 n1_m1_33600_38400 0 1.399040e-07
I835 n1_m1_33600_43200 0 1.399040e-07
I836 n1_m1_33600_48000 0 2.098560e-07
I837 n1_m1_33600_52800 0 1.399307e-07
I838 n1_m1_33600_57600 0 2.131960e-07
I839 n1_m1_33600_62400 0 1.462138e-07
I840 n1_m1_33600_67200 0 1.465661e-07
I841 n1_m1_33600_72000 0 2.295160e-07
I842 n1_m1_33600_76800 0 1.703339e-07
I843 n1_m1_33600_81600 0 2.310633e-07
I844 n1_m1_33600_86400 0 1.445627e-07
I845 n1_m1_33600_91200 0 1.475855e-07
I846 n1_m1_33600_96000 0 2.229685e-07
I847 n1_m1_33600_100800 0 1.514382e-07
I848 n1_m1_33600_105600 0 2.367950e-07
I849 n1_m1_33600_110400 0 1.660193e-07
I850 n1_m1_33600_115200 0 1.618232e-07
I851 n1_m1_33600_120000 0 2.332790e-07
I852 n1_m1_33600_124800 0 1.511998e-07
I853 n1_m1_33600_129600 0 2.158782e-07
I854 n1_m1_33600_134400 0 1.408558e-07
I855 n1_m1_33600_139200 0 1.452533e-07
I856 n1_m1_33600_144000 0 2.263726e-07
I857 n1_m1_33600_148800 0 1.543168e-07
I858 n1_m1_33600_153600 0 2.303705e-07
I859 n1_m1_33600_158400 0 1.492367e-07
I860 n1_m1_33600_163200 0 1.485694e-07
I861 n1_m1_33600_168000 0 2.243419e-07
I862 n1_m1_33600_172800 0 1.537142e-07
I863 n1_m1_33600_177600 0 2.310857e-07
I864 n1_m1_33600_182400 0 1.603661e-07
I865 n1_m1_33600_187200 0 1.565077e-07
I866 n1_m1_33600_192000 0 2.616740e-07
I867 n1_m1_33600_196800 0 3.428761e-07
I868 n1_m1_33600_201600 0 5.658116e-07
I869 n1_m1_33600_206400 0 2.103669e-07
I870 n1_m1_33600_211200 0 1.848736e-07
I871 n1_m1_33600_216000 0 2.610345e-07
I872 n1_m1_33600_220800 0 2.691554e-07
I873 n1_m1_33600_225600 0 8.421153e-07
I874 n1_m1_33600_230400 0 4.505962e-07
I875 n1_m1_33600_235200 0 4.417418e-07
I876 n1_m1_33600_240000 0 4.407280e-07
I877 n1_m1_33600_244800 0 1.671524e-07
I878 n1_m1_33600_249600 0 2.409129e-07
I879 n1_m1_33600_254400 0 1.526634e-07
I880 n1_m1_33600_259200 0 1.526614e-07
I881 n1_m1_33600_264000 0 2.304310e-07
I882 n1_m1_33600_268800 0 1.492699e-07
I883 n1_m1_33600_273600 0 2.250251e-07
I884 n1_m1_33600_278400 0 1.553024e-07
I885 n1_m1_33600_283200 0 1.563524e-07
I886 n1_m1_33600_288000 0 2.290081e-07
I887 n1_m1_33600_292800 0 1.500011e-07
I888 n1_m1_33600_297600 0 2.247294e-07
I889 n1_m1_33600_302400 0 1.540130e-07
I890 n1_m1_33600_307200 0 1.509047e-07
I891 n1_m1_33600_312000 0 2.294982e-07
I892 n1_m1_33600_316800 0 1.641258e-07
I893 n1_m1_33600_321600 0 2.355055e-07
I894 n1_m1_33600_326400 0 1.858748e-07
I895 n1_m1_33600_331200 0 2.567946e-07
I896 n1_m1_33600_336000 0 2.552192e-07
I897 n1_m1_33600_340800 0 1.566540e-07
I898 n1_m1_33600_345600 0 2.409232e-07
I899 n1_m1_33600_350400 0 1.591478e-07
I900 n1_m1_33600_355200 0 1.656159e-07
I901 n1_m1_33600_360000 0 2.514145e-07
I902 n1_m1_33600_364800 0 1.551043e-07
I903 n1_m1_33600_369600 0 2.323626e-07
I904 n1_m1_33600_374400 0 1.458351e-07
I905 n1_m1_33600_379200 0 1.420638e-07
I906 n1_m1_33600_384000 0 2.283683e-07
I907 n1_m1_33600_388800 0 1.579185e-07
I908 n1_m1_33600_393600 0 2.232174e-07
I909 n1_m1_33600_398400 0 1.612054e-07
I910 n1_m1_33600_403200 0 1.604841e-07
I911 n1_m1_33600_408000 0 2.804144e-07
I912 n1_m1_33600_412800 0 2.142245e-07
I913 n1_m1_33600_417600 0 2.392971e-07
I914 n1_m1_33600_422400 0 1.511957e-07
I915 n1_m1_33600_427200 0 1.533305e-07
I916 n1_m1_33600_432000 0 2.235081e-07
I917 n1_m1_33600_436800 0 1.503073e-07
I918 n1_m1_33600_441600 0 2.136006e-07
I919 n1_m1_33600_446400 0 1.429339e-07
I920 n1_m1_33600_451200 0 1.480025e-07
I921 n1_m1_33600_456000 0 2.189699e-07
I922 n1_m1_33600_460800 0 1.447287e-07
I923 n1_m1_33600_465600 0 2.218044e-07
I924 n1_m1_33600_470400 0 1.467924e-07
I925 n1_m1_33600_475200 0 1.462386e-07
I926 n1_m1_33600_480000 0 2.138019e-07
I927 n1_m1_33600_484800 0 1.419073e-07
I928 n1_m1_33600_489600 0 2.128610e-07
I929 n1_m1_33600_494400 0 1.419073e-07
I930 n1_m1_33600_499200 0 1.411481e-07
I931 n1_m1_33600_504000 0 2.098560e-07
I932 n1_m1_33600_508800 0 1.399040e-07
I933 n1_m1_33600_513600 0 2.098560e-07
I934 n1_m1_33600_518400 0 1.399040e-07
I935 n1_m1_33600_523200 0 1.399040e-07
I936 n1_m1_33600_528000 0 2.113200e-07
I937 n1_m1_33600_532800 0 1.473840e-07
I938 n1_m1_33600_537600 0 2.259363e-07
I939 n1_m1_33600_542400 0 1.492333e-07
I940 n1_m1_33600_547200 0 1.553027e-07
I941 n1_m1_33600_552000 0 2.366593e-07
I942 n1_m1_33600_556800 0 1.485639e-07
I943 n1_m1_33600_561600 0 7.349636e-08
I944 n1_m1_38400_0 0 1.511670e-07
I945 n1_m1_38400_4800 0 1.493862e-07
I946 n1_m1_38400_9600 0 2.161759e-07
I947 n1_m1_38400_14400 0 1.405567e-07
I948 n1_m1_38400_19200 0 1.422760e-07
I949 n1_m1_38400_24000 0 2.148449e-07
I950 n1_m1_38400_28800 0 1.442323e-07
I951 n1_m1_38400_33600 0 2.119139e-07
I952 n1_m1_38400_38400 0 1.399040e-07
I953 n1_m1_38400_43200 0 1.399040e-07
I954 n1_m1_38400_48000 0 2.098560e-07
I955 n1_m1_38400_52800 0 1.399040e-07
I956 n1_m1_38400_57600 0 2.111659e-07
I957 n1_m1_38400_62400 0 1.460623e-07
I958 n1_m1_38400_67200 0 1.465661e-07
I959 n1_m1_38400_72000 0 2.302043e-07
I960 n1_m1_38400_76800 0 1.733560e-07
I961 n1_m1_38400_81600 0 2.348742e-07
I962 n1_m1_38400_86400 0 1.469133e-07
I963 n1_m1_38400_91200 0 1.499651e-07
I964 n1_m1_38400_96000 0 2.180444e-07
I965 n1_m1_38400_100800 0 1.443986e-07
I966 n1_m1_38400_105600 0 2.298994e-07
I967 n1_m1_38400_110400 0 1.550359e-07
I968 n1_m1_38400_115200 0 1.501875e-07
I969 n1_m1_38400_120000 0 2.229995e-07
I970 n1_m1_38400_124800 0 1.451888e-07
I971 n1_m1_38400_129600 0 2.102531e-07
I972 n1_m1_38400_134400 0 1.399040e-07
I973 n1_m1_38400_139200 0 1.409064e-07
I974 n1_m1_38400_144000 0 2.189956e-07
I975 n1_m1_38400_148800 0 1.508852e-07
I976 n1_m1_38400_153600 0 2.245124e-07
I977 n1_m1_38400_158400 0 1.469379e-07
I978 n1_m1_38400_163200 0 1.467289e-07
I979 n1_m1_38400_168000 0 2.264736e-07
I980 n1_m1_38400_172800 0 1.550497e-07
I981 n1_m1_38400_177600 0 2.254474e-07
I982 n1_m1_38400_182400 0 1.547664e-07
I983 n1_m1_38400_187200 0 1.519331e-07
I984 n1_m1_38400_192000 0 2.547237e-07
I985 n1_m1_38400_196800 0 3.547780e-07
I986 n1_m1_38400_201600 0 5.676588e-07
I987 n1_m1_38400_206400 0 2.019309e-07
I988 n1_m1_38400_211200 0 1.690908e-07
I989 n1_m1_38400_216000 0 2.453907e-07
I990 n1_m1_38400_220800 0 2.479902e-07
I991 n1_m1_38400_225600 0 8.282847e-07
I992 n1_m1_38400_230400 0 3.555313e-07
I993 n1_m1_38400_235200 0 3.424030e-07
I994 n1_m1_38400_240000 0 3.885903e-07
I995 n1_m1_38400_244800 0 1.591971e-07
I996 n1_m1_38400_249600 0 2.394264e-07
I997 n1_m1_38400_254400 0 1.546329e-07
I998 n1_m1_38400_259200 0 1.532282e-07
I999 n1_m1_38400_264000 0 2.223266e-07
I1000 n1_m1_38400_268800 0 1.465661e-07
I1001 n1_m1_38400_273600 0 2.198491e-07
I1002 n1_m1_38400_278400 0 1.483798e-07
I1003 n1_m1_38400_283200 0 1.530800e-07
I1004 n1_m1_38400_288000 0 2.298422e-07
I1005 n1_m1_38400_292800 0 1.520317e-07
I1006 n1_m1_38400_297600 0 2.224746e-07
I1007 n1_m1_38400_302400 0 1.484831e-07
I1008 n1_m1_38400_307200 0 1.474761e-07
I1009 n1_m1_38400_312000 0 2.288547e-07
I1010 n1_m1_38400_316800 0 1.656362e-07
I1011 n1_m1_38400_321600 0 2.336689e-07
I1012 n1_m1_38400_326400 0 1.716684e-07
I1013 n1_m1_38400_331200 0 2.251015e-07
I1014 n1_m1_38400_336000 0 2.394370e-07
I1015 n1_m1_38400_340800 0 1.555189e-07
I1016 n1_m1_38400_345600 0 2.220372e-07
I1017 n1_m1_38400_350400 0 1.612977e-07
I1018 n1_m1_38400_355200 0 1.895395e-07
I1019 n1_m1_38400_360000 0 2.785783e-07
I1020 n1_m1_38400_364800 0 1.558302e-07
I1021 n1_m1_38400_369600 0 2.338231e-07
I1022 n1_m1_38400_374400 0 1.528592e-07
I1023 n1_m1_38400_379200 0 1.467714e-07
I1024 n1_m1_38400_384000 0 2.297035e-07
I1025 n1_m1_38400_388800 0 1.504261e-07
I1026 n1_m1_38400_393600 0 2.275641e-07
I1027 n1_m1_38400_398400 0 1.542524e-07
I1028 n1_m1_38400_403200 0 1.577673e-07
I1029 n1_m1_38400_408000 0 3.714575e-07
I1030 n1_m1_38400_412800 0 3.097812e-07
I1031 n1_m1_38400_417600 0 2.901618e-07
I1032 n1_m1_38400_422400 0 1.655584e-07
I1033 n1_m1_38400_427200 0 1.502477e-07
I1034 n1_m1_38400_432000 0 2.301697e-07
I1035 n1_m1_38400_436800 0 1.497904e-07
I1036 n1_m1_38400_441600 0 2.144080e-07
I1037 n1_m1_38400_446400 0 1.394298e-07
I1038 n1_m1_38400_451200 0 1.396957e-07
I1039 n1_m1_38400_456000 0 2.149119e-07
I1040 n1_m1_38400_460800 0 1.417841e-07
I1041 n1_m1_38400_465600 0 2.183660e-07
I1042 n1_m1_38400_470400 0 1.460994e-07
I1043 n1_m1_38400_475200 0 1.429579e-07
I1044 n1_m1_38400_480000 0 2.103803e-07
I1045 n1_m1_38400_484800 0 1.399040e-07
I1046 n1_m1_38400_489600 0 2.098560e-07
I1047 n1_m1_38400_494400 0 1.399040e-07
I1048 n1_m1_38400_499200 0 1.399040e-07
I1049 n1_m1_38400_504000 0 2.098560e-07
I1050 n1_m1_38400_508800 0 1.399040e-07
I1051 n1_m1_38400_513600 0 2.098560e-07
I1052 n1_m1_38400_518400 0 1.399040e-07
I1053 n1_m1_38400_523200 0 1.402006e-07
I1054 n1_m1_38400_528000 0 2.206421e-07
I1055 n1_m1_38400_532800 0 1.502382e-07
I1056 n1_m1_38400_537600 0 2.206259e-07
I1057 n1_m1_38400_542400 0 1.467951e-07
I1058 n1_m1_38400_547200 0 1.578349e-07
I1059 n1_m1_38400_552000 0 2.502340e-07
I1060 n1_m1_38400_556800 0 1.551839e-07
I1061 n1_m1_38400_561600 0 7.638517e-08
I1062 n1_m1_43200_0 0 1.473571e-07
I1063 n1_m1_43200_4800 0 1.495758e-07
I1064 n1_m1_43200_9600 0 2.279343e-07
I1065 n1_m1_43200_14400 0 1.464833e-07
I1066 n1_m1_43200_19200 0 1.431857e-07
I1067 n1_m1_43200_24000 0 2.103102e-07
I1068 n1_m1_43200_28800 0 1.399040e-07
I1069 n1_m1_43200_33600 0 2.098560e-07
I1070 n1_m1_43200_38400 0 1.399040e-07
I1071 n1_m1_43200_43200 0 1.399040e-07
I1072 n1_m1_43200_48000 0 2.098560e-07
I1073 n1_m1_43200_52800 0 1.399040e-07
I1074 n1_m1_43200_57600 0 2.111659e-07
I1075 n1_m1_43200_62400 0 1.460623e-07
I1076 n1_m1_43200_67200 0 1.461922e-07
I1077 n1_m1_43200_72000 0 2.246468e-07
I1078 n1_m1_43200_76800 0 1.679749e-07
I1079 n1_m1_43200_81600 0 2.301514e-07
I1080 n1_m1_43200_86400 0 1.452501e-07
I1081 n1_m1_43200_91200 0 1.483080e-07
I1082 n1_m1_43200_96000 0 2.111678e-07
I1083 n1_m1_43200_100800 0 1.389708e-07
I1084 n1_m1_43200_105600 0 2.211091e-07
I1085 n1_m1_43200_110400 0 1.493775e-07
I1086 n1_m1_43200_115200 0 1.470569e-07
I1087 n1_m1_43200_120000 0 2.198491e-07
I1088 n1_m1_43200_124800 0 1.458880e-07
I1089 n1_m1_43200_129600 0 2.152560e-07
I1090 n1_m1_43200_134400 0 1.433773e-07
I1091 n1_m1_43200_139200 0 1.420362e-07
I1092 n1_m1_43200_144000 0 2.123667e-07
I1093 n1_m1_43200_148800 0 1.430928e-07
I1094 n1_m1_43200_153600 0 2.183720e-07
I1095 n1_m1_43200_158400 0 1.465661e-07
I1096 n1_m1_43200_163200 0 1.468328e-07
I1097 n1_m1_43200_168000 0 2.297533e-07
I1098 n1_m1_43200_172800 0 1.578027e-07
I1099 n1_m1_43200_177600 0 2.258380e-07
I1100 n1_m1_43200_182400 0 1.497549e-07
I1101 n1_m1_43200_187200 0 1.498455e-07
I1102 n1_m1_43200_192000 0 2.453305e-07
I1103 n1_m1_43200_196800 0 2.526702e-07
I1104 n1_m1_43200_201600 0 3.808441e-07
I1105 n1_m1_43200_206400 0 1.763913e-07
I1106 n1_m1_43200_211200 0 1.657198e-07
I1107 n1_m1_43200_216000 0 2.383136e-07
I1108 n1_m1_43200_220800 0 2.040070e-07
I1109 n1_m1_43200_225600 0 5.536333e-07
I1110 n1_m1_43200_230400 0 2.155647e-07
I1111 n1_m1_43200_235200 0 2.187290e-07
I1112 n1_m1_43200_240000 0 2.898328e-07
I1113 n1_m1_43200_244800 0 1.567489e-07
I1114 n1_m1_43200_249600 0 2.394264e-07
I1115 n1_m1_43200_254400 0 1.546329e-07
I1116 n1_m1_43200_259200 0 1.532282e-07
I1117 n1_m1_43200_264000 0 2.257041e-07
I1118 n1_m1_43200_268800 0 1.469709e-07
I1119 n1_m1_43200_273600 0 2.198491e-07
I1120 n1_m1_43200_278400 0 1.483798e-07
I1121 n1_m1_43200_283200 0 1.530800e-07
I1122 n1_m1_43200_288000 0 2.298422e-07
I1123 n1_m1_43200_292800 0 1.532282e-07
I1124 n1_m1_43200_297600 0 2.240337e-07
I1125 n1_m1_43200_302400 0 1.465661e-07
I1126 n1_m1_43200_307200 0 1.488219e-07
I1127 n1_m1_43200_312000 0 2.296415e-07
I1128 n1_m1_43200_316800 0 1.613511e-07
I1129 n1_m1_43200_321600 0 2.395205e-07
I1130 n1_m1_43200_326400 0 1.623765e-07
I1131 n1_m1_43200_331200 0 1.745532e-07
I1132 n1_m1_43200_336000 0 2.369019e-07
I1133 n1_m1_43200_340800 0 1.699664e-07
I1134 n1_m1_43200_345600 0 2.196084e-07
I1135 n1_m1_43200_350400 0 1.529294e-07
I1136 n1_m1_43200_355200 0 1.763510e-07
I1137 n1_m1_43200_360000 0 2.555610e-07
I1138 n1_m1_43200_364800 0 1.495607e-07
I1139 n1_m1_43200_369600 0 2.294623e-07
I1140 n1_m1_43200_374400 0 1.577784e-07
I1141 n1_m1_43200_379200 0 1.522830e-07
I1142 n1_m1_43200_384000 0 2.329879e-07
I1143 n1_m1_43200_388800 0 1.476044e-07
I1144 n1_m1_43200_393600 0 2.248305e-07
I1145 n1_m1_43200_398400 0 1.519629e-07
I1146 n1_m1_43200_403200 0 1.602262e-07
I1147 n1_m1_43200_408000 0 3.882254e-07
I1148 n1_m1_43200_412800 0 3.241375e-07
I1149 n1_m1_43200_417600 0 3.156052e-07
I1150 n1_m1_43200_422400 0 1.803144e-07
I1151 n1_m1_43200_427200 0 1.529314e-07
I1152 n1_m1_43200_432000 0 2.340782e-07
I1153 n1_m1_43200_436800 0 1.481094e-07
I1154 n1_m1_43200_441600 0 2.194140e-07
I1155 n1_m1_43200_446400 0 1.429031e-07
I1156 n1_m1_43200_451200 0 1.381394e-07
I1157 n1_m1_43200_456000 0 2.098560e-07
I1158 n1_m1_43200_460800 0 1.399040e-07
I1159 n1_m1_43200_465600 0 2.174190e-07
I1160 n1_m1_43200_470400 0 1.462001e-07
I1161 n1_m1_43200_475200 0 1.438794e-07
I1162 n1_m1_43200_480000 0 2.140956e-07
I1163 n1_m1_43200_484800 0 1.399689e-07
I1164 n1_m1_43200_489600 0 2.098560e-07
I1165 n1_m1_43200_494400 0 1.399040e-07
I1166 n1_m1_43200_499200 0 1.399040e-07
I1167 n1_m1_43200_504000 0 2.098560e-07
I1168 n1_m1_43200_508800 0 1.399040e-07
I1169 n1_m1_43200_513600 0 2.098560e-07
I1170 n1_m1_43200_518400 0 1.399040e-07
I1171 n1_m1_43200_523200 0 1.403900e-07
I1172 n1_m1_43200_528000 0 2.258309e-07
I1173 n1_m1_43200_532800 0 1.487695e-07
I1174 n1_m1_43200_537600 0 2.137249e-07
I1175 n1_m1_43200_542400 0 1.452384e-07
I1176 n1_m1_43200_547200 0 1.594517e-07
I1177 n1_m1_43200_552000 0 2.597683e-07
I1178 n1_m1_43200_556800 0 1.593975e-07
I1179 n1_m1_43200_561600 0 7.807077e-08
I1180 n1_m1_48000_0 0 2.297515e-07
I1181 n1_m1_48000_4800 0 2.398101e-07
I1182 n1_m1_48000_9600 0 3.752572e-07
I1183 n1_m1_48000_14400 0 2.444671e-07
I1184 n1_m1_48000_19200 0 2.257029e-07
I1185 n1_m1_48000_24000 0 3.169033e-07
I1186 n1_m1_48000_28800 0 2.119228e-07
I1187 n1_m1_48000_33600 0 3.197079e-07
I1188 n1_m1_48000_38400 0 2.098560e-07
I1189 n1_m1_48000_43200 0 2.098560e-07
I1190 n1_m1_48000_48000 0 3.147839e-07
I1191 n1_m1_48000_52800 0 2.098560e-07
I1192 n1_m1_48000_57600 0 3.167488e-07
I1193 n1_m1_48000_62400 0 2.190934e-07
I1194 n1_m1_48000_67200 0 2.188148e-07
I1195 n1_m1_48000_72000 0 3.287613e-07
I1196 n1_m1_48000_76800 0 2.393206e-07
I1197 n1_m1_48000_81600 0 3.304465e-07
I1198 n1_m1_48000_86400 0 2.152793e-07
I1199 n1_m1_48000_91200 0 2.198491e-07
I1200 n1_m1_48000_96000 0 3.190851e-07
I1201 n1_m1_48000_100800 0 2.238020e-07
I1202 n1_m1_48000_105600 0 3.413916e-07
I1203 n1_m1_48000_110400 0 2.267857e-07
I1204 n1_m1_48000_115200 0 2.264768e-07
I1205 n1_m1_48000_120000 0 3.374984e-07
I1206 n1_m1_48000_124800 0 2.202406e-07
I1207 n1_m1_48000_129600 0 3.297966e-07
I1208 n1_m1_48000_134400 0 2.198491e-07
I1209 n1_m1_48000_139200 0 2.162881e-07
I1210 n1_m1_48000_144000 0 3.205272e-07
I1211 n1_m1_48000_148800 0 2.167086e-07
I1212 n1_m1_48000_153600 0 3.288575e-07
I1213 n1_m1_48000_158400 0 2.198717e-07
I1214 n1_m1_48000_163200 0 2.197030e-07
I1215 n1_m1_48000_168000 0 3.366054e-07
I1216 n1_m1_48000_172800 0 2.321610e-07
I1217 n1_m1_48000_177600 0 3.401196e-07
I1218 n1_m1_48000_182400 0 2.198491e-07
I1219 n1_m1_48000_187200 0 2.250104e-07
I1220 n1_m1_48000_192000 0 3.701199e-07
I1221 n1_m1_48000_196800 0 2.670043e-07
I1222 n1_m1_48000_201600 0 3.919582e-07
I1223 n1_m1_48000_206400 0 2.478271e-07
I1224 n1_m1_48000_211200 0 2.390604e-07
I1225 n1_m1_48000_216000 0 3.457702e-07
I1226 n1_m1_48000_220800 0 2.595791e-07
I1227 n1_m1_48000_225600 0 5.778263e-07
I1228 n1_m1_48000_230400 0 2.520076e-07
I1229 n1_m1_48000_235200 0 2.563092e-07
I1230 n1_m1_48000_240000 0 3.739159e-07
I1231 n1_m1_48000_244800 0 2.318407e-07
I1232 n1_m1_48000_249600 0 3.501798e-07
I1233 n1_m1_48000_254400 0 2.303356e-07
I1234 n1_m1_48000_259200 0 2.294570e-07
I1235 n1_m1_48000_264000 0 3.426896e-07
I1236 n1_m1_48000_268800 0 2.209689e-07
I1237 n1_m1_48000_273600 0 3.297737e-07
I1238 n1_m1_48000_278400 0 2.241558e-07
I1239 n1_m1_48000_283200 0 2.353168e-07
I1240 n1_m1_48000_288000 0 3.502995e-07
I1241 n1_m1_48000_292800 0 2.296647e-07
I1242 n1_m1_48000_297600 0 3.358085e-07
I1243 n1_m1_48000_302400 0 2.198491e-07
I1244 n1_m1_48000_307200 0 2.223051e-07
I1245 n1_m1_48000_312000 0 3.425412e-07
I1246 n1_m1_48000_316800 0 2.337739e-07
I1247 n1_m1_48000_321600 0 3.560147e-07
I1248 n1_m1_48000_326400 0 2.436188e-07
I1249 n1_m1_48000_331200 0 2.678690e-07
I1250 n1_m1_48000_336000 0 3.720069e-07
I1251 n1_m1_48000_340800 0 2.720547e-07
I1252 n1_m1_48000_345600 0 3.648418e-07
I1253 n1_m1_48000_350400 0 3.292994e-07
I1254 n1_m1_48000_355200 0 3.988655e-07
I1255 n1_m1_48000_360000 0 4.571987e-07
I1256 n1_m1_48000_364800 0 2.283556e-07
I1257 n1_m1_48000_369600 0 3.465098e-07
I1258 n1_m1_48000_374400 0 2.306069e-07
I1259 n1_m1_48000_379200 0 2.193966e-07
I1260 n1_m1_48000_384000 0 3.333077e-07
I1261 n1_m1_48000_388800 0 2.218900e-07
I1262 n1_m1_48000_393600 0 3.398212e-07
I1263 n1_m1_48000_398400 0 2.348513e-07
I1264 n1_m1_48000_403200 0 2.452477e-07
I1265 n1_m1_48000_408000 0 4.499282e-07
I1266 n1_m1_48000_412800 0 3.384106e-07
I1267 n1_m1_48000_417600 0 5.870672e-07
I1268 n1_m1_48000_422400 0 2.919258e-07
I1269 n1_m1_48000_427200 0 2.312780e-07
I1270 n1_m1_48000_432000 0 3.506607e-07
I1271 n1_m1_48000_436800 0 2.216506e-07
I1272 n1_m1_48000_441600 0 3.416818e-07
I1273 n1_m1_48000_446400 0 2.256127e-07
I1274 n1_m1_48000_451200 0 2.193329e-07
I1275 n1_m1_48000_456000 0 3.136487e-07
I1276 n1_m1_48000_460800 0 2.082490e-07
I1277 n1_m1_48000_465600 0 3.257525e-07
I1278 n1_m1_48000_470400 0 2.198056e-07
I1279 n1_m1_48000_475200 0 2.198491e-07
I1280 n1_m1_48000_480000 0 3.269820e-07
I1281 n1_m1_48000_484800 0 2.100427e-07
I1282 n1_m1_48000_489600 0 3.147839e-07
I1283 n1_m1_48000_494400 0 2.098560e-07
I1284 n1_m1_48000_499200 0 2.098560e-07
I1285 n1_m1_48000_504000 0 3.147839e-07
I1286 n1_m1_48000_508800 0 2.098560e-07
I1287 n1_m1_48000_513600 0 3.147839e-07
I1288 n1_m1_48000_518400 0 2.098560e-07
I1289 n1_m1_48000_523200 0 2.101459e-07
I1290 n1_m1_48000_528000 0 3.240225e-07
I1291 n1_m1_48000_532800 0 2.150122e-07
I1292 n1_m1_48000_537600 0 3.248330e-07
I1293 n1_m1_48000_542400 0 2.243002e-07
I1294 n1_m1_48000_547200 0 2.432149e-07
I1295 n1_m1_48000_552000 0 3.806155e-07
I1296 n1_m1_48000_556800 0 2.313997e-07
I1297 n1_m1_48000_561600 0 1.138148e-07
I1298 n1_m1_52800_0 0 1.561537e-07
I1299 n1_m1_52800_4800 0 1.642983e-07
I1300 n1_m1_52800_9600 0 2.580347e-07
I1301 n1_m1_52800_14400 0 1.692517e-07
I1302 n1_m1_52800_19200 0 1.529078e-07
I1303 n1_m1_52800_24000 0 2.115753e-07
I1304 n1_m1_52800_28800 0 1.420911e-07
I1305 n1_m1_52800_33600 0 2.150666e-07
I1306 n1_m1_52800_38400 0 1.399040e-07
I1307 n1_m1_52800_43200 0 1.399040e-07
I1308 n1_m1_52800_48000 0 2.098560e-07
I1309 n1_m1_52800_52800 0 1.399040e-07
I1310 n1_m1_52800_57600 0 2.111659e-07
I1311 n1_m1_52800_62400 0 1.460623e-07
I1312 n1_m1_52800_67200 0 1.464123e-07
I1313 n1_m1_52800_72000 0 2.231339e-07
I1314 n1_m1_52800_76800 0 1.562924e-07
I1315 n1_m1_52800_81600 0 2.159823e-07
I1316 n1_m1_52800_86400 0 1.435678e-07
I1317 n1_m1_52800_91200 0 1.466146e-07
I1318 n1_m1_52800_96000 0 2.238734e-07
I1319 n1_m1_52800_100800 0 1.727075e-07
I1320 n1_m1_52800_105600 0 2.517014e-07
I1321 n1_m1_52800_110400 0 1.630762e-07
I1322 n1_m1_52800_115200 0 1.588874e-07
I1323 n1_m1_52800_120000 0 2.305616e-07
I1324 n1_m1_52800_124800 0 1.507098e-07
I1325 n1_m1_52800_129600 0 2.201611e-07
I1326 n1_m1_52800_134400 0 1.465238e-07
I1327 n1_m1_52800_139200 0 1.480151e-07
I1328 n1_m1_52800_144000 0 2.268150e-07
I1329 n1_m1_52800_148800 0 1.553032e-07
I1330 n1_m1_52800_153600 0 2.293342e-07
I1331 n1_m1_52800_158400 0 1.468861e-07
I1332 n1_m1_52800_163200 0 1.425209e-07
I1333 n1_m1_52800_168000 0 2.188371e-07
I1334 n1_m1_52800_172800 0 1.488403e-07
I1335 n1_m1_52800_177600 0 2.259651e-07
I1336 n1_m1_52800_182400 0 1.465661e-07
I1337 n1_m1_52800_187200 0 1.507816e-07
I1338 n1_m1_52800_192000 0 2.452517e-07
I1339 n1_m1_52800_196800 0 1.639737e-07
I1340 n1_m1_52800_201600 0 2.430556e-07
I1341 n1_m1_52800_206400 0 1.687466e-07
I1342 n1_m1_52800_211200 0 1.533685e-07
I1343 n1_m1_52800_216000 0 2.273891e-07
I1344 n1_m1_52800_220800 0 1.759429e-07
I1345 n1_m1_52800_225600 0 4.225385e-07
I1346 n1_m1_52800_230400 0 1.792828e-07
I1347 n1_m1_52800_235200 0 1.707867e-07
I1348 n1_m1_52800_240000 0 2.427816e-07
I1349 n1_m1_52800_244800 0 1.531393e-07
I1350 n1_m1_52800_249600 0 2.293931e-07
I1351 n1_m1_52800_254400 0 1.490793e-07
I1352 n1_m1_52800_259200 0 1.479945e-07
I1353 n1_m1_52800_264000 0 2.217694e-07
I1354 n1_m1_52800_268800 0 1.467326e-07
I1355 n1_m1_52800_273600 0 2.198812e-07
I1356 n1_m1_52800_278400 0 1.488334e-07
I1357 n1_m1_52800_283200 0 1.544786e-07
I1358 n1_m1_52800_288000 0 2.311995e-07
I1359 n1_m1_52800_292800 0 1.508162e-07
I1360 n1_m1_52800_297600 0 2.207463e-07
I1361 n1_m1_52800_302400 0 1.465661e-07
I1362 n1_m1_52800_307200 0 1.465661e-07
I1363 n1_m1_52800_312000 0 2.275413e-07
I1364 n1_m1_52800_316800 0 1.569066e-07
I1365 n1_m1_52800_321600 0 2.270476e-07
I1366 n1_m1_52800_326400 0 1.824246e-07
I1367 n1_m1_52800_331200 0 2.582005e-07
I1368 n1_m1_52800_336000 0 2.577960e-07
I1369 n1_m1_52800_340800 0 1.733127e-07
I1370 n1_m1_52800_345600 0 2.926044e-07
I1371 n1_m1_52800_350400 0 2.978216e-07
I1372 n1_m1_52800_355200 0 3.499773e-07
I1373 n1_m1_52800_360000 0 3.630693e-07
I1374 n1_m1_52800_364800 0 1.635823e-07
I1375 n1_m1_52800_369600 0 2.380367e-07
I1376 n1_m1_52800_374400 0 1.511852e-07
I1377 n1_m1_52800_379200 0 1.412024e-07
I1378 n1_m1_52800_384000 0 2.155980e-07
I1379 n1_m1_52800_388800 0 1.473321e-07
I1380 n1_m1_52800_393600 0 2.207216e-07
I1381 n1_m1_52800_398400 0 1.596138e-07
I1382 n1_m1_52800_403200 0 1.634914e-07
I1383 n1_m1_52800_408000 0 2.643290e-07
I1384 n1_m1_52800_412800 0 2.268081e-07
I1385 n1_m1_52800_417600 0 9.808860e-07
I1386 n1_m1_52800_422400 0 3.275164e-07
I1387 n1_m1_52800_427200 0 1.759713e-07
I1388 n1_m1_52800_432000 0 2.549826e-07
I1389 n1_m1_52800_436800 0 1.516796e-07
I1390 n1_m1_52800_441600 0 2.363388e-07
I1391 n1_m1_52800_446400 0 1.509754e-07
I1392 n1_m1_52800_451200 0 1.480137e-07
I1393 n1_m1_52800_456000 0 2.096539e-07
I1394 n1_m1_52800_460800 0 1.395989e-07
I1395 n1_m1_52800_465600 0 2.124302e-07
I1396 n1_m1_52800_470400 0 1.459848e-07
I1397 n1_m1_52800_475200 0 1.465598e-07
I1398 n1_m1_52800_480000 0 2.178974e-07
I1399 n1_m1_52800_484800 0 1.400268e-07
I1400 n1_m1_52800_489600 0 2.098560e-07
I1401 n1_m1_52800_494400 0 1.399040e-07
I1402 n1_m1_52800_499200 0 1.399040e-07
I1403 n1_m1_52800_504000 0 2.098560e-07
I1404 n1_m1_52800_508800 0 1.399040e-07
I1405 n1_m1_52800_513600 0 2.098560e-07
I1406 n1_m1_52800_518400 0 1.399040e-07
I1407 n1_m1_52800_523200 0 1.400949e-07
I1408 n1_m1_52800_528000 0 2.175807e-07
I1409 n1_m1_52800_532800 0 1.512330e-07
I1410 n1_m1_52800_537600 0 2.320936e-07
I1411 n1_m1_52800_542400 0 1.548254e-07
I1412 n1_m1_52800_547200 0 1.605685e-07
I1413 n1_m1_52800_552000 0 2.421027e-07
I1414 n1_m1_52800_556800 0 1.551252e-07
I1415 n1_m1_52800_561600 0 7.700115e-08
I1416 n1_m1_57600_0 0 1.504557e-07
I1417 n1_m1_57600_4800 0 1.558546e-07
I1418 n1_m1_57600_9600 0 2.430300e-07
I1419 n1_m1_57600_14400 0 1.563858e-07
I1420 n1_m1_57600_19200 0 1.445384e-07
I1421 n1_m1_57600_24000 0 2.103614e-07
I1422 n1_m1_57600_28800 0 1.405469e-07
I1423 n1_m1_57600_33600 0 2.113877e-07
I1424 n1_m1_57600_38400 0 1.399040e-07
I1425 n1_m1_57600_43200 0 1.399040e-07
I1426 n1_m1_57600_48000 0 2.098560e-07
I1427 n1_m1_57600_52800 0 1.399040e-07
I1428 n1_m1_57600_57600 0 2.111659e-07
I1429 n1_m1_57600_62400 0 1.460623e-07
I1430 n1_m1_57600_67200 0 1.465661e-07
I1431 n1_m1_57600_72000 0 2.228923e-07
I1432 n1_m1_57600_76800 0 1.528818e-07
I1433 n1_m1_57600_81600 0 2.158626e-07
I1434 n1_m1_57600_86400 0 1.460864e-07
I1435 n1_m1_57600_91200 0 1.491498e-07
I1436 n1_m1_57600_96000 0 2.265241e-07
I1437 n1_m1_57600_100800 0 1.810477e-07
I1438 n1_m1_57600_105600 0 2.586683e-07
I1439 n1_m1_57600_110400 0 1.657640e-07
I1440 n1_m1_57600_115200 0 1.607730e-07
I1441 n1_m1_57600_120000 0 2.359654e-07
I1442 n1_m1_57600_124800 0 1.518831e-07
I1443 n1_m1_57600_129600 0 2.202462e-07
I1444 n1_m1_57600_134400 0 1.443190e-07
I1445 n1_m1_57600_139200 0 1.480612e-07
I1446 n1_m1_57600_144000 0 2.369370e-07
I1447 n1_m1_57600_148800 0 1.592404e-07
I1448 n1_m1_57600_153600 0 2.362891e-07
I1449 n1_m1_57600_158400 0 1.476348e-07
I1450 n1_m1_57600_163200 0 1.412320e-07
I1451 n1_m1_57600_168000 0 2.133533e-07
I1452 n1_m1_57600_172800 0 1.466802e-07
I1453 n1_m1_57600_177600 0 2.216077e-07
I1454 n1_m1_57600_182400 0 1.465661e-07
I1455 n1_m1_57600_187200 0 1.493034e-07
I1456 n1_m1_57600_192000 0 2.373104e-07
I1457 n1_m1_57600_196800 0 1.606707e-07
I1458 n1_m1_57600_201600 0 2.454170e-07
I1459 n1_m1_57600_206400 0 1.705813e-07
I1460 n1_m1_57600_211200 0 1.562814e-07
I1461 n1_m1_57600_216000 0 2.479254e-07
I1462 n1_m1_57600_220800 0 1.880526e-07
I1463 n1_m1_57600_225600 0 4.903660e-07
I1464 n1_m1_57600_230400 0 2.132340e-07
I1465 n1_m1_57600_235200 0 1.691697e-07
I1466 n1_m1_57600_240000 0 2.308632e-07
I1467 n1_m1_57600_244800 0 1.484983e-07
I1468 n1_m1_57600_249600 0 2.226289e-07
I1469 n1_m1_57600_254400 0 1.469735e-07
I1470 n1_m1_57600_259200 0 1.465661e-07
I1471 n1_m1_57600_264000 0 2.198491e-07
I1472 n1_m1_57600_268800 0 1.465661e-07
I1473 n1_m1_57600_273600 0 2.215576e-07
I1474 n1_m1_57600_278400 0 1.518220e-07
I1475 n1_m1_57600_283200 0 1.531852e-07
I1476 n1_m1_57600_288000 0 2.298422e-07
I1477 n1_m1_57600_292800 0 1.501579e-07
I1478 n1_m1_57600_297600 0 2.198491e-07
I1479 n1_m1_57600_302400 0 1.465661e-07
I1480 n1_m1_57600_307200 0 1.465661e-07
I1481 n1_m1_57600_312000 0 2.271498e-07
I1482 n1_m1_57600_316800 0 1.542047e-07
I1483 n1_m1_57600_321600 0 2.262569e-07
I1484 n1_m1_57600_326400 0 2.164970e-07
I1485 n1_m1_57600_331200 0 3.607657e-07
I1486 n1_m1_57600_336000 0 3.284576e-07
I1487 n1_m1_57600_340800 0 2.511197e-07
I1488 n1_m1_57600_345600 0 6.069737e-07
I1489 n1_m1_57600_350400 0 4.156012e-07
I1490 n1_m1_57600_355200 0 3.778308e-07
I1491 n1_m1_57600_360000 0 3.991084e-07
I1492 n1_m1_57600_364800 0 1.728058e-07
I1493 n1_m1_57600_369600 0 2.404827e-07
I1494 n1_m1_57600_374400 0 1.556156e-07
I1495 n1_m1_57600_379200 0 1.464834e-07
I1496 n1_m1_57600_384000 0 2.269732e-07
I1497 n1_m1_57600_388800 0 1.545303e-07
I1498 n1_m1_57600_393600 0 2.265313e-07
I1499 n1_m1_57600_398400 0 1.608665e-07
I1500 n1_m1_57600_403200 0 1.704782e-07
I1501 n1_m1_57600_408000 0 5.041929e-07
I1502 n1_m1_57600_412800 0 5.283917e-07
I1503 n1_m1_57600_417600 0 1.563510e-06
I1504 n1_m1_57600_422400 0 6.544530e-07
I1505 n1_m1_57600_427200 0 3.463666e-07
I1506 n1_m1_57600_432000 0 5.552787e-07
I1507 n1_m1_57600_436800 0 1.886441e-07
I1508 n1_m1_57600_441600 0 2.955246e-07
I1509 n1_m1_57600_446400 0 1.595939e-07
I1510 n1_m1_57600_451200 0 1.525121e-07
I1511 n1_m1_57600_456000 0 2.139125e-07
I1512 n1_m1_57600_460800 0 1.446338e-07
I1513 n1_m1_57600_465600 0 2.172585e-07
I1514 n1_m1_57600_470400 0 1.463477e-07
I1515 n1_m1_57600_475200 0 1.462336e-07
I1516 n1_m1_57600_480000 0 2.131698e-07
I1517 n1_m1_57600_484800 0 1.399401e-07
I1518 n1_m1_57600_489600 0 2.098560e-07
I1519 n1_m1_57600_494400 0 1.399040e-07
I1520 n1_m1_57600_499200 0 1.399040e-07
I1521 n1_m1_57600_504000 0 2.098560e-07
I1522 n1_m1_57600_508800 0 1.399040e-07
I1523 n1_m1_57600_513600 0 2.098560e-07
I1524 n1_m1_57600_518400 0 1.399040e-07
I1525 n1_m1_57600_523200 0 1.401470e-07
I1526 n1_m1_57600_528000 0 2.196891e-07
I1527 n1_m1_57600_532800 0 1.523881e-07
I1528 n1_m1_57600_537600 0 2.226572e-07
I1529 n1_m1_57600_542400 0 1.445420e-07
I1530 n1_m1_57600_547200 0 1.486463e-07
I1531 n1_m1_57600_552000 0 2.359219e-07
I1532 n1_m1_57600_556800 0 1.559665e-07
I1533 n1_m1_57600_561600 0 7.752093e-08
I1534 n1_m1_62400_0 0 1.484771e-07
I1535 n1_m1_62400_4800 0 1.481036e-07
I1536 n1_m1_62400_9600 0 2.188664e-07
I1537 n1_m1_62400_14400 0 1.411489e-07
I1538 n1_m1_62400_19200 0 1.409170e-07
I1539 n1_m1_62400_24000 0 2.118037e-07
I1540 n1_m1_62400_28800 0 1.415938e-07
I1541 n1_m1_62400_33600 0 2.106594e-07
I1542 n1_m1_62400_38400 0 1.399040e-07
I1543 n1_m1_62400_43200 0 1.399040e-07
I1544 n1_m1_62400_48000 0 2.098560e-07
I1545 n1_m1_62400_52800 0 1.399040e-07
I1546 n1_m1_62400_57600 0 2.111659e-07
I1547 n1_m1_62400_62400 0 1.460623e-07
I1548 n1_m1_62400_67200 0 1.459031e-07
I1549 n1_m1_62400_72000 0 2.139843e-07
I1550 n1_m1_62400_76800 0 1.455723e-07
I1551 n1_m1_62400_81600 0 2.158495e-07
I1552 n1_m1_62400_86400 0 1.543069e-07
I1553 n1_m1_62400_91200 0 1.536632e-07
I1554 n1_m1_62400_96000 0 2.150547e-07
I1555 n1_m1_62400_100800 0 1.634169e-07
I1556 n1_m1_62400_105600 0 2.364367e-07
I1557 n1_m1_62400_110400 0 1.531626e-07
I1558 n1_m1_62400_115200 0 1.524161e-07
I1559 n1_m1_62400_120000 0 2.222369e-07
I1560 n1_m1_62400_124800 0 1.469704e-07
I1561 n1_m1_62400_129600 0 2.198791e-07
I1562 n1_m1_62400_134400 0 1.463267e-07
I1563 n1_m1_62400_139200 0 1.486323e-07
I1564 n1_m1_62400_144000 0 2.331284e-07
I1565 n1_m1_62400_148800 0 1.585359e-07
I1566 n1_m1_62400_153600 0 2.309029e-07
I1567 n1_m1_62400_158400 0 1.474047e-07
I1568 n1_m1_62400_163200 0 1.461568e-07
I1569 n1_m1_62400_168000 0 2.194322e-07
I1570 n1_m1_62400_172800 0 1.473241e-07
I1571 n1_m1_62400_177600 0 2.204469e-07
I1572 n1_m1_62400_182400 0 1.471666e-07
I1573 n1_m1_62400_187200 0 1.464037e-07
I1574 n1_m1_62400_192000 0 2.236543e-07
I1575 n1_m1_62400_196800 0 1.606643e-07
I1576 n1_m1_62400_201600 0 2.473384e-07
I1577 n1_m1_62400_206400 0 1.549581e-07
I1578 n1_m1_62400_211200 0 1.525292e-07
I1579 n1_m1_62400_216000 0 2.613329e-07
I1580 n1_m1_62400_220800 0 1.748540e-07
I1581 n1_m1_62400_225600 0 3.740279e-07
I1582 n1_m1_62400_230400 0 1.815606e-07
I1583 n1_m1_62400_235200 0 1.615368e-07
I1584 n1_m1_62400_240000 0 2.268334e-07
I1585 n1_m1_62400_244800 0 1.504257e-07
I1586 n1_m1_62400_249600 0 2.198491e-07
I1587 n1_m1_62400_254400 0 1.464791e-07
I1588 n1_m1_62400_259200 0 1.428769e-07
I1589 n1_m1_62400_264000 0 2.129330e-07
I1590 n1_m1_62400_268800 0 1.466513e-07
I1591 n1_m1_62400_273600 0 2.282768e-07
I1592 n1_m1_62400_278400 0 1.532282e-07
I1593 n1_m1_62400_283200 0 1.530199e-07
I1594 n1_m1_62400_288000 0 2.255609e-07
I1595 n1_m1_62400_292800 0 1.468377e-07
I1596 n1_m1_62400_297600 0 2.198491e-07
I1597 n1_m1_62400_302400 0 1.465661e-07
I1598 n1_m1_62400_307200 0 1.499074e-07
I1599 n1_m1_62400_312000 0 2.285483e-07
I1600 n1_m1_62400_316800 0 1.494515e-07
I1601 n1_m1_62400_321600 0 2.371259e-07
I1602 n1_m1_62400_326400 0 2.231889e-07
I1603 n1_m1_62400_331200 0 3.713714e-07
I1604 n1_m1_62400_336000 0 5.112699e-07
I1605 n1_m1_62400_340800 0 4.840092e-07
I1606 n1_m1_62400_345600 0 9.302896e-07
I1607 n1_m1_62400_350400 0 7.693315e-07
I1608 n1_m1_62400_355200 0 8.131718e-07
I1609 n1_m1_62400_360000 0 9.351871e-07
I1610 n1_m1_62400_364800 0 2.980969e-07
I1611 n1_m1_62400_369600 0 2.737909e-07
I1612 n1_m1_62400_374400 0 1.526221e-07
I1613 n1_m1_62400_379200 0 1.474679e-07
I1614 n1_m1_62400_384000 0 2.243867e-07
I1615 n1_m1_62400_388800 0 1.688530e-07
I1616 n1_m1_62400_393600 0 2.745105e-07
I1617 n1_m1_62400_398400 0 1.670215e-07
I1618 n1_m1_62400_403200 0 2.112305e-07
I1619 n1_m1_62400_408000 0 1.205712e-06
I1620 n1_m1_62400_412800 0 9.334927e-07
I1621 n1_m1_62400_417600 0 1.721802e-06
I1622 n1_m1_62400_422400 0 8.541777e-07
I1623 n1_m1_62400_427200 0 5.195624e-07
I1624 n1_m1_62400_432000 0 8.567927e-07
I1625 n1_m1_62400_436800 0 2.512649e-07
I1626 n1_m1_62400_441600 0 3.529196e-07
I1627 n1_m1_62400_446400 0 1.647296e-07
I1628 n1_m1_62400_451200 0 1.619850e-07
I1629 n1_m1_62400_456000 0 2.289811e-07
I1630 n1_m1_62400_460800 0 1.537379e-07
I1631 n1_m1_62400_465600 0 2.304454e-07
I1632 n1_m1_62400_470400 0 1.521321e-07
I1633 n1_m1_62400_475200 0 1.474292e-07
I1634 n1_m1_62400_480000 0 2.164423e-07
I1635 n1_m1_62400_484800 0 1.400001e-07
I1636 n1_m1_62400_489600 0 2.098560e-07
I1637 n1_m1_62400_494400 0 1.399040e-07
I1638 n1_m1_62400_499200 0 1.399040e-07
I1639 n1_m1_62400_504000 0 2.098560e-07
I1640 n1_m1_62400_508800 0 1.399040e-07
I1641 n1_m1_62400_513600 0 2.098560e-07
I1642 n1_m1_62400_518400 0 1.399040e-07
I1643 n1_m1_62400_523200 0 1.401470e-07
I1644 n1_m1_62400_528000 0 2.172052e-07
I1645 n1_m1_62400_532800 0 1.422581e-07
I1646 n1_m1_62400_537600 0 2.208333e-07
I1647 n1_m1_62400_542400 0 1.816812e-07
I1648 n1_m1_62400_547200 0 2.256608e-07
I1649 n1_m1_62400_552000 0 3.223848e-07
I1650 n1_m1_62400_556800 0 1.615679e-07
I1651 n1_m1_62400_561600 0 7.833625e-08
I1652 n1_m1_67200_0 0 1.560105e-07
I1653 n1_m1_67200_4800 0 1.533301e-07
I1654 n1_m1_67200_9600 0 2.160787e-07
I1655 n1_m1_67200_14400 0 1.415379e-07
I1656 n1_m1_67200_19200 0 1.447681e-07
I1657 n1_m1_67200_24000 0 2.207246e-07
I1658 n1_m1_67200_28800 0 1.489602e-07
I1659 n1_m1_67200_33600 0 2.139342e-07
I1660 n1_m1_67200_38400 0 1.399040e-07
I1661 n1_m1_67200_43200 0 1.399040e-07
I1662 n1_m1_67200_48000 0 2.098974e-07
I1663 n1_m1_67200_52800 0 1.404674e-07
I1664 n1_m1_67200_57600 0 2.119596e-07
I1665 n1_m1_67200_62400 0 1.455627e-07
I1666 n1_m1_67200_67200 0 1.457627e-07
I1667 n1_m1_67200_72000 0 2.173747e-07
I1668 n1_m1_67200_76800 0 1.555471e-07
I1669 n1_m1_67200_81600 0 2.246848e-07
I1670 n1_m1_67200_86400 0 1.582247e-07
I1671 n1_m1_67200_91200 0 1.542543e-07
I1672 n1_m1_67200_96000 0 2.117220e-07
I1673 n1_m1_67200_100800 0 1.535016e-07
I1674 n1_m1_67200_105600 0 2.258497e-07
I1675 n1_m1_67200_110400 0 1.479986e-07
I1676 n1_m1_67200_115200 0 1.474175e-07
I1677 n1_m1_67200_120000 0 2.198024e-07
I1678 n1_m1_67200_124800 0 1.458597e-07
I1679 n1_m1_67200_129600 0 2.187733e-07
I1680 n1_m1_67200_134400 0 1.458489e-07
I1681 n1_m1_67200_139200 0 1.461578e-07
I1682 n1_m1_67200_144000 0 2.211683e-07
I1683 n1_m1_67200_148800 0 1.520570e-07
I1684 n1_m1_67200_153600 0 2.243650e-07
I1685 n1_m1_67200_158400 0 1.461690e-07
I1686 n1_m1_67200_163200 0 1.458489e-07
I1687 n1_m1_67200_168000 0 2.202425e-07
I1688 n1_m1_67200_172800 0 1.511861e-07
I1689 n1_m1_67200_177600 0 2.236035e-07
I1690 n1_m1_67200_182400 0 1.496145e-07
I1691 n1_m1_67200_187200 0 1.449274e-07
I1692 n1_m1_67200_192000 0 2.167018e-07
I1693 n1_m1_67200_196800 0 1.586650e-07
I1694 n1_m1_67200_201600 0 2.411592e-07
I1695 n1_m1_67200_206400 0 1.457344e-07
I1696 n1_m1_67200_211200 0 1.480731e-07
I1697 n1_m1_67200_216000 0 2.517496e-07
I1698 n1_m1_67200_220800 0 1.569747e-07
I1699 n1_m1_67200_225600 0 2.758410e-07
I1700 n1_m1_67200_230400 0 1.705020e-07
I1701 n1_m1_67200_235200 0 1.604117e-07
I1702 n1_m1_67200_240000 0 2.386886e-07
I1703 n1_m1_67200_244800 0 1.560345e-07
I1704 n1_m1_67200_249600 0 2.216848e-07
I1705 n1_m1_67200_254400 0 1.467038e-07
I1706 n1_m1_67200_259200 0 1.459923e-07
I1707 n1_m1_67200_264000 0 2.188851e-07
I1708 n1_m1_67200_268800 0 1.477675e-07
I1709 n1_m1_67200_273600 0 2.288849e-07
I1710 n1_m1_67200_278400 0 1.532282e-07
I1711 n1_m1_67200_283200 0 1.521708e-07
I1712 n1_m1_67200_288000 0 2.220285e-07
I1713 n1_m1_67200_292800 0 1.472833e-07
I1714 n1_m1_67200_297600 0 2.209051e-07
I1715 n1_m1_67200_302400 0 1.467537e-07
I1716 n1_m1_67200_307200 0 1.470857e-07
I1717 n1_m1_67200_312000 0 2.264952e-07
I1718 n1_m1_67200_316800 0 1.538081e-07
I1719 n1_m1_67200_321600 0 2.519862e-07
I1720 n1_m1_67200_326400 0 1.973089e-07
I1721 n1_m1_67200_331200 0 2.696006e-07
I1722 n1_m1_67200_336000 0 4.176741e-07
I1723 n1_m1_67200_340800 0 4.456729e-07
I1724 n1_m1_67200_345600 0 6.948705e-07
I1725 n1_m1_67200_350400 0 4.813716e-07
I1726 n1_m1_67200_355200 0 5.321541e-07
I1727 n1_m1_67200_360000 0 6.185663e-07
I1728 n1_m1_67200_364800 0 2.138281e-07
I1729 n1_m1_67200_369600 0 2.442159e-07
I1730 n1_m1_67200_374400 0 1.478649e-07
I1731 n1_m1_67200_379200 0 1.479580e-07
I1732 n1_m1_67200_384000 0 2.268545e-07
I1733 n1_m1_67200_388800 0 1.801566e-07
I1734 n1_m1_67200_393600 0 3.168439e-07
I1735 n1_m1_67200_398400 0 1.667512e-07
I1736 n1_m1_67200_403200 0 2.131778e-07
I1737 n1_m1_67200_408000 0 1.224934e-06
I1738 n1_m1_67200_412800 0 8.211147e-07
I1739 n1_m1_67200_417600 0 1.381155e-06
I1740 n1_m1_67200_422400 0 6.616530e-07
I1741 n1_m1_67200_427200 0 3.857831e-07
I1742 n1_m1_67200_432000 0 6.824513e-07
I1743 n1_m1_67200_436800 0 1.984836e-07
I1744 n1_m1_67200_441600 0 2.799741e-07
I1745 n1_m1_67200_446400 0 1.556357e-07
I1746 n1_m1_67200_451200 0 1.551824e-07
I1747 n1_m1_67200_456000 0 2.298741e-07
I1748 n1_m1_67200_460800 0 1.576557e-07
I1749 n1_m1_67200_465600 0 2.356643e-07
I1750 n1_m1_67200_470400 0 1.524100e-07
I1751 n1_m1_67200_475200 0 1.470902e-07
I1752 n1_m1_67200_480000 0 2.120165e-07
I1753 n1_m1_67200_484800 0 1.399189e-07
I1754 n1_m1_67200_489600 0 2.098560e-07
I1755 n1_m1_67200_494400 0 1.399040e-07
I1756 n1_m1_67200_499200 0 1.399040e-07
I1757 n1_m1_67200_504000 0 2.098560e-07
I1758 n1_m1_67200_508800 0 1.399040e-07
I1759 n1_m1_67200_513600 0 2.098560e-07
I1760 n1_m1_67200_518400 0 1.399040e-07
I1761 n1_m1_67200_523200 0 1.401470e-07
I1762 n1_m1_67200_528000 0 2.178916e-07
I1763 n1_m1_67200_532800 0 1.461558e-07
I1764 n1_m1_67200_537600 0 2.611897e-07
I1765 n1_m1_67200_542400 0 3.094942e-07
I1766 n1_m1_67200_547200 0 4.448399e-07
I1767 n1_m1_67200_552000 0 5.305889e-07
I1768 n1_m1_67200_556800 0 1.795503e-07
I1769 n1_m1_67200_561600 0 8.420639e-08
I1770 n1_m1_72000_0 0 2.258450e-07
I1771 n1_m1_72000_4800 0 2.356199e-07
I1772 n1_m1_72000_9600 0 3.517147e-07
I1773 n1_m1_72000_14400 0 2.198680e-07
I1774 n1_m1_72000_19200 0 2.130877e-07
I1775 n1_m1_72000_24000 0 3.290725e-07
I1776 n1_m1_72000_28800 0 2.176205e-07
I1777 n1_m1_72000_33600 0 3.156532e-07
I1778 n1_m1_72000_38400 0 2.098560e-07
I1779 n1_m1_72000_43200 0 2.098560e-07
I1780 n1_m1_72000_48000 0 3.152984e-07
I1781 n1_m1_72000_52800 0 2.168450e-07
I1782 n1_m1_72000_57600 0 3.270591e-07
I1783 n1_m1_72000_62400 0 2.147176e-07
I1784 n1_m1_72000_67200 0 2.182421e-07
I1785 n1_m1_72000_72000 0 3.802035e-07
I1786 n1_m1_72000_76800 0 3.507435e-07
I1787 n1_m1_72000_81600 0 3.645147e-07
I1788 n1_m1_72000_86400 0 2.252546e-07
I1789 n1_m1_72000_91200 0 2.324042e-07
I1790 n1_m1_72000_96000 0 3.309035e-07
I1791 n1_m1_72000_100800 0 2.511311e-07
I1792 n1_m1_72000_105600 0 3.616279e-07
I1793 n1_m1_72000_110400 0 2.324110e-07
I1794 n1_m1_72000_115200 0 2.259364e-07
I1795 n1_m1_72000_120000 0 3.343020e-07
I1796 n1_m1_72000_124800 0 2.158050e-07
I1797 n1_m1_72000_129600 0 3.235057e-07
I1798 n1_m1_72000_134400 0 2.145497e-07
I1799 n1_m1_72000_139200 0 2.142223e-07
I1800 n1_m1_72000_144000 0 3.286532e-07
I1801 n1_m1_72000_148800 0 2.288406e-07
I1802 n1_m1_72000_153600 0 3.422927e-07
I1803 n1_m1_72000_158400 0 2.135012e-07
I1804 n1_m1_72000_163200 0 2.109525e-07
I1805 n1_m1_72000_168000 0 3.201202e-07
I1806 n1_m1_72000_172800 0 2.264783e-07
I1807 n1_m1_72000_177600 0 3.369813e-07
I1808 n1_m1_72000_182400 0 2.195376e-07
I1809 n1_m1_72000_187200 0 2.178922e-07
I1810 n1_m1_72000_192000 0 3.349836e-07
I1811 n1_m1_72000_196800 0 2.360097e-07
I1812 n1_m1_72000_201600 0 3.501735e-07
I1813 n1_m1_72000_206400 0 2.220799e-07
I1814 n1_m1_72000_211200 0 2.366079e-07
I1815 n1_m1_72000_216000 0 3.450028e-07
I1816 n1_m1_72000_220800 0 2.417511e-07
I1817 n1_m1_72000_225600 0 4.204036e-07
I1818 n1_m1_72000_230400 0 2.817723e-07
I1819 n1_m1_72000_235200 0 2.684213e-07
I1820 n1_m1_72000_240000 0 3.816928e-07
I1821 n1_m1_72000_244800 0 2.427827e-07
I1822 n1_m1_72000_249600 0 3.547618e-07
I1823 n1_m1_72000_254400 0 2.240840e-07
I1824 n1_m1_72000_259200 0 2.222081e-07
I1825 n1_m1_72000_264000 0 3.343300e-07
I1826 n1_m1_72000_268800 0 2.281057e-07
I1827 n1_m1_72000_273600 0 3.445868e-07
I1828 n1_m1_72000_278400 0 2.298422e-07
I1829 n1_m1_72000_283200 0 2.296169e-07
I1830 n1_m1_72000_288000 0 3.431918e-07
I1831 n1_m1_72000_292800 0 2.276586e-07
I1832 n1_m1_72000_297600 0 3.413915e-07
I1833 n1_m1_72000_302400 0 2.221762e-07
I1834 n1_m1_72000_307200 0 2.198491e-07
I1835 n1_m1_72000_312000 0 3.317334e-07
I1836 n1_m1_72000_316800 0 2.281321e-07
I1837 n1_m1_72000_321600 0 3.649025e-07
I1838 n1_m1_72000_326400 0 2.620388e-07
I1839 n1_m1_72000_331200 0 3.391958e-07
I1840 n1_m1_72000_336000 0 5.500570e-07
I1841 n1_m1_72000_340800 0 5.594689e-07
I1842 n1_m1_72000_345600 0 7.604864e-07
I1843 n1_m1_72000_350400 0 3.490856e-07
I1844 n1_m1_72000_355200 0 3.436672e-07
I1845 n1_m1_72000_360000 0 4.736438e-07
I1846 n1_m1_72000_364800 0 2.552004e-07
I1847 n1_m1_72000_369600 0 3.449351e-07
I1848 n1_m1_72000_374400 0 2.206755e-07
I1849 n1_m1_72000_379200 0 2.210717e-07
I1850 n1_m1_72000_384000 0 3.247496e-07
I1851 n1_m1_72000_388800 0 2.269169e-07
I1852 n1_m1_72000_393600 0 3.652223e-07
I1853 n1_m1_72000_398400 0 2.579201e-07
I1854 n1_m1_72000_403200 0 2.916876e-07
I1855 n1_m1_72000_408000 0 9.338091e-07
I1856 n1_m1_72000_412800 0 7.358717e-07
I1857 n1_m1_72000_417600 0 1.738544e-06
I1858 n1_m1_72000_422400 0 6.296252e-07
I1859 n1_m1_72000_427200 0 4.467873e-07
I1860 n1_m1_72000_432000 0 6.451569e-07
I1861 n1_m1_72000_436800 0 3.013842e-07
I1862 n1_m1_72000_441600 0 3.670952e-07
I1863 n1_m1_72000_446400 0 2.345173e-07
I1864 n1_m1_72000_451200 0 2.285501e-07
I1865 n1_m1_72000_456000 0 3.301392e-07
I1866 n1_m1_72000_460800 0 2.220421e-07
I1867 n1_m1_72000_465600 0 3.325129e-07
I1868 n1_m1_72000_470400 0 2.185805e-07
I1869 n1_m1_72000_475200 0 2.151387e-07
I1870 n1_m1_72000_480000 0 3.134462e-07
I1871 n1_m1_72000_484800 0 2.098119e-07
I1872 n1_m1_72000_489600 0 3.147839e-07
I1873 n1_m1_72000_494400 0 2.098560e-07
I1874 n1_m1_72000_499200 0 2.098560e-07
I1875 n1_m1_72000_504000 0 3.147839e-07
I1876 n1_m1_72000_508800 0 2.098560e-07
I1877 n1_m1_72000_513600 0 3.147839e-07
I1878 n1_m1_72000_518400 0 2.098560e-07
I1879 n1_m1_72000_523200 0 2.102205e-07
I1880 n1_m1_72000_528000 0 3.253826e-07
I1881 n1_m1_72000_532800 0 2.131709e-07
I1882 n1_m1_72000_537600 0 4.542452e-07
I1883 n1_m1_72000_542400 0 5.244999e-07
I1884 n1_m1_72000_547200 0 5.320600e-07
I1885 n1_m1_72000_552000 0 5.189143e-07
I1886 n1_m1_72000_556800 0 2.536958e-07
I1887 n1_m1_72000_561600 0 1.211335e-07
I1888 n1_m1_76800_0 0 1.496008e-07
I1889 n1_m1_76800_4800 0 1.575671e-07
I1890 n1_m1_76800_9600 0 2.401226e-07
I1891 n1_m1_76800_14400 0 1.511031e-07
I1892 n1_m1_76800_19200 0 1.419963e-07
I1893 n1_m1_76800_24000 0 2.189778e-07
I1894 n1_m1_76800_28800 0 1.443493e-07
I1895 n1_m1_76800_33600 0 2.098560e-07
I1896 n1_m1_76800_38400 0 1.399040e-07
I1897 n1_m1_76800_43200 0 1.399040e-07
I1898 n1_m1_76800_48000 0 2.102412e-07
I1899 n1_m1_76800_52800 0 1.451376e-07
I1900 n1_m1_76800_57600 0 2.198491e-07
I1901 n1_m1_76800_62400 0 1.465661e-07
I1902 n1_m1_76800_67200 0 1.469464e-07
I1903 n1_m1_76800_72000 0 2.854178e-07
I1904 n1_m1_76800_76800 0 2.874539e-07
I1905 n1_m1_76800_81600 0 2.636322e-07
I1906 n1_m1_76800_86400 0 1.555635e-07
I1907 n1_m1_76800_91200 0 1.608551e-07
I1908 n1_m1_76800_96000 0 2.290708e-07
I1909 n1_m1_76800_100800 0 1.696349e-07
I1910 n1_m1_76800_105600 0 2.562675e-07
I1911 n1_m1_76800_110400 0 1.693123e-07
I1912 n1_m1_76800_115200 0 1.659426e-07
I1913 n1_m1_76800_120000 0 2.458751e-07
I1914 n1_m1_76800_124800 0 1.586278e-07
I1915 n1_m1_76800_129600 0 2.367942e-07
I1916 n1_m1_76800_134400 0 1.535956e-07
I1917 n1_m1_76800_139200 0 1.533530e-07
I1918 n1_m1_76800_144000 0 2.363998e-07
I1919 n1_m1_76800_148800 0 1.588378e-07
I1920 n1_m1_76800_153600 0 2.309565e-07
I1921 n1_m1_76800_158400 0 1.418125e-07
I1922 n1_m1_76800_163200 0 1.399040e-07
I1923 n1_m1_76800_168000 0 2.109492e-07
I1924 n1_m1_76800_172800 0 1.448761e-07
I1925 n1_m1_76800_177600 0 2.196841e-07
I1926 n1_m1_76800_182400 0 1.438514e-07
I1927 n1_m1_76800_187200 0 1.420259e-07
I1928 n1_m1_76800_192000 0 2.244189e-07
I1929 n1_m1_76800_196800 0 1.561465e-07
I1930 n1_m1_76800_201600 0 2.316211e-07
I1931 n1_m1_76800_206400 0 1.480834e-07
I1932 n1_m1_76800_211200 0 1.517218e-07
I1933 n1_m1_76800_216000 0 2.343935e-07
I1934 n1_m1_76800_220800 0 2.166951e-07
I1935 n1_m1_76800_225600 0 4.684096e-07
I1936 n1_m1_76800_230400 0 2.871938e-07
I1937 n1_m1_76800_235200 0 2.267514e-07
I1938 n1_m1_76800_240000 0 2.624365e-07
I1939 n1_m1_76800_244800 0 1.620359e-07
I1940 n1_m1_76800_249600 0 2.458099e-07
I1941 n1_m1_76800_254400 0 1.563693e-07
I1942 n1_m1_76800_259200 0 1.537279e-07
I1943 n1_m1_76800_264000 0 2.318348e-07
I1944 n1_m1_76800_268800 0 1.547980e-07
I1945 n1_m1_76800_273600 0 2.294887e-07
I1946 n1_m1_76800_278400 0 1.519427e-07
I1947 n1_m1_76800_283200 0 1.531889e-07
I1948 n1_m1_76800_288000 0 2.298422e-07
I1949 n1_m1_76800_292800 0 1.501579e-07
I1950 n1_m1_76800_297600 0 2.254740e-07
I1951 n1_m1_76800_302400 0 1.483086e-07
I1952 n1_m1_76800_307200 0 1.465661e-07
I1953 n1_m1_76800_312000 0 2.198491e-07
I1954 n1_m1_76800_316800 0 1.481442e-07
I1955 n1_m1_76800_321600 0 2.464604e-07
I1956 n1_m1_76800_326400 0 2.231473e-07
I1957 n1_m1_76800_331200 0 3.930908e-07
I1958 n1_m1_76800_336000 0 5.724280e-07
I1959 n1_m1_76800_340800 0 5.129584e-07
I1960 n1_m1_76800_345600 0 6.350010e-07
I1961 n1_m1_76800_350400 0 2.301770e-07
I1962 n1_m1_76800_355200 0 1.834091e-07
I1963 n1_m1_76800_360000 0 2.630756e-07
I1964 n1_m1_76800_364800 0 1.552545e-07
I1965 n1_m1_76800_369600 0 2.205722e-07
I1966 n1_m1_76800_374400 0 1.464171e-07
I1967 n1_m1_76800_379200 0 1.517957e-07
I1968 n1_m1_76800_384000 0 2.250189e-07
I1969 n1_m1_76800_388800 0 1.539754e-07
I1970 n1_m1_76800_393600 0 2.345365e-07
I1971 n1_m1_76800_398400 0 1.614417e-07
I1972 n1_m1_76800_403200 0 1.597509e-07
I1973 n1_m1_76800_408000 0 3.047081e-07
I1974 n1_m1_76800_412800 0 2.274714e-07
I1975 n1_m1_76800_417600 0 7.631178e-07
I1976 n1_m1_76800_422400 0 3.065041e-07
I1977 n1_m1_76800_427200 0 2.406314e-07
I1978 n1_m1_76800_432000 0 3.715988e-07
I1979 n1_m1_76800_436800 0 2.418048e-07
I1980 n1_m1_76800_441600 0 2.722874e-07
I1981 n1_m1_76800_446400 0 1.587830e-07
I1982 n1_m1_76800_451200 0 1.472773e-07
I1983 n1_m1_76800_456000 0 2.155697e-07
I1984 n1_m1_76800_460800 0 1.465661e-07
I1985 n1_m1_76800_465600 0 2.187881e-07
I1986 n1_m1_76800_470400 0 1.398921e-07
I1987 n1_m1_76800_475200 0 1.342910e-07
I1988 n1_m1_76800_480000 0 2.017239e-07
I1989 n1_m1_76800_484800 0 1.397795e-07
I1990 n1_m1_76800_489600 0 2.098560e-07
I1991 n1_m1_76800_494400 0 1.399040e-07
I1992 n1_m1_76800_499200 0 1.399040e-07
I1993 n1_m1_76800_504000 0 2.098560e-07
I1994 n1_m1_76800_508800 0 1.399040e-07
I1995 n1_m1_76800_513600 0 2.098560e-07
I1996 n1_m1_76800_518400 0 1.399040e-07
I1997 n1_m1_76800_523200 0 1.402114e-07
I1998 n1_m1_76800_528000 0 2.189799e-07
I1999 n1_m1_76800_532800 0 1.428780e-07
I2000 n1_m1_76800_537600 0 2.930938e-07
I2001 n1_m1_76800_542400 0 3.231868e-07
I2002 n1_m1_76800_547200 0 3.166886e-07
I2003 n1_m1_76800_552000 0 3.206206e-07
I2004 n1_m1_76800_556800 0 1.726631e-07
I2005 n1_m1_76800_561600 0 8.192555e-08
I2006 n1_m1_81600_0 0 2.286094e-07
I2007 n1_m1_81600_4800 0 2.406987e-07
I2008 n1_m1_81600_9600 0 3.686029e-07
I2009 n1_m1_81600_14400 0 2.277370e-07
I2010 n1_m1_81600_19200 0 2.162442e-07
I2011 n1_m1_81600_24000 0 3.290171e-07
I2012 n1_m1_81600_28800 0 2.165240e-07
I2013 n1_m1_81600_33600 0 3.147839e-07
I2014 n1_m1_81600_38400 0 2.098560e-07
I2015 n1_m1_81600_43200 0 2.098560e-07
I2016 n1_m1_81600_48000 0 3.153618e-07
I2017 n1_m1_81600_52800 0 2.177064e-07
I2018 n1_m1_81600_57600 0 3.297737e-07
I2019 n1_m1_81600_62400 0 2.198491e-07
I2020 n1_m1_81600_67200 0 2.224167e-07
I2021 n1_m1_81600_72000 0 4.381678e-07
I2022 n1_m1_81600_76800 0 4.165943e-07
I2023 n1_m1_81600_81600 0 4.095326e-07
I2024 n1_m1_81600_86400 0 2.401576e-07
I2025 n1_m1_81600_91200 0 2.429016e-07
I2026 n1_m1_81600_96000 0 3.433328e-07
I2027 n1_m1_81600_100800 0 2.461298e-07
I2028 n1_m1_81600_105600 0 3.896915e-07
I2029 n1_m1_81600_110400 0 2.688739e-07
I2030 n1_m1_81600_115200 0 2.728862e-07
I2031 n1_m1_81600_120000 0 4.073983e-07
I2032 n1_m1_81600_124800 0 2.627706e-07
I2033 n1_m1_81600_129600 0 3.836701e-07
I2034 n1_m1_81600_134400 0 2.447371e-07
I2035 n1_m1_81600_139200 0 2.471424e-07
I2036 n1_m1_81600_144000 0 3.812261e-07
I2037 n1_m1_81600_148800 0 2.402874e-07
I2038 n1_m1_81600_153600 0 3.412082e-07
I2039 n1_m1_81600_158400 0 2.157215e-07
I2040 n1_m1_81600_163200 0 2.140642e-07
I2041 n1_m1_81600_168000 0 3.211347e-07
I2042 n1_m1_81600_172800 0 2.152314e-07
I2043 n1_m1_81600_177600 0 3.292493e-07
I2044 n1_m1_81600_182400 0 2.174919e-07
I2045 n1_m1_81600_187200 0 2.159067e-07
I2046 n1_m1_81600_192000 0 3.366284e-07
I2047 n1_m1_81600_196800 0 2.299447e-07
I2048 n1_m1_81600_201600 0 3.485356e-07
I2049 n1_m1_81600_206400 0 2.293698e-07
I2050 n1_m1_81600_211200 0 2.295443e-07
I2051 n1_m1_81600_216000 0 3.991522e-07
I2052 n1_m1_81600_220800 0 5.072379e-07
I2053 n1_m1_81600_225600 0 1.170140e-06
I2054 n1_m1_81600_230400 0 6.556442e-07
I2055 n1_m1_81600_235200 0 4.578183e-07
I2056 n1_m1_81600_240000 0 4.369689e-07
I2057 n1_m1_81600_244800 0 2.522100e-07
I2058 n1_m1_81600_249600 0 3.794726e-07
I2059 n1_m1_81600_254400 0 2.416757e-07
I2060 n1_m1_81600_259200 0 2.356385e-07
I2061 n1_m1_81600_264000 0 3.574079e-07
I2062 n1_m1_81600_268800 0 2.385713e-07
I2063 n1_m1_81600_273600 0 3.427974e-07
I2064 n1_m1_81600_278400 0 2.226947e-07
I2065 n1_m1_81600_283200 0 2.296238e-07
I2066 n1_m1_81600_288000 0 3.447634e-07
I2067 n1_m1_81600_292800 0 2.271763e-07
I2068 n1_m1_81600_297600 0 3.373011e-07
I2069 n1_m1_81600_302400 0 2.213622e-07
I2070 n1_m1_81600_307200 0 2.198491e-07
I2071 n1_m1_81600_312000 0 3.307995e-07
I2072 n1_m1_81600_316800 0 2.341937e-07
I2073 n1_m1_81600_321600 0 4.612256e-07
I2074 n1_m1_81600_326400 0 4.426101e-07
I2075 n1_m1_81600_331200 0 8.365746e-07
I2076 n1_m1_81600_336000 0 1.105487e-06
I2077 n1_m1_81600_340800 0 8.292579e-07
I2078 n1_m1_81600_345600 0 9.552008e-07
I2079 n1_m1_81600_350400 0 4.028330e-07
I2080 n1_m1_81600_355200 0 3.652060e-07
I2081 n1_m1_81600_360000 0 4.598194e-07
I2082 n1_m1_81600_364800 0 2.409678e-07
I2083 n1_m1_81600_369600 0 3.304828e-07
I2084 n1_m1_81600_374400 0 2.133198e-07
I2085 n1_m1_81600_379200 0 2.242079e-07
I2086 n1_m1_81600_384000 0 3.296328e-07
I2087 n1_m1_81600_388800 0 2.111547e-07
I2088 n1_m1_81600_393600 0 3.336702e-07
I2089 n1_m1_81600_398400 0 2.296065e-07
I2090 n1_m1_81600_403200 0 2.356222e-07
I2091 n1_m1_81600_408000 0 6.024606e-07
I2092 n1_m1_81600_412800 0 4.825603e-07
I2093 n1_m1_81600_417600 0 1.482939e-06
I2094 n1_m1_81600_422400 0 6.135699e-07
I2095 n1_m1_81600_427200 0 4.616516e-07
I2096 n1_m1_81600_432000 0 7.374225e-07
I2097 n1_m1_81600_436800 0 4.759633e-07
I2098 n1_m1_81600_441600 0 4.607852e-07
I2099 n1_m1_81600_446400 0 2.613904e-07
I2100 n1_m1_81600_451200 0 2.381983e-07
I2101 n1_m1_81600_456000 0 3.385964e-07
I2102 n1_m1_81600_460800 0 2.252180e-07
I2103 n1_m1_81600_465600 0 3.344946e-07
I2104 n1_m1_81600_470400 0 2.140464e-07
I2105 n1_m1_81600_475200 0 2.056447e-07
I2106 n1_m1_81600_480000 0 3.088983e-07
I2107 n1_m1_81600_484800 0 2.138775e-07
I2108 n1_m1_81600_489600 0 3.187526e-07
I2109 n1_m1_81600_494400 0 2.118253e-07
I2110 n1_m1_81600_499200 0 2.124693e-07
I2111 n1_m1_81600_504000 0 3.180525e-07
I2112 n1_m1_81600_508800 0 2.113011e-07
I2113 n1_m1_81600_513600 0 3.147839e-07
I2114 n1_m1_81600_518400 0 2.101967e-07
I2115 n1_m1_81600_523200 0 2.136750e-07
I2116 n1_m1_81600_528000 0 3.341434e-07
I2117 n1_m1_81600_532800 0 2.192734e-07
I2118 n1_m1_81600_537600 0 3.843150e-07
I2119 n1_m1_81600_542400 0 3.735950e-07
I2120 n1_m1_81600_547200 0 3.853728e-07
I2121 n1_m1_81600_552000 0 4.682422e-07
I2122 n1_m1_81600_556800 0 2.648903e-07
I2123 n1_m1_81600_561600 0 1.248408e-07
I2124 n1_m1_86400_0 0 7.813143e-08
I2125 n1_m1_86400_4800 0 8.207297e-08
I2126 n1_m1_86400_9600 0 1.233614e-07
I2127 n1_m1_86400_14400 0 7.627327e-08
I2128 n1_m1_86400_19200 0 7.357050e-08
I2129 n1_m1_86400_24000 0 1.099246e-07
I2130 n1_m1_86400_28800 0 7.217466e-08
I2131 n1_m1_86400_33600 0 1.049280e-07
I2132 n1_m1_86400_38400 0 6.995199e-08
I2133 n1_m1_86400_43200 0 6.995199e-08
I2134 n1_m1_86400_48000 0 1.050599e-07
I2135 n1_m1_86400_52800 0 7.175866e-08
I2136 n1_m1_86400_57600 0 1.096203e-07
I2137 n1_m1_86400_62400 0 7.328303e-08
I2138 n1_m1_86400_67200 0 7.413293e-08
I2139 n1_m1_86400_72000 0 1.320862e-07
I2140 n1_m1_86400_76800 0 1.076624e-07
I2141 n1_m1_86400_81600 0 1.293704e-07
I2142 n1_m1_86400_86400 0 7.994513e-08
I2143 n1_m1_86400_91200 0 7.946911e-08
I2144 n1_m1_86400_96000 0 1.145870e-07
I2145 n1_m1_86400_100800 0 8.010584e-08
I2146 n1_m1_86400_105600 0 1.276882e-07
I2147 n1_m1_86400_110400 0 8.879467e-08
I2148 n1_m1_86400_115200 0 9.081989e-08
I2149 n1_m1_86400_120000 0 1.361029e-07
I2150 n1_m1_86400_124800 0 8.821539e-08
I2151 n1_m1_86400_129600 0 1.266568e-07
I2152 n1_m1_86400_134400 0 8.114295e-08
I2153 n1_m1_86400_139200 0 8.251750e-08
I2154 n1_m1_86400_144000 0 1.264621e-07
I2155 n1_m1_86400_148800 0 7.780544e-08
I2156 n1_m1_86400_153600 0 1.108950e-07
I2157 n1_m1_86400_158400 0 7.328303e-08
I2158 n1_m1_86400_163200 0 7.328303e-08
I2159 n1_m1_86400_168000 0 1.099246e-07
I2160 n1_m1_86400_172800 0 7.328303e-08
I2161 n1_m1_86400_177600 0 1.099246e-07
I2162 n1_m1_86400_182400 0 7.328303e-08
I2163 n1_m1_86400_187200 0 7.328303e-08
I2164 n1_m1_86400_192000 0 1.114898e-07
I2165 n1_m1_86400_196800 0 7.619033e-08
I2166 n1_m1_86400_201600 0 1.183757e-07
I2167 n1_m1_86400_206400 0 8.063957e-08
I2168 n1_m1_86400_211200 0 7.842953e-08
I2169 n1_m1_86400_216000 0 1.372758e-07
I2170 n1_m1_86400_220800 0 1.732352e-07
I2171 n1_m1_86400_225600 0 3.840021e-07
I2172 n1_m1_86400_230400 0 2.066763e-07
I2173 n1_m1_86400_235200 0 1.434453e-07
I2174 n1_m1_86400_240000 0 1.455071e-07
I2175 n1_m1_86400_244800 0 8.503653e-08
I2176 n1_m1_86400_249600 0 1.265768e-07
I2177 n1_m1_86400_254400 0 8.064749e-08
I2178 n1_m1_86400_259200 0 7.994513e-08
I2179 n1_m1_86400_264000 0 1.211012e-07
I2180 n1_m1_86400_268800 0 8.050711e-08
I2181 n1_m1_86400_273600 0 1.144233e-07
I2182 n1_m1_86400_278400 0 7.418989e-08
I2183 n1_m1_86400_283200 0 7.653999e-08
I2184 n1_m1_86400_288000 0 1.149211e-07
I2185 n1_m1_86400_292800 0 7.613060e-08
I2186 n1_m1_86400_297600 0 1.113579e-07
I2187 n1_m1_86400_302400 0 7.328303e-08
I2188 n1_m1_86400_307200 0 7.328303e-08
I2189 n1_m1_86400_312000 0 1.104808e-07
I2190 n1_m1_86400_316800 0 8.003951e-08
I2191 n1_m1_86400_321600 0 1.636649e-07
I2192 n1_m1_86400_326400 0 1.446032e-07
I2193 n1_m1_86400_331200 0 2.442183e-07
I2194 n1_m1_86400_336000 0 2.761296e-07
I2195 n1_m1_86400_340800 0 2.054156e-07
I2196 n1_m1_86400_345600 0 2.462177e-07
I2197 n1_m1_86400_350400 0 1.485774e-07
I2198 n1_m1_86400_355200 0 1.609274e-07
I2199 n1_m1_86400_360000 0 1.895582e-07
I2200 n1_m1_86400_364800 0 8.872962e-08
I2201 n1_m1_86400_369600 0 1.130363e-07
I2202 n1_m1_86400_374400 0 7.156842e-08
I2203 n1_m1_86400_379200 0 7.307798e-08
I2204 n1_m1_86400_384000 0 1.098484e-07
I2205 n1_m1_86400_388800 0 7.492701e-08
I2206 n1_m1_86400_393600 0 1.142863e-07
I2207 n1_m1_86400_398400 0 7.465951e-08
I2208 n1_m1_86400_403200 0 7.610446e-08
I2209 n1_m1_86400_408000 0 1.896222e-07
I2210 n1_m1_86400_412800 0 1.364151e-07
I2211 n1_m1_86400_417600 0 3.987076e-07
I2212 n1_m1_86400_422400 0 1.420806e-07
I2213 n1_m1_86400_427200 0 1.056244e-07
I2214 n1_m1_86400_432000 0 1.804455e-07
I2215 n1_m1_86400_436800 0 1.277376e-07
I2216 n1_m1_86400_441600 0 1.397357e-07
I2217 n1_m1_86400_446400 0 9.278210e-08
I2218 n1_m1_86400_451200 0 8.778703e-08
I2219 n1_m1_86400_456000 0 1.214232e-07
I2220 n1_m1_86400_460800 0 7.858189e-08
I2221 n1_m1_86400_465600 0 1.147733e-07
I2222 n1_m1_86400_470400 0 7.327711e-08
I2223 n1_m1_86400_475200 0 7.047654e-08
I2224 n1_m1_86400_480000 0 1.058585e-07
I2225 n1_m1_86400_484800 0 7.344014e-08
I2226 n1_m1_86400_489600 0 1.095767e-07
I2227 n1_m1_86400_494400 0 7.206898e-08
I2228 n1_m1_86400_499200 0 7.241817e-08
I2229 n1_m1_86400_504000 0 1.082740e-07
I2230 n1_m1_86400_508800 0 7.109592e-08
I2231 n1_m1_86400_513600 0 1.049280e-07
I2232 n1_m1_86400_518400 0 7.022167e-08
I2233 n1_m1_86400_523200 0 7.264587e-08
I2234 n1_m1_86400_528000 0 1.096940e-07
I2235 n1_m1_86400_532800 0 7.170518e-08
I2236 n1_m1_86400_537600 0 1.145737e-07
I2237 n1_m1_86400_542400 0 9.931986e-08
I2238 n1_m1_86400_547200 0 1.058403e-07
I2239 n1_m1_86400_552000 0 1.498214e-07
I2240 n1_m1_86400_556800 0 8.686356e-08
I2241 n1_m1_86400_561600 0 4.096184e-08
I2242 n1_m1_91200_0 0 1.585972e-07
I2243 n1_m1_91200_4800 0 1.648344e-07
I2244 n1_m1_91200_9600 0 2.505766e-07
I2245 n1_m1_91200_14400 0 1.550073e-07
I2246 n1_m1_91200_19200 0 1.474019e-07
I2247 n1_m1_91200_24000 0 2.198491e-07
I2248 n1_m1_91200_28800 0 1.443493e-07
I2249 n1_m1_91200_33600 0 2.119940e-07
I2250 n1_m1_91200_38400 0 1.410819e-07
I2251 n1_m1_91200_43200 0 1.399040e-07
I2252 n1_m1_91200_48000 0 2.098560e-07
I2253 n1_m1_91200_52800 0 1.399525e-07
I2254 n1_m1_91200_57600 0 2.148537e-07
I2255 n1_m1_91200_62400 0 1.463375e-07
I2256 n1_m1_91200_67200 0 1.469578e-07
I2257 n1_m1_91200_72000 0 2.296453e-07
I2258 n1_m1_91200_76800 0 1.639825e-07
I2259 n1_m1_91200_81600 0 2.411019e-07
I2260 n1_m1_91200_86400 0 1.568674e-07
I2261 n1_m1_91200_91200 0 1.552162e-07
I2262 n1_m1_91200_96000 0 2.300023e-07
I2263 n1_m1_91200_100800 0 1.581003e-07
I2264 n1_m1_91200_105600 0 2.445852e-07
I2265 n1_m1_91200_110400 0 1.667705e-07
I2266 n1_m1_91200_115200 0 1.671688e-07
I2267 n1_m1_91200_120000 0 2.507532e-07
I2268 n1_m1_91200_124800 0 1.663949e-07
I2269 n1_m1_91200_129600 0 2.417534e-07
I2270 n1_m1_91200_134400 0 1.568674e-07
I2271 n1_m1_91200_139200 0 1.608450e-07
I2272 n1_m1_91200_144000 0 2.450223e-07
I2273 n1_m1_91200_148800 0 1.530532e-07
I2274 n1_m1_91200_153600 0 2.211346e-07
I2275 n1_m1_91200_158400 0 1.465661e-07
I2276 n1_m1_91200_163200 0 1.465661e-07
I2277 n1_m1_91200_168000 0 2.205241e-07
I2278 n1_m1_91200_172800 0 1.489004e-07
I2279 n1_m1_91200_177600 0 2.201315e-07
I2280 n1_m1_91200_182400 0 1.477978e-07
I2281 n1_m1_91200_187200 0 1.486261e-07
I2282 n1_m1_91200_192000 0 2.198491e-07
I2283 n1_m1_91200_196800 0 1.505372e-07
I2284 n1_m1_91200_201600 0 2.374737e-07
I2285 n1_m1_91200_206400 0 1.675227e-07
I2286 n1_m1_91200_211200 0 1.643513e-07
I2287 n1_m1_91200_216000 0 2.490870e-07
I2288 n1_m1_91200_220800 0 2.351683e-07
I2289 n1_m1_91200_225600 0 4.901782e-07
I2290 n1_m1_91200_230400 0 2.590507e-07
I2291 n1_m1_91200_235200 0 2.045670e-07
I2292 n1_m1_91200_240000 0 2.594570e-07
I2293 n1_m1_91200_244800 0 1.640274e-07
I2294 n1_m1_91200_249600 0 2.471107e-07
I2295 n1_m1_91200_254400 0 1.606576e-07
I2296 n1_m1_91200_259200 0 1.598903e-07
I2297 n1_m1_91200_264000 0 2.473510e-07
I2298 n1_m1_91200_268800 0 1.650706e-07
I2299 n1_m1_91200_273600 0 2.295815e-07
I2300 n1_m1_91200_278400 0 1.483798e-07
I2301 n1_m1_91200_283200 0 1.530800e-07
I2302 n1_m1_91200_288000 0 2.298422e-07
I2303 n1_m1_91200_292800 0 1.501579e-07
I2304 n1_m1_91200_297600 0 2.198491e-07
I2305 n1_m1_91200_302400 0 1.465661e-07
I2306 n1_m1_91200_307200 0 1.465661e-07
I2307 n1_m1_91200_312000 0 2.198491e-07
I2308 n1_m1_91200_316800 0 1.489104e-07
I2309 n1_m1_91200_321600 0 2.583109e-07
I2310 n1_m1_91200_326400 0 2.175186e-07
I2311 n1_m1_91200_331200 0 3.336072e-07
I2312 n1_m1_91200_336000 0 3.419741e-07
I2313 n1_m1_91200_340800 0 3.112597e-07
I2314 n1_m1_91200_345600 0 4.736252e-07
I2315 n1_m1_91200_350400 0 3.026002e-07
I2316 n1_m1_91200_355200 0 3.222255e-07
I2317 n1_m1_91200_360000 0 3.955905e-07
I2318 n1_m1_91200_364800 0 1.842827e-07
I2319 n1_m1_91200_369600 0 2.329184e-07
I2320 n1_m1_91200_374400 0 1.468684e-07
I2321 n1_m1_91200_379200 0 1.465661e-07
I2322 n1_m1_91200_384000 0 2.228667e-07
I2323 n1_m1_91200_388800 0 1.560139e-07
I2324 n1_m1_91200_393600 0 2.289430e-07
I2325 n1_m1_91200_398400 0 1.453666e-07
I2326 n1_m1_91200_403200 0 1.499920e-07
I2327 n1_m1_91200_408000 0 3.473751e-07
I2328 n1_m1_91200_412800 0 2.054794e-07
I2329 n1_m1_91200_417600 0 4.692466e-07
I2330 n1_m1_91200_422400 0 2.111904e-07
I2331 n1_m1_91200_427200 0 1.854880e-07
I2332 n1_m1_91200_432000 0 3.129141e-07
I2333 n1_m1_91200_436800 0 2.186864e-07
I2334 n1_m1_91200_441600 0 2.669358e-07
I2335 n1_m1_91200_446400 0 1.788028e-07
I2336 n1_m1_91200_451200 0 1.715667e-07
I2337 n1_m1_91200_456000 0 2.432162e-07
I2338 n1_m1_91200_460800 0 1.587048e-07
I2339 n1_m1_91200_465600 0 2.301088e-07
I2340 n1_m1_91200_470400 0 1.465542e-07
I2341 n1_m1_91200_475200 0 1.409531e-07
I2342 n1_m1_91200_480000 0 2.117171e-07
I2343 n1_m1_91200_484800 0 1.465705e-07
I2344 n1_m1_91200_489600 0 2.203915e-07
I2345 n1_m1_91200_494400 0 1.465661e-07
I2346 n1_m1_91200_499200 0 1.465661e-07
I2347 n1_m1_91200_504000 0 2.198491e-07
I2348 n1_m1_91200_508800 0 1.441766e-07
I2349 n1_m1_91200_513600 0 2.143902e-07
I2350 n1_m1_91200_518400 0 1.432214e-07
I2351 n1_m1_91200_523200 0 1.457597e-07
I2352 n1_m1_91200_528000 0 2.152520e-07
I2353 n1_m1_91200_532800 0 1.389274e-07
I2354 n1_m1_91200_537600 0 2.200684e-07
I2355 n1_m1_91200_542400 0 1.773387e-07
I2356 n1_m1_91200_547200 0 1.844571e-07
I2357 n1_m1_91200_552000 0 2.974479e-07
I2358 n1_m1_91200_556800 0 1.697723e-07
I2359 n1_m1_91200_561600 0 7.984344e-08
I2360 n1_m1_96000_0 0 2.434236e-07
I2361 n1_m1_96000_4800 0 2.529439e-07
I2362 n1_m1_96000_9600 0 3.841212e-07
I2363 n1_m1_96000_14400 0 2.380261e-07
I2364 n1_m1_96000_19200 0 2.260456e-07
I2365 n1_m1_96000_24000 0 3.306788e-07
I2366 n1_m1_96000_28800 0 2.165240e-07
I2367 n1_m1_96000_33600 0 3.177772e-07
I2368 n1_m1_96000_38400 0 2.115051e-07
I2369 n1_m1_96000_43200 0 2.098560e-07
I2370 n1_m1_96000_48000 0 3.147839e-07
I2371 n1_m1_96000_52800 0 2.098560e-07
I2372 n1_m1_96000_57600 0 3.167488e-07
I2373 n1_m1_96000_62400 0 2.190934e-07
I2374 n1_m1_96000_67200 0 2.204865e-07
I2375 n1_m1_96000_72000 0 3.370827e-07
I2376 n1_m1_96000_76800 0 2.267729e-07
I2377 n1_m1_96000_81600 0 3.521565e-07
I2378 n1_m1_96000_86400 0 2.326232e-07
I2379 n1_m1_96000_91200 0 2.273008e-07
I2380 n1_m1_96000_96000 0 3.461507e-07
I2381 n1_m1_96000_100800 0 2.344851e-07
I2382 n1_m1_96000_105600 0 3.511113e-07
I2383 n1_m1_96000_110400 0 2.340742e-07
I2384 n1_m1_96000_115200 0 2.340624e-07
I2385 n1_m1_96000_120000 0 3.509030e-07
I2386 n1_m1_96000_124800 0 2.327232e-07
I2387 n1_m1_96000_129600 0 3.404164e-07
I2388 n1_m1_96000_134400 0 2.240811e-07
I2389 n1_m1_96000_139200 0 2.302259e-07
I2390 n1_m1_96000_144000 0 3.646553e-07
I2391 n1_m1_96000_148800 0 2.469316e-07
I2392 n1_m1_96000_153600 0 3.580271e-07
I2393 n1_m1_96000_158400 0 2.219843e-07
I2394 n1_m1_96000_163200 0 2.154237e-07
I2395 n1_m1_96000_168000 0 3.304396e-07
I2396 n1_m1_96000_172800 0 2.274348e-07
I2397 n1_m1_96000_177600 0 3.307717e-07
I2398 n1_m1_96000_182400 0 2.240159e-07
I2399 n1_m1_96000_187200 0 2.266594e-07
I2400 n1_m1_96000_192000 0 3.297737e-07
I2401 n1_m1_96000_196800 0 2.258059e-07
I2402 n1_m1_96000_201600 0 3.619992e-07
I2403 n1_m1_96000_206400 0 2.572284e-07
I2404 n1_m1_96000_211200 0 2.566505e-07
I2405 n1_m1_96000_216000 0 3.593997e-07
I2406 n1_m1_96000_220800 0 2.797658e-07
I2407 n1_m1_96000_225600 0 5.406387e-07
I2408 n1_m1_96000_230400 0 3.077897e-07
I2409 n1_m1_96000_235200 0 2.728624e-07
I2410 n1_m1_96000_240000 0 3.683722e-07
I2411 n1_m1_96000_244800 0 2.292776e-07
I2412 n1_m1_96000_249600 0 3.459528e-07
I2413 n1_m1_96000_254400 0 2.328305e-07
I2414 n1_m1_96000_259200 0 2.380454e-07
I2415 n1_m1_96000_264000 0 3.707864e-07
I2416 n1_m1_96000_268800 0 2.474636e-07
I2417 n1_m1_96000_273600 0 3.464274e-07
I2418 n1_m1_96000_278400 0 2.267624e-07
I2419 n1_m1_96000_283200 0 2.297481e-07
I2420 n1_m1_96000_288000 0 3.447634e-07
I2421 n1_m1_96000_292800 0 2.252369e-07
I2422 n1_m1_96000_297600 0 3.297737e-07
I2423 n1_m1_96000_302400 0 2.198491e-07
I2424 n1_m1_96000_307200 0 2.198491e-07
I2425 n1_m1_96000_312000 0 3.298127e-07
I2426 n1_m1_96000_316800 0 2.265223e-07
I2427 n1_m1_96000_321600 0 4.434544e-07
I2428 n1_m1_96000_326400 0 4.047439e-07
I2429 n1_m1_96000_331200 0 6.265678e-07
I2430 n1_m1_96000_336000 0 6.444873e-07
I2431 n1_m1_96000_340800 0 5.887973e-07
I2432 n1_m1_96000_345600 0 9.332919e-07
I2433 n1_m1_96000_350400 0 5.230381e-07
I2434 n1_m1_96000_355200 0 4.977996e-07
I2435 n1_m1_96000_360000 0 5.981384e-07
I2436 n1_m1_96000_364800 0 2.766575e-07
I2437 n1_m1_96000_369600 0 3.433290e-07
I2438 n1_m1_96000_374400 0 2.209683e-07
I2439 n1_m1_96000_379200 0 2.250782e-07
I2440 n1_m1_96000_384000 0 3.382827e-07
I2441 n1_m1_96000_388800 0 2.268246e-07
I2442 n1_m1_96000_393600 0 3.354284e-07
I2443 n1_m1_96000_398400 0 2.294285e-07
I2444 n1_m1_96000_403200 0 2.568102e-07
I2445 n1_m1_96000_408000 0 6.907831e-07
I2446 n1_m1_96000_412800 0 3.651672e-07
I2447 n1_m1_96000_417600 0 5.610891e-07
I2448 n1_m1_96000_422400 0 3.315681e-07
I2449 n1_m1_96000_427200 0 2.718213e-07
I2450 n1_m1_96000_432000 0 3.837344e-07
I2451 n1_m1_96000_436800 0 2.523147e-07
I2452 n1_m1_96000_441600 0 3.748886e-07
I2453 n1_m1_96000_446400 0 2.626615e-07
I2454 n1_m1_96000_451200 0 2.493718e-07
I2455 n1_m1_96000_456000 0 3.531672e-07
I2456 n1_m1_96000_460800 0 2.328743e-07
I2457 n1_m1_96000_465600 0 3.436520e-07
I2458 n1_m1_96000_470400 0 2.207942e-07
I2459 n1_m1_96000_475200 0 2.160751e-07
I2460 n1_m1_96000_480000 0 3.175328e-07
I2461 n1_m1_96000_484800 0 2.132536e-07
I2462 n1_m1_96000_489600 0 3.206270e-07
I2463 n1_m1_96000_494400 0 2.198491e-07
I2464 n1_m1_96000_499200 0 2.198491e-07
I2465 n1_m1_96000_504000 0 3.297737e-07
I2466 n1_m1_96000_508800 0 2.198491e-07
I2467 n1_m1_96000_513600 0 3.297737e-07
I2468 n1_m1_96000_518400 0 2.198491e-07
I2469 n1_m1_96000_523200 0 2.194846e-07
I2470 n1_m1_96000_528000 0 3.185212e-07
I2471 n1_m1_96000_532800 0 2.137149e-07
I2472 n1_m1_96000_537600 0 3.361653e-07
I2473 n1_m1_96000_542400 0 2.662890e-07
I2474 n1_m1_96000_547200 0 2.789973e-07
I2475 n1_m1_96000_552000 0 4.709709e-07
I2476 n1_m1_96000_556800 0 2.665132e-07
I2477 n1_m1_96000_561600 0 1.236911e-07
I2478 n1_m1_100800_0 0 1.629249e-07
I2479 n1_m1_100800_4800 0 1.708080e-07
I2480 n1_m1_100800_9600 0 2.567159e-07
I2481 n1_m1_100800_14400 0 1.592086e-07
I2482 n1_m1_100800_19200 0 1.535499e-07
I2483 n1_m1_100800_24000 0 2.253368e-07
I2484 n1_m1_100800_28800 0 1.443493e-07
I2485 n1_m1_100800_33600 0 2.098560e-07
I2486 n1_m1_100800_38400 0 1.399040e-07
I2487 n1_m1_100800_43200 0 1.399040e-07
I2488 n1_m1_100800_48000 0 2.098560e-07
I2489 n1_m1_100800_52800 0 1.399040e-07
I2490 n1_m1_100800_57600 0 2.111659e-07
I2491 n1_m1_100800_62400 0 1.460623e-07
I2492 n1_m1_100800_67200 0 1.478077e-07
I2493 n1_m1_100800_72000 0 2.311678e-07
I2494 n1_m1_100800_76800 0 1.496241e-07
I2495 n1_m1_100800_81600 0 2.441386e-07
I2496 n1_m1_100800_86400 0 1.607307e-07
I2497 n1_m1_100800_91200 0 1.524160e-07
I2498 n1_m1_100800_96000 0 2.343063e-07
I2499 n1_m1_100800_100800 0 1.550182e-07
I2500 n1_m1_100800_105600 0 2.298422e-07
I2501 n1_m1_100800_110400 0 1.532282e-07
I2502 n1_m1_100800_115200 0 1.528684e-07
I2503 n1_m1_100800_120000 0 2.235007e-07
I2504 n1_m1_100800_124800 0 1.479755e-07
I2505 n1_m1_100800_129600 0 2.199558e-07
I2506 n1_m1_100800_134400 0 1.465661e-07
I2507 n1_m1_100800_139200 0 1.535920e-07
I2508 n1_m1_100800_144000 0 2.562252e-07
I2509 n1_m1_100800_148800 0 1.807182e-07
I2510 n1_m1_100800_153600 0 2.594635e-07
I2511 n1_m1_100800_158400 0 1.533261e-07
I2512 n1_m1_100800_163200 0 1.421409e-07
I2513 n1_m1_100800_168000 0 2.136051e-07
I2514 n1_m1_100800_172800 0 1.477100e-07
I2515 n1_m1_100800_177600 0 2.224350e-07
I2516 n1_m1_100800_182400 0 1.521675e-07
I2517 n1_m1_100800_187200 0 1.511063e-07
I2518 n1_m1_100800_192000 0 2.198491e-07
I2519 n1_m1_100800_196800 0 1.505372e-07
I2520 n1_m1_100800_201600 0 2.443593e-07
I2521 n1_m1_100800_206400 0 1.762915e-07
I2522 n1_m1_100800_211200 0 1.817245e-07
I2523 n1_m1_100800_216000 0 2.494248e-07
I2524 n1_m1_100800_220800 0 1.995607e-07
I2525 n1_m1_100800_225600 0 4.409619e-07
I2526 n1_m1_100800_230400 0 2.701144e-07
I2527 n1_m1_100800_235200 0 2.209155e-07
I2528 n1_m1_100800_240000 0 2.495499e-07
I2529 n1_m1_100800_244800 0 1.475120e-07
I2530 n1_m1_100800_249600 0 2.209623e-07
I2531 n1_m1_100800_254400 0 1.480913e-07
I2532 n1_m1_100800_259200 0 1.531333e-07
I2533 n1_m1_100800_264000 0 2.400428e-07
I2534 n1_m1_100800_268800 0 1.607403e-07
I2535 n1_m1_100800_273600 0 2.312033e-07
I2536 n1_m1_100800_278400 0 1.532282e-07
I2537 n1_m1_100800_283200 0 1.532282e-07
I2538 n1_m1_100800_288000 0 2.298422e-07
I2539 n1_m1_100800_292800 0 1.501579e-07
I2540 n1_m1_100800_297600 0 2.198491e-07
I2541 n1_m1_100800_302400 0 1.465661e-07
I2542 n1_m1_100800_307200 0 1.465661e-07
I2543 n1_m1_100800_312000 0 2.210368e-07
I2544 n1_m1_100800_316800 0 1.661741e-07
I2545 n1_m1_100800_321600 0 4.370841e-07
I2546 n1_m1_100800_326400 0 4.093867e-07
I2547 n1_m1_100800_331200 0 5.809992e-07
I2548 n1_m1_100800_336000 0 5.417302e-07
I2549 n1_m1_100800_340800 0 3.902487e-07
I2550 n1_m1_100800_345600 0 5.399380e-07
I2551 n1_m1_100800_350400 0 4.133269e-07
I2552 n1_m1_100800_355200 0 4.421776e-07
I2553 n1_m1_100800_360000 0 4.903861e-07
I2554 n1_m1_100800_364800 0 1.930566e-07
I2555 n1_m1_100800_369600 0 2.248606e-07
I2556 n1_m1_100800_374400 0 1.440187e-07
I2557 n1_m1_100800_379200 0 1.521917e-07
I2558 n1_m1_100800_384000 0 2.258024e-07
I2559 n1_m1_100800_388800 0 1.482434e-07
I2560 n1_m1_100800_393600 0 2.426915e-07
I2561 n1_m1_100800_398400 0 2.857685e-07
I2562 n1_m1_100800_403200 0 5.210301e-07
I2563 n1_m1_100800_408000 0 1.345548e-06
I2564 n1_m1_100800_412800 0 9.324027e-07
I2565 n1_m1_100800_417600 0 1.417779e-06
I2566 n1_m1_100800_422400 0 9.142765e-07
I2567 n1_m1_100800_427200 0 6.311474e-07
I2568 n1_m1_100800_432000 0 4.202462e-07
I2569 n1_m1_100800_436800 0 1.640734e-07
I2570 n1_m1_100800_441600 0 2.397110e-07
I2571 n1_m1_100800_446400 0 1.693010e-07
I2572 n1_m1_100800_451200 0 1.604066e-07
I2573 n1_m1_100800_456000 0 2.365683e-07
I2574 n1_m1_100800_460800 0 1.634660e-07
I2575 n1_m1_100800_465600 0 2.433976e-07
I2576 n1_m1_100800_470400 0 1.565039e-07
I2577 n1_m1_100800_475200 0 1.520796e-07
I2578 n1_m1_100800_480000 0 2.234727e-07
I2579 n1_m1_100800_484800 0 1.438485e-07
I2580 n1_m1_100800_489600 0 2.138741e-07
I2581 n1_m1_100800_494400 0 1.465661e-07
I2582 n1_m1_100800_499200 0 1.465661e-07
I2583 n1_m1_100800_504000 0 2.198491e-07
I2584 n1_m1_100800_508800 0 1.465661e-07
I2585 n1_m1_100800_513600 0 2.198491e-07
I2586 n1_m1_100800_518400 0 1.465661e-07
I2587 n1_m1_100800_523200 0 1.463231e-07
I2588 n1_m1_100800_528000 0 2.140146e-07
I2589 n1_m1_100800_532800 0 1.496651e-07
I2590 n1_m1_100800_537600 0 2.341098e-07
I2591 n1_m1_100800_542400 0 1.834210e-07
I2592 n1_m1_100800_547200 0 1.980366e-07
I2593 n1_m1_100800_552000 0 3.505922e-07
I2594 n1_m1_100800_556800 0 1.889893e-07
I2595 n1_m1_100800_561600 0 8.620753e-08
I2596 n1_m1_105600_0 0 2.398420e-07
I2597 n1_m1_105600_4800 0 2.561956e-07
I2598 n1_m1_105600_9600 0 3.714354e-07
I2599 n1_m1_105600_14400 0 2.309351e-07
I2600 n1_m1_105600_19200 0 2.372243e-07
I2601 n1_m1_105600_24000 0 3.386188e-07
I2602 n1_m1_105600_28800 0 2.121677e-07
I2603 n1_m1_105600_33600 0 3.165036e-07
I2604 n1_m1_105600_38400 0 2.098560e-07
I2605 n1_m1_105600_43200 0 2.098560e-07
I2606 n1_m1_105600_48000 0 3.147839e-07
I2607 n1_m1_105600_52800 0 2.098560e-07
I2608 n1_m1_105600_57600 0 3.152524e-07
I2609 n1_m1_105600_62400 0 2.120585e-07
I2610 n1_m1_105600_67200 0 2.167313e-07
I2611 n1_m1_105600_72000 0 3.596953e-07
I2612 n1_m1_105600_76800 0 2.166045e-07
I2613 n1_m1_105600_81600 0 3.501691e-07
I2614 n1_m1_105600_86400 0 2.354140e-07
I2615 n1_m1_105600_91200 0 2.335949e-07
I2616 n1_m1_105600_96000 0 3.576034e-07
I2617 n1_m1_105600_100800 0 2.396113e-07
I2618 n1_m1_105600_105600 0 3.445647e-07
I2619 n1_m1_105600_110400 0 2.360244e-07
I2620 n1_m1_105600_115200 0 2.367148e-07
I2621 n1_m1_105600_120000 0 3.428612e-07
I2622 n1_m1_105600_124800 0 2.250037e-07
I2623 n1_m1_105600_129600 0 3.295508e-07
I2624 n1_m1_105600_134400 0 2.280654e-07
I2625 n1_m1_105600_139200 0 2.457156e-07
I2626 n1_m1_105600_144000 0 3.856264e-07
I2627 n1_m1_105600_148800 0 2.540135e-07
I2628 n1_m1_105600_153600 0 3.632619e-07
I2629 n1_m1_105600_158400 0 2.300392e-07
I2630 n1_m1_105600_163200 0 2.191698e-07
I2631 n1_m1_105600_168000 0 3.333490e-07
I2632 n1_m1_105600_172800 0 2.228397e-07
I2633 n1_m1_105600_177600 0 3.207601e-07
I2634 n1_m1_105600_182400 0 2.146214e-07
I2635 n1_m1_105600_187200 0 2.162864e-07
I2636 n1_m1_105600_192000 0 3.297737e-07
I2637 n1_m1_105600_196800 0 2.258059e-07
I2638 n1_m1_105600_201600 0 3.507408e-07
I2639 n1_m1_105600_206400 0 2.446923e-07
I2640 n1_m1_105600_211200 0 2.455771e-07
I2641 n1_m1_105600_216000 0 4.072763e-07
I2642 n1_m1_105600_220800 0 3.434629e-07
I2643 n1_m1_105600_225600 0 5.907938e-07
I2644 n1_m1_105600_230400 0 3.852393e-07
I2645 n1_m1_105600_235200 0 2.872402e-07
I2646 n1_m1_105600_240000 0 3.602863e-07
I2647 n1_m1_105600_244800 0 2.302268e-07
I2648 n1_m1_105600_249600 0 3.319420e-07
I2649 n1_m1_105600_254400 0 2.202284e-07
I2650 n1_m1_105600_259200 0 2.262372e-07
I2651 n1_m1_105600_264000 0 3.458243e-07
I2652 n1_m1_105600_268800 0 2.316010e-07
I2653 n1_m1_105600_273600 0 3.518661e-07
I2654 n1_m1_105600_278400 0 2.309408e-07
I2655 n1_m1_105600_283200 0 2.240620e-07
I2656 n1_m1_105600_288000 0 3.400712e-07
I2657 n1_m1_105600_292800 0 2.211337e-07
I2658 n1_m1_105600_297600 0 3.295638e-07
I2659 n1_m1_105600_302400 0 2.142293e-07
I2660 n1_m1_105600_307200 0 2.122387e-07
I2661 n1_m1_105600_312000 0 3.293959e-07
I2662 n1_m1_105600_316800 0 2.573627e-07
I2663 n1_m1_105600_321600 0 6.751045e-07
I2664 n1_m1_105600_326400 0 6.955926e-07
I2665 n1_m1_105600_331200 0 1.128050e-06
I2666 n1_m1_105600_336000 0 1.140170e-06
I2667 n1_m1_105600_340800 0 5.253456e-07
I2668 n1_m1_105600_345600 0 7.796288e-07
I2669 n1_m1_105600_350400 0 6.810196e-07
I2670 n1_m1_105600_355200 0 6.889359e-07
I2671 n1_m1_105600_360000 0 6.459517e-07
I2672 n1_m1_105600_364800 0 2.635227e-07
I2673 n1_m1_105600_369600 0 3.563482e-07
I2674 n1_m1_105600_374400 0 2.171063e-07
I2675 n1_m1_105600_379200 0 2.168785e-07
I2676 n1_m1_105600_384000 0 3.402858e-07
I2677 n1_m1_105600_388800 0 2.471808e-07
I2678 n1_m1_105600_393600 0 4.401630e-07
I2679 n1_m1_105600_398400 0 8.958282e-07
I2680 n1_m1_105600_403200 0 1.160786e-06
I2681 n1_m1_105600_408000 0 1.599631e-06
I2682 n1_m1_105600_412800 0 1.289207e-06
I2683 n1_m1_105600_417600 0 1.856706e-06
I2684 n1_m1_105600_422400 0 9.145590e-07
I2685 n1_m1_105600_427200 0 5.572418e-07
I2686 n1_m1_105600_432000 0 6.469647e-07
I2687 n1_m1_105600_436800 0 2.532802e-07
I2688 n1_m1_105600_441600 0 3.563824e-07
I2689 n1_m1_105600_446400 0 2.335919e-07
I2690 n1_m1_105600_451200 0 2.367598e-07
I2691 n1_m1_105600_456000 0 3.615339e-07
I2692 n1_m1_105600_460800 0 2.422181e-07
I2693 n1_m1_105600_465600 0 3.541353e-07
I2694 n1_m1_105600_470400 0 2.305096e-07
I2695 n1_m1_105600_475200 0 2.236347e-07
I2696 n1_m1_105600_480000 0 3.326821e-07
I2697 n1_m1_105600_484800 0 2.193955e-07
I2698 n1_m1_105600_489600 0 3.234386e-07
I2699 n1_m1_105600_494400 0 2.122387e-07
I2700 n1_m1_105600_499200 0 2.122387e-07
I2701 n1_m1_105600_504000 0 3.183580e-07
I2702 n1_m1_105600_508800 0 2.122387e-07
I2703 n1_m1_105600_513600 0 3.183580e-07
I2704 n1_m1_105600_518400 0 2.122387e-07
I2705 n1_m1_105600_523200 0 2.121518e-07
I2706 n1_m1_105600_528000 0 3.164120e-07
I2707 n1_m1_105600_532800 0 2.150974e-07
I2708 n1_m1_105600_537600 0 3.378292e-07
I2709 n1_m1_105600_542400 0 2.534685e-07
I2710 n1_m1_105600_547200 0 2.917668e-07
I2711 n1_m1_105600_552000 0 4.748641e-07
I2712 n1_m1_105600_556800 0 2.606797e-07
I2713 n1_m1_105600_561600 0 1.256138e-07
I2714 n1_m1_110400_0 0 1.656032e-07
I2715 n1_m1_110400_4800 0 1.822685e-07
I2716 n1_m1_110400_9600 0 2.744530e-07
I2717 n1_m1_110400_14400 0 1.669593e-07
I2718 n1_m1_110400_19200 0 1.672365e-07
I2719 n1_m1_110400_24000 0 2.256934e-07
I2720 n1_m1_110400_28800 0 1.435900e-07
I2721 n1_m1_110400_33600 0 2.191950e-07
I2722 n1_m1_110400_38400 0 1.406923e-07
I2723 n1_m1_110400_43200 0 1.402813e-07
I2724 n1_m1_110400_48000 0 2.098560e-07
I2725 n1_m1_110400_52800 0 1.399040e-07
I2726 n1_m1_110400_57600 0 2.098560e-07
I2727 n1_m1_110400_62400 0 1.399040e-07
I2728 n1_m1_110400_67200 0 1.425117e-07
I2729 n1_m1_110400_72000 0 2.357284e-07
I2730 n1_m1_110400_76800 0 1.473943e-07
I2731 n1_m1_110400_81600 0 2.325814e-07
I2732 n1_m1_110400_86400 0 1.511184e-07
I2733 n1_m1_110400_91200 0 1.440309e-07
I2734 n1_m1_110400_96000 0 2.181220e-07
I2735 n1_m1_110400_100800 0 1.494483e-07
I2736 n1_m1_110400_105600 0 2.357652e-07
I2737 n1_m1_110400_110400 0 1.592082e-07
I2738 n1_m1_110400_115200 0 1.594516e-07
I2739 n1_m1_110400_120000 0 2.320908e-07
I2740 n1_m1_110400_124800 0 1.482096e-07
I2741 n1_m1_110400_129600 0 2.197532e-07
I2742 n1_m1_110400_134400 0 1.437018e-07
I2743 n1_m1_110400_139200 0 1.538224e-07
I2744 n1_m1_110400_144000 0 2.604307e-07
I2745 n1_m1_110400_148800 0 1.768812e-07
I2746 n1_m1_110400_153600 0 2.511317e-07
I2747 n1_m1_110400_158400 0 1.538633e-07
I2748 n1_m1_110400_163200 0 1.430266e-07
I2749 n1_m1_110400_168000 0 2.120466e-07
I2750 n1_m1_110400_172800 0 1.418510e-07
I2751 n1_m1_110400_177600 0 2.107833e-07
I2752 n1_m1_110400_182400 0 1.399040e-07
I2753 n1_m1_110400_187200 0 1.417748e-07
I2754 n1_m1_110400_192000 0 2.192074e-07
I2755 n1_m1_110400_196800 0 1.500673e-07
I2756 n1_m1_110400_201600 0 2.300129e-07
I2757 n1_m1_110400_206400 0 1.584669e-07
I2758 n1_m1_110400_211200 0 1.656610e-07
I2759 n1_m1_110400_216000 0 3.389835e-07
I2760 n1_m1_110400_220800 0 3.343271e-07
I2761 n1_m1_110400_225600 0 5.278598e-07
I2762 n1_m1_110400_230400 0 2.756105e-07
I2763 n1_m1_110400_235200 0 1.764979e-07
I2764 n1_m1_110400_240000 0 2.254218e-07
I2765 n1_m1_110400_244800 0 1.546117e-07
I2766 n1_m1_110400_249600 0 2.324989e-07
I2767 n1_m1_110400_254400 0 1.492398e-07
I2768 n1_m1_110400_259200 0 1.486655e-07
I2769 n1_m1_110400_264000 0 2.231849e-07
I2770 n1_m1_110400_268800 0 1.482564e-07
I2771 n1_m1_110400_273600 0 2.212429e-07
I2772 n1_m1_110400_278400 0 1.444568e-07
I2773 n1_m1_110400_283200 0 1.478708e-07
I2774 n1_m1_110400_288000 0 2.257347e-07
I2775 n1_m1_110400_292800 0 1.465661e-07
I2776 n1_m1_110400_297600 0 2.196871e-07
I2777 n1_m1_110400_302400 0 1.422287e-07
I2778 n1_m1_110400_307200 0 1.401803e-07
I2779 n1_m1_110400_312000 0 2.172838e-07
I2780 n1_m1_110400_316800 0 1.563634e-07
I2781 n1_m1_110400_321600 0 3.507813e-07
I2782 n1_m1_110400_326400 0 3.189341e-07
I2783 n1_m1_110400_331200 0 4.894455e-07
I2784 n1_m1_110400_336000 0 4.645316e-07
I2785 n1_m1_110400_340800 0 2.421955e-07
I2786 n1_m1_110400_345600 0 3.624099e-07
I2787 n1_m1_110400_350400 0 3.088459e-07
I2788 n1_m1_110400_355200 0 3.439518e-07
I2789 n1_m1_110400_360000 0 3.548856e-07
I2790 n1_m1_110400_364800 0 1.586921e-07
I2791 n1_m1_110400_369600 0 2.216458e-07
I2792 n1_m1_110400_374400 0 1.408327e-07
I2793 n1_m1_110400_379200 0 1.418069e-07
I2794 n1_m1_110400_384000 0 2.377612e-07
I2795 n1_m1_110400_388800 0 2.088407e-07
I2796 n1_m1_110400_393600 0 3.437105e-07
I2797 n1_m1_110400_398400 0 6.219277e-07
I2798 n1_m1_110400_403200 0 7.224759e-07
I2799 n1_m1_110400_408000 0 1.040402e-06
I2800 n1_m1_110400_412800 0 8.576775e-07
I2801 n1_m1_110400_417600 0 1.253134e-06
I2802 n1_m1_110400_422400 0 5.097334e-07
I2803 n1_m1_110400_427200 0 2.350031e-07
I2804 n1_m1_110400_432000 0 3.462017e-07
I2805 n1_m1_110400_436800 0 1.661241e-07
I2806 n1_m1_110400_441600 0 2.622044e-07
I2807 n1_m1_110400_446400 0 1.627567e-07
I2808 n1_m1_110400_451200 0 1.518495e-07
I2809 n1_m1_110400_456000 0 2.335245e-07
I2810 n1_m1_110400_460800 0 1.591019e-07
I2811 n1_m1_110400_465600 0 2.302706e-07
I2812 n1_m1_110400_470400 0 1.477023e-07
I2813 n1_m1_110400_475200 0 1.460167e-07
I2814 n1_m1_110400_480000 0 2.186666e-07
I2815 n1_m1_110400_484800 0 1.457778e-07
I2816 n1_m1_110400_489600 0 2.153953e-07
I2817 n1_m1_110400_494400 0 1.399040e-07
I2818 n1_m1_110400_499200 0 1.399040e-07
I2819 n1_m1_110400_504000 0 2.098560e-07
I2820 n1_m1_110400_508800 0 1.399040e-07
I2821 n1_m1_110400_513600 0 2.098560e-07
I2822 n1_m1_110400_518400 0 1.399040e-07
I2823 n1_m1_110400_523200 0 1.399040e-07
I2824 n1_m1_110400_528000 0 2.098560e-07
I2825 n1_m1_110400_532800 0 1.400318e-07
I2826 n1_m1_110400_537600 0 2.170419e-07
I2827 n1_m1_110400_542400 0 1.635814e-07
I2828 n1_m1_110400_547200 0 1.912897e-07
I2829 n1_m1_110400_552000 0 3.012742e-07
I2830 n1_m1_110400_556800 0 1.681053e-07
I2831 n1_m1_110400_561600 0 8.266568e-08
I2832 n1_m1_115200_0 0 8.455521e-08
I2833 n1_m1_115200_4800 0 9.653063e-08
I2834 n1_m1_115200_9600 0 1.468752e-07
I2835 n1_m1_115200_14400 0 8.552574e-08
I2836 n1_m1_115200_19200 0 8.121791e-08
I2837 n1_m1_115200_24000 0 1.106309e-07
I2838 n1_m1_115200_28800 0 7.140155e-08
I2839 n1_m1_115200_33600 0 1.100121e-07
I2840 n1_m1_115200_38400 0 7.225764e-08
I2841 n1_m1_115200_43200 0 7.105558e-08
I2842 n1_m1_115200_48000 0 1.049280e-07
I2843 n1_m1_115200_52800 0 6.995199e-08
I2844 n1_m1_115200_57600 0 1.049280e-07
I2845 n1_m1_115200_62400 0 6.995199e-08
I2846 n1_m1_115200_67200 0 7.039353e-08
I2847 n1_m1_115200_72000 0 1.101324e-07
I2848 n1_m1_115200_76800 0 7.355489e-08
I2849 n1_m1_115200_81600 0 1.149967e-07
I2850 n1_m1_115200_86400 0 7.827567e-08
I2851 n1_m1_115200_91200 0 7.582279e-08
I2852 n1_m1_115200_96000 0 1.181034e-07
I2853 n1_m1_115200_100800 0 8.991107e-08
I2854 n1_m1_115200_105600 0 1.264729e-07
I2855 n1_m1_115200_110400 0 7.841692e-08
I2856 n1_m1_115200_115200 0 7.985505e-08
I2857 n1_m1_115200_120000 0 1.223098e-07
I2858 n1_m1_115200_124800 0 7.619907e-08
I2859 n1_m1_115200_129600 0 1.174262e-07
I2860 n1_m1_115200_134400 0 7.588843e-08
I2861 n1_m1_115200_139200 0 7.423727e-08
I2862 n1_m1_115200_144000 0 1.223305e-07
I2863 n1_m1_115200_148800 0 8.685723e-08
I2864 n1_m1_115200_153600 0 1.259075e-07
I2865 n1_m1_115200_158400 0 7.700527e-08
I2866 n1_m1_115200_163200 0 7.120261e-08
I2867 n1_m1_115200_168000 0 1.054429e-07
I2868 n1_m1_115200_172800 0 7.214482e-08
I2869 n1_m1_115200_177600 0 1.072418e-07
I2870 n1_m1_115200_182400 0 6.995199e-08
I2871 n1_m1_115200_187200 0 7.027858e-08
I2872 n1_m1_115200_192000 0 1.080476e-07
I2873 n1_m1_115200_196800 0 7.389426e-08
I2874 n1_m1_115200_201600 0 1.138823e-07
I2875 n1_m1_115200_206400 0 7.732808e-08
I2876 n1_m1_115200_211200 0 7.573877e-08
I2877 n1_m1_115200_216000 0 1.370954e-07
I2878 n1_m1_115200_220800 0 1.303728e-07
I2879 n1_m1_115200_225600 0 2.527022e-07
I2880 n1_m1_115200_230400 0 1.332527e-07
I2881 n1_m1_115200_235200 0 8.768471e-08
I2882 n1_m1_115200_240000 0 1.172717e-07
I2883 n1_m1_115200_244800 0 7.897812e-08
I2884 n1_m1_115200_249600 0 1.188914e-07
I2885 n1_m1_115200_254400 0 7.811055e-08
I2886 n1_m1_115200_259200 0 7.789434e-08
I2887 n1_m1_115200_264000 0 1.164825e-07
I2888 n1_m1_115200_268800 0 7.585741e-08
I2889 n1_m1_115200_273600 0 1.130127e-07
I2890 n1_m1_115200_278400 0 7.421475e-08
I2891 n1_m1_115200_283200 0 7.399609e-08
I2892 n1_m1_115200_288000 0 1.128674e-07
I2893 n1_m1_115200_292800 0 7.328303e-08
I2894 n1_m1_115200_297600 0 1.098963e-07
I2895 n1_m1_115200_302400 0 7.252585e-08
I2896 n1_m1_115200_307200 0 7.076020e-08
I2897 n1_m1_115200_312000 0 1.087416e-07
I2898 n1_m1_115200_316800 0 8.093355e-08
I2899 n1_m1_115200_321600 0 2.021341e-07
I2900 n1_m1_115200_326400 0 1.420995e-07
I2901 n1_m1_115200_331200 0 1.831527e-07
I2902 n1_m1_115200_336000 0 1.681458e-07
I2903 n1_m1_115200_340800 0 1.043818e-07
I2904 n1_m1_115200_345600 0 1.530648e-07
I2905 n1_m1_115200_350400 0 1.103434e-07
I2906 n1_m1_115200_355200 0 1.371444e-07
I2907 n1_m1_115200_360000 0 1.652384e-07
I2908 n1_m1_115200_364800 0 7.704166e-08
I2909 n1_m1_115200_369600 0 1.069980e-07
I2910 n1_m1_115200_374400 0 6.999851e-08
I2911 n1_m1_115200_379200 0 7.087069e-08
I2912 n1_m1_115200_384000 0 1.142399e-07
I2913 n1_m1_115200_388800 0 8.881208e-08
I2914 n1_m1_115200_393600 0 1.584361e-07
I2915 n1_m1_115200_398400 0 3.827235e-07
I2916 n1_m1_115200_403200 0 4.885117e-07
I2917 n1_m1_115200_408000 0 7.613440e-07
I2918 n1_m1_115200_412800 0 5.048198e-07
I2919 n1_m1_115200_417600 0 6.866185e-07
I2920 n1_m1_115200_422400 0 3.078886e-07
I2921 n1_m1_115200_427200 0 1.486007e-07
I2922 n1_m1_115200_432000 0 2.675602e-07
I2923 n1_m1_115200_436800 0 8.416036e-08
I2924 n1_m1_115200_441600 0 1.260170e-07
I2925 n1_m1_115200_446400 0 7.942558e-08
I2926 n1_m1_115200_451200 0 7.693972e-08
I2927 n1_m1_115200_456000 0 1.181040e-07
I2928 n1_m1_115200_460800 0 7.763948e-08
I2929 n1_m1_115200_465600 0 1.125144e-07
I2930 n1_m1_115200_470400 0 7.313428e-08
I2931 n1_m1_115200_475200 0 7.134046e-08
I2932 n1_m1_115200_480000 0 1.064661e-07
I2933 n1_m1_115200_484800 0 7.097738e-08
I2934 n1_m1_115200_489600 0 1.058950e-07
I2935 n1_m1_115200_494400 0 6.995199e-08
I2936 n1_m1_115200_499200 0 6.995199e-08
I2937 n1_m1_115200_504000 0 1.049280e-07
I2938 n1_m1_115200_508800 0 6.995199e-08
I2939 n1_m1_115200_513600 0 1.049280e-07
I2940 n1_m1_115200_518400 0 6.995199e-08
I2941 n1_m1_115200_523200 0 6.995199e-08
I2942 n1_m1_115200_528000 0 1.049280e-07
I2943 n1_m1_115200_532800 0 6.995199e-08
I2944 n1_m1_115200_537600 0 1.081879e-07
I2945 n1_m1_115200_542400 0 8.102542e-08
I2946 n1_m1_115200_547200 0 9.313815e-08
I2947 n1_m1_115200_552000 0 1.474994e-07
I2948 n1_m1_115200_556800 0 8.405263e-08
I2949 n1_m1_115200_561600 0 4.133284e-08
I2950 n1_m1_120000_0 0 1.719936e-07
I2951 n1_m1_120000_4800 0 1.975322e-07
I2952 n1_m1_120000_9600 0 2.781030e-07
I2953 n1_m1_120000_14400 0 1.601207e-07
I2954 n1_m1_120000_19200 0 1.548745e-07
I2955 n1_m1_120000_24000 0 2.233869e-07
I2956 n1_m1_120000_28800 0 1.453027e-07
I2957 n1_m1_120000_33600 0 2.213620e-07
I2958 n1_m1_120000_38400 0 1.465661e-07
I2959 n1_m1_120000_43200 0 1.465661e-07
I2960 n1_m1_120000_48000 0 2.136375e-07
I2961 n1_m1_120000_52800 0 1.399040e-07
I2962 n1_m1_120000_57600 0 2.098560e-07
I2963 n1_m1_120000_62400 0 1.401943e-07
I2964 n1_m1_120000_67200 0 1.420950e-07
I2965 n1_m1_120000_72000 0 2.241289e-07
I2966 n1_m1_120000_76800 0 1.558117e-07
I2967 n1_m1_120000_81600 0 2.156214e-07
I2968 n1_m1_120000_86400 0 1.523524e-07
I2969 n1_m1_120000_91200 0 1.532625e-07
I2970 n1_m1_120000_96000 0 2.312016e-07
I2971 n1_m1_120000_100800 0 1.596386e-07
I2972 n1_m1_120000_105600 0 2.379917e-07
I2973 n1_m1_120000_110400 0 1.552829e-07
I2974 n1_m1_120000_115200 0 1.585731e-07
I2975 n1_m1_120000_120000 0 2.402541e-07
I2976 n1_m1_120000_124800 0 1.472884e-07
I2977 n1_m1_120000_129600 0 2.222362e-07
I2978 n1_m1_120000_134400 0 1.512066e-07
I2979 n1_m1_120000_139200 0 1.496027e-07
I2980 n1_m1_120000_144000 0 2.421734e-07
I2981 n1_m1_120000_148800 0 1.643289e-07
I2982 n1_m1_120000_153600 0 2.409975e-07
I2983 n1_m1_120000_158400 0 1.541824e-07
I2984 n1_m1_120000_163200 0 1.529614e-07
I2985 n1_m1_120000_168000 0 2.224872e-07
I2986 n1_m1_120000_172800 0 1.502370e-07
I2987 n1_m1_120000_177600 0 2.193457e-07
I2988 n1_m1_120000_182400 0 1.446575e-07
I2989 n1_m1_120000_187200 0 1.437514e-07
I2990 n1_m1_120000_192000 0 2.146703e-07
I2991 n1_m1_120000_196800 0 1.457952e-07
I2992 n1_m1_120000_201600 0 2.248182e-07
I2993 n1_m1_120000_206400 0 1.537102e-07
I2994 n1_m1_120000_211200 0 1.659991e-07
I2995 n1_m1_120000_216000 0 3.129809e-07
I2996 n1_m1_120000_220800 0 3.464851e-07
I2997 n1_m1_120000_225600 0 7.198479e-07
I2998 n1_m1_120000_230400 0 3.001362e-07
I2999 n1_m1_120000_235200 0 1.736933e-07
I3000 n1_m1_120000_240000 0 2.479246e-07
I3001 n1_m1_120000_244800 0 1.493212e-07
I3002 n1_m1_120000_249600 0 2.215990e-07
I3003 n1_m1_120000_254400 0 1.512894e-07
I3004 n1_m1_120000_259200 0 1.522917e-07
I3005 n1_m1_120000_264000 0 2.259873e-07
I3006 n1_m1_120000_268800 0 1.484848e-07
I3007 n1_m1_120000_273600 0 2.201564e-07
I3008 n1_m1_120000_278400 0 1.483798e-07
I3009 n1_m1_120000_283200 0 1.530800e-07
I3010 n1_m1_120000_288000 0 2.261793e-07
I3011 n1_m1_120000_292800 0 1.465661e-07
I3012 n1_m1_120000_297600 0 2.198491e-07
I3013 n1_m1_120000_302400 0 1.465661e-07
I3014 n1_m1_120000_307200 0 1.422393e-07
I3015 n1_m1_120000_312000 0 2.190104e-07
I3016 n1_m1_120000_316800 0 1.716635e-07
I3017 n1_m1_120000_321600 0 4.134173e-07
I3018 n1_m1_120000_326400 0 3.116268e-07
I3019 n1_m1_120000_331200 0 4.211274e-07
I3020 n1_m1_120000_336000 0 3.504563e-07
I3021 n1_m1_120000_340800 0 1.729107e-07
I3022 n1_m1_120000_345600 0 2.475581e-07
I3023 n1_m1_120000_350400 0 1.656158e-07
I3024 n1_m1_120000_355200 0 2.014187e-07
I3025 n1_m1_120000_360000 0 2.887852e-07
I3026 n1_m1_120000_364800 0 1.525156e-07
I3027 n1_m1_120000_369600 0 2.262100e-07
I3028 n1_m1_120000_374400 0 1.548317e-07
I3029 n1_m1_120000_379200 0 1.481632e-07
I3030 n1_m1_120000_384000 0 2.295059e-07
I3031 n1_m1_120000_388800 0 1.725796e-07
I3032 n1_m1_120000_393600 0 2.872761e-07
I3033 n1_m1_120000_398400 0 5.926903e-07
I3034 n1_m1_120000_403200 0 7.654257e-07
I3035 n1_m1_120000_408000 0 1.569837e-06
I3036 n1_m1_120000_412800 0 1.101161e-06
I3037 n1_m1_120000_417600 0 1.707854e-06
I3038 n1_m1_120000_422400 0 1.013074e-06
I3039 n1_m1_120000_427200 0 5.673953e-07
I3040 n1_m1_120000_432000 0 8.508867e-07
I3041 n1_m1_120000_436800 0 1.685111e-07
I3042 n1_m1_120000_441600 0 2.314633e-07
I3043 n1_m1_120000_446400 0 1.474297e-07
I3044 n1_m1_120000_451200 0 1.526422e-07
I3045 n1_m1_120000_456000 0 2.338904e-07
I3046 n1_m1_120000_460800 0 1.465661e-07
I3047 n1_m1_120000_465600 0 2.130431e-07
I3048 n1_m1_120000_470400 0 1.435749e-07
I3049 n1_m1_120000_475200 0 1.406525e-07
I3050 n1_m1_120000_480000 0 2.098560e-07
I3051 n1_m1_120000_484800 0 1.399040e-07
I3052 n1_m1_120000_489600 0 2.098560e-07
I3053 n1_m1_120000_494400 0 1.399040e-07
I3054 n1_m1_120000_499200 0 1.399040e-07
I3055 n1_m1_120000_504000 0 2.098560e-07
I3056 n1_m1_120000_508800 0 1.399040e-07
I3057 n1_m1_120000_513600 0 2.098560e-07
I3058 n1_m1_120000_518400 0 1.399040e-07
I3059 n1_m1_120000_523200 0 1.401470e-07
I3060 n1_m1_120000_528000 0 2.167611e-07
I3061 n1_m1_120000_532800 0 1.402537e-07
I3062 n1_m1_120000_537600 0 2.131159e-07
I3063 n1_m1_120000_542400 0 1.572349e-07
I3064 n1_m1_120000_547200 0 1.788436e-07
I3065 n1_m1_120000_552000 0 2.778571e-07
I3066 n1_m1_120000_556800 0 1.661967e-07
I3067 n1_m1_120000_561600 0 8.171141e-08
I3068 n1_m1_124800_0 0 1.852632e-07
I3069 n1_m1_124800_4800 0 2.318497e-07
I3070 n1_m1_124800_9600 0 3.027545e-07
I3071 n1_m1_124800_14400 0 1.626721e-07
I3072 n1_m1_124800_19200 0 1.599062e-07
I3073 n1_m1_124800_24000 0 2.367368e-07
I3074 n1_m1_124800_28800 0 1.525888e-07
I3075 n1_m1_124800_33600 0 2.229254e-07
I3076 n1_m1_124800_38400 0 1.451495e-07
I3077 n1_m1_124800_43200 0 1.451495e-07
I3078 n1_m1_124800_48000 0 2.141542e-07
I3079 n1_m1_124800_52800 0 1.413206e-07
I3080 n1_m1_124800_57600 0 2.119808e-07
I3081 n1_m1_124800_62400 0 1.421033e-07
I3082 n1_m1_124800_67200 0 1.458582e-07
I3083 n1_m1_124800_72000 0 2.450280e-07
I3084 n1_m1_124800_76800 0 2.003318e-07
I3085 n1_m1_124800_81600 0 2.390738e-07
I3086 n1_m1_124800_86400 0 1.994199e-07
I3087 n1_m1_124800_91200 0 2.006835e-07
I3088 n1_m1_124800_96000 0 2.590432e-07
I3089 n1_m1_124800_100800 0 1.672582e-07
I3090 n1_m1_124800_105600 0 2.534393e-07
I3091 n1_m1_124800_110400 0 1.723567e-07
I3092 n1_m1_124800_115200 0 1.714963e-07
I3093 n1_m1_124800_120000 0 2.500192e-07
I3094 n1_m1_124800_124800 0 1.547376e-07
I3095 n1_m1_124800_129600 0 2.258192e-07
I3096 n1_m1_124800_134400 0 1.531147e-07
I3097 n1_m1_124800_139200 0 1.599336e-07
I3098 n1_m1_124800_144000 0 2.530730e-07
I3099 n1_m1_124800_148800 0 1.620009e-07
I3100 n1_m1_124800_153600 0 2.370767e-07
I3101 n1_m1_124800_158400 0 1.539795e-07
I3102 n1_m1_124800_163200 0 1.529614e-07
I3103 n1_m1_124800_168000 0 2.214482e-07
I3104 n1_m1_124800_172800 0 1.466439e-07
I3105 n1_m1_124800_177600 0 2.173045e-07
I3106 n1_m1_124800_182400 0 1.408441e-07
I3107 n1_m1_124800_187200 0 1.416113e-07
I3108 n1_m1_124800_192000 0 2.150849e-07
I3109 n1_m1_124800_196800 0 1.436436e-07
I3110 n1_m1_124800_201600 0 2.197421e-07
I3111 n1_m1_124800_206400 0 1.514643e-07
I3112 n1_m1_124800_211200 0 1.606505e-07
I3113 n1_m1_124800_216000 0 3.009752e-07
I3114 n1_m1_124800_220800 0 3.416690e-07
I3115 n1_m1_124800_225600 0 8.356047e-07
I3116 n1_m1_124800_230400 0 3.705235e-07
I3117 n1_m1_124800_235200 0 2.159466e-07
I3118 n1_m1_124800_240000 0 2.914496e-07
I3119 n1_m1_124800_244800 0 1.574694e-07
I3120 n1_m1_124800_249600 0 2.450674e-07
I3121 n1_m1_124800_254400 0 1.645135e-07
I3122 n1_m1_124800_259200 0 1.648335e-07
I3123 n1_m1_124800_264000 0 2.420229e-07
I3124 n1_m1_124800_268800 0 1.545790e-07
I3125 n1_m1_124800_273600 0 2.225189e-07
I3126 n1_m1_124800_278400 0 1.483798e-07
I3127 n1_m1_124800_283200 0 1.530800e-07
I3128 n1_m1_124800_288000 0 2.261793e-07
I3129 n1_m1_124800_292800 0 1.465661e-07
I3130 n1_m1_124800_297600 0 2.198491e-07
I3131 n1_m1_124800_302400 0 1.465661e-07
I3132 n1_m1_124800_307200 0 1.431593e-07
I3133 n1_m1_124800_312000 0 2.207672e-07
I3134 n1_m1_124800_316800 0 1.788496e-07
I3135 n1_m1_124800_321600 0 4.360185e-07
I3136 n1_m1_124800_326400 0 4.250887e-07
I3137 n1_m1_124800_331200 0 6.675506e-07
I3138 n1_m1_124800_336000 0 5.612564e-07
I3139 n1_m1_124800_340800 0 1.859903e-07
I3140 n1_m1_124800_345600 0 2.582397e-07
I3141 n1_m1_124800_350400 0 1.696117e-07
I3142 n1_m1_124800_355200 0 1.808196e-07
I3143 n1_m1_124800_360000 0 2.654651e-07
I3144 n1_m1_124800_364800 0 1.528974e-07
I3145 n1_m1_124800_369600 0 2.377148e-07
I3146 n1_m1_124800_374400 0 1.602522e-07
I3147 n1_m1_124800_379200 0 1.486892e-07
I3148 n1_m1_124800_384000 0 2.360842e-07
I3149 n1_m1_124800_388800 0 1.927352e-07
I3150 n1_m1_124800_393600 0 3.121708e-07
I3151 n1_m1_124800_398400 0 2.875620e-07
I3152 n1_m1_124800_403200 0 4.228874e-07
I3153 n1_m1_124800_408000 0 1.319836e-06
I3154 n1_m1_124800_412800 0 1.058243e-06
I3155 n1_m1_124800_417600 0 1.615356e-06
I3156 n1_m1_124800_422400 0 8.612374e-07
I3157 n1_m1_124800_427200 0 3.991692e-07
I3158 n1_m1_124800_432000 0 5.035774e-07
I3159 n1_m1_124800_436800 0 1.607043e-07
I3160 n1_m1_124800_441600 0 2.538126e-07
I3161 n1_m1_124800_446400 0 1.571197e-07
I3162 n1_m1_124800_451200 0 1.417418e-07
I3163 n1_m1_124800_456000 0 2.159291e-07
I3164 n1_m1_124800_460800 0 1.455402e-07
I3165 n1_m1_124800_465600 0 2.117854e-07
I3166 n1_m1_124800_470400 0 1.399818e-07
I3167 n1_m1_124800_475200 0 1.399198e-07
I3168 n1_m1_124800_480000 0 2.098560e-07
I3169 n1_m1_124800_484800 0 1.402001e-07
I3170 n1_m1_124800_489600 0 2.111024e-07
I3171 n1_m1_124800_494400 0 1.399040e-07
I3172 n1_m1_124800_499200 0 1.399040e-07
I3173 n1_m1_124800_504000 0 2.098560e-07
I3174 n1_m1_124800_508800 0 1.399040e-07
I3175 n1_m1_124800_513600 0 2.098560e-07
I3176 n1_m1_124800_518400 0 1.399040e-07
I3177 n1_m1_124800_523200 0 1.401470e-07
I3178 n1_m1_124800_528000 0 2.170724e-07
I3179 n1_m1_124800_532800 0 1.413476e-07
I3180 n1_m1_124800_537600 0 2.132533e-07
I3181 n1_m1_124800_542400 0 1.566678e-07
I3182 n1_m1_124800_547200 0 1.764193e-07
I3183 n1_m1_124800_552000 0 2.708865e-07
I3184 n1_m1_124800_556800 0 1.615439e-07
I3185 n1_m1_124800_561600 0 7.938502e-08
I3186 n1_m1_129600_0 0 2.963420e-07
I3187 n1_m1_129600_4800 0 4.376455e-07
I3188 n1_m1_129600_9600 0 6.937605e-07
I3189 n1_m1_129600_14400 0 2.820294e-07
I3190 n1_m1_129600_19200 0 2.456282e-07
I3191 n1_m1_129600_24000 0 3.493004e-07
I3192 n1_m1_129600_28800 0 2.203840e-07
I3193 n1_m1_129600_33600 0 3.203224e-07
I3194 n1_m1_129600_38400 0 2.102531e-07
I3195 n1_m1_129600_43200 0 2.102531e-07
I3196 n1_m1_129600_48000 0 3.239565e-07
I3197 n1_m1_129600_52800 0 2.194520e-07
I3198 n1_m1_129600_57600 0 3.291780e-07
I3199 n1_m1_129600_62400 0 2.200841e-07
I3200 n1_m1_129600_67200 0 2.243215e-07
I3201 n1_m1_129600_72000 0 5.078021e-07
I3202 n1_m1_129600_76800 0 5.686019e-07
I3203 n1_m1_129600_81600 0 4.129428e-07
I3204 n1_m1_129600_86400 0 3.701990e-07
I3205 n1_m1_129600_91200 0 3.605801e-07
I3206 n1_m1_129600_96000 0 4.071589e-07
I3207 n1_m1_129600_100800 0 3.218914e-07
I3208 n1_m1_129600_105600 0 4.246209e-07
I3209 n1_m1_129600_110400 0 3.138122e-07
I3210 n1_m1_129600_115200 0 2.641766e-07
I3211 n1_m1_129600_120000 0 3.756378e-07
I3212 n1_m1_129600_124800 0 3.020681e-07
I3213 n1_m1_129600_129600 0 3.636407e-07
I3214 n1_m1_129600_134400 0 2.291769e-07
I3215 n1_m1_129600_139200 0 2.384999e-07
I3216 n1_m1_129600_144000 0 3.554267e-07
I3217 n1_m1_129600_148800 0 2.467680e-07
I3218 n1_m1_129600_153600 0 3.720370e-07
I3219 n1_m1_129600_158400 0 2.383943e-07
I3220 n1_m1_129600_163200 0 2.308530e-07
I3221 n1_m1_129600_168000 0 3.329777e-07
I3222 n1_m1_129600_172800 0 2.227510e-07
I3223 n1_m1_129600_177600 0 3.299276e-07
I3224 n1_m1_129600_182400 0 2.155419e-07
I3225 n1_m1_129600_187200 0 2.099824e-07
I3226 n1_m1_129600_192000 0 3.191119e-07
I3227 n1_m1_129600_196800 0 2.124508e-07
I3228 n1_m1_129600_201600 0 3.254395e-07
I3229 n1_m1_129600_206400 0 2.246634e-07
I3230 n1_m1_129600_211200 0 2.459997e-07
I3231 n1_m1_129600_216000 0 5.493821e-07
I3232 n1_m1_129600_220800 0 7.659783e-07
I3233 n1_m1_129600_225600 0 2.059787e-06
I3234 n1_m1_129600_230400 0 9.769576e-07
I3235 n1_m1_129600_235200 0 5.490392e-07
I3236 n1_m1_129600_240000 0 6.120160e-07
I3237 n1_m1_129600_244800 0 2.302648e-07
I3238 n1_m1_129600_249600 0 3.465438e-07
I3239 n1_m1_129600_254400 0 2.382091e-07
I3240 n1_m1_129600_259200 0 2.402325e-07
I3241 n1_m1_129600_264000 0 3.649311e-07
I3242 n1_m1_129600_268800 0 2.353159e-07
I3243 n1_m1_129600_273600 0 3.329998e-07
I3244 n1_m1_129600_278400 0 2.198349e-07
I3245 n1_m1_129600_283200 0 2.295364e-07
I3246 n1_m1_129600_288000 0 3.392689e-07
I3247 n1_m1_129600_292800 0 2.198491e-07
I3248 n1_m1_129600_297600 0 3.297737e-07
I3249 n1_m1_129600_302400 0 2.198491e-07
I3250 n1_m1_129600_307200 0 2.195912e-07
I3251 n1_m1_129600_312000 0 3.326391e-07
I3252 n1_m1_129600_316800 0 2.563184e-07
I3253 n1_m1_129600_321600 0 6.529506e-07
I3254 n1_m1_129600_326400 0 6.944330e-07
I3255 n1_m1_129600_331200 0 1.145660e-06
I3256 n1_m1_129600_336000 0 1.024254e-06
I3257 n1_m1_129600_340800 0 3.040165e-07
I3258 n1_m1_129600_345600 0 3.844998e-07
I3259 n1_m1_129600_350400 0 2.557716e-07
I3260 n1_m1_129600_355200 0 2.634910e-07
I3261 n1_m1_129600_360000 0 3.841759e-07
I3262 n1_m1_129600_364800 0 2.364632e-07
I3263 n1_m1_129600_369600 0 3.496645e-07
I3264 n1_m1_129600_374400 0 2.215808e-07
I3265 n1_m1_129600_379200 0 2.471980e-07
I3266 n1_m1_129600_384000 0 6.257252e-07
I3267 n1_m1_129600_388800 0 6.703384e-07
I3268 n1_m1_129600_393600 0 9.759784e-07
I3269 n1_m1_129600_398400 0 3.839200e-07
I3270 n1_m1_129600_403200 0 5.191062e-07
I3271 n1_m1_129600_408000 0 1.305051e-06
I3272 n1_m1_129600_412800 0 9.879640e-07
I3273 n1_m1_129600_417600 0 1.169513e-06
I3274 n1_m1_129600_422400 0 5.496992e-07
I3275 n1_m1_129600_427200 0 3.166327e-07
I3276 n1_m1_129600_432000 0 4.167033e-07
I3277 n1_m1_129600_436800 0 2.399005e-07
I3278 n1_m1_129600_441600 0 3.550245e-07
I3279 n1_m1_129600_446400 0 2.347147e-07
I3280 n1_m1_129600_451200 0 2.321511e-07
I3281 n1_m1_129600_456000 0 3.280627e-07
I3282 n1_m1_129600_460800 0 2.156211e-07
I3283 n1_m1_129600_465600 0 3.168980e-07
I3284 n1_m1_129600_470400 0 2.131892e-07
I3285 n1_m1_129600_475200 0 2.136138e-07
I3286 n1_m1_129600_480000 0 3.204206e-07
I3287 n1_m1_129600_484800 0 2.148344e-07
I3288 n1_m1_129600_489600 0 3.234648e-07
I3289 n1_m1_129600_494400 0 2.098560e-07
I3290 n1_m1_129600_499200 0 2.098560e-07
I3291 n1_m1_129600_504000 0 3.147839e-07
I3292 n1_m1_129600_508800 0 2.098560e-07
I3293 n1_m1_129600_513600 0 3.147839e-07
I3294 n1_m1_129600_518400 0 2.098560e-07
I3295 n1_m1_129600_523200 0 2.103576e-07
I3296 n1_m1_129600_528000 0 3.311452e-07
I3297 n1_m1_129600_532800 0 2.179882e-07
I3298 n1_m1_129600_537600 0 3.187656e-07
I3299 n1_m1_129600_542400 0 2.297572e-07
I3300 n1_m1_129600_547200 0 2.594372e-07
I3301 n1_m1_129600_552000 0 4.060836e-07
I3302 n1_m1_129600_556800 0 2.421647e-07
I3303 n1_m1_129600_561600 0 1.190020e-07
I3304 n1_m1_134400_0 0 2.213980e-07
I3305 n1_m1_134400_4800 0 4.060119e-07
I3306 n1_m1_134400_9600 0 8.204924e-07
I3307 n1_m1_134400_14400 0 3.264707e-07
I3308 n1_m1_134400_19200 0 1.904173e-07
I3309 n1_m1_134400_24000 0 2.319554e-07
I3310 n1_m1_134400_28800 0 1.430691e-07
I3311 n1_m1_134400_33600 0 2.123649e-07
I3312 n1_m1_134400_38400 0 1.399040e-07
I3313 n1_m1_134400_43200 0 1.399040e-07
I3314 n1_m1_134400_48000 0 2.132996e-07
I3315 n1_m1_134400_52800 0 1.459297e-07
I3316 n1_m1_134400_57600 0 2.236787e-07
I3317 n1_m1_134400_62400 0 1.502632e-07
I3318 n1_m1_134400_67200 0 1.539375e-07
I3319 n1_m1_134400_72000 0 3.952980e-07
I3320 n1_m1_134400_76800 0 4.814712e-07
I3321 n1_m1_134400_81600 0 2.715587e-07
I3322 n1_m1_134400_86400 0 1.961752e-07
I3323 n1_m1_134400_91200 0 2.274893e-07
I3324 n1_m1_134400_96000 0 7.052809e-07
I3325 n1_m1_134400_100800 0 7.397281e-07
I3326 n1_m1_134400_105600 0 1.028275e-06
I3327 n1_m1_134400_110400 0 6.978201e-07
I3328 n1_m1_134400_115200 0 4.909808e-07
I3329 n1_m1_134400_120000 0 6.285433e-07
I3330 n1_m1_134400_124800 0 6.235670e-07
I3331 n1_m1_134400_129600 0 5.904258e-07
I3332 n1_m1_134400_134400 0 2.427749e-07
I3333 n1_m1_134400_139200 0 2.665144e-07
I3334 n1_m1_134400_144000 0 4.342844e-07
I3335 n1_m1_134400_148800 0 3.991872e-07
I3336 n1_m1_134400_153600 0 5.546366e-07
I3337 n1_m1_134400_158400 0 2.210170e-07
I3338 n1_m1_134400_163200 0 1.618717e-07
I3339 n1_m1_134400_168000 0 2.189148e-07
I3340 n1_m1_134400_172800 0 1.491117e-07
I3341 n1_m1_134400_177600 0 2.201758e-07
I3342 n1_m1_134400_182400 0 1.438514e-07
I3343 n1_m1_134400_187200 0 1.399040e-07
I3344 n1_m1_134400_192000 0 2.098560e-07
I3345 n1_m1_134400_196800 0 1.399040e-07
I3346 n1_m1_134400_201600 0 2.171997e-07
I3347 n1_m1_134400_206400 0 1.525470e-07
I3348 n1_m1_134400_211200 0 1.616460e-07
I3349 n1_m1_134400_216000 0 4.664601e-07
I3350 n1_m1_134400_220800 0 7.392383e-07
I3351 n1_m1_134400_225600 0 1.836701e-06
I3352 n1_m1_134400_230400 0 1.059602e-06
I3353 n1_m1_134400_235200 0 8.055660e-07
I3354 n1_m1_134400_240000 0 9.266309e-07
I3355 n1_m1_134400_244800 0 3.845816e-07
I3356 n1_m1_134400_249600 0 5.414154e-07
I3357 n1_m1_134400_254400 0 3.403204e-07
I3358 n1_m1_134400_259200 0 3.053604e-07
I3359 n1_m1_134400_264000 0 3.721993e-07
I3360 n1_m1_134400_268800 0 1.834275e-07
I3361 n1_m1_134400_273600 0 2.349823e-07
I3362 n1_m1_134400_278400 0 1.504416e-07
I3363 n1_m1_134400_283200 0 1.531430e-07
I3364 n1_m1_134400_288000 0 2.261793e-07
I3365 n1_m1_134400_292800 0 1.465661e-07
I3366 n1_m1_134400_297600 0 2.198491e-07
I3367 n1_m1_134400_302400 0 1.465661e-07
I3368 n1_m1_134400_307200 0 1.445105e-07
I3369 n1_m1_134400_312000 0 2.256724e-07
I3370 n1_m1_134400_316800 0 1.972514e-07
I3371 n1_m1_134400_321600 0 6.339894e-07
I3372 n1_m1_134400_326400 0 5.638520e-07
I3373 n1_m1_134400_331200 0 7.364096e-07
I3374 n1_m1_134400_336000 0 6.557919e-07
I3375 n1_m1_134400_340800 0 2.568947e-07
I3376 n1_m1_134400_345600 0 2.687575e-07
I3377 n1_m1_134400_350400 0 1.740074e-07
I3378 n1_m1_134400_355200 0 1.834210e-07
I3379 n1_m1_134400_360000 0 2.623514e-07
I3380 n1_m1_134400_364800 0 1.637159e-07
I3381 n1_m1_134400_369600 0 2.242606e-07
I3382 n1_m1_134400_374400 0 1.400199e-07
I3383 n1_m1_134400_379200 0 2.159257e-07
I3384 n1_m1_134400_384000 0 7.498310e-07
I3385 n1_m1_134400_388800 0 6.216521e-07
I3386 n1_m1_134400_393600 0 8.728350e-07
I3387 n1_m1_134400_398400 0 2.493548e-07
I3388 n1_m1_134400_403200 0 3.778869e-07
I3389 n1_m1_134400_408000 0 8.999579e-07
I3390 n1_m1_134400_412800 0 7.175904e-07
I3391 n1_m1_134400_417600 0 7.183853e-07
I3392 n1_m1_134400_422400 0 4.384144e-07
I3393 n1_m1_134400_427200 0 3.080326e-07
I3394 n1_m1_134400_432000 0 2.781387e-07
I3395 n1_m1_134400_436800 0 1.641182e-07
I3396 n1_m1_134400_441600 0 2.328114e-07
I3397 n1_m1_134400_446400 0 1.884357e-07
I3398 n1_m1_134400_451200 0 1.931717e-07
I3399 n1_m1_134400_456000 0 2.200623e-07
I3400 n1_m1_134400_460800 0 1.465661e-07
I3401 n1_m1_134400_465600 0 2.164361e-07
I3402 n1_m1_134400_470400 0 1.461709e-07
I3403 n1_m1_134400_475200 0 1.465661e-07
I3404 n1_m1_134400_480000 0 2.198491e-07
I3405 n1_m1_134400_484800 0 1.465661e-07
I3406 n1_m1_134400_489600 0 2.161387e-07
I3407 n1_m1_134400_494400 0 1.399040e-07
I3408 n1_m1_134400_499200 0 1.399040e-07
I3409 n1_m1_134400_504000 0 2.098560e-07
I3410 n1_m1_134400_508800 0 1.399040e-07
I3411 n1_m1_134400_513600 0 2.098560e-07
I3412 n1_m1_134400_518400 0 1.399040e-07
I3413 n1_m1_134400_523200 0 1.403900e-07
I3414 n1_m1_134400_528000 0 2.251302e-07
I3415 n1_m1_134400_532800 0 1.457481e-07
I3416 n1_m1_134400_537600 0 2.120508e-07
I3417 n1_m1_134400_542400 0 1.512036e-07
I3418 n1_m1_134400_547200 0 1.696108e-07
I3419 n1_m1_134400_552000 0 2.681198e-07
I3420 n1_m1_134400_556800 0 1.614432e-07
I3421 n1_m1_134400_561600 0 7.933463e-08
I3422 n1_m1_139200_0 0 2.198977e-07
I3423 n1_m1_139200_4800 0 3.786935e-07
I3424 n1_m1_139200_9600 0 7.402127e-07
I3425 n1_m1_139200_14400 0 3.328235e-07
I3426 n1_m1_139200_19200 0 1.954678e-07
I3427 n1_m1_139200_24000 0 2.431867e-07
I3428 n1_m1_139200_28800 0 1.482825e-07
I3429 n1_m1_139200_33600 0 2.187759e-07
I3430 n1_m1_139200_38400 0 1.607484e-07
I3431 n1_m1_139200_43200 0 1.600436e-07
I3432 n1_m1_139200_48000 0 2.187777e-07
I3433 n1_m1_139200_52800 0 1.516689e-07
I3434 n1_m1_139200_57600 0 2.244291e-07
I3435 n1_m1_139200_62400 0 1.629844e-07
I3436 n1_m1_139200_67200 0 2.150544e-07
I3437 n1_m1_139200_72000 0 3.613192e-07
I3438 n1_m1_139200_76800 0 3.929920e-07
I3439 n1_m1_139200_81600 0 3.196826e-07
I3440 n1_m1_139200_86400 0 3.312887e-07
I3441 n1_m1_139200_91200 0 3.536423e-07
I3442 n1_m1_139200_96000 0 9.922282e-07
I3443 n1_m1_139200_100800 0 1.089774e-06
I3444 n1_m1_139200_105600 0 1.709049e-06
I3445 n1_m1_139200_110400 0 9.907945e-07
I3446 n1_m1_139200_115200 0 7.605442e-07
I3447 n1_m1_139200_120000 0 8.959352e-07
I3448 n1_m1_139200_124800 0 8.251700e-07
I3449 n1_m1_139200_129600 0 8.244140e-07
I3450 n1_m1_139200_134400 0 5.659953e-07
I3451 n1_m1_139200_139200 0 5.891248e-07
I3452 n1_m1_139200_144000 0 7.944168e-07
I3453 n1_m1_139200_148800 0 6.575283e-07
I3454 n1_m1_139200_153600 0 7.097837e-07
I3455 n1_m1_139200_158400 0 2.891017e-07
I3456 n1_m1_139200_163200 0 1.746926e-07
I3457 n1_m1_139200_168000 0 2.167603e-07
I3458 n1_m1_139200_172800 0 1.561726e-07
I3459 n1_m1_139200_177600 0 2.210506e-07
I3460 n1_m1_139200_182400 0 1.438514e-07
I3461 n1_m1_139200_187200 0 1.407233e-07
I3462 n1_m1_139200_192000 0 2.137145e-07
I3463 n1_m1_139200_196800 0 1.424764e-07
I3464 n1_m1_139200_201600 0 2.215480e-07
I3465 n1_m1_139200_206400 0 1.592697e-07
I3466 n1_m1_139200_211200 0 1.707588e-07
I3467 n1_m1_139200_216000 0 9.417393e-07
I3468 n1_m1_139200_220800 0 9.264033e-07
I3469 n1_m1_139200_225600 0 1.979724e-06
I3470 n1_m1_139200_230400 0 1.265027e-06
I3471 n1_m1_139200_235200 0 1.186308e-06
I3472 n1_m1_139200_240000 0 1.457594e-06
I3473 n1_m1_139200_244800 0 6.822329e-07
I3474 n1_m1_139200_249600 0 1.006076e-06
I3475 n1_m1_139200_254400 0 5.756261e-07
I3476 n1_m1_139200_259200 0 4.918095e-07
I3477 n1_m1_139200_264000 0 5.458653e-07
I3478 n1_m1_139200_268800 0 2.151266e-07
I3479 n1_m1_139200_273600 0 2.526558e-07
I3480 n1_m1_139200_278400 0 1.543324e-07
I3481 n1_m1_139200_283200 0 1.522046e-07
I3482 n1_m1_139200_288000 0 2.244628e-07
I3483 n1_m1_139200_292800 0 1.505253e-07
I3484 n1_m1_139200_297600 0 2.213939e-07
I3485 n1_m1_139200_302400 0 1.446665e-07
I3486 n1_m1_139200_307200 0 1.463496e-07
I3487 n1_m1_139200_312000 0 4.370267e-07
I3488 n1_m1_139200_316800 0 3.131470e-07
I3489 n1_m1_139200_321600 0 9.346522e-07
I3490 n1_m1_139200_326400 0 7.808832e-07
I3491 n1_m1_139200_331200 0 9.355969e-07
I3492 n1_m1_139200_336000 0 9.697702e-07
I3493 n1_m1_139200_340800 0 3.179234e-07
I3494 n1_m1_139200_345600 0 3.514271e-07
I3495 n1_m1_139200_350400 0 2.265695e-07
I3496 n1_m1_139200_355200 0 2.093096e-07
I3497 n1_m1_139200_360000 0 2.764626e-07
I3498 n1_m1_139200_364800 0 1.632966e-07
I3499 n1_m1_139200_369600 0 2.187156e-07
I3500 n1_m1_139200_374400 0 1.449931e-07
I3501 n1_m1_139200_379200 0 2.198781e-07
I3502 n1_m1_139200_384000 0 6.493679e-07
I3503 n1_m1_139200_388800 0 4.531615e-07
I3504 n1_m1_139200_393600 0 8.606626e-07
I3505 n1_m1_139200_398400 0 3.565268e-07
I3506 n1_m1_139200_403200 0 5.855879e-07
I3507 n1_m1_139200_408000 0 1.453254e-06
I3508 n1_m1_139200_412800 0 1.118103e-06
I3509 n1_m1_139200_417600 0 1.308286e-06
I3510 n1_m1_139200_422400 0 6.460979e-07
I3511 n1_m1_139200_427200 0 3.564852e-07
I3512 n1_m1_139200_432000 0 2.808728e-07
I3513 n1_m1_139200_436800 0 1.676443e-07
I3514 n1_m1_139200_441600 0 2.296527e-07
I3515 n1_m1_139200_446400 0 1.989316e-07
I3516 n1_m1_139200_451200 0 2.019560e-07
I3517 n1_m1_139200_456000 0 2.231816e-07
I3518 n1_m1_139200_460800 0 1.479850e-07
I3519 n1_m1_139200_465600 0 2.173385e-07
I3520 n1_m1_139200_470400 0 1.462754e-07
I3521 n1_m1_139200_475200 0 1.463853e-07
I3522 n1_m1_139200_480000 0 2.165101e-07
I3523 n1_m1_139200_484800 0 1.445315e-07
I3524 n1_m1_139200_489600 0 2.159762e-07
I3525 n1_m1_139200_494400 0 1.399040e-07
I3526 n1_m1_139200_499200 0 1.399040e-07
I3527 n1_m1_139200_504000 0 2.098560e-07
I3528 n1_m1_139200_508800 0 1.399040e-07
I3529 n1_m1_139200_513600 0 2.101787e-07
I3530 n1_m1_139200_518400 0 1.418905e-07
I3531 n1_m1_139200_523200 0 1.406006e-07
I3532 n1_m1_139200_528000 0 2.165663e-07
I3533 n1_m1_139200_532800 0 1.442583e-07
I3534 n1_m1_139200_537600 0 2.232481e-07
I3535 n1_m1_139200_542400 0 1.776380e-07
I3536 n1_m1_139200_547200 0 2.237999e-07
I3537 n1_m1_139200_552000 0 3.460482e-07
I3538 n1_m1_139200_556800 0 1.750465e-07
I3539 n1_m1_139200_561600 0 8.470824e-08
I3540 n1_m1_144000_0 0 2.725575e-07
I3541 n1_m1_144000_4800 0 3.162627e-07
I3542 n1_m1_144000_9600 0 4.109681e-07
I3543 n1_m1_144000_14400 0 2.383054e-07
I3544 n1_m1_144000_19200 0 2.451772e-07
I3545 n1_m1_144000_24000 0 3.679147e-07
I3546 n1_m1_144000_28800 0 2.230170e-07
I3547 n1_m1_144000_33600 0 3.368418e-07
I3548 n1_m1_144000_38400 0 2.748252e-07
I3549 n1_m1_144000_43200 0 2.728056e-07
I3550 n1_m1_144000_48000 0 3.452434e-07
I3551 n1_m1_144000_52800 0 2.388163e-07
I3552 n1_m1_144000_57600 0 3.268209e-07
I3553 n1_m1_144000_62400 0 2.621571e-07
I3554 n1_m1_144000_67200 0 4.416687e-07
I3555 n1_m1_144000_72000 0 5.769461e-07
I3556 n1_m1_144000_76800 0 6.011060e-07
I3557 n1_m1_144000_81600 0 6.877077e-07
I3558 n1_m1_144000_86400 0 8.039322e-07
I3559 n1_m1_144000_91200 0 7.312360e-07
I3560 n1_m1_144000_96000 0 9.401628e-07
I3561 n1_m1_144000_100800 0 9.066211e-07
I3562 n1_m1_144000_105600 0 1.604316e-06
I3563 n1_m1_144000_110400 0 8.809700e-07
I3564 n1_m1_144000_115200 0 8.923620e-07
I3565 n1_m1_144000_120000 0 7.940044e-07
I3566 n1_m1_144000_124800 0 5.729134e-07
I3567 n1_m1_144000_129600 0 8.467520e-07
I3568 n1_m1_144000_134400 0 1.245850e-06
I3569 n1_m1_144000_139200 0 1.175942e-06
I3570 n1_m1_144000_144000 0 1.201347e-06
I3571 n1_m1_144000_148800 0 8.045746e-07
I3572 n1_m1_144000_153600 0 5.818040e-07
I3573 n1_m1_144000_158400 0 3.771177e-07
I3574 n1_m1_144000_163200 0 2.570178e-07
I3575 n1_m1_144000_168000 0 3.246814e-07
I3576 n1_m1_144000_172800 0 2.386297e-07
I3577 n1_m1_144000_177600 0 3.367654e-07
I3578 n1_m1_144000_182400 0 2.157772e-07
I3579 n1_m1_144000_187200 0 2.130388e-07
I3580 n1_m1_144000_192000 0 3.297737e-07
I3581 n1_m1_144000_196800 0 2.198491e-07
I3582 n1_m1_144000_201600 0 3.426918e-07
I3583 n1_m1_144000_206400 0 2.545139e-07
I3584 n1_m1_144000_211200 0 2.705680e-07
I3585 n1_m1_144000_216000 0 2.347597e-06
I3586 n1_m1_144000_220800 0 1.553498e-06
I3587 n1_m1_144000_225600 0 2.799904e-06
I3588 n1_m1_144000_230400 0 1.752722e-06
I3589 n1_m1_144000_235200 0 1.730002e-06
I3590 n1_m1_144000_240000 0 2.026508e-06
I3591 n1_m1_144000_244800 0 1.010273e-06
I3592 n1_m1_144000_249600 0 1.581563e-06
I3593 n1_m1_144000_254400 0 7.841535e-07
I3594 n1_m1_144000_259200 0 6.439722e-07
I3595 n1_m1_144000_264000 0 6.898159e-07
I3596 n1_m1_144000_268800 0 2.882245e-07
I3597 n1_m1_144000_273600 0 3.548117e-07
I3598 n1_m1_144000_278400 0 2.278152e-07
I3599 n1_m1_144000_283200 0 2.296800e-07
I3600 n1_m1_144000_288000 0 3.329509e-07
I3601 n1_m1_144000_292800 0 2.352300e-07
I3602 n1_m1_144000_297600 0 3.357749e-07
I3603 n1_m1_144000_302400 0 2.124698e-07
I3604 n1_m1_144000_307200 0 2.361401e-07
I3605 n1_m1_144000_312000 0 1.261762e-06
I3606 n1_m1_144000_316800 0 8.339841e-07
I3607 n1_m1_144000_321600 0 2.008195e-06
I3608 n1_m1_144000_326400 0 1.582601e-06
I3609 n1_m1_144000_331200 0 1.687969e-06
I3610 n1_m1_144000_336000 0 1.821350e-06
I3611 n1_m1_144000_340800 0 4.558266e-07
I3612 n1_m1_144000_345600 0 5.844998e-07
I3613 n1_m1_144000_350400 0 3.724730e-07
I3614 n1_m1_144000_355200 0 3.174426e-07
I3615 n1_m1_144000_360000 0 4.140231e-07
I3616 n1_m1_144000_364800 0 2.396459e-07
I3617 n1_m1_144000_369600 0 3.283169e-07
I3618 n1_m1_144000_374400 0 2.259674e-07
I3619 n1_m1_144000_379200 0 2.601727e-07
I3620 n1_m1_144000_384000 0 4.811440e-07
I3621 n1_m1_144000_388800 0 5.595678e-07
I3622 n1_m1_144000_393600 0 1.222942e-06
I3623 n1_m1_144000_398400 0 6.025323e-07
I3624 n1_m1_144000_403200 0 8.939435e-07
I3625 n1_m1_144000_408000 0 2.416077e-06
I3626 n1_m1_144000_412800 0 1.844314e-06
I3627 n1_m1_144000_417600 0 2.548464e-06
I3628 n1_m1_144000_422400 0 9.090040e-07
I3629 n1_m1_144000_427200 0 3.441974e-07
I3630 n1_m1_144000_432000 0 4.112277e-07
I3631 n1_m1_144000_436800 0 2.983104e-07
I3632 n1_m1_144000_441600 0 3.617203e-07
I3633 n1_m1_144000_446400 0 3.480522e-07
I3634 n1_m1_144000_451200 0 3.487007e-07
I3635 n1_m1_144000_456000 0 3.675322e-07
I3636 n1_m1_144000_460800 0 2.306068e-07
I3637 n1_m1_144000_465600 0 3.270535e-07
I3638 n1_m1_144000_470400 0 2.193127e-07
I3639 n1_m1_144000_475200 0 2.191467e-07
I3640 n1_m1_144000_480000 0 3.168021e-07
I3641 n1_m1_144000_484800 0 2.119453e-07
I3642 n1_m1_144000_489600 0 3.235768e-07
I3643 n1_m1_144000_494400 0 2.098560e-07
I3644 n1_m1_144000_499200 0 2.098560e-07
I3645 n1_m1_144000_504000 0 3.188581e-07
I3646 n1_m1_144000_508800 0 2.151015e-07
I3647 n1_m1_144000_513600 0 3.232478e-07
I3648 n1_m1_144000_518400 0 2.183431e-07
I3649 n1_m1_144000_523200 0 2.114029e-07
I3650 n1_m1_144000_528000 0 3.032736e-07
I3651 n1_m1_144000_532800 0 2.069448e-07
I3652 n1_m1_144000_537600 0 3.422670e-07
I3653 n1_m1_144000_542400 0 2.900435e-07
I3654 n1_m1_144000_547200 0 3.880533e-07
I3655 n1_m1_144000_552000 0 5.943353e-07
I3656 n1_m1_144000_556800 0 2.641820e-07
I3657 n1_m1_144000_561600 0 1.270109e-07
I3658 n1_m1_148800_0 0 1.742560e-07
I3659 n1_m1_148800_4800 0 2.053307e-07
I3660 n1_m1_148800_9600 0 3.018147e-07
I3661 n1_m1_148800_14400 0 1.660721e-07
I3662 n1_m1_148800_19200 0 1.640033e-07
I3663 n1_m1_148800_24000 0 2.369176e-07
I3664 n1_m1_148800_28800 0 1.480373e-07
I3665 n1_m1_148800_33600 0 2.249388e-07
I3666 n1_m1_148800_38400 0 1.664380e-07
I3667 n1_m1_148800_43200 0 1.661074e-07
I3668 n1_m1_148800_48000 0 2.215502e-07
I3669 n1_m1_148800_52800 0 1.524040e-07
I3670 n1_m1_148800_57600 0 2.156802e-07
I3671 n1_m1_148800_62400 0 1.653466e-07
I3672 n1_m1_148800_67200 0 2.504131e-07
I3673 n1_m1_148800_72000 0 5.407467e-07
I3674 n1_m1_148800_76800 0 7.644815e-07
I3675 n1_m1_148800_81600 0 9.224573e-07
I3676 n1_m1_148800_86400 0 8.761806e-07
I3677 n1_m1_148800_91200 0 9.876020e-07
I3678 n1_m1_148800_96000 0 1.400388e-06
I3679 n1_m1_148800_100800 0 9.143491e-07
I3680 n1_m1_148800_105600 0 1.277456e-06
I3681 n1_m1_148800_110400 0 9.174321e-07
I3682 n1_m1_148800_115200 0 8.477764e-07
I3683 n1_m1_148800_120000 0 6.513433e-07
I3684 n1_m1_148800_124800 0 4.774016e-07
I3685 n1_m1_148800_129600 0 5.904820e-07
I3686 n1_m1_148800_134400 0 5.922527e-07
I3687 n1_m1_148800_139200 0 5.633220e-07
I3688 n1_m1_148800_144000 0 7.174013e-07
I3689 n1_m1_148800_148800 0 4.475082e-07
I3690 n1_m1_148800_153600 0 3.246085e-07
I3691 n1_m1_148800_158400 0 1.868329e-07
I3692 n1_m1_148800_163200 0 1.627352e-07
I3693 n1_m1_148800_168000 0 2.150131e-07
I3694 n1_m1_148800_172800 0 1.466407e-07
I3695 n1_m1_148800_177600 0 2.196932e-07
I3696 n1_m1_148800_182400 0 1.412315e-07
I3697 n1_m1_148800_187200 0 1.420259e-07
I3698 n1_m1_148800_192000 0 2.198491e-07
I3699 n1_m1_148800_196800 0 1.439304e-07
I3700 n1_m1_148800_201600 0 2.258610e-07
I3701 n1_m1_148800_206400 0 1.700733e-07
I3702 n1_m1_148800_211200 0 2.378603e-07
I3703 n1_m1_148800_216000 0 1.697147e-06
I3704 n1_m1_148800_220800 0 1.218724e-06
I3705 n1_m1_148800_225600 0 1.966490e-06
I3706 n1_m1_148800_230400 0 1.297084e-06
I3707 n1_m1_148800_235200 0 1.333673e-06
I3708 n1_m1_148800_240000 0 1.511091e-06
I3709 n1_m1_148800_244800 0 6.807642e-07
I3710 n1_m1_148800_249600 0 9.315695e-07
I3711 n1_m1_148800_254400 0 3.803084e-07
I3712 n1_m1_148800_259200 0 2.636526e-07
I3713 n1_m1_148800_264000 0 2.910798e-07
I3714 n1_m1_148800_268800 0 1.615619e-07
I3715 n1_m1_148800_273600 0 2.234070e-07
I3716 n1_m1_148800_278400 0 1.486061e-07
I3717 n1_m1_148800_283200 0 1.563466e-07
I3718 n1_m1_148800_288000 0 2.285159e-07
I3719 n1_m1_148800_292800 0 1.592039e-07
I3720 n1_m1_148800_297600 0 2.239719e-07
I3721 n1_m1_148800_302400 0 1.449116e-07
I3722 n1_m1_148800_307200 0 1.688313e-07
I3723 n1_m1_148800_312000 0 9.781751e-07
I3724 n1_m1_148800_316800 0 7.674487e-07
I3725 n1_m1_148800_321600 0 1.759558e-06
I3726 n1_m1_148800_326400 0 1.249592e-06
I3727 n1_m1_148800_331200 0 1.141123e-06
I3728 n1_m1_148800_336000 0 1.168869e-06
I3729 n1_m1_148800_340800 0 4.134999e-07
I3730 n1_m1_148800_345600 0 4.319902e-07
I3731 n1_m1_148800_350400 0 2.010617e-07
I3732 n1_m1_148800_355200 0 1.776954e-07
I3733 n1_m1_148800_360000 0 2.569197e-07
I3734 n1_m1_148800_364800 0 1.609489e-07
I3735 n1_m1_148800_369600 0 2.229075e-07
I3736 n1_m1_148800_374400 0 1.485984e-07
I3737 n1_m1_148800_379200 0 1.588542e-07
I3738 n1_m1_148800_384000 0 2.541041e-07
I3739 n1_m1_148800_388800 0 3.138991e-07
I3740 n1_m1_148800_393600 0 7.561553e-07
I3741 n1_m1_148800_398400 0 3.382267e-07
I3742 n1_m1_148800_403200 0 4.730047e-07
I3743 n1_m1_148800_408000 0 1.343376e-06
I3744 n1_m1_148800_412800 0 1.089448e-06
I3745 n1_m1_148800_417600 0 1.813284e-06
I3746 n1_m1_148800_422400 0 8.334558e-07
I3747 n1_m1_148800_427200 0 4.493569e-07
I3748 n1_m1_148800_432000 0 5.643803e-07
I3749 n1_m1_148800_436800 0 3.692730e-07
I3750 n1_m1_148800_441600 0 3.865258e-07
I3751 n1_m1_148800_446400 0 3.115090e-07
I3752 n1_m1_148800_451200 0 2.531589e-07
I3753 n1_m1_148800_456000 0 2.396341e-07
I3754 n1_m1_148800_460800 0 1.569030e-07
I3755 n1_m1_148800_465600 0 2.229834e-07
I3756 n1_m1_148800_470400 0 1.504881e-07
I3757 n1_m1_148800_475200 0 1.505195e-07
I3758 n1_m1_148800_480000 0 2.165987e-07
I3759 n1_m1_148800_484800 0 1.413795e-07
I3760 n1_m1_148800_489600 0 2.157179e-07
I3761 n1_m1_148800_494400 0 1.399040e-07
I3762 n1_m1_148800_499200 0 1.399040e-07
I3763 n1_m1_148800_504000 0 2.150303e-07
I3764 n1_m1_148800_508800 0 1.465661e-07
I3765 n1_m1_148800_513600 0 2.198491e-07
I3766 n1_m1_148800_518400 0 1.460267e-07
I3767 n1_m1_148800_523200 0 1.412579e-07
I3768 n1_m1_148800_528000 0 2.125960e-07
I3769 n1_m1_148800_532800 0 1.424778e-07
I3770 n1_m1_148800_537600 0 2.238873e-07
I3771 n1_m1_148800_542400 0 1.723293e-07
I3772 n1_m1_148800_547200 0 2.103284e-07
I3773 n1_m1_148800_552000 0 3.253757e-07
I3774 n1_m1_148800_556800 0 1.575194e-07
I3775 n1_m1_148800_561600 0 7.691044e-08
I3776 n1_m1_153600_0 0 2.913003e-07
I3777 n1_m1_153600_4800 0 4.057232e-07
I3778 n1_m1_153600_9600 0 6.535254e-07
I3779 n1_m1_153600_14400 0 2.770305e-07
I3780 n1_m1_153600_19200 0 2.557978e-07
I3781 n1_m1_153600_24000 0 3.535680e-07
I3782 n1_m1_153600_28800 0 2.231742e-07
I3783 n1_m1_153600_33600 0 3.376953e-07
I3784 n1_m1_153600_38400 0 2.306110e-07
I3785 n1_m1_153600_43200 0 2.293182e-07
I3786 n1_m1_153600_48000 0 3.234342e-07
I3787 n1_m1_153600_52800 0 2.248108e-07
I3788 n1_m1_153600_57600 0 3.221273e-07
I3789 n1_m1_153600_62400 0 2.316003e-07
I3790 n1_m1_153600_67200 0 2.944872e-07
I3791 n1_m1_153600_72000 0 7.831943e-07
I3792 n1_m1_153600_76800 0 1.148445e-06
I3793 n1_m1_153600_81600 0 1.296813e-06
I3794 n1_m1_153600_86400 0 1.229608e-06
I3795 n1_m1_153600_91200 0 1.541550e-06
I3796 n1_m1_153600_96000 0 2.335981e-06
I3797 n1_m1_153600_100800 0 1.662836e-06
I3798 n1_m1_153600_105600 0 2.397325e-06
I3799 n1_m1_153600_110400 0 1.574287e-06
I3800 n1_m1_153600_115200 0 1.376745e-06
I3801 n1_m1_153600_120000 0 1.500370e-06
I3802 n1_m1_153600_124800 0 1.063882e-06
I3803 n1_m1_153600_129600 0 7.395297e-07
I3804 n1_m1_153600_134400 0 8.056074e-07
I3805 n1_m1_153600_139200 0 1.204288e-06
I3806 n1_m1_153600_144000 0 2.132018e-06
I3807 n1_m1_153600_148800 0 1.224687e-06
I3808 n1_m1_153600_153600 0 7.154132e-07
I3809 n1_m1_153600_158400 0 2.640895e-07
I3810 n1_m1_153600_163200 0 2.432722e-07
I3811 n1_m1_153600_168000 0 3.438604e-07
I3812 n1_m1_153600_172800 0 2.196634e-07
I3813 n1_m1_153600_177600 0 3.247324e-07
I3814 n1_m1_153600_182400 0 2.098560e-07
I3815 n1_m1_153600_187200 0 2.130388e-07
I3816 n1_m1_153600_192000 0 3.297737e-07
I3817 n1_m1_153600_196800 0 2.138923e-07
I3818 n1_m1_153600_201600 0 3.294202e-07
I3819 n1_m1_153600_206400 0 2.476640e-07
I3820 n1_m1_153600_211200 0 3.131479e-07
I3821 n1_m1_153600_216000 0 2.447962e-06
I3822 n1_m1_153600_220800 0 1.866142e-06
I3823 n1_m1_153600_225600 0 2.975739e-06
I3824 n1_m1_153600_230400 0 1.984122e-06
I3825 n1_m1_153600_235200 0 2.035822e-06
I3826 n1_m1_153600_240000 0 2.205916e-06
I3827 n1_m1_153600_244800 0 9.227416e-07
I3828 n1_m1_153600_249600 0 1.177309e-06
I3829 n1_m1_153600_254400 0 4.109457e-07
I3830 n1_m1_153600_259200 0 2.890835e-07
I3831 n1_m1_153600_264000 0 3.715252e-07
I3832 n1_m1_153600_268800 0 2.256859e-07
I3833 n1_m1_153600_273600 0 3.282199e-07
I3834 n1_m1_153600_278400 0 2.170853e-07
I3835 n1_m1_153600_283200 0 2.300246e-07
I3836 n1_m1_153600_288000 0 3.518625e-07
I3837 n1_m1_153600_292800 0 2.402217e-07
I3838 n1_m1_153600_297600 0 3.301674e-07
I3839 n1_m1_153600_302400 0 2.175665e-07
I3840 n1_m1_153600_307200 0 2.521644e-07
I3841 n1_m1_153600_312000 0 1.381613e-06
I3842 n1_m1_153600_316800 0 1.132895e-06
I3843 n1_m1_153600_321600 0 2.700227e-06
I3844 n1_m1_153600_326400 0 1.864454e-06
I3845 n1_m1_153600_331200 0 1.581588e-06
I3846 n1_m1_153600_336000 0 1.573598e-06
I3847 n1_m1_153600_340800 0 5.776113e-07
I3848 n1_m1_153600_345600 0 5.383764e-07
I3849 n1_m1_153600_350400 0 2.647849e-07
I3850 n1_m1_153600_355200 0 2.481363e-07
I3851 n1_m1_153600_360000 0 3.637061e-07
I3852 n1_m1_153600_364800 0 2.331347e-07
I3853 n1_m1_153600_369600 0 3.325205e-07
I3854 n1_m1_153600_374400 0 2.218284e-07
I3855 n1_m1_153600_379200 0 2.314952e-07
I3856 n1_m1_153600_384000 0 3.684369e-07
I3857 n1_m1_153600_388800 0 4.469156e-07
I3858 n1_m1_153600_393600 0 9.354082e-07
I3859 n1_m1_153600_398400 0 3.425677e-07
I3860 n1_m1_153600_403200 0 4.706640e-07
I3861 n1_m1_153600_408000 0 1.276370e-06
I3862 n1_m1_153600_412800 0 1.061056e-06
I3863 n1_m1_153600_417600 0 2.342520e-06
I3864 n1_m1_153600_422400 0 9.807490e-07
I3865 n1_m1_153600_427200 0 5.519391e-07
I3866 n1_m1_153600_432000 0 7.485613e-07
I3867 n1_m1_153600_436800 0 4.774220e-07
I3868 n1_m1_153600_441600 0 5.308177e-07
I3869 n1_m1_153600_446400 0 3.828589e-07
I3870 n1_m1_153600_451200 0 2.956959e-07
I3871 n1_m1_153600_456000 0 3.492095e-07
I3872 n1_m1_153600_460800 0 2.353545e-07
I3873 n1_m1_153600_465600 0 3.350103e-07
I3874 n1_m1_153600_470400 0 2.287131e-07
I3875 n1_m1_153600_475200 0 2.291399e-07
I3876 n1_m1_153600_480000 0 3.310004e-07
I3877 n1_m1_153600_484800 0 2.191582e-07
I3878 n1_m1_153600_489600 0 3.303291e-07
I3879 n1_m1_153600_494400 0 2.098560e-07
I3880 n1_m1_153600_499200 0 2.098560e-07
I3881 n1_m1_153600_504000 0 3.225455e-07
I3882 n1_m1_153600_508800 0 2.198491e-07
I3883 n1_m1_153600_513600 0 3.297737e-07
I3884 n1_m1_153600_518400 0 2.190401e-07
I3885 n1_m1_153600_523200 0 2.125603e-07
I3886 n1_m1_153600_528000 0 3.407032e-07
I3887 n1_m1_153600_532800 0 2.256209e-07
I3888 n1_m1_153600_537600 0 3.477151e-07
I3889 n1_m1_153600_542400 0 2.725038e-07
I3890 n1_m1_153600_547200 0 3.477110e-07
I3891 n1_m1_153600_552000 0 5.333989e-07
I3892 n1_m1_153600_556800 0 2.502458e-07
I3893 n1_m1_153600_561600 0 1.224086e-07
I3894 n1_m1_158400_0 0 2.169571e-07
I3895 n1_m1_158400_4800 0 3.337213e-07
I3896 n1_m1_158400_9600 0 5.247311e-07
I3897 n1_m1_158400_14400 0 1.917133e-07
I3898 n1_m1_158400_19200 0 1.719164e-07
I3899 n1_m1_158400_24000 0 2.351144e-07
I3900 n1_m1_158400_28800 0 1.482197e-07
I3901 n1_m1_158400_33600 0 2.250821e-07
I3902 n1_m1_158400_38400 0 1.470242e-07
I3903 n1_m1_158400_43200 0 1.437775e-07
I3904 n1_m1_158400_48000 0 2.157973e-07
I3905 n1_m1_158400_52800 0 1.465746e-07
I3906 n1_m1_158400_57600 0 2.122000e-07
I3907 n1_m1_158400_62400 0 1.461768e-07
I3908 n1_m1_158400_67200 0 1.700821e-07
I3909 n1_m1_158400_72000 0 4.075340e-07
I3910 n1_m1_158400_76800 0 5.158706e-07
I3911 n1_m1_158400_81600 0 4.920363e-07
I3912 n1_m1_158400_86400 0 4.621813e-07
I3913 n1_m1_158400_91200 0 5.971630e-07
I3914 n1_m1_158400_96000 0 9.344987e-07
I3915 n1_m1_158400_100800 0 8.753761e-07
I3916 n1_m1_158400_105600 0 1.360913e-06
I3917 n1_m1_158400_110400 0 1.054384e-06
I3918 n1_m1_158400_115200 0 1.099481e-06
I3919 n1_m1_158400_120000 0 1.506705e-06
I3920 n1_m1_158400_124800 0 8.026031e-07
I3921 n1_m1_158400_129600 0 4.897033e-07
I3922 n1_m1_158400_134400 0 7.658700e-07
I3923 n1_m1_158400_139200 0 1.132804e-06
I3924 n1_m1_158400_144000 0 1.663246e-06
I3925 n1_m1_158400_148800 0 1.001189e-06
I3926 n1_m1_158400_153600 0 5.789790e-07
I3927 n1_m1_158400_158400 0 1.675704e-07
I3928 n1_m1_158400_163200 0 1.478187e-07
I3929 n1_m1_158400_168000 0 2.196603e-07
I3930 n1_m1_158400_172800 0 1.421509e-07
I3931 n1_m1_158400_177600 0 2.154961e-07
I3932 n1_m1_158400_182400 0 1.399040e-07
I3933 n1_m1_158400_187200 0 1.422052e-07
I3934 n1_m1_158400_192000 0 2.203075e-07
I3935 n1_m1_158400_196800 0 1.425949e-07
I3936 n1_m1_158400_201600 0 2.126660e-07
I3937 n1_m1_158400_206400 0 1.568126e-07
I3938 n1_m1_158400_211200 0 1.658063e-07
I3939 n1_m1_158400_216000 0 1.400992e-06
I3940 n1_m1_158400_220800 0 1.205069e-06
I3941 n1_m1_158400_225600 0 1.993882e-06
I3942 n1_m1_158400_230400 0 1.295650e-06
I3943 n1_m1_158400_235200 0 1.215819e-06
I3944 n1_m1_158400_240000 0 1.101491e-06
I3945 n1_m1_158400_244800 0 3.164717e-07
I3946 n1_m1_158400_249600 0 3.667805e-07
I3947 n1_m1_158400_254400 0 1.702316e-07
I3948 n1_m1_158400_259200 0 1.568778e-07
I3949 n1_m1_158400_264000 0 2.308416e-07
I3950 n1_m1_158400_268800 0 1.519333e-07
I3951 n1_m1_158400_273600 0 2.272215e-07
I3952 n1_m1_158400_278400 0 1.498755e-07
I3953 n1_m1_158400_283200 0 1.465350e-07
I3954 n1_m1_158400_288000 0 2.268900e-07
I3955 n1_m1_158400_292800 0 1.577373e-07
I3956 n1_m1_158400_297600 0 2.203455e-07
I3957 n1_m1_158400_302400 0 1.430805e-07
I3958 n1_m1_158400_307200 0 1.547415e-07
I3959 n1_m1_158400_312000 0 7.062057e-07
I3960 n1_m1_158400_316800 0 6.730633e-07
I3961 n1_m1_158400_321600 0 1.683679e-06
I3962 n1_m1_158400_326400 0 1.106723e-06
I3963 n1_m1_158400_331200 0 8.429625e-07
I3964 n1_m1_158400_336000 0 7.818859e-07
I3965 n1_m1_158400_340800 0 2.388667e-07
I3966 n1_m1_158400_345600 0 2.564872e-07
I3967 n1_m1_158400_350400 0 1.598358e-07
I3968 n1_m1_158400_355200 0 1.599617e-07
I3969 n1_m1_158400_360000 0 2.327368e-07
I3970 n1_m1_158400_364800 0 1.481426e-07
I3971 n1_m1_158400_369600 0 2.193513e-07
I3972 n1_m1_158400_374400 0 1.487966e-07
I3973 n1_m1_158400_379200 0 1.587432e-07
I3974 n1_m1_158400_384000 0 2.459270e-07
I3975 n1_m1_158400_388800 0 2.187746e-07
I3976 n1_m1_158400_393600 0 3.808954e-07
I3977 n1_m1_158400_398400 0 1.648047e-07
I3978 n1_m1_158400_403200 0 2.212656e-07
I3979 n1_m1_158400_408000 0 5.568165e-07
I3980 n1_m1_158400_412800 0 4.230379e-07
I3981 n1_m1_158400_417600 0 1.079684e-06
I3982 n1_m1_158400_422400 0 3.603161e-07
I3983 n1_m1_158400_427200 0 2.121133e-07
I3984 n1_m1_158400_432000 0 3.004063e-07
I3985 n1_m1_158400_436800 0 1.931203e-07
I3986 n1_m1_158400_441600 0 2.615019e-07
I3987 n1_m1_158400_446400 0 1.858673e-07
I3988 n1_m1_158400_451200 0 1.668069e-07
I3989 n1_m1_158400_456000 0 2.360932e-07
I3990 n1_m1_158400_460800 0 1.564952e-07
I3991 n1_m1_158400_465600 0 2.224956e-07
I3992 n1_m1_158400_470400 0 1.519123e-07
I3993 n1_m1_158400_475200 0 1.522364e-07
I3994 n1_m1_158400_480000 0 2.210808e-07
I3995 n1_m1_158400_484800 0 1.478412e-07
I3996 n1_m1_158400_489600 0 2.215052e-07
I3997 n1_m1_158400_494400 0 1.399040e-07
I3998 n1_m1_158400_499200 0 1.399040e-07
I3999 n1_m1_158400_504000 0 2.150303e-07
I4000 n1_m1_158400_508800 0 1.465661e-07
I4001 n1_m1_158400_513600 0 2.198491e-07
I4002 n1_m1_158400_518400 0 1.460267e-07
I4003 n1_m1_158400_523200 0 1.412827e-07
I4004 n1_m1_158400_528000 0 2.132426e-07
I4005 n1_m1_158400_532800 0 1.418626e-07
I4006 n1_m1_158400_537600 0 2.189631e-07
I4007 n1_m1_158400_542400 0 1.667706e-07
I4008 n1_m1_158400_547200 0 2.079803e-07
I4009 n1_m1_158400_552000 0 3.354557e-07
I4010 n1_m1_158400_556800 0 1.687289e-07
I4011 n1_m1_158400_561600 0 8.287222e-08
I4012 n1_m1_163200_0 0 2.161294e-07
I4013 n1_m1_163200_4800 0 3.271901e-07
I4014 n1_m1_163200_9600 0 4.910929e-07
I4015 n1_m1_163200_14400 0 1.855718e-07
I4016 n1_m1_163200_19200 0 1.668390e-07
I4017 n1_m1_163200_24000 0 2.279194e-07
I4018 n1_m1_163200_28800 0 1.435493e-07
I4019 n1_m1_163200_33600 0 2.248566e-07
I4020 n1_m1_163200_38400 0 1.454760e-07
I4021 n1_m1_163200_43200 0 1.405026e-07
I4022 n1_m1_163200_48000 0 2.159879e-07
I4023 n1_m1_163200_52800 0 1.423554e-07
I4024 n1_m1_163200_57600 0 2.112827e-07
I4025 n1_m1_163200_62400 0 1.466402e-07
I4026 n1_m1_163200_67200 0 1.549826e-07
I4027 n1_m1_163200_72000 0 2.588796e-07
I4028 n1_m1_163200_76800 0 2.210707e-07
I4029 n1_m1_163200_81600 0 2.743482e-07
I4030 n1_m1_163200_86400 0 2.205929e-07
I4031 n1_m1_163200_91200 0 2.545087e-07
I4032 n1_m1_163200_96000 0 4.311158e-07
I4033 n1_m1_163200_100800 0 5.335498e-07
I4034 n1_m1_163200_105600 0 8.654151e-07
I4035 n1_m1_163200_110400 0 8.102759e-07
I4036 n1_m1_163200_115200 0 8.869558e-07
I4037 n1_m1_163200_120000 0 1.074858e-06
I4038 n1_m1_163200_124800 0 4.746932e-07
I4039 n1_m1_163200_129600 0 3.308647e-07
I4040 n1_m1_163200_134400 0 5.675351e-07
I4041 n1_m1_163200_139200 0 8.211015e-07
I4042 n1_m1_163200_144000 0 1.095516e-06
I4043 n1_m1_163200_148800 0 7.562994e-07
I4044 n1_m1_163200_153600 0 4.962556e-07
I4045 n1_m1_163200_158400 0 1.653952e-07
I4046 n1_m1_163200_163200 0 1.451946e-07
I4047 n1_m1_163200_168000 0 2.173396e-07
I4048 n1_m1_163200_172800 0 1.404797e-07
I4049 n1_m1_163200_177600 0 2.109942e-07
I4050 n1_m1_163200_182400 0 1.400127e-07
I4051 n1_m1_163200_187200 0 1.439312e-07
I4052 n1_m1_163200_192000 0 2.242543e-07
I4053 n1_m1_163200_196800 0 1.425949e-07
I4054 n1_m1_163200_201600 0 2.112434e-07
I4055 n1_m1_163200_206400 0 1.526582e-07
I4056 n1_m1_163200_211200 0 1.700868e-07
I4057 n1_m1_163200_216000 0 1.055549e-06
I4058 n1_m1_163200_220800 0 1.054769e-06
I4059 n1_m1_163200_225600 0 1.887045e-06
I4060 n1_m1_163200_230400 0 1.161864e-06
I4061 n1_m1_163200_235200 0 9.045996e-07
I4062 n1_m1_163200_240000 0 6.308505e-07
I4063 n1_m1_163200_244800 0 1.993609e-07
I4064 n1_m1_163200_249600 0 2.523018e-07
I4065 n1_m1_163200_254400 0 1.501698e-07
I4066 n1_m1_163200_259200 0 1.483501e-07
I4067 n1_m1_163200_264000 0 2.218819e-07
I4068 n1_m1_163200_268800 0 1.475811e-07
I4069 n1_m1_163200_273600 0 2.214213e-07
I4070 n1_m1_163200_278400 0 1.475488e-07
I4071 n1_m1_163200_283200 0 1.465428e-07
I4072 n1_m1_163200_288000 0 2.266289e-07
I4073 n1_m1_163200_292800 0 1.566512e-07
I4074 n1_m1_163200_297600 0 2.279968e-07
I4075 n1_m1_163200_302400 0 1.513208e-07
I4076 n1_m1_163200_307200 0 1.497426e-07
I4077 n1_m1_163200_312000 0 5.141976e-07
I4078 n1_m1_163200_316800 0 5.213100e-07
I4079 n1_m1_163200_321600 0 1.336321e-06
I4080 n1_m1_163200_326400 0 8.059660e-07
I4081 n1_m1_163200_331200 0 5.854392e-07
I4082 n1_m1_163200_336000 0 5.188287e-07
I4083 n1_m1_163200_340800 0 1.793923e-07
I4084 n1_m1_163200_345600 0 2.516158e-07
I4085 n1_m1_163200_350400 0 1.623322e-07
I4086 n1_m1_163200_355200 0 1.562081e-07
I4087 n1_m1_163200_360000 0 2.240049e-07
I4088 n1_m1_163200_364800 0 1.423440e-07
I4089 n1_m1_163200_369600 0 2.132379e-07
I4090 n1_m1_163200_374400 0 1.487628e-07
I4091 n1_m1_163200_379200 0 1.595749e-07
I4092 n1_m1_163200_384000 0 2.456967e-07
I4093 n1_m1_163200_388800 0 1.755978e-07
I4094 n1_m1_163200_393600 0 2.712520e-07
I4095 n1_m1_163200_398400 0 1.626490e-07
I4096 n1_m1_163200_403200 0 1.839742e-07
I4097 n1_m1_163200_408000 0 4.142867e-07
I4098 n1_m1_163200_412800 0 2.987563e-07
I4099 n1_m1_163200_417600 0 7.013265e-07
I4100 n1_m1_163200_422400 0 3.211137e-07
I4101 n1_m1_163200_427200 0 2.051437e-07
I4102 n1_m1_163200_432000 0 2.698224e-07
I4103 n1_m1_163200_436800 0 1.693760e-07
I4104 n1_m1_163200_441600 0 2.342614e-07
I4105 n1_m1_163200_446400 0 1.608623e-07
I4106 n1_m1_163200_451200 0 1.563445e-07
I4107 n1_m1_163200_456000 0 2.370690e-07
I4108 n1_m1_163200_460800 0 1.529104e-07
I4109 n1_m1_163200_465600 0 2.152230e-07
I4110 n1_m1_163200_470400 0 1.470639e-07
I4111 n1_m1_163200_475200 0 1.477100e-07
I4112 n1_m1_163200_480000 0 2.198300e-07
I4113 n1_m1_163200_484800 0 1.468226e-07
I4114 n1_m1_163200_489600 0 2.172391e-07
I4115 n1_m1_163200_494400 0 1.399040e-07
I4116 n1_m1_163200_499200 0 1.399040e-07
I4117 n1_m1_163200_504000 0 2.150303e-07
I4118 n1_m1_163200_508800 0 1.463909e-07
I4119 n1_m1_163200_513600 0 2.194490e-07
I4120 n1_m1_163200_518400 0 1.457816e-07
I4121 n1_m1_163200_523200 0 1.411370e-07
I4122 n1_m1_163200_528000 0 2.101910e-07
I4123 n1_m1_163200_532800 0 1.401239e-07
I4124 n1_m1_163200_537600 0 2.138842e-07
I4125 n1_m1_163200_542400 0 1.587522e-07
I4126 n1_m1_163200_547200 0 1.961153e-07
I4127 n1_m1_163200_552000 0 3.257042e-07
I4128 n1_m1_163200_556800 0 1.707534e-07
I4129 n1_m1_163200_561600 0 8.363271e-08
I4130 n1_m1_168000_0 0 3.101317e-07
I4131 n1_m1_168000_4800 0 4.388731e-07
I4132 n1_m1_168000_9600 0 6.269406e-07
I4133 n1_m1_168000_14400 0 2.654031e-07
I4134 n1_m1_168000_19200 0 2.428595e-07
I4135 n1_m1_168000_24000 0 3.436290e-07
I4136 n1_m1_168000_28800 0 2.207798e-07
I4137 n1_m1_168000_33600 0 3.462056e-07
I4138 n1_m1_168000_38400 0 2.215037e-07
I4139 n1_m1_168000_43200 0 2.098560e-07
I4140 n1_m1_168000_48000 0 3.308842e-07
I4141 n1_m1_168000_52800 0 2.138032e-07
I4142 n1_m1_168000_57600 0 3.167488e-07
I4143 n1_m1_168000_62400 0 2.191069e-07
I4144 n1_m1_168000_67200 0 2.217299e-07
I4145 n1_m1_168000_72000 0 3.487918e-07
I4146 n1_m1_168000_76800 0 2.294927e-07
I4147 n1_m1_168000_81600 0 3.592778e-07
I4148 n1_m1_168000_86400 0 2.388427e-07
I4149 n1_m1_168000_91200 0 2.405535e-07
I4150 n1_m1_168000_96000 0 3.929014e-07
I4151 n1_m1_168000_100800 0 3.322964e-07
I4152 n1_m1_168000_105600 0 5.211779e-07
I4153 n1_m1_168000_110400 0 4.631992e-07
I4154 n1_m1_168000_115200 0 4.895997e-07
I4155 n1_m1_168000_120000 0 6.006549e-07
I4156 n1_m1_168000_124800 0 3.190552e-07
I4157 n1_m1_168000_129600 0 3.883360e-07
I4158 n1_m1_168000_134400 0 3.832499e-07
I4159 n1_m1_168000_139200 0 4.775839e-07
I4160 n1_m1_168000_144000 0 6.963635e-07
I4161 n1_m1_168000_148800 0 5.486625e-07
I4162 n1_m1_168000_153600 0 5.062453e-07
I4163 n1_m1_168000_158400 0 2.448877e-07
I4164 n1_m1_168000_163200 0 2.181544e-07
I4165 n1_m1_168000_168000 0 3.426841e-07
I4166 n1_m1_168000_172800 0 2.114347e-07
I4167 n1_m1_168000_177600 0 3.161380e-07
I4168 n1_m1_168000_182400 0 2.132855e-07
I4169 n1_m1_168000_187200 0 2.219575e-07
I4170 n1_m1_168000_192000 0 3.379086e-07
I4171 n1_m1_168000_196800 0 2.138923e-07
I4172 n1_m1_168000_201600 0 3.165449e-07
I4173 n1_m1_168000_206400 0 2.268261e-07
I4174 n1_m1_168000_211200 0 2.587707e-07
I4175 n1_m1_168000_216000 0 1.188973e-06
I4176 n1_m1_168000_220800 0 1.411970e-06
I4177 n1_m1_168000_225600 0 2.711814e-06
I4178 n1_m1_168000_230400 0 1.586339e-06
I4179 n1_m1_168000_235200 0 1.024129e-06
I4180 n1_m1_168000_240000 0 5.224703e-07
I4181 n1_m1_168000_244800 0 2.526798e-07
I4182 n1_m1_168000_249600 0 3.532786e-07
I4183 n1_m1_168000_254400 0 2.326033e-07
I4184 n1_m1_168000_259200 0 2.347735e-07
I4185 n1_m1_168000_264000 0 3.341700e-07
I4186 n1_m1_168000_268800 0 2.125790e-07
I4187 n1_m1_168000_273600 0 3.232557e-07
I4188 n1_m1_168000_278400 0 2.253885e-07
I4189 n1_m1_168000_283200 0 2.261422e-07
I4190 n1_m1_168000_288000 0 3.345643e-07
I4191 n1_m1_168000_292800 0 2.253258e-07
I4192 n1_m1_168000_297600 0 3.446656e-07
I4193 n1_m1_168000_302400 0 2.389682e-07
I4194 n1_m1_168000_307200 0 2.268238e-07
I4195 n1_m1_168000_312000 0 5.827238e-07
I4196 n1_m1_168000_316800 0 5.640657e-07
I4197 n1_m1_168000_321600 0 1.797249e-06
I4198 n1_m1_168000_326400 0 1.110442e-06
I4199 n1_m1_168000_331200 0 7.390012e-07
I4200 n1_m1_168000_336000 0 5.790610e-07
I4201 n1_m1_168000_340800 0 2.453024e-07
I4202 n1_m1_168000_345600 0 3.433482e-07
I4203 n1_m1_168000_350400 0 2.230423e-07
I4204 n1_m1_168000_355200 0 2.157001e-07
I4205 n1_m1_168000_360000 0 3.171861e-07
I4206 n1_m1_168000_364800 0 2.116621e-07
I4207 n1_m1_168000_369600 0 3.261760e-07
I4208 n1_m1_168000_374400 0 2.231514e-07
I4209 n1_m1_168000_379200 0 2.371080e-07
I4210 n1_m1_168000_384000 0 3.559242e-07
I4211 n1_m1_168000_388800 0 2.359691e-07
I4212 n1_m1_168000_393600 0 3.979723e-07
I4213 n1_m1_168000_398400 0 3.200097e-07
I4214 n1_m1_168000_403200 0 2.923337e-07
I4215 n1_m1_168000_408000 0 4.467632e-07
I4216 n1_m1_168000_412800 0 3.629178e-07
I4217 n1_m1_168000_417600 0 7.194913e-07
I4218 n1_m1_168000_422400 0 4.993021e-07
I4219 n1_m1_168000_427200 0 3.441001e-07
I4220 n1_m1_168000_432000 0 3.755148e-07
I4221 n1_m1_168000_436800 0 2.308861e-07
I4222 n1_m1_168000_441600 0 3.374871e-07
I4223 n1_m1_168000_446400 0 2.267779e-07
I4224 n1_m1_168000_451200 0 2.412875e-07
I4225 n1_m1_168000_456000 0 3.694512e-07
I4226 n1_m1_168000_460800 0 2.257962e-07
I4227 n1_m1_168000_465600 0 3.197836e-07
I4228 n1_m1_168000_470400 0 2.174004e-07
I4229 n1_m1_168000_475200 0 2.178744e-07
I4230 n1_m1_168000_480000 0 3.204838e-07
I4231 n1_m1_168000_484800 0 2.185430e-07
I4232 n1_m1_168000_489600 0 3.241141e-07
I4233 n1_m1_168000_494400 0 2.098560e-07
I4234 n1_m1_168000_499200 0 2.098560e-07
I4235 n1_m1_168000_504000 0 3.225455e-07
I4236 n1_m1_168000_508800 0 2.143230e-07
I4237 n1_m1_168000_513600 0 3.171489e-07
I4238 n1_m1_168000_518400 0 2.113049e-07
I4239 n1_m1_168000_523200 0 2.104645e-07
I4240 n1_m1_168000_528000 0 3.253570e-07
I4241 n1_m1_168000_532800 0 2.167973e-07
I4242 n1_m1_168000_537600 0 3.238805e-07
I4243 n1_m1_168000_542400 0 2.427812e-07
I4244 n1_m1_168000_547200 0 3.043406e-07
I4245 n1_m1_168000_552000 0 5.125908e-07
I4246 n1_m1_168000_556800 0 2.681513e-07
I4247 n1_m1_168000_561600 0 1.318858e-07
I4248 n1_m1_172800_0 0 1.010767e-07
I4249 n1_m1_172800_4800 0 1.414450e-07
I4250 n1_m1_172800_9600 0 2.113757e-07
I4251 n1_m1_172800_14400 0 9.840036e-08
I4252 n1_m1_172800_19200 0 8.671207e-08
I4253 n1_m1_172800_24000 0 1.172824e-07
I4254 n1_m1_172800_28800 0 7.533975e-08
I4255 n1_m1_172800_33600 0 1.170144e-07
I4256 n1_m1_172800_38400 0 7.401428e-08
I4257 n1_m1_172800_43200 0 7.114334e-08
I4258 n1_m1_172800_48000 0 1.103887e-07
I4259 n1_m1_172800_52800 0 7.110909e-08
I4260 n1_m1_172800_57600 0 1.041414e-07
I4261 n1_m1_172800_62400 0 7.169550e-08
I4262 n1_m1_172800_67200 0 7.207652e-08
I4263 n1_m1_172800_72000 0 1.158707e-07
I4264 n1_m1_172800_76800 0 7.546404e-08
I4265 n1_m1_172800_81600 0 1.151531e-07
I4266 n1_m1_172800_86400 0 7.592604e-08
I4267 n1_m1_172800_91200 0 7.827010e-08
I4268 n1_m1_172800_96000 0 1.298427e-07
I4269 n1_m1_172800_100800 0 8.355472e-08
I4270 n1_m1_172800_105600 0 1.227406e-07
I4271 n1_m1_172800_110400 0 8.556616e-08
I4272 n1_m1_172800_115200 0 9.029504e-08
I4273 n1_m1_172800_120000 0 1.385570e-07
I4274 n1_m1_172800_124800 0 7.738472e-08
I4275 n1_m1_172800_129600 0 1.112381e-07
I4276 n1_m1_172800_134400 0 7.701412e-08
I4277 n1_m1_172800_139200 0 8.949212e-08
I4278 n1_m1_172800_144000 0 1.410509e-07
I4279 n1_m1_172800_148800 0 9.165611e-08
I4280 n1_m1_172800_153600 0 1.206095e-07
I4281 n1_m1_172800_158400 0 7.647687e-08
I4282 n1_m1_172800_163200 0 7.173302e-08
I4283 n1_m1_172800_168000 0 1.154124e-07
I4284 n1_m1_172800_172800 0 7.536538e-08
I4285 n1_m1_172800_177600 0 1.074319e-07
I4286 n1_m1_172800_182400 0 7.130930e-08
I4287 n1_m1_172800_187200 0 7.396454e-08
I4288 n1_m1_172800_192000 0 1.108492e-07
I4289 n1_m1_172800_196800 0 7.081624e-08
I4290 n1_m1_172800_201600 0 1.052451e-07
I4291 n1_m1_172800_206400 0 7.358599e-08
I4292 n1_m1_172800_211200 0 8.906090e-08
I4293 n1_m1_172800_216000 0 5.694579e-07
I4294 n1_m1_172800_220800 0 6.065183e-07
I4295 n1_m1_172800_225600 0 1.027145e-06
I4296 n1_m1_172800_230400 0 6.187093e-07
I4297 n1_m1_172800_235200 0 4.374392e-07
I4298 n1_m1_172800_240000 0 2.345289e-07
I4299 n1_m1_172800_244800 0 8.064256e-08
I4300 n1_m1_172800_249600 0 1.117116e-07
I4301 n1_m1_172800_254400 0 7.451056e-08
I4302 n1_m1_172800_259200 0 7.600872e-08
I4303 n1_m1_172800_264000 0 1.119887e-07
I4304 n1_m1_172800_268800 0 7.176952e-08
I4305 n1_m1_172800_273600 0 1.118986e-07
I4306 n1_m1_172800_278400 0 7.983443e-08
I4307 n1_m1_172800_283200 0 7.831848e-08
I4308 n1_m1_172800_288000 0 1.104601e-07
I4309 n1_m1_172800_292800 0 7.367485e-08
I4310 n1_m1_172800_297600 0 1.117947e-07
I4311 n1_m1_172800_302400 0 7.832627e-08
I4312 n1_m1_172800_307200 0 7.666302e-08
I4313 n1_m1_172800_312000 0 3.761385e-07
I4314 n1_m1_172800_316800 0 3.464150e-07
I4315 n1_m1_172800_321600 0 8.539984e-07
I4316 n1_m1_172800_326400 0 5.637872e-07
I4317 n1_m1_172800_331200 0 4.144915e-07
I4318 n1_m1_172800_336000 0 3.652063e-07
I4319 n1_m1_172800_340800 0 1.011543e-07
I4320 n1_m1_172800_345600 0 1.207795e-07
I4321 n1_m1_172800_350400 0 7.264687e-08
I4322 n1_m1_172800_355200 0 6.970333e-08
I4323 n1_m1_172800_360000 0 1.053192e-07
I4324 n1_m1_172800_364800 0 7.375706e-08
I4325 n1_m1_172800_369600 0 1.086844e-07
I4326 n1_m1_172800_374400 0 7.291650e-08
I4327 n1_m1_172800_379200 0 7.781708e-08
I4328 n1_m1_172800_384000 0 1.302644e-07
I4329 n1_m1_172800_388800 0 1.024389e-07
I4330 n1_m1_172800_393600 0 2.637390e-07
I4331 n1_m1_172800_398400 0 2.097953e-07
I4332 n1_m1_172800_403200 0 1.495071e-07
I4333 n1_m1_172800_408000 0 2.520672e-07
I4334 n1_m1_172800_412800 0 2.345426e-07
I4335 n1_m1_172800_417600 0 4.442264e-07
I4336 n1_m1_172800_422400 0 3.238795e-07
I4337 n1_m1_172800_427200 0 1.969489e-07
I4338 n1_m1_172800_432000 0 1.519418e-07
I4339 n1_m1_172800_436800 0 8.364792e-08
I4340 n1_m1_172800_441600 0 1.234525e-07
I4341 n1_m1_172800_446400 0 7.983251e-08
I4342 n1_m1_172800_451200 0 8.265014e-08
I4343 n1_m1_172800_456000 0 1.225302e-07
I4344 n1_m1_172800_460800 0 7.512045e-08
I4345 n1_m1_172800_465600 0 1.063328e-07
I4346 n1_m1_172800_470400 0 7.100873e-08
I4347 n1_m1_172800_475200 0 7.122707e-08
I4348 n1_m1_172800_480000 0 1.079286e-07
I4349 n1_m1_172800_484800 0 7.111479e-08
I4350 n1_m1_172800_489600 0 1.065012e-07
I4351 n1_m1_172800_494400 0 7.058582e-08
I4352 n1_m1_172800_499200 0 6.995199e-08
I4353 n1_m1_172800_504000 0 1.065899e-07
I4354 n1_m1_172800_508800 0 7.146902e-08
I4355 n1_m1_172800_513600 0 1.065656e-07
I4356 n1_m1_172800_518400 0 7.012688e-08
I4357 n1_m1_172800_523200 0 7.007349e-08
I4358 n1_m1_172800_528000 0 1.088507e-07
I4359 n1_m1_172800_532800 0 7.177920e-08
I4360 n1_m1_172800_537600 0 1.067654e-07
I4361 n1_m1_172800_542400 0 7.861745e-08
I4362 n1_m1_172800_547200 0 9.438289e-08
I4363 n1_m1_172800_552000 0 1.540808e-07
I4364 n1_m1_172800_556800 0 8.619232e-08
I4365 n1_m1_172800_561600 0 4.240269e-08
I4366 n1_m1_177600_0 0 3.000441e-07
I4367 n1_m1_177600_4800 0 4.492525e-07
I4368 n1_m1_177600_9600 0 7.685036e-07
I4369 n1_m1_177600_14400 0 3.257668e-07
I4370 n1_m1_177600_19200 0 2.682705e-07
I4371 n1_m1_177600_24000 0 3.469709e-07
I4372 n1_m1_177600_28800 0 2.166326e-07
I4373 n1_m1_177600_33600 0 3.277922e-07
I4374 n1_m1_177600_38400 0 2.178340e-07
I4375 n1_m1_177600_43200 0 2.175025e-07
I4376 n1_m1_177600_48000 0 3.246170e-07
I4377 n1_m1_177600_52800 0 2.113420e-07
I4378 n1_m1_177600_57600 0 3.094122e-07
I4379 n1_m1_177600_62400 0 2.143609e-07
I4380 n1_m1_177600_67200 0 2.216250e-07
I4381 n1_m1_177600_72000 0 3.425094e-07
I4382 n1_m1_177600_76800 0 2.348959e-07
I4383 n1_m1_177600_81600 0 3.429045e-07
I4384 n1_m1_177600_86400 0 2.443823e-07
I4385 n1_m1_177600_91200 0 2.409319e-07
I4386 n1_m1_177600_96000 0 3.746972e-07
I4387 n1_m1_177600_100800 0 2.490360e-07
I4388 n1_m1_177600_105600 0 3.705476e-07
I4389 n1_m1_177600_110400 0 2.527930e-07
I4390 n1_m1_177600_115200 0 2.518059e-07
I4391 n1_m1_177600_120000 0 3.607885e-07
I4392 n1_m1_177600_124800 0 2.449700e-07
I4393 n1_m1_177600_129600 0 3.903036e-07
I4394 n1_m1_177600_134400 0 4.195252e-07
I4395 n1_m1_177600_139200 0 6.570867e-07
I4396 n1_m1_177600_144000 0 8.702342e-07
I4397 n1_m1_177600_148800 0 3.380385e-07
I4398 n1_m1_177600_153600 0 3.889009e-07
I4399 n1_m1_177600_158400 0 2.324717e-07
I4400 n1_m1_177600_163200 0 2.150093e-07
I4401 n1_m1_177600_168000 0 3.353697e-07
I4402 n1_m1_177600_172800 0 2.315102e-07
I4403 n1_m1_177600_177600 0 3.178735e-07
I4404 n1_m1_177600_182400 0 2.139279e-07
I4405 n1_m1_177600_187200 0 2.189939e-07
I4406 n1_m1_177600_192000 0 3.234287e-07
I4407 n1_m1_177600_196800 0 2.134147e-07
I4408 n1_m1_177600_201600 0 3.206963e-07
I4409 n1_m1_177600_206400 0 2.236451e-07
I4410 n1_m1_177600_211200 0 2.674897e-07
I4411 n1_m1_177600_216000 0 2.271535e-06
I4412 n1_m1_177600_220800 0 1.916055e-06
I4413 n1_m1_177600_225600 0 3.072967e-06
I4414 n1_m1_177600_230400 0 1.737302e-06
I4415 n1_m1_177600_235200 0 1.178404e-06
I4416 n1_m1_177600_240000 0 8.383955e-07
I4417 n1_m1_177600_244800 0 2.379649e-07
I4418 n1_m1_177600_249600 0 3.440329e-07
I4419 n1_m1_177600_254400 0 2.317845e-07
I4420 n1_m1_177600_259200 0 2.306019e-07
I4421 n1_m1_177600_264000 0 3.425054e-07
I4422 n1_m1_177600_268800 0 2.204606e-07
I4423 n1_m1_177600_273600 0 3.315425e-07
I4424 n1_m1_177600_278400 0 2.330883e-07
I4425 n1_m1_177600_283200 0 2.467089e-07
I4426 n1_m1_177600_288000 0 3.488210e-07
I4427 n1_m1_177600_292800 0 2.352319e-07
I4428 n1_m1_177600_297600 0 3.467686e-07
I4429 n1_m1_177600_302400 0 2.251226e-07
I4430 n1_m1_177600_307200 0 2.403015e-07
I4431 n1_m1_177600_312000 0 1.990331e-06
I4432 n1_m1_177600_316800 0 1.235635e-06
I4433 n1_m1_177600_321600 0 2.468053e-06
I4434 n1_m1_177600_326400 0 1.605511e-06
I4435 n1_m1_177600_331200 0 1.172751e-06
I4436 n1_m1_177600_336000 0 1.117420e-06
I4437 n1_m1_177600_340800 0 2.695284e-07
I4438 n1_m1_177600_345600 0 3.635483e-07
I4439 n1_m1_177600_350400 0 2.256765e-07
I4440 n1_m1_177600_355200 0 2.159477e-07
I4441 n1_m1_177600_360000 0 3.279364e-07
I4442 n1_m1_177600_364800 0 2.298698e-07
I4443 n1_m1_177600_369600 0 3.242300e-07
I4444 n1_m1_177600_374400 0 2.147633e-07
I4445 n1_m1_177600_379200 0 2.433604e-07
I4446 n1_m1_177600_384000 0 4.500240e-07
I4447 n1_m1_177600_388800 0 4.008317e-07
I4448 n1_m1_177600_393600 0 1.020311e-06
I4449 n1_m1_177600_398400 0 4.423678e-07
I4450 n1_m1_177600_403200 0 3.415137e-07
I4451 n1_m1_177600_408000 0 1.175956e-06
I4452 n1_m1_177600_412800 0 7.782787e-07
I4453 n1_m1_177600_417600 0 1.512571e-06
I4454 n1_m1_177600_422400 0 5.561445e-07
I4455 n1_m1_177600_427200 0 3.190674e-07
I4456 n1_m1_177600_432000 0 4.437964e-07
I4457 n1_m1_177600_436800 0 2.372921e-07
I4458 n1_m1_177600_441600 0 3.656619e-07
I4459 n1_m1_177600_446400 0 2.459124e-07
I4460 n1_m1_177600_451200 0 2.387140e-07
I4461 n1_m1_177600_456000 0 3.488092e-07
I4462 n1_m1_177600_460800 0 2.220540e-07
I4463 n1_m1_177600_465600 0 3.181883e-07
I4464 n1_m1_177600_470400 0 2.152343e-07
I4465 n1_m1_177600_475200 0 2.163456e-07
I4466 n1_m1_177600_480000 0 3.300559e-07
I4467 n1_m1_177600_484800 0 2.129359e-07
I4468 n1_m1_177600_489600 0 3.126882e-07
I4469 n1_m1_177600_494400 0 2.163892e-07
I4470 n1_m1_177600_499200 0 2.119098e-07
I4471 n1_m1_177600_504000 0 3.178361e-07
I4472 n1_m1_177600_508800 0 2.173582e-07
I4473 n1_m1_177600_513600 0 3.280795e-07
I4474 n1_m1_177600_518400 0 2.140534e-07
I4475 n1_m1_177600_523200 0 2.134072e-07
I4476 n1_m1_177600_528000 0 3.268114e-07
I4477 n1_m1_177600_532800 0 2.134152e-07
I4478 n1_m1_177600_537600 0 3.232916e-07
I4479 n1_m1_177600_542400 0 2.424670e-07
I4480 n1_m1_177600_547200 0 2.894865e-07
I4481 n1_m1_177600_552000 0 4.652638e-07
I4482 n1_m1_177600_556800 0 2.541397e-07
I4483 n1_m1_177600_561600 0 1.247599e-07
I4484 n1_m1_182400_0 0 2.134738e-07
I4485 n1_m1_182400_4800 0 3.725425e-07
I4486 n1_m1_182400_9600 0 6.282673e-07
I4487 n1_m1_182400_14400 0 1.890633e-07
I4488 n1_m1_182400_19200 0 1.609612e-07
I4489 n1_m1_182400_24000 0 2.388844e-07
I4490 n1_m1_182400_28800 0 1.501888e-07
I4491 n1_m1_182400_33600 0 2.198491e-07
I4492 n1_m1_182400_38400 0 1.465661e-07
I4493 n1_m1_182400_43200 0 1.445080e-07
I4494 n1_m1_182400_48000 0 2.117108e-07
I4495 n1_m1_182400_52800 0 1.442054e-07
I4496 n1_m1_182400_57600 0 2.220606e-07
I4497 n1_m1_182400_62400 0 1.522974e-07
I4498 n1_m1_182400_67200 0 1.549110e-07
I4499 n1_m1_182400_72000 0 2.322390e-07
I4500 n1_m1_182400_76800 0 1.638022e-07
I4501 n1_m1_182400_81600 0 2.357234e-07
I4502 n1_m1_182400_86400 0 1.646386e-07
I4503 n1_m1_182400_91200 0 1.629142e-07
I4504 n1_m1_182400_96000 0 2.383588e-07
I4505 n1_m1_182400_100800 0 1.650706e-07
I4506 n1_m1_182400_105600 0 2.562689e-07
I4507 n1_m1_182400_110400 0 1.688737e-07
I4508 n1_m1_182400_115200 0 1.707426e-07
I4509 n1_m1_182400_120000 0 2.543202e-07
I4510 n1_m1_182400_124800 0 1.891129e-07
I4511 n1_m1_182400_129600 0 3.788115e-07
I4512 n1_m1_182400_134400 0 5.268537e-07
I4513 n1_m1_182400_139200 0 8.453121e-07
I4514 n1_m1_182400_144000 0 9.449480e-07
I4515 n1_m1_182400_148800 0 2.739348e-07
I4516 n1_m1_182400_153600 0 2.781291e-07
I4517 n1_m1_182400_158400 0 1.627669e-07
I4518 n1_m1_182400_163200 0 1.446283e-07
I4519 n1_m1_182400_168000 0 2.113993e-07
I4520 n1_m1_182400_172800 0 1.452410e-07
I4521 n1_m1_182400_177600 0 2.105016e-07
I4522 n1_m1_182400_182400 0 1.415125e-07
I4523 n1_m1_182400_187200 0 1.434588e-07
I4524 n1_m1_182400_192000 0 2.166356e-07
I4525 n1_m1_182400_196800 0 1.465661e-07
I4526 n1_m1_182400_201600 0 2.204833e-07
I4527 n1_m1_182400_206400 0 1.536002e-07
I4528 n1_m1_182400_211200 0 1.836491e-07
I4529 n1_m1_182400_216000 0 1.545293e-06
I4530 n1_m1_182400_220800 0 1.272398e-06
I4531 n1_m1_182400_225600 0 2.030956e-06
I4532 n1_m1_182400_230400 0 1.213782e-06
I4533 n1_m1_182400_235200 0 9.420570e-07
I4534 n1_m1_182400_240000 0 6.954888e-07
I4535 n1_m1_182400_244800 0 1.550895e-07
I4536 n1_m1_182400_249600 0 2.302512e-07
I4537 n1_m1_182400_254400 0 1.583729e-07
I4538 n1_m1_182400_259200 0 1.551130e-07
I4539 n1_m1_182400_264000 0 2.288050e-07
I4540 n1_m1_182400_268800 0 1.476444e-07
I4541 n1_m1_182400_273600 0 2.249098e-07
I4542 n1_m1_182400_278400 0 1.553775e-07
I4543 n1_m1_182400_283200 0 1.579558e-07
I4544 n1_m1_182400_288000 0 2.339797e-07
I4545 n1_m1_182400_292800 0 1.625401e-07
I4546 n1_m1_182400_297600 0 2.388000e-07
I4547 n1_m1_182400_302400 0 1.560033e-07
I4548 n1_m1_182400_307200 0 1.766252e-07
I4549 n1_m1_182400_312000 0 1.417535e-06
I4550 n1_m1_182400_316800 0 8.879299e-07
I4551 n1_m1_182400_321600 0 1.746477e-06
I4552 n1_m1_182400_326400 0 1.177481e-06
I4553 n1_m1_182400_331200 0 9.047689e-07
I4554 n1_m1_182400_336000 0 8.112960e-07
I4555 n1_m1_182400_340800 0 1.745421e-07
I4556 n1_m1_182400_345600 0 2.429501e-07
I4557 n1_m1_182400_350400 0 1.473439e-07
I4558 n1_m1_182400_355200 0 1.415546e-07
I4559 n1_m1_182400_360000 0 2.234330e-07
I4560 n1_m1_182400_364800 0 1.561045e-07
I4561 n1_m1_182400_369600 0 2.236059e-07
I4562 n1_m1_182400_374400 0 1.444697e-07
I4563 n1_m1_182400_379200 0 1.719638e-07
I4564 n1_m1_182400_384000 0 3.381756e-07
I4565 n1_m1_182400_388800 0 3.654768e-07
I4566 n1_m1_182400_393600 0 7.679031e-07
I4567 n1_m1_182400_398400 0 2.110106e-07
I4568 n1_m1_182400_403200 0 2.896597e-07
I4569 n1_m1_182400_408000 0 1.203087e-06
I4570 n1_m1_182400_412800 0 7.133769e-07
I4571 n1_m1_182400_417600 0 1.403380e-06
I4572 n1_m1_182400_422400 0 4.465619e-07
I4573 n1_m1_182400_427200 0 2.503483e-07
I4574 n1_m1_182400_432000 0 4.257861e-07
I4575 n1_m1_182400_436800 0 1.684164e-07
I4576 n1_m1_182400_441600 0 2.466787e-07
I4577 n1_m1_182400_446400 0 1.553104e-07
I4578 n1_m1_182400_451200 0 1.468645e-07
I4579 n1_m1_182400_456000 0 2.225471e-07
I4580 n1_m1_182400_460800 0 1.462934e-07
I4581 n1_m1_182400_465600 0 2.139279e-07
I4582 n1_m1_182400_470400 0 1.426186e-07
I4583 n1_m1_182400_475200 0 1.426186e-07
I4584 n1_m1_182400_480000 0 2.139279e-07
I4585 n1_m1_182400_484800 0 1.417933e-07
I4586 n1_m1_182400_489600 0 2.126531e-07
I4587 n1_m1_182400_494400 0 1.465661e-07
I4588 n1_m1_182400_499200 0 1.450700e-07
I4589 n1_m1_182400_504000 0 2.169939e-07
I4590 n1_m1_182400_508800 0 1.465661e-07
I4591 n1_m1_182400_513600 0 2.224067e-07
I4592 n1_m1_182400_518400 0 1.469646e-07
I4593 n1_m1_182400_523200 0 1.465661e-07
I4594 n1_m1_182400_528000 0 2.198491e-07
I4595 n1_m1_182400_532800 0 1.463500e-07
I4596 n1_m1_182400_537600 0 2.278992e-07
I4597 n1_m1_182400_542400 0 1.901170e-07
I4598 n1_m1_182400_547200 0 2.575301e-07
I4599 n1_m1_182400_552000 0 4.076636e-07
I4600 n1_m1_182400_556800 0 1.813688e-07
I4601 n1_m1_182400_561600 0 8.751647e-08
I4602 n1_m1_187200_0 0 2.285602e-07
I4603 n1_m1_187200_4800 0 4.090095e-07
I4604 n1_m1_187200_9600 0 6.543852e-07
I4605 n1_m1_187200_14400 0 1.798645e-07
I4606 n1_m1_187200_19200 0 1.515099e-07
I4607 n1_m1_187200_24000 0 2.435104e-07
I4608 n1_m1_187200_28800 0 1.540409e-07
I4609 n1_m1_187200_33600 0 2.213499e-07
I4610 n1_m1_187200_38400 0 1.486880e-07
I4611 n1_m1_187200_43200 0 1.464755e-07
I4612 n1_m1_187200_48000 0 2.130809e-07
I4613 n1_m1_187200_52800 0 1.488216e-07
I4614 n1_m1_187200_57600 0 2.372877e-07
I4615 n1_m1_187200_62400 0 1.595674e-07
I4616 n1_m1_187200_67200 0 1.585120e-07
I4617 n1_m1_187200_72000 0 2.529029e-07
I4618 n1_m1_187200_76800 0 1.876248e-07
I4619 n1_m1_187200_81600 0 2.475244e-07
I4620 n1_m1_187200_86400 0 1.633314e-07
I4621 n1_m1_187200_91200 0 1.653669e-07
I4622 n1_m1_187200_96000 0 2.653622e-07
I4623 n1_m1_187200_100800 0 2.065289e-07
I4624 n1_m1_187200_105600 0 3.390682e-07
I4625 n1_m1_187200_110400 0 1.729066e-07
I4626 n1_m1_187200_115200 0 1.679882e-07
I4627 n1_m1_187200_120000 0 2.938314e-07
I4628 n1_m1_187200_124800 0 2.489696e-07
I4629 n1_m1_187200_129600 0 4.822091e-07
I4630 n1_m1_187200_134400 0 4.936327e-07
I4631 n1_m1_187200_139200 0 6.245075e-07
I4632 n1_m1_187200_144000 0 5.566198e-07
I4633 n1_m1_187200_148800 0 3.589387e-07
I4634 n1_m1_187200_153600 0 3.509367e-07
I4635 n1_m1_187200_158400 0 1.529373e-07
I4636 n1_m1_187200_163200 0 1.423467e-07
I4637 n1_m1_187200_168000 0 2.232127e-07
I4638 n1_m1_187200_172800 0 1.563619e-07
I4639 n1_m1_187200_177600 0 2.147353e-07
I4640 n1_m1_187200_182400 0 1.411613e-07
I4641 n1_m1_187200_187200 0 1.420259e-07
I4642 n1_m1_187200_192000 0 2.198491e-07
I4643 n1_m1_187200_196800 0 1.465661e-07
I4644 n1_m1_187200_201600 0 2.226203e-07
I4645 n1_m1_187200_206400 0 1.550915e-07
I4646 n1_m1_187200_211200 0 1.752050e-07
I4647 n1_m1_187200_216000 0 1.370975e-06
I4648 n1_m1_187200_220800 0 1.182053e-06
I4649 n1_m1_187200_225600 0 1.977234e-06
I4650 n1_m1_187200_230400 0 1.219647e-06
I4651 n1_m1_187200_235200 0 9.761962e-07
I4652 n1_m1_187200_240000 0 7.048387e-07
I4653 n1_m1_187200_244800 0 1.542287e-07
I4654 n1_m1_187200_249600 0 2.302512e-07
I4655 n1_m1_187200_254400 0 1.584088e-07
I4656 n1_m1_187200_259200 0 1.566346e-07
I4657 n1_m1_187200_264000 0 2.299245e-07
I4658 n1_m1_187200_268800 0 1.494861e-07
I4659 n1_m1_187200_273600 0 2.262700e-07
I4660 n1_m1_187200_278400 0 1.516839e-07
I4661 n1_m1_187200_283200 0 1.518118e-07
I4662 n1_m1_187200_288000 0 2.301159e-07
I4663 n1_m1_187200_292800 0 1.582899e-07
I4664 n1_m1_187200_297600 0 2.304342e-07
I4665 n1_m1_187200_302400 0 1.507269e-07
I4666 n1_m1_187200_307200 0 1.735671e-07
I4667 n1_m1_187200_312000 0 1.363673e-06
I4668 n1_m1_187200_316800 0 9.450592e-07
I4669 n1_m1_187200_321600 0 1.844908e-06
I4670 n1_m1_187200_326400 0 1.243102e-06
I4671 n1_m1_187200_331200 0 9.740703e-07
I4672 n1_m1_187200_336000 0 8.441015e-07
I4673 n1_m1_187200_340800 0 1.705947e-07
I4674 n1_m1_187200_345600 0 2.372654e-07
I4675 n1_m1_187200_350400 0 1.434940e-07
I4676 n1_m1_187200_355200 0 1.399040e-07
I4677 n1_m1_187200_360000 0 2.211654e-07
I4678 n1_m1_187200_364800 0 1.527449e-07
I4679 n1_m1_187200_369600 0 2.246050e-07
I4680 n1_m1_187200_374400 0 1.452725e-07
I4681 n1_m1_187200_379200 0 1.734674e-07
I4682 n1_m1_187200_384000 0 3.373798e-07
I4683 n1_m1_187200_388800 0 4.150156e-07
I4684 n1_m1_187200_393600 0 8.423435e-07
I4685 n1_m1_187200_398400 0 2.122602e-07
I4686 n1_m1_187200_403200 0 3.553957e-07
I4687 n1_m1_187200_408000 0 1.446056e-06
I4688 n1_m1_187200_412800 0 9.149111e-07
I4689 n1_m1_187200_417600 0 1.676154e-06
I4690 n1_m1_187200_422400 0 6.448808e-07
I4691 n1_m1_187200_427200 0 3.306269e-07
I4692 n1_m1_187200_432000 0 4.806164e-07
I4693 n1_m1_187200_436800 0 1.780435e-07
I4694 n1_m1_187200_441600 0 2.789209e-07
I4695 n1_m1_187200_446400 0 1.773072e-07
I4696 n1_m1_187200_451200 0 1.615393e-07
I4697 n1_m1_187200_456000 0 2.296844e-07
I4698 n1_m1_187200_460800 0 1.517776e-07
I4699 n1_m1_187200_465600 0 2.206231e-07
I4700 n1_m1_187200_470400 0 1.465661e-07
I4701 n1_m1_187200_475200 0 1.467152e-07
I4702 n1_m1_187200_480000 0 2.226034e-07
I4703 n1_m1_187200_484800 0 1.486880e-07
I4704 n1_m1_187200_489600 0 2.218502e-07
I4705 n1_m1_187200_494400 0 1.465661e-07
I4706 n1_m1_187200_499200 0 1.465661e-07
I4707 n1_m1_187200_504000 0 2.198491e-07
I4708 n1_m1_187200_508800 0 1.465661e-07
I4709 n1_m1_187200_513600 0 2.241267e-07
I4710 n1_m1_187200_518400 0 1.470608e-07
I4711 n1_m1_187200_523200 0 1.449274e-07
I4712 n1_m1_187200_528000 0 2.193318e-07
I4713 n1_m1_187200_532800 0 1.473618e-07
I4714 n1_m1_187200_537600 0 2.370372e-07
I4715 n1_m1_187200_542400 0 2.202560e-07
I4716 n1_m1_187200_547200 0 3.230605e-07
I4717 n1_m1_187200_552000 0 4.924504e-07
I4718 n1_m1_187200_556800 0 2.014125e-07
I4719 n1_m1_187200_561600 0 9.517900e-08
I4720 n1_m1_192000_0 0 3.165156e-07
I4721 n1_m1_192000_4800 0 4.621980e-07
I4722 n1_m1_192000_9600 0 6.665931e-07
I4723 n1_m1_192000_14400 0 2.518420e-07
I4724 n1_m1_192000_19200 0 2.320479e-07
I4725 n1_m1_192000_24000 0 3.530019e-07
I4726 n1_m1_192000_28800 0 2.234679e-07
I4727 n1_m1_192000_33600 0 3.336095e-07
I4728 n1_m1_192000_38400 0 2.280615e-07
I4729 n1_m1_192000_43200 0 2.241873e-07
I4730 n1_m1_192000_48000 0 3.293356e-07
I4731 n1_m1_192000_52800 0 2.308248e-07
I4732 n1_m1_192000_57600 0 3.936658e-07
I4733 n1_m1_192000_62400 0 2.964014e-07
I4734 n1_m1_192000_67200 0 2.804120e-07
I4735 n1_m1_192000_72000 0 4.865280e-07
I4736 n1_m1_192000_76800 0 3.925303e-07
I4737 n1_m1_192000_81600 0 3.745377e-07
I4738 n1_m1_192000_86400 0 2.826783e-07
I4739 n1_m1_192000_91200 0 3.148174e-07
I4740 n1_m1_192000_96000 0 5.040137e-07
I4741 n1_m1_192000_100800 0 3.764394e-07
I4742 n1_m1_192000_105600 0 5.526337e-07
I4743 n1_m1_192000_110400 0 2.708768e-07
I4744 n1_m1_192000_115200 0 3.248852e-07
I4745 n1_m1_192000_120000 0 6.210066e-07
I4746 n1_m1_192000_124800 0 4.281492e-07
I4747 n1_m1_192000_129600 0 7.845565e-07
I4748 n1_m1_192000_134400 0 7.442026e-07
I4749 n1_m1_192000_139200 0 1.193426e-06
I4750 n1_m1_192000_144000 0 1.773630e-06
I4751 n1_m1_192000_148800 0 1.236114e-06
I4752 n1_m1_192000_153600 0 8.366627e-07
I4753 n1_m1_192000_158400 0 2.327891e-07
I4754 n1_m1_192000_163200 0 2.283061e-07
I4755 n1_m1_192000_168000 0 3.608733e-07
I4756 n1_m1_192000_172800 0 2.142581e-07
I4757 n1_m1_192000_177600 0 3.289199e-07
I4758 n1_m1_192000_182400 0 2.157772e-07
I4759 n1_m1_192000_187200 0 2.115833e-07
I4760 n1_m1_192000_192000 0 3.260536e-07
I4761 n1_m1_192000_196800 0 2.225731e-07
I4762 n1_m1_192000_201600 0 3.476440e-07
I4763 n1_m1_192000_206400 0 2.426360e-07
I4764 n1_m1_192000_211200 0 2.491256e-07
I4765 n1_m1_192000_216000 0 1.345874e-06
I4766 n1_m1_192000_220800 0 1.439870e-06
I4767 n1_m1_192000_225600 0 2.836101e-06
I4768 n1_m1_192000_230400 0 1.669128e-06
I4769 n1_m1_192000_235200 0 1.135129e-06
I4770 n1_m1_192000_240000 0 7.765908e-07
I4771 n1_m1_192000_244800 0 2.367091e-07
I4772 n1_m1_192000_249600 0 3.450963e-07
I4773 n1_m1_192000_254400 0 2.341220e-07
I4774 n1_m1_192000_259200 0 2.352656e-07
I4775 n1_m1_192000_264000 0 3.460687e-07
I4776 n1_m1_192000_268800 0 2.252019e-07
I4777 n1_m1_192000_273600 0 3.306470e-07
I4778 n1_m1_192000_278400 0 2.238138e-07
I4779 n1_m1_192000_283200 0 2.310952e-07
I4780 n1_m1_192000_288000 0 3.367091e-07
I4781 n1_m1_192000_292800 0 2.256970e-07
I4782 n1_m1_192000_297600 0 3.333564e-07
I4783 n1_m1_192000_302400 0 2.136651e-07
I4784 n1_m1_192000_307200 0 2.334032e-07
I4785 n1_m1_192000_312000 0 1.521297e-06
I4786 n1_m1_192000_316800 0 1.116454e-06
I4787 n1_m1_192000_321600 0 2.549869e-06
I4788 n1_m1_192000_326400 0 1.655940e-06
I4789 n1_m1_192000_331200 0 1.094692e-06
I4790 n1_m1_192000_336000 0 9.782994e-07
I4791 n1_m1_192000_340800 0 2.412068e-07
I4792 n1_m1_192000_345600 0 3.494115e-07
I4793 n1_m1_192000_350400 0 2.182773e-07
I4794 n1_m1_192000_355200 0 2.117668e-07
I4795 n1_m1_192000_360000 0 3.251836e-07
I4796 n1_m1_192000_364800 0 2.240372e-07
I4797 n1_m1_192000_369600 0 3.287514e-07
I4798 n1_m1_192000_374400 0 2.159328e-07
I4799 n1_m1_192000_379200 0 2.428004e-07
I4800 n1_m1_192000_384000 0 4.071329e-07
I4801 n1_m1_192000_388800 0 3.801577e-07
I4802 n1_m1_192000_393600 0 7.445611e-07
I4803 n1_m1_192000_398400 0 3.031007e-07
I4804 n1_m1_192000_403200 0 4.346696e-07
I4805 n1_m1_192000_408000 0 1.863275e-06
I4806 n1_m1_192000_412800 0 1.478075e-06
I4807 n1_m1_192000_417600 0 2.554882e-06
I4808 n1_m1_192000_422400 0 1.025632e-06
I4809 n1_m1_192000_427200 0 4.509228e-07
I4810 n1_m1_192000_432000 0 4.930351e-07
I4811 n1_m1_192000_436800 0 2.398299e-07
I4812 n1_m1_192000_441600 0 4.014955e-07
I4813 n1_m1_192000_446400 0 2.632650e-07
I4814 n1_m1_192000_451200 0 2.374905e-07
I4815 n1_m1_192000_456000 0 3.354817e-07
I4816 n1_m1_192000_460800 0 2.267682e-07
I4817 n1_m1_192000_465600 0 3.317519e-07
I4818 n1_m1_192000_470400 0 2.198491e-07
I4819 n1_m1_192000_475200 0 2.202303e-07
I4820 n1_m1_192000_480000 0 3.368134e-07
I4821 n1_m1_192000_484800 0 2.252724e-07
I4822 n1_m1_192000_489600 0 3.348882e-07
I4823 n1_m1_192000_494400 0 2.177106e-07
I4824 n1_m1_192000_499200 0 2.170113e-07
I4825 n1_m1_192000_504000 0 3.297737e-07
I4826 n1_m1_192000_508800 0 2.168486e-07
I4827 n1_m1_192000_513600 0 3.277977e-07
I4828 n1_m1_192000_518400 0 2.190401e-07
I4829 n1_m1_192000_523200 0 2.121320e-07
I4830 n1_m1_192000_528000 0 3.263334e-07
I4831 n1_m1_192000_532800 0 2.155192e-07
I4832 n1_m1_192000_537600 0 3.402423e-07
I4833 n1_m1_192000_542400 0 3.212088e-07
I4834 n1_m1_192000_547200 0 4.859654e-07
I4835 n1_m1_192000_552000 0 7.712622e-07
I4836 n1_m1_192000_556800 0 3.108785e-07
I4837 n1_m1_192000_561600 0 1.460477e-07
I4838 n1_m1_196800_0 0 1.793135e-07
I4839 n1_m1_196800_4800 0 1.941479e-07
I4840 n1_m1_196800_9600 0 2.692760e-07
I4841 n1_m1_196800_14400 0 1.637392e-07
I4842 n1_m1_196800_19200 0 1.587288e-07
I4843 n1_m1_196800_24000 0 2.224667e-07
I4844 n1_m1_196800_28800 0 1.452376e-07
I4845 n1_m1_196800_33600 0 2.229971e-07
I4846 n1_m1_196800_38400 0 1.530558e-07
I4847 n1_m1_196800_43200 0 1.654809e-07
I4848 n1_m1_196800_48000 0 3.114884e-07
I4849 n1_m1_196800_52800 0 3.243114e-07
I4850 n1_m1_196800_57600 0 7.932261e-07
I4851 n1_m1_196800_62400 0 6.923430e-07
I4852 n1_m1_196800_67200 0 7.299276e-07
I4853 n1_m1_196800_72000 0 1.310416e-06
I4854 n1_m1_196800_76800 0 9.118212e-07
I4855 n1_m1_196800_81600 0 1.084536e-06
I4856 n1_m1_196800_86400 0 7.597606e-07
I4857 n1_m1_196800_91200 0 7.415545e-07
I4858 n1_m1_196800_96000 0 6.313214e-07
I4859 n1_m1_196800_100800 0 1.782420e-07
I4860 n1_m1_196800_105600 0 2.422213e-07
I4861 n1_m1_196800_110400 0 1.615300e-07
I4862 n1_m1_196800_115200 0 2.089301e-07
I4863 n1_m1_196800_120000 0 3.623082e-07
I4864 n1_m1_196800_124800 0 2.838735e-07
I4865 n1_m1_196800_129600 0 7.929816e-07
I4866 n1_m1_196800_134400 0 7.149276e-07
I4867 n1_m1_196800_139200 0 1.159292e-06
I4868 n1_m1_196800_144000 0 1.600236e-06
I4869 n1_m1_196800_148800 0 7.307433e-07
I4870 n1_m1_196800_153600 0 4.618538e-07
I4871 n1_m1_196800_158400 0 1.590935e-07
I4872 n1_m1_196800_163200 0 1.554375e-07
I4873 n1_m1_196800_168000 0 2.372140e-07
I4874 n1_m1_196800_172800 0 1.439038e-07
I4875 n1_m1_196800_177600 0 2.249321e-07
I4876 n1_m1_196800_182400 0 1.478226e-07
I4877 n1_m1_196800_187200 0 1.426103e-07
I4878 n1_m1_196800_192000 0 2.144258e-07
I4879 n1_m1_196800_196800 0 1.529044e-07
I4880 n1_m1_196800_201600 0 2.431427e-07
I4881 n1_m1_196800_206400 0 1.697468e-07
I4882 n1_m1_196800_211200 0 1.780214e-07
I4883 n1_m1_196800_216000 0 5.935918e-07
I4884 n1_m1_196800_220800 0 8.216557e-07
I4885 n1_m1_196800_225600 0 1.842328e-06
I4886 n1_m1_196800_230400 0 9.999585e-07
I4887 n1_m1_196800_235200 0 5.311922e-07
I4888 n1_m1_196800_240000 0 3.312715e-07
I4889 n1_m1_196800_244800 0 1.613835e-07
I4890 n1_m1_196800_249600 0 2.300860e-07
I4891 n1_m1_196800_254400 0 1.562949e-07
I4892 n1_m1_196800_259200 0 1.543517e-07
I4893 n1_m1_196800_264000 0 2.288050e-07
I4894 n1_m1_196800_268800 0 1.473425e-07
I4895 n1_m1_196800_273600 0 2.198491e-07
I4896 n1_m1_196800_278400 0 1.501935e-07
I4897 n1_m1_196800_283200 0 1.576717e-07
I4898 n1_m1_196800_288000 0 2.242465e-07
I4899 n1_m1_196800_292800 0 1.465661e-07
I4900 n1_m1_196800_297600 0 2.288621e-07
I4901 n1_m1_196800_302400 0 1.502928e-07
I4902 n1_m1_196800_307200 0 1.564999e-07
I4903 n1_m1_196800_312000 0 5.809945e-07
I4904 n1_m1_196800_316800 0 5.552152e-07
I4905 n1_m1_196800_321600 0 1.409893e-06
I4906 n1_m1_196800_326400 0 8.295029e-07
I4907 n1_m1_196800_331200 0 4.346870e-07
I4908 n1_m1_196800_336000 0 3.918070e-07
I4909 n1_m1_196800_340800 0 1.491859e-07
I4910 n1_m1_196800_345600 0 2.160398e-07
I4911 n1_m1_196800_350400 0 1.430658e-07
I4912 n1_m1_196800_355200 0 1.473110e-07
I4913 n1_m1_196800_360000 0 2.201486e-07
I4914 n1_m1_196800_364800 0 1.433262e-07
I4915 n1_m1_196800_369600 0 2.132819e-07
I4916 n1_m1_196800_374400 0 1.417319e-07
I4917 n1_m1_196800_379200 0 1.506250e-07
I4918 n1_m1_196800_384000 0 2.523423e-07
I4919 n1_m1_196800_388800 0 1.746913e-07
I4920 n1_m1_196800_393600 0 3.114747e-07
I4921 n1_m1_196800_398400 0 2.056925e-07
I4922 n1_m1_196800_403200 0 2.003444e-07
I4923 n1_m1_196800_408000 0 7.280358e-07
I4924 n1_m1_196800_412800 0 7.451754e-07
I4925 n1_m1_196800_417600 0 1.324365e-06
I4926 n1_m1_196800_422400 0 4.374464e-07
I4927 n1_m1_196800_427200 0 2.188070e-07
I4928 n1_m1_196800_432000 0 3.293736e-07
I4929 n1_m1_196800_436800 0 1.595378e-07
I4930 n1_m1_196800_441600 0 2.412711e-07
I4931 n1_m1_196800_446400 0 1.635495e-07
I4932 n1_m1_196800_451200 0 1.636554e-07
I4933 n1_m1_196800_456000 0 2.275017e-07
I4934 n1_m1_196800_460800 0 1.465661e-07
I4935 n1_m1_196800_465600 0 2.249897e-07
I4936 n1_m1_196800_470400 0 1.540597e-07
I4937 n1_m1_196800_475200 0 1.542293e-07
I4938 n1_m1_196800_480000 0 2.266079e-07
I4939 n1_m1_196800_484800 0 1.505372e-07
I4940 n1_m1_196800_489600 0 2.235942e-07
I4941 n1_m1_196800_494400 0 1.453068e-07
I4942 n1_m1_196800_499200 0 1.448950e-07
I4943 n1_m1_196800_504000 0 2.198491e-07
I4944 n1_m1_196800_508800 0 1.447993e-07
I4945 n1_m1_196800_513600 0 2.186856e-07
I4946 n1_m1_196800_518400 0 1.460267e-07
I4947 n1_m1_196800_523200 0 1.414213e-07
I4948 n1_m1_196800_528000 0 2.167611e-07
I4949 n1_m1_196800_532800 0 1.402537e-07
I4950 n1_m1_196800_537600 0 2.196357e-07
I4951 n1_m1_196800_542400 0 1.993858e-07
I4952 n1_m1_196800_547200 0 3.004300e-07
I4953 n1_m1_196800_552000 0 4.890059e-07
I4954 n1_m1_196800_556800 0 1.988861e-07
I4955 n1_m1_196800_561600 0 9.398412e-08
I4956 n1_m1_201600_0 0 2.200692e-07
I4957 n1_m1_201600_4800 0 3.231159e-07
I4958 n1_m1_201600_9600 0 4.847153e-07
I4959 n1_m1_201600_14400 0 1.851355e-07
I4960 n1_m1_201600_19200 0 1.556076e-07
I4961 n1_m1_201600_24000 0 2.180264e-07
I4962 n1_m1_201600_28800 0 1.422036e-07
I4963 n1_m1_201600_33600 0 2.204950e-07
I4964 n1_m1_201600_38400 0 1.690099e-07
I4965 n1_m1_201600_43200 0 2.641403e-07
I4966 n1_m1_201600_48000 0 6.060953e-07
I4967 n1_m1_201600_52800 0 5.833041e-07
I4968 n1_m1_201600_57600 0 1.395484e-06
I4969 n1_m1_201600_62400 0 1.156033e-06
I4970 n1_m1_201600_67200 0 1.195158e-06
I4971 n1_m1_201600_72000 0 1.796387e-06
I4972 n1_m1_201600_76800 0 1.196687e-06
I4973 n1_m1_201600_81600 0 1.426260e-06
I4974 n1_m1_201600_86400 0 1.082524e-06
I4975 n1_m1_201600_91200 0 1.137885e-06
I4976 n1_m1_201600_96000 0 1.027949e-06
I4977 n1_m1_201600_100800 0 2.711101e-07
I4978 n1_m1_201600_105600 0 6.807693e-07
I4979 n1_m1_201600_110400 0 3.147495e-07
I4980 n1_m1_201600_115200 0 2.676130e-07
I4981 n1_m1_201600_120000 0 5.404262e-07
I4982 n1_m1_201600_124800 0 6.592045e-07
I4983 n1_m1_201600_129600 0 1.609428e-06
I4984 n1_m1_201600_134400 0 1.053752e-06
I4985 n1_m1_201600_139200 0 1.227640e-06
I4986 n1_m1_201600_144000 0 1.493603e-06
I4987 n1_m1_201600_148800 0 7.059952e-07
I4988 n1_m1_201600_153600 0 5.630350e-07
I4989 n1_m1_201600_158400 0 1.822574e-07
I4990 n1_m1_201600_163200 0 1.464263e-07
I4991 n1_m1_201600_168000 0 2.179251e-07
I4992 n1_m1_201600_172800 0 1.556825e-07
I4993 n1_m1_201600_177600 0 2.307583e-07
I4994 n1_m1_201600_182400 0 1.505135e-07
I4995 n1_m1_201600_187200 0 1.462848e-07
I4996 n1_m1_201600_192000 0 2.195652e-07
I4997 n1_m1_201600_196800 0 1.547646e-07
I4998 n1_m1_201600_201600 0 2.477574e-07
I4999 n1_m1_201600_206400 0 1.727264e-07
I5000 n1_m1_201600_211200 0 1.825551e-07
I5001 n1_m1_201600_216000 0 4.444791e-07
I5002 n1_m1_201600_220800 0 7.350258e-07
I5003 n1_m1_201600_225600 0 1.727243e-06
I5004 n1_m1_201600_230400 0 8.660263e-07
I5005 n1_m1_201600_235200 0 4.633643e-07
I5006 n1_m1_201600_240000 0 2.827942e-07
I5007 n1_m1_201600_244800 0 1.593293e-07
I5008 n1_m1_201600_249600 0 2.298965e-07
I5009 n1_m1_201600_254400 0 1.539102e-07
I5010 n1_m1_201600_259200 0 1.534780e-07
I5011 n1_m1_201600_264000 0 2.231854e-07
I5012 n1_m1_201600_268800 0 1.466690e-07
I5013 n1_m1_201600_273600 0 2.198491e-07
I5014 n1_m1_201600_278400 0 1.468743e-07
I5015 n1_m1_201600_283200 0 1.488095e-07
I5016 n1_m1_201600_288000 0 2.258103e-07
I5017 n1_m1_201600_292800 0 1.492293e-07
I5018 n1_m1_201600_297600 0 2.287854e-07
I5019 n1_m1_201600_302400 0 1.483917e-07
I5020 n1_m1_201600_307200 0 1.642108e-07
I5021 n1_m1_201600_312000 0 4.189259e-07
I5022 n1_m1_201600_316800 0 3.817359e-07
I5023 n1_m1_201600_321600 0 1.090340e-06
I5024 n1_m1_201600_326400 0 6.353691e-07
I5025 n1_m1_201600_331200 0 2.947449e-07
I5026 n1_m1_201600_336000 0 2.913570e-07
I5027 n1_m1_201600_340800 0 1.556400e-07
I5028 n1_m1_201600_345600 0 2.329380e-07
I5029 n1_m1_201600_350400 0 1.490183e-07
I5030 n1_m1_201600_355200 0 1.525937e-07
I5031 n1_m1_201600_360000 0 2.226408e-07
I5032 n1_m1_201600_364800 0 1.411585e-07
I5033 n1_m1_201600_369600 0 2.119728e-07
I5034 n1_m1_201600_374400 0 1.472700e-07
I5035 n1_m1_201600_379200 0 1.533336e-07
I5036 n1_m1_201600_384000 0 2.401086e-07
I5037 n1_m1_201600_388800 0 1.584133e-07
I5038 n1_m1_201600_393600 0 2.371867e-07
I5039 n1_m1_201600_398400 0 1.736831e-07
I5040 n1_m1_201600_403200 0 1.911247e-07
I5041 n1_m1_201600_408000 0 5.495460e-07
I5042 n1_m1_201600_412800 0 4.790883e-07
I5043 n1_m1_201600_417600 0 1.190748e-06
I5044 n1_m1_201600_422400 0 5.284493e-07
I5045 n1_m1_201600_427200 0 2.849846e-07
I5046 n1_m1_201600_432000 0 3.728369e-07
I5047 n1_m1_201600_436800 0 1.569965e-07
I5048 n1_m1_201600_441600 0 2.353606e-07
I5049 n1_m1_201600_446400 0 1.598943e-07
I5050 n1_m1_201600_451200 0 1.565188e-07
I5051 n1_m1_201600_456000 0 2.214854e-07
I5052 n1_m1_201600_460800 0 1.586621e-07
I5053 n1_m1_201600_465600 0 2.609085e-07
I5054 n1_m1_201600_470400 0 1.821526e-07
I5055 n1_m1_201600_475200 0 1.782585e-07
I5056 n1_m1_201600_480000 0 2.557067e-07
I5057 n1_m1_201600_484800 0 1.648940e-07
I5058 n1_m1_201600_489600 0 2.406034e-07
I5059 n1_m1_201600_494400 0 1.502748e-07
I5060 n1_m1_201600_499200 0 1.472003e-07
I5061 n1_m1_201600_504000 0 2.208004e-07
I5062 n1_m1_201600_508800 0 1.509946e-07
I5063 n1_m1_201600_513600 0 2.287439e-07
I5064 n1_m1_201600_518400 0 1.479771e-07
I5065 n1_m1_201600_523200 0 1.464951e-07
I5066 n1_m1_201600_528000 0 2.184638e-07
I5067 n1_m1_201600_532800 0 1.408546e-07
I5068 n1_m1_201600_537600 0 2.262426e-07
I5069 n1_m1_201600_542400 0 2.350987e-07
I5070 n1_m1_201600_547200 0 3.632602e-07
I5071 n1_m1_201600_552000 0 5.223311e-07
I5072 n1_m1_201600_556800 0 1.928969e-07
I5073 n1_m1_201600_561600 0 9.091792e-08
I5074 n1_m1_206400_0 0 2.810897e-07
I5075 n1_m1_206400_4800 0 5.180988e-07
I5076 n1_m1_206400_9600 0 8.359528e-07
I5077 n1_m1_206400_14400 0 2.308881e-07
I5078 n1_m1_206400_19200 0 1.590650e-07
I5079 n1_m1_206400_24000 0 2.185602e-07
I5080 n1_m1_206400_28800 0 1.407473e-07
I5081 n1_m1_206400_33600 0 2.196198e-07
I5082 n1_m1_206400_38400 0 1.968052e-07
I5083 n1_m1_206400_43200 0 2.984480e-07
I5084 n1_m1_206400_48000 0 5.381528e-07
I5085 n1_m1_206400_52800 0 4.093607e-07
I5086 n1_m1_206400_57600 0 9.623613e-07
I5087 n1_m1_206400_62400 0 8.724490e-07
I5088 n1_m1_206400_67200 0 9.350088e-07
I5089 n1_m1_206400_72000 0 1.381570e-06
I5090 n1_m1_206400_76800 0 9.976450e-07
I5091 n1_m1_206400_81600 0 1.091191e-06
I5092 n1_m1_206400_86400 0 9.384421e-07
I5093 n1_m1_206400_91200 0 1.093214e-06
I5094 n1_m1_206400_96000 0 1.180684e-06
I5095 n1_m1_206400_100800 0 4.565226e-07
I5096 n1_m1_206400_105600 0 6.056645e-07
I5097 n1_m1_206400_110400 0 2.888191e-07
I5098 n1_m1_206400_115200 0 2.807261e-07
I5099 n1_m1_206400_120000 0 5.531602e-07
I5100 n1_m1_206400_124800 0 6.686812e-07
I5101 n1_m1_206400_129600 0 1.677545e-06
I5102 n1_m1_206400_134400 0 1.091570e-06
I5103 n1_m1_206400_139200 0 1.250533e-06
I5104 n1_m1_206400_144000 0 1.710258e-06
I5105 n1_m1_206400_148800 0 9.618011e-07
I5106 n1_m1_206400_153600 0 6.949427e-07
I5107 n1_m1_206400_158400 0 1.791438e-07
I5108 n1_m1_206400_163200 0 1.446053e-07
I5109 n1_m1_206400_168000 0 2.249561e-07
I5110 n1_m1_206400_172800 0 1.505315e-07
I5111 n1_m1_206400_177600 0 2.337557e-07
I5112 n1_m1_206400_182400 0 1.502508e-07
I5113 n1_m1_206400_187200 0 1.467963e-07
I5114 n1_m1_206400_192000 0 2.233781e-07
I5115 n1_m1_206400_196800 0 1.567878e-07
I5116 n1_m1_206400_201600 0 2.517935e-07
I5117 n1_m1_206400_206400 0 1.732323e-07
I5118 n1_m1_206400_211200 0 1.708407e-07
I5119 n1_m1_206400_216000 0 3.545643e-07
I5120 n1_m1_206400_220800 0 6.166125e-07
I5121 n1_m1_206400_225600 0 1.589364e-06
I5122 n1_m1_206400_230400 0 7.749509e-07
I5123 n1_m1_206400_235200 0 4.648646e-07
I5124 n1_m1_206400_240000 0 2.963341e-07
I5125 n1_m1_206400_244800 0 1.548377e-07
I5126 n1_m1_206400_249600 0 2.297349e-07
I5127 n1_m1_206400_254400 0 1.531626e-07
I5128 n1_m1_206400_259200 0 1.534704e-07
I5129 n1_m1_206400_264000 0 2.221238e-07
I5130 n1_m1_206400_268800 0 1.465643e-07
I5131 n1_m1_206400_273600 0 2.200574e-07
I5132 n1_m1_206400_278400 0 1.451955e-07
I5133 n1_m1_206400_283200 0 1.445986e-07
I5134 n1_m1_206400_288000 0 2.252337e-07
I5135 n1_m1_206400_292800 0 1.496892e-07
I5136 n1_m1_206400_297600 0 2.206993e-07
I5137 n1_m1_206400_302400 0 1.421561e-07
I5138 n1_m1_206400_307200 0 1.684321e-07
I5139 n1_m1_206400_312000 0 5.098375e-07
I5140 n1_m1_206400_316800 0 7.321264e-07
I5141 n1_m1_206400_321600 0 1.625926e-06
I5142 n1_m1_206400_326400 0 9.654557e-07
I5143 n1_m1_206400_331200 0 4.988840e-07
I5144 n1_m1_206400_336000 0 4.335843e-07
I5145 n1_m1_206400_340800 0 1.535661e-07
I5146 n1_m1_206400_345600 0 2.185609e-07
I5147 n1_m1_206400_350400 0 1.439702e-07
I5148 n1_m1_206400_355200 0 1.505425e-07
I5149 n1_m1_206400_360000 0 2.223874e-07
I5150 n1_m1_206400_364800 0 1.422115e-07
I5151 n1_m1_206400_369600 0 2.202823e-07
I5152 n1_m1_206400_374400 0 1.542512e-07
I5153 n1_m1_206400_379200 0 1.592721e-07
I5154 n1_m1_206400_384000 0 2.386029e-07
I5155 n1_m1_206400_388800 0 1.581136e-07
I5156 n1_m1_206400_393600 0 2.417770e-07
I5157 n1_m1_206400_398400 0 2.417782e-07
I5158 n1_m1_206400_403200 0 3.924239e-07
I5159 n1_m1_206400_408000 0 1.165543e-06
I5160 n1_m1_206400_412800 0 7.871353e-07
I5161 n1_m1_206400_417600 0 1.757524e-06
I5162 n1_m1_206400_422400 0 1.060417e-06
I5163 n1_m1_206400_427200 0 7.029803e-07
I5164 n1_m1_206400_432000 0 6.351931e-07
I5165 n1_m1_206400_436800 0 1.722435e-07
I5166 n1_m1_206400_441600 0 2.683052e-07
I5167 n1_m1_206400_446400 0 1.737589e-07
I5168 n1_m1_206400_451200 0 1.574505e-07
I5169 n1_m1_206400_456000 0 2.172683e-07
I5170 n1_m1_206400_460800 0 1.568250e-07
I5171 n1_m1_206400_465600 0 2.635611e-07
I5172 n1_m1_206400_470400 0 1.886100e-07
I5173 n1_m1_206400_475200 0 1.845117e-07
I5174 n1_m1_206400_480000 0 2.593315e-07
I5175 n1_m1_206400_484800 0 1.658599e-07
I5176 n1_m1_206400_489600 0 2.438532e-07
I5177 n1_m1_206400_494400 0 1.552336e-07
I5178 n1_m1_206400_499200 0 1.521767e-07
I5179 n1_m1_206400_504000 0 2.288422e-07
I5180 n1_m1_206400_508800 0 1.568768e-07
I5181 n1_m1_206400_513600 0 2.373765e-07
I5182 n1_m1_206400_518400 0 1.529993e-07
I5183 n1_m1_206400_523200 0 1.515755e-07
I5184 n1_m1_206400_528000 0 2.204196e-07
I5185 n1_m1_206400_532800 0 1.451699e-07
I5186 n1_m1_206400_537600 0 2.341814e-07
I5187 n1_m1_206400_542400 0 2.620227e-07
I5188 n1_m1_206400_547200 0 4.139055e-07
I5189 n1_m1_206400_552000 0 5.497858e-07
I5190 n1_m1_206400_556800 0 1.890258e-07
I5191 n1_m1_206400_561600 0 8.872533e-08
I5192 n1_m1_211200_0 0 2.407514e-07
I5193 n1_m1_211200_4800 0 3.803502e-07
I5194 n1_m1_211200_9600 0 6.363005e-07
I5195 n1_m1_211200_14400 0 2.276210e-07
I5196 n1_m1_211200_19200 0 1.654527e-07
I5197 n1_m1_211200_24000 0 2.282140e-07
I5198 n1_m1_211200_28800 0 1.467697e-07
I5199 n1_m1_211200_33600 0 2.228896e-07
I5200 n1_m1_211200_38400 0 1.700411e-07
I5201 n1_m1_211200_43200 0 1.990402e-07
I5202 n1_m1_211200_48000 0 3.240030e-07
I5203 n1_m1_211200_52800 0 2.225218e-07
I5204 n1_m1_211200_57600 0 4.305378e-07
I5205 n1_m1_211200_62400 0 4.414292e-07
I5206 n1_m1_211200_67200 0 5.793414e-07
I5207 n1_m1_211200_72000 0 9.495564e-07
I5208 n1_m1_211200_76800 0 5.962276e-07
I5209 n1_m1_211200_81600 0 7.363173e-07
I5210 n1_m1_211200_86400 0 5.488492e-07
I5211 n1_m1_211200_91200 0 5.949283e-07
I5212 n1_m1_211200_96000 0 7.245613e-07
I5213 n1_m1_211200_100800 0 3.224262e-07
I5214 n1_m1_211200_105600 0 4.015425e-07
I5215 n1_m1_211200_110400 0 2.058403e-07
I5216 n1_m1_211200_115200 0 1.986415e-07
I5217 n1_m1_211200_120000 0 4.737400e-07
I5218 n1_m1_211200_124800 0 5.267385e-07
I5219 n1_m1_211200_129600 0 1.194530e-06
I5220 n1_m1_211200_134400 0 9.631269e-07
I5221 n1_m1_211200_139200 0 1.283603e-06
I5222 n1_m1_211200_144000 0 1.555768e-06
I5223 n1_m1_211200_148800 0 8.221906e-07
I5224 n1_m1_211200_153600 0 5.953107e-07
I5225 n1_m1_211200_158400 0 1.694853e-07
I5226 n1_m1_211200_163200 0 1.452795e-07
I5227 n1_m1_211200_168000 0 2.509638e-07
I5228 n1_m1_211200_172800 0 1.457107e-07
I5229 n1_m1_211200_177600 0 2.249993e-07
I5230 n1_m1_211200_182400 0 1.465223e-07
I5231 n1_m1_211200_187200 0 1.501287e-07
I5232 n1_m1_211200_192000 0 2.209184e-07
I5233 n1_m1_211200_196800 0 1.583779e-07
I5234 n1_m1_211200_201600 0 2.479051e-07
I5235 n1_m1_211200_206400 0 1.797706e-07
I5236 n1_m1_211200_211200 0 1.683524e-07
I5237 n1_m1_211200_216000 0 3.713602e-07
I5238 n1_m1_211200_220800 0 4.467759e-07
I5239 n1_m1_211200_225600 0 1.214568e-06
I5240 n1_m1_211200_230400 0 6.158434e-07
I5241 n1_m1_211200_235200 0 4.213822e-07
I5242 n1_m1_211200_240000 0 3.035793e-07
I5243 n1_m1_211200_244800 0 1.608231e-07
I5244 n1_m1_211200_249600 0 2.282183e-07
I5245 n1_m1_211200_254400 0 1.522223e-07
I5246 n1_m1_211200_259200 0 1.569471e-07
I5247 n1_m1_211200_264000 0 2.192121e-07
I5248 n1_m1_211200_268800 0 1.465384e-07
I5249 n1_m1_211200_273600 0 2.230617e-07
I5250 n1_m1_211200_278400 0 1.466446e-07
I5251 n1_m1_211200_283200 0 1.565324e-07
I5252 n1_m1_211200_288000 0 2.232339e-07
I5253 n1_m1_211200_292800 0 1.504708e-07
I5254 n1_m1_211200_297600 0 2.251335e-07
I5255 n1_m1_211200_302400 0 1.516636e-07
I5256 n1_m1_211200_307200 0 1.604767e-07
I5257 n1_m1_211200_312000 0 1.113215e-06
I5258 n1_m1_211200_316800 0 8.234705e-07
I5259 n1_m1_211200_321600 0 1.461598e-06
I5260 n1_m1_211200_326400 0 8.799819e-07
I5261 n1_m1_211200_331200 0 4.544291e-07
I5262 n1_m1_211200_336000 0 3.745453e-07
I5263 n1_m1_211200_340800 0 1.480582e-07
I5264 n1_m1_211200_345600 0 2.185917e-07
I5265 n1_m1_211200_350400 0 1.456081e-07
I5266 n1_m1_211200_355200 0 1.444313e-07
I5267 n1_m1_211200_360000 0 2.187346e-07
I5268 n1_m1_211200_364800 0 1.543331e-07
I5269 n1_m1_211200_369600 0 2.497677e-07
I5270 n1_m1_211200_374400 0 1.739796e-07
I5271 n1_m1_211200_379200 0 1.746484e-07
I5272 n1_m1_211200_384000 0 2.555634e-07
I5273 n1_m1_211200_388800 0 1.714098e-07
I5274 n1_m1_211200_393600 0 3.026876e-07
I5275 n1_m1_211200_398400 0 2.390101e-07
I5276 n1_m1_211200_403200 0 3.893026e-07
I5277 n1_m1_211200_408000 0 1.294091e-06
I5278 n1_m1_211200_412800 0 7.265498e-07
I5279 n1_m1_211200_417600 0 1.690513e-06
I5280 n1_m1_211200_422400 0 5.602782e-07
I5281 n1_m1_211200_427200 0 3.392578e-07
I5282 n1_m1_211200_432000 0 4.474193e-07
I5283 n1_m1_211200_436800 0 1.724827e-07
I5284 n1_m1_211200_441600 0 2.434689e-07
I5285 n1_m1_211200_446400 0 1.541872e-07
I5286 n1_m1_211200_451200 0 1.566163e-07
I5287 n1_m1_211200_456000 0 2.256415e-07
I5288 n1_m1_211200_460800 0 1.524181e-07
I5289 n1_m1_211200_465600 0 2.442037e-07
I5290 n1_m1_211200_470400 0 1.713254e-07
I5291 n1_m1_211200_475200 0 1.705989e-07
I5292 n1_m1_211200_480000 0 2.439831e-07
I5293 n1_m1_211200_484800 0 1.541029e-07
I5294 n1_m1_211200_489600 0 2.214301e-07
I5295 n1_m1_211200_494400 0 1.512541e-07
I5296 n1_m1_211200_499200 0 1.551780e-07
I5297 n1_m1_211200_504000 0 2.415875e-07
I5298 n1_m1_211200_508800 0 1.645282e-07
I5299 n1_m1_211200_513600 0 2.411851e-07
I5300 n1_m1_211200_518400 0 1.537802e-07
I5301 n1_m1_211200_523200 0 1.487925e-07
I5302 n1_m1_211200_528000 0 2.137368e-07
I5303 n1_m1_211200_532800 0 1.422764e-07
I5304 n1_m1_211200_537600 0 2.329510e-07
I5305 n1_m1_211200_542400 0 2.297289e-07
I5306 n1_m1_211200_547200 0 3.406015e-07
I5307 n1_m1_211200_552000 0 4.761533e-07
I5308 n1_m1_211200_556800 0 1.813566e-07
I5309 n1_m1_211200_561600 0 8.681896e-08
I5310 n1_m1_216000_0 0 4.785716e-07
I5311 n1_m1_216000_4800 0 1.063725e-06
I5312 n1_m1_216000_9600 0 2.230705e-06
I5313 n1_m1_216000_14400 0 1.229621e-06
I5314 n1_m1_216000_19200 0 6.163120e-07
I5315 n1_m1_216000_24000 0 4.054831e-07
I5316 n1_m1_216000_28800 0 2.167731e-07
I5317 n1_m1_216000_33600 0 3.265054e-07
I5318 n1_m1_216000_38400 0 2.256577e-07
I5319 n1_m1_216000_43200 0 2.259630e-07
I5320 n1_m1_216000_48000 0 3.498205e-07
I5321 n1_m1_216000_52800 0 2.428669e-07
I5322 n1_m1_216000_57600 0 3.700041e-07
I5323 n1_m1_216000_62400 0 2.989053e-07
I5324 n1_m1_216000_67200 0 3.633652e-07
I5325 n1_m1_216000_72000 0 5.738509e-07
I5326 n1_m1_216000_76800 0 3.590522e-07
I5327 n1_m1_216000_81600 0 5.105227e-07
I5328 n1_m1_216000_86400 0 3.411017e-07
I5329 n1_m1_216000_91200 0 3.424211e-07
I5330 n1_m1_216000_96000 0 4.737566e-07
I5331 n1_m1_216000_100800 0 2.783157e-07
I5332 n1_m1_216000_105600 0 3.932780e-07
I5333 n1_m1_216000_110400 0 2.561253e-07
I5334 n1_m1_216000_115200 0 2.537215e-07
I5335 n1_m1_216000_120000 0 4.574547e-07
I5336 n1_m1_216000_124800 0 3.851010e-07
I5337 n1_m1_216000_129600 0 8.340510e-07
I5338 n1_m1_216000_134400 0 1.184587e-06
I5339 n1_m1_216000_139200 0 1.834681e-06
I5340 n1_m1_216000_144000 0 2.585672e-06
I5341 n1_m1_216000_148800 0 1.677764e-06
I5342 n1_m1_216000_153600 0 1.100039e-06
I5343 n1_m1_216000_158400 0 2.776815e-07
I5344 n1_m1_216000_163200 0 2.299816e-07
I5345 n1_m1_216000_168000 0 3.719389e-07
I5346 n1_m1_216000_172800 0 2.346692e-07
I5347 n1_m1_216000_177600 0 3.462938e-07
I5348 n1_m1_216000_182400 0 2.254515e-07
I5349 n1_m1_216000_187200 0 2.312278e-07
I5350 n1_m1_216000_192000 0 3.407022e-07
I5351 n1_m1_216000_196800 0 2.869437e-07
I5352 n1_m1_216000_201600 0 5.154215e-07
I5353 n1_m1_216000_206400 0 4.825266e-07
I5354 n1_m1_216000_211200 0 5.453215e-07
I5355 n1_m1_216000_216000 0 8.908922e-07
I5356 n1_m1_216000_220800 0 6.510119e-07
I5357 n1_m1_216000_225600 0 1.342685e-06
I5358 n1_m1_216000_230400 0 5.840253e-07
I5359 n1_m1_216000_235200 0 3.575399e-07
I5360 n1_m1_216000_240000 0 4.177631e-07
I5361 n1_m1_216000_244800 0 2.405369e-07
I5362 n1_m1_216000_249600 0 3.479481e-07
I5363 n1_m1_216000_254400 0 2.291239e-07
I5364 n1_m1_216000_259200 0 2.364600e-07
I5365 n1_m1_216000_264000 0 3.270193e-07
I5366 n1_m1_216000_268800 0 2.199362e-07
I5367 n1_m1_216000_273600 0 3.400467e-07
I5368 n1_m1_216000_278400 0 2.243668e-07
I5369 n1_m1_216000_283200 0 2.347499e-07
I5370 n1_m1_216000_288000 0 3.377829e-07
I5371 n1_m1_216000_292800 0 2.308959e-07
I5372 n1_m1_216000_297600 0 3.416945e-07
I5373 n1_m1_216000_302400 0 2.392708e-07
I5374 n1_m1_216000_307200 0 2.701014e-07
I5375 n1_m1_216000_312000 0 2.003845e-06
I5376 n1_m1_216000_316800 0 1.092251e-06
I5377 n1_m1_216000_321600 0 1.807138e-06
I5378 n1_m1_216000_326400 0 1.140124e-06
I5379 n1_m1_216000_331200 0 5.425781e-07
I5380 n1_m1_216000_336000 0 4.560709e-07
I5381 n1_m1_216000_340800 0 2.240173e-07
I5382 n1_m1_216000_345600 0 3.378140e-07
I5383 n1_m1_216000_350400 0 2.212246e-07
I5384 n1_m1_216000_355200 0 2.186696e-07
I5385 n1_m1_216000_360000 0 3.243294e-07
I5386 n1_m1_216000_364800 0 2.348164e-07
I5387 n1_m1_216000_369600 0 3.889295e-07
I5388 n1_m1_216000_374400 0 2.771963e-07
I5389 n1_m1_216000_379200 0 2.789986e-07
I5390 n1_m1_216000_384000 0 4.199674e-07
I5391 n1_m1_216000_388800 0 2.727725e-07
I5392 n1_m1_216000_393600 0 4.137468e-07
I5393 n1_m1_216000_398400 0 2.761123e-07
I5394 n1_m1_216000_403200 0 4.265094e-07
I5395 n1_m1_216000_408000 0 2.063362e-06
I5396 n1_m1_216000_412800 0 1.422279e-06
I5397 n1_m1_216000_417600 0 2.303266e-06
I5398 n1_m1_216000_422400 0 6.593184e-07
I5399 n1_m1_216000_427200 0 3.261253e-07
I5400 n1_m1_216000_432000 0 4.648730e-07
I5401 n1_m1_216000_436800 0 2.312219e-07
I5402 n1_m1_216000_441600 0 3.338084e-07
I5403 n1_m1_216000_446400 0 2.194950e-07
I5404 n1_m1_216000_451200 0 2.260051e-07
I5405 n1_m1_216000_456000 0 3.273463e-07
I5406 n1_m1_216000_460800 0 2.182058e-07
I5407 n1_m1_216000_465600 0 3.436555e-07
I5408 n1_m1_216000_470400 0 2.383510e-07
I5409 n1_m1_216000_475200 0 2.386351e-07
I5410 n1_m1_216000_480000 0 3.435957e-07
I5411 n1_m1_216000_484800 0 2.185276e-07
I5412 n1_m1_216000_489600 0 3.210291e-07
I5413 n1_m1_216000_494400 0 2.239348e-07
I5414 n1_m1_216000_499200 0 2.293480e-07
I5415 n1_m1_216000_504000 0 3.536718e-07
I5416 n1_m1_216000_508800 0 2.406000e-07
I5417 n1_m1_216000_513600 0 3.499769e-07
I5418 n1_m1_216000_518400 0 2.281705e-07
I5419 n1_m1_216000_523200 0 2.214912e-07
I5420 n1_m1_216000_528000 0 3.267852e-07
I5421 n1_m1_216000_532800 0 2.092995e-07
I5422 n1_m1_216000_537600 0 3.182150e-07
I5423 n1_m1_216000_542400 0 2.603839e-07
I5424 n1_m1_216000_547200 0 3.645256e-07
I5425 n1_m1_216000_552000 0 6.389471e-07
I5426 n1_m1_216000_556800 0 2.953808e-07
I5427 n1_m1_216000_561600 0 1.410024e-07
I5428 n1_m1_220800_0 0 2.634324e-07
I5429 n1_m1_220800_4800 0 4.570269e-07
I5430 n1_m1_220800_9600 0 7.636220e-07
I5431 n1_m1_220800_14400 0 2.791147e-07
I5432 n1_m1_220800_19200 0 1.931143e-07
I5433 n1_m1_220800_24000 0 2.598673e-07
I5434 n1_m1_220800_28800 0 1.602917e-07
I5435 n1_m1_220800_33600 0 2.245791e-07
I5436 n1_m1_220800_38400 0 1.569905e-07
I5437 n1_m1_220800_43200 0 1.482374e-07
I5438 n1_m1_220800_48000 0 2.201222e-07
I5439 n1_m1_220800_52800 0 1.534353e-07
I5440 n1_m1_220800_57600 0 2.244641e-07
I5441 n1_m1_220800_62400 0 1.511768e-07
I5442 n1_m1_220800_67200 0 1.564748e-07
I5443 n1_m1_220800_72000 0 2.323802e-07
I5444 n1_m1_220800_76800 0 1.596954e-07
I5445 n1_m1_220800_81600 0 2.408733e-07
I5446 n1_m1_220800_86400 0 1.571132e-07
I5447 n1_m1_220800_91200 0 1.547808e-07
I5448 n1_m1_220800_96000 0 2.314763e-07
I5449 n1_m1_220800_100800 0 1.562629e-07
I5450 n1_m1_220800_105600 0 2.233447e-07
I5451 n1_m1_220800_110400 0 1.495252e-07
I5452 n1_m1_220800_115200 0 1.608854e-07
I5453 n1_m1_220800_120000 0 2.427749e-07
I5454 n1_m1_220800_124800 0 1.746932e-07
I5455 n1_m1_220800_129600 0 3.155643e-07
I5456 n1_m1_220800_134400 0 7.154531e-07
I5457 n1_m1_220800_139200 0 1.146693e-06
I5458 n1_m1_220800_144000 0 1.763951e-06
I5459 n1_m1_220800_148800 0 1.119310e-06
I5460 n1_m1_220800_153600 0 6.567999e-07
I5461 n1_m1_220800_158400 0 2.082004e-07
I5462 n1_m1_220800_163200 0 1.705055e-07
I5463 n1_m1_220800_168000 0 2.220545e-07
I5464 n1_m1_220800_172800 0 1.578857e-07
I5465 n1_m1_220800_177600 0 2.327014e-07
I5466 n1_m1_220800_182400 0 1.508651e-07
I5467 n1_m1_220800_187200 0 1.527987e-07
I5468 n1_m1_220800_192000 0 2.289887e-07
I5469 n1_m1_220800_196800 0 2.592015e-07
I5470 n1_m1_220800_201600 0 5.206848e-07
I5471 n1_m1_220800_206400 0 4.381457e-07
I5472 n1_m1_220800_211200 0 4.057860e-07
I5473 n1_m1_220800_216000 0 4.474945e-07
I5474 n1_m1_220800_220800 0 3.096862e-07
I5475 n1_m1_220800_225600 0 5.646252e-07
I5476 n1_m1_220800_230400 0 2.820311e-07
I5477 n1_m1_220800_235200 0 2.415480e-07
I5478 n1_m1_220800_240000 0 4.627195e-07
I5479 n1_m1_220800_244800 0 1.894696e-07
I5480 n1_m1_220800_249600 0 2.459386e-07
I5481 n1_m1_220800_254400 0 1.592139e-07
I5482 n1_m1_220800_259200 0 1.563184e-07
I5483 n1_m1_220800_264000 0 2.173520e-07
I5484 n1_m1_220800_268800 0 1.473227e-07
I5485 n1_m1_220800_273600 0 2.323380e-07
I5486 n1_m1_220800_278400 0 1.499305e-07
I5487 n1_m1_220800_283200 0 1.547403e-07
I5488 n1_m1_220800_288000 0 2.252458e-07
I5489 n1_m1_220800_292800 0 1.570119e-07
I5490 n1_m1_220800_297600 0 2.310797e-07
I5491 n1_m1_220800_302400 0 1.641500e-07
I5492 n1_m1_220800_307200 0 2.244553e-07
I5493 n1_m1_220800_312000 0 1.382806e-06
I5494 n1_m1_220800_316800 0 9.799240e-07
I5495 n1_m1_220800_321600 0 1.691767e-06
I5496 n1_m1_220800_326400 0 1.026738e-06
I5497 n1_m1_220800_331200 0 5.123211e-07
I5498 n1_m1_220800_336000 0 3.885925e-07
I5499 n1_m1_220800_340800 0 1.549583e-07
I5500 n1_m1_220800_345600 0 2.122788e-07
I5501 n1_m1_220800_350400 0 1.427244e-07
I5502 n1_m1_220800_355200 0 1.465661e-07
I5503 n1_m1_220800_360000 0 2.191115e-07
I5504 n1_m1_220800_364800 0 1.529767e-07
I5505 n1_m1_220800_369600 0 2.569368e-07
I5506 n1_m1_220800_374400 0 1.851602e-07
I5507 n1_m1_220800_379200 0 1.917203e-07
I5508 n1_m1_220800_384000 0 3.257847e-07
I5509 n1_m1_220800_388800 0 2.307581e-07
I5510 n1_m1_220800_393600 0 2.817457e-07
I5511 n1_m1_220800_398400 0 1.876409e-07
I5512 n1_m1_220800_403200 0 2.480574e-07
I5513 n1_m1_220800_408000 0 1.428927e-06
I5514 n1_m1_220800_412800 0 1.197526e-06
I5515 n1_m1_220800_417600 0 1.590056e-06
I5516 n1_m1_220800_422400 0 7.809204e-07
I5517 n1_m1_220800_427200 0 3.920577e-07
I5518 n1_m1_220800_432000 0 4.365145e-07
I5519 n1_m1_220800_436800 0 1.622496e-07
I5520 n1_m1_220800_441600 0 2.370473e-07
I5521 n1_m1_220800_446400 0 1.569657e-07
I5522 n1_m1_220800_451200 0 1.592711e-07
I5523 n1_m1_220800_456000 0 2.201355e-07
I5524 n1_m1_220800_460800 0 1.403032e-07
I5525 n1_m1_220800_465600 0 2.172368e-07
I5526 n1_m1_220800_470400 0 1.466401e-07
I5527 n1_m1_220800_475200 0 1.463021e-07
I5528 n1_m1_220800_480000 0 2.127759e-07
I5529 n1_m1_220800_484800 0 1.410963e-07
I5530 n1_m1_220800_489600 0 2.136622e-07
I5531 n1_m1_220800_494400 0 1.468240e-07
I5532 n1_m1_220800_499200 0 1.471173e-07
I5533 n1_m1_220800_504000 0 2.243496e-07
I5534 n1_m1_220800_508800 0 1.518471e-07
I5535 n1_m1_220800_513600 0 2.218108e-07
I5536 n1_m1_220800_518400 0 1.469308e-07
I5537 n1_m1_220800_523200 0 1.468592e-07
I5538 n1_m1_220800_528000 0 2.237175e-07
I5539 n1_m1_220800_532800 0 1.396947e-07
I5540 n1_m1_220800_537600 0 2.097397e-07
I5541 n1_m1_220800_542400 0 1.636022e-07
I5542 n1_m1_220800_547200 0 2.240379e-07
I5543 n1_m1_220800_552000 0 4.201955e-07
I5544 n1_m1_220800_556800 0 2.030668e-07
I5545 n1_m1_220800_561600 0 9.633027e-08
I5546 n1_m1_225600_0 0 2.663746e-07
I5547 n1_m1_225600_4800 0 4.166847e-07
I5548 n1_m1_225600_9600 0 7.602962e-07
I5549 n1_m1_225600_14400 0 3.371650e-07
I5550 n1_m1_225600_19200 0 2.351037e-07
I5551 n1_m1_225600_24000 0 2.733290e-07
I5552 n1_m1_225600_28800 0 1.621283e-07
I5553 n1_m1_225600_33600 0 2.338673e-07
I5554 n1_m1_225600_38400 0 1.671923e-07
I5555 n1_m1_225600_43200 0 1.582598e-07
I5556 n1_m1_225600_48000 0 2.333158e-07
I5557 n1_m1_225600_52800 0 1.581112e-07
I5558 n1_m1_225600_57600 0 2.315838e-07
I5559 n1_m1_225600_62400 0 1.596937e-07
I5560 n1_m1_225600_67200 0 1.672458e-07
I5561 n1_m1_225600_72000 0 2.594977e-07
I5562 n1_m1_225600_76800 0 1.712110e-07
I5563 n1_m1_225600_81600 0 2.529249e-07
I5564 n1_m1_225600_86400 0 1.658904e-07
I5565 n1_m1_225600_91200 0 1.661160e-07
I5566 n1_m1_225600_96000 0 2.491660e-07
I5567 n1_m1_225600_100800 0 1.657069e-07
I5568 n1_m1_225600_105600 0 2.523372e-07
I5569 n1_m1_225600_110400 0 1.459386e-07
I5570 n1_m1_225600_115200 0 1.480003e-07
I5571 n1_m1_225600_120000 0 2.277075e-07
I5572 n1_m1_225600_124800 0 1.846896e-07
I5573 n1_m1_225600_129600 0 3.004140e-07
I5574 n1_m1_225600_134400 0 6.517485e-07
I5575 n1_m1_225600_139200 0 1.068487e-06
I5576 n1_m1_225600_144000 0 1.753069e-06
I5577 n1_m1_225600_148800 0 1.141424e-06
I5578 n1_m1_225600_153600 0 8.781129e-07
I5579 n1_m1_225600_158400 0 3.606459e-07
I5580 n1_m1_225600_163200 0 2.097064e-07
I5581 n1_m1_225600_168000 0 2.264916e-07
I5582 n1_m1_225600_172800 0 1.721953e-07
I5583 n1_m1_225600_177600 0 2.334754e-07
I5584 n1_m1_225600_182400 0 1.586801e-07
I5585 n1_m1_225600_187200 0 1.608273e-07
I5586 n1_m1_225600_192000 0 2.309980e-07
I5587 n1_m1_225600_196800 0 2.739526e-07
I5588 n1_m1_225600_201600 0 5.176996e-07
I5589 n1_m1_225600_206400 0 3.782880e-07
I5590 n1_m1_225600_211200 0 3.268443e-07
I5591 n1_m1_225600_216000 0 3.519093e-07
I5592 n1_m1_225600_220800 0 2.856939e-07
I5593 n1_m1_225600_225600 0 5.120918e-07
I5594 n1_m1_225600_230400 0 3.011287e-07
I5595 n1_m1_225600_235200 0 3.136290e-07
I5596 n1_m1_225600_240000 0 7.502483e-07
I5597 n1_m1_225600_244800 0 2.813588e-07
I5598 n1_m1_225600_249600 0 2.818141e-07
I5599 n1_m1_225600_254400 0 1.679790e-07
I5600 n1_m1_225600_259200 0 1.622670e-07
I5601 n1_m1_225600_264000 0 2.241629e-07
I5602 n1_m1_225600_268800 0 1.479491e-07
I5603 n1_m1_225600_273600 0 2.328769e-07
I5604 n1_m1_225600_278400 0 1.487929e-07
I5605 n1_m1_225600_283200 0 1.515134e-07
I5606 n1_m1_225600_288000 0 2.219329e-07
I5607 n1_m1_225600_292800 0 1.565253e-07
I5608 n1_m1_225600_297600 0 2.303745e-07
I5609 n1_m1_225600_302400 0 1.627943e-07
I5610 n1_m1_225600_307200 0 2.117644e-07
I5611 n1_m1_225600_312000 0 1.138934e-06
I5612 n1_m1_225600_316800 0 7.352066e-07
I5613 n1_m1_225600_321600 0 1.481368e-06
I5614 n1_m1_225600_326400 0 9.423050e-07
I5615 n1_m1_225600_331200 0 4.375899e-07
I5616 n1_m1_225600_336000 0 3.507827e-07
I5617 n1_m1_225600_340800 0 1.581475e-07
I5618 n1_m1_225600_345600 0 2.174433e-07
I5619 n1_m1_225600_350400 0 1.424005e-07
I5620 n1_m1_225600_355200 0 1.465661e-07
I5621 n1_m1_225600_360000 0 2.151159e-07
I5622 n1_m1_225600_364800 0 1.509726e-07
I5623 n1_m1_225600_369600 0 2.476951e-07
I5624 n1_m1_225600_374400 0 1.744444e-07
I5625 n1_m1_225600_379200 0 1.806691e-07
I5626 n1_m1_225600_384000 0 2.794440e-07
I5627 n1_m1_225600_388800 0 1.744238e-07
I5628 n1_m1_225600_393600 0 2.469554e-07
I5629 n1_m1_225600_398400 0 1.780022e-07
I5630 n1_m1_225600_403200 0 2.050569e-07
I5631 n1_m1_225600_408000 0 1.264264e-06
I5632 n1_m1_225600_412800 0 1.078615e-06
I5633 n1_m1_225600_417600 0 1.728980e-06
I5634 n1_m1_225600_422400 0 8.498404e-07
I5635 n1_m1_225600_427200 0 3.858535e-07
I5636 n1_m1_225600_432000 0 3.592097e-07
I5637 n1_m1_225600_436800 0 1.499392e-07
I5638 n1_m1_225600_441600 0 2.273560e-07
I5639 n1_m1_225600_446400 0 1.489913e-07
I5640 n1_m1_225600_451200 0 1.465040e-07
I5641 n1_m1_225600_456000 0 2.120637e-07
I5642 n1_m1_225600_460800 0 1.405737e-07
I5643 n1_m1_225600_465600 0 2.110625e-07
I5644 n1_m1_225600_470400 0 1.407516e-07
I5645 n1_m1_225600_475200 0 1.406920e-07
I5646 n1_m1_225600_480000 0 2.116515e-07
I5647 n1_m1_225600_484800 0 1.445342e-07
I5648 n1_m1_225600_489600 0 2.145230e-07
I5649 n1_m1_225600_494400 0 1.465661e-07
I5650 n1_m1_225600_499200 0 1.463122e-07
I5651 n1_m1_225600_504000 0 2.155069e-07
I5652 n1_m1_225600_508800 0 1.415991e-07
I5653 n1_m1_225600_513600 0 2.122232e-07
I5654 n1_m1_225600_518400 0 1.457125e-07
I5655 n1_m1_225600_523200 0 1.465970e-07
I5656 n1_m1_225600_528000 0 2.194108e-07
I5657 n1_m1_225600_532800 0 1.416859e-07
I5658 n1_m1_225600_537600 0 2.234095e-07
I5659 n1_m1_225600_542400 0 1.797701e-07
I5660 n1_m1_225600_547200 0 2.506104e-07
I5661 n1_m1_225600_552000 0 4.253714e-07
I5662 n1_m1_225600_556800 0 1.889292e-07
I5663 n1_m1_225600_561600 0 9.071671e-08
I5664 n1_m1_230400_0 0 2.440725e-07
I5665 n1_m1_230400_4800 0 4.574872e-07
I5666 n1_m1_230400_9600 0 1.406611e-06
I5667 n1_m1_230400_14400 0 1.034108e-06
I5668 n1_m1_230400_19200 0 7.032513e-07
I5669 n1_m1_230400_24000 0 3.937687e-07
I5670 n1_m1_230400_28800 0 1.734157e-07
I5671 n1_m1_230400_33600 0 2.679700e-07
I5672 n1_m1_230400_38400 0 1.656701e-07
I5673 n1_m1_230400_43200 0 1.630791e-07
I5674 n1_m1_230400_48000 0 2.336238e-07
I5675 n1_m1_230400_52800 0 1.532282e-07
I5676 n1_m1_230400_57600 0 2.329072e-07
I5677 n1_m1_230400_62400 0 1.768587e-07
I5678 n1_m1_230400_67200 0 2.196540e-07
I5679 n1_m1_230400_72000 0 3.022615e-07
I5680 n1_m1_230400_76800 0 1.718156e-07
I5681 n1_m1_230400_81600 0 2.475881e-07
I5682 n1_m1_230400_86400 0 1.747592e-07
I5683 n1_m1_230400_91200 0 1.839267e-07
I5684 n1_m1_230400_96000 0 2.772286e-07
I5685 n1_m1_230400_100800 0 1.756128e-07
I5686 n1_m1_230400_105600 0 2.837894e-07
I5687 n1_m1_230400_110400 0 1.559439e-07
I5688 n1_m1_230400_115200 0 1.578063e-07
I5689 n1_m1_230400_120000 0 2.402163e-07
I5690 n1_m1_230400_124800 0 1.833532e-07
I5691 n1_m1_230400_129600 0 2.683033e-07
I5692 n1_m1_230400_134400 0 5.443350e-07
I5693 n1_m1_230400_139200 0 8.999840e-07
I5694 n1_m1_230400_144000 0 1.633018e-06
I5695 n1_m1_230400_148800 0 1.285999e-06
I5696 n1_m1_230400_153600 0 1.337704e-06
I5697 n1_m1_230400_158400 0 4.376158e-07
I5698 n1_m1_230400_163200 0 2.168781e-07
I5699 n1_m1_230400_168000 0 3.160405e-07
I5700 n1_m1_230400_172800 0 1.635453e-07
I5701 n1_m1_230400_177600 0 2.376117e-07
I5702 n1_m1_230400_182400 0 1.662204e-07
I5703 n1_m1_230400_187200 0 1.756861e-07
I5704 n1_m1_230400_192000 0 2.508182e-07
I5705 n1_m1_230400_196800 0 2.257230e-07
I5706 n1_m1_230400_201600 0 3.542885e-07
I5707 n1_m1_230400_206400 0 2.618545e-07
I5708 n1_m1_230400_211200 0 3.232070e-07
I5709 n1_m1_230400_216000 0 5.153832e-07
I5710 n1_m1_230400_220800 0 3.863939e-07
I5711 n1_m1_230400_225600 0 5.960706e-07
I5712 n1_m1_230400_230400 0 3.371846e-07
I5713 n1_m1_230400_235200 0 2.587752e-07
I5714 n1_m1_230400_240000 0 5.590304e-07
I5715 n1_m1_230400_244800 0 3.204355e-07
I5716 n1_m1_230400_249600 0 3.806514e-07
I5717 n1_m1_230400_254400 0 1.870527e-07
I5718 n1_m1_230400_259200 0 1.763804e-07
I5719 n1_m1_230400_264000 0 2.297593e-07
I5720 n1_m1_230400_268800 0 1.480479e-07
I5721 n1_m1_230400_273600 0 2.328769e-07
I5722 n1_m1_230400_278400 0 1.495771e-07
I5723 n1_m1_230400_283200 0 1.537379e-07
I5724 n1_m1_230400_288000 0 2.171195e-07
I5725 n1_m1_230400_292800 0 1.520074e-07
I5726 n1_m1_230400_297600 0 2.299011e-07
I5727 n1_m1_230400_302400 0 1.548038e-07
I5728 n1_m1_230400_307200 0 1.640155e-07
I5729 n1_m1_230400_312000 0 4.356786e-07
I5730 n1_m1_230400_316800 0 2.969320e-07
I5731 n1_m1_230400_321600 0 8.180488e-07
I5732 n1_m1_230400_326400 0 5.914788e-07
I5733 n1_m1_230400_331200 0 2.486287e-07
I5734 n1_m1_230400_336000 0 2.598940e-07
I5735 n1_m1_230400_340800 0 1.460313e-07
I5736 n1_m1_230400_345600 0 2.160303e-07
I5737 n1_m1_230400_350400 0 1.443730e-07
I5738 n1_m1_230400_355200 0 1.465661e-07
I5739 n1_m1_230400_360000 0 2.158698e-07
I5740 n1_m1_230400_364800 0 1.459479e-07
I5741 n1_m1_230400_369600 0 2.269479e-07
I5742 n1_m1_230400_374400 0 1.581259e-07
I5743 n1_m1_230400_379200 0 1.625475e-07
I5744 n1_m1_230400_384000 0 2.429634e-07
I5745 n1_m1_230400_388800 0 1.677769e-07
I5746 n1_m1_230400_393600 0 2.876807e-07
I5747 n1_m1_230400_398400 0 1.633535e-07
I5748 n1_m1_230400_403200 0 1.723661e-07
I5749 n1_m1_230400_408000 0 9.985458e-07
I5750 n1_m1_230400_412800 0 8.409101e-07
I5751 n1_m1_230400_417600 0 1.682782e-06
I5752 n1_m1_230400_422400 0 5.788232e-07
I5753 n1_m1_230400_427200 0 2.216994e-07
I5754 n1_m1_230400_432000 0 2.457816e-07
I5755 n1_m1_230400_436800 0 1.433754e-07
I5756 n1_m1_230400_441600 0 2.323896e-07
I5757 n1_m1_230400_446400 0 1.577565e-07
I5758 n1_m1_230400_451200 0 1.507944e-07
I5759 n1_m1_230400_456000 0 2.170241e-07
I5760 n1_m1_230400_460800 0 1.465661e-07
I5761 n1_m1_230400_465600 0 2.144959e-07
I5762 n1_m1_230400_470400 0 1.401598e-07
I5763 n1_m1_230400_475200 0 1.400631e-07
I5764 n1_m1_230400_480000 0 2.140235e-07
I5765 n1_m1_230400_484800 0 1.464839e-07
I5766 n1_m1_230400_489600 0 2.198491e-07
I5767 n1_m1_230400_494400 0 1.465661e-07
I5768 n1_m1_230400_499200 0 1.440411e-07
I5769 n1_m1_230400_504000 0 2.098560e-07
I5770 n1_m1_230400_508800 0 1.399040e-07
I5771 n1_m1_230400_513600 0 2.106917e-07
I5772 n1_m1_230400_518400 0 1.454048e-07
I5773 n1_m1_230400_523200 0 1.449828e-07
I5774 n1_m1_230400_528000 0 2.234931e-07
I5775 n1_m1_230400_532800 0 1.442616e-07
I5776 n1_m1_230400_537600 0 2.197960e-07
I5777 n1_m1_230400_542400 0 1.677915e-07
I5778 n1_m1_230400_547200 0 2.132549e-07
I5779 n1_m1_230400_552000 0 3.503457e-07
I5780 n1_m1_230400_556800 0 1.721771e-07
I5781 n1_m1_230400_561600 0 8.439641e-08
I5782 n1_m1_235200_0 0 2.438099e-07
I5783 n1_m1_235200_4800 0 3.788532e-07
I5784 n1_m1_235200_9600 0 1.082961e-06
I5785 n1_m1_235200_14400 0 8.342369e-07
I5786 n1_m1_235200_19200 0 5.686939e-07
I5787 n1_m1_235200_24000 0 3.571238e-07
I5788 n1_m1_235200_28800 0 1.903676e-07
I5789 n1_m1_235200_33600 0 3.004156e-07
I5790 n1_m1_235200_38400 0 1.635875e-07
I5791 n1_m1_235200_43200 0 1.614076e-07
I5792 n1_m1_235200_48000 0 2.326750e-07
I5793 n1_m1_235200_52800 0 1.532282e-07
I5794 n1_m1_235200_57600 0 2.334433e-07
I5795 n1_m1_235200_62400 0 1.856009e-07
I5796 n1_m1_235200_67200 0 2.502891e-07
I5797 n1_m1_235200_72000 0 2.743281e-07
I5798 n1_m1_235200_76800 0 1.601200e-07
I5799 n1_m1_235200_81600 0 2.328998e-07
I5800 n1_m1_235200_86400 0 1.698298e-07
I5801 n1_m1_235200_91200 0 1.827340e-07
I5802 n1_m1_235200_96000 0 2.776839e-07
I5803 n1_m1_235200_100800 0 1.746739e-07
I5804 n1_m1_235200_105600 0 2.445324e-07
I5805 n1_m1_235200_110400 0 1.561069e-07
I5806 n1_m1_235200_115200 0 1.675585e-07
I5807 n1_m1_235200_120000 0 2.610910e-07
I5808 n1_m1_235200_124800 0 1.914995e-07
I5809 n1_m1_235200_129600 0 3.275721e-07
I5810 n1_m1_235200_134400 0 6.571631e-07
I5811 n1_m1_235200_139200 0 1.160219e-06
I5812 n1_m1_235200_144000 0 1.940157e-06
I5813 n1_m1_235200_148800 0 1.336052e-06
I5814 n1_m1_235200_153600 0 1.331650e-06
I5815 n1_m1_235200_158400 0 5.294629e-07
I5816 n1_m1_235200_163200 0 2.841188e-07
I5817 n1_m1_235200_168000 0 5.208105e-07
I5818 n1_m1_235200_172800 0 1.907926e-07
I5819 n1_m1_235200_177600 0 2.392701e-07
I5820 n1_m1_235200_182400 0 1.584150e-07
I5821 n1_m1_235200_187200 0 1.716249e-07
I5822 n1_m1_235200_192000 0 2.557590e-07
I5823 n1_m1_235200_196800 0 1.821531e-07
I5824 n1_m1_235200_201600 0 3.019314e-07
I5825 n1_m1_235200_206400 0 3.071795e-07
I5826 n1_m1_235200_211200 0 3.476106e-07
I5827 n1_m1_235200_216000 0 6.573470e-07
I5828 n1_m1_235200_220800 0 3.811700e-07
I5829 n1_m1_235200_225600 0 6.421290e-07
I5830 n1_m1_235200_230400 0 4.113442e-07
I5831 n1_m1_235200_235200 0 2.870729e-07
I5832 n1_m1_235200_240000 0 4.572834e-07
I5833 n1_m1_235200_244800 0 3.309012e-07
I5834 n1_m1_235200_249600 0 4.024140e-07
I5835 n1_m1_235200_254400 0 1.957813e-07
I5836 n1_m1_235200_259200 0 1.783960e-07
I5837 n1_m1_235200_264000 0 2.297593e-07
I5838 n1_m1_235200_268800 0 1.480479e-07
I5839 n1_m1_235200_273600 0 2.328769e-07
I5840 n1_m1_235200_278400 0 1.483798e-07
I5841 n1_m1_235200_283200 0 1.506852e-07
I5842 n1_m1_235200_288000 0 2.158846e-07
I5843 n1_m1_235200_292800 0 1.496363e-07
I5844 n1_m1_235200_297600 0 2.297046e-07
I5845 n1_m1_235200_302400 0 1.495429e-07
I5846 n1_m1_235200_307200 0 1.579767e-07
I5847 n1_m1_235200_312000 0 2.720841e-07
I5848 n1_m1_235200_316800 0 2.750211e-07
I5849 n1_m1_235200_321600 0 7.438246e-07
I5850 n1_m1_235200_326400 0 5.458415e-07
I5851 n1_m1_235200_331200 0 2.536717e-07
I5852 n1_m1_235200_336000 0 2.755770e-07
I5853 n1_m1_235200_340800 0 1.422327e-07
I5854 n1_m1_235200_345600 0 2.148703e-07
I5855 n1_m1_235200_350400 0 1.454735e-07
I5856 n1_m1_235200_355200 0 1.455935e-07
I5857 n1_m1_235200_360000 0 2.190015e-07
I5858 n1_m1_235200_364800 0 1.465661e-07
I5859 n1_m1_235200_369600 0 2.213605e-07
I5860 n1_m1_235200_374400 0 1.529259e-07
I5861 n1_m1_235200_379200 0 1.541469e-07
I5862 n1_m1_235200_384000 0 2.334163e-07
I5863 n1_m1_235200_388800 0 1.812367e-07
I5864 n1_m1_235200_393600 0 3.181310e-07
I5865 n1_m1_235200_398400 0 1.538239e-07
I5866 n1_m1_235200_403200 0 1.593979e-07
I5867 n1_m1_235200_408000 0 9.691413e-07
I5868 n1_m1_235200_412800 0 7.810828e-07
I5869 n1_m1_235200_417600 0 1.458704e-06
I5870 n1_m1_235200_422400 0 4.847286e-07
I5871 n1_m1_235200_427200 0 2.038881e-07
I5872 n1_m1_235200_432000 0 2.514966e-07
I5873 n1_m1_235200_436800 0 1.454857e-07
I5874 n1_m1_235200_441600 0 2.406279e-07
I5875 n1_m1_235200_446400 0 1.598665e-07
I5876 n1_m1_235200_451200 0 1.524333e-07
I5877 n1_m1_235200_456000 0 2.177018e-07
I5878 n1_m1_235200_460800 0 1.465661e-07
I5879 n1_m1_235200_465600 0 2.190543e-07
I5880 n1_m1_235200_470400 0 1.421393e-07
I5881 n1_m1_235200_475200 0 1.419262e-07
I5882 n1_m1_235200_480000 0 2.188412e-07
I5883 n1_m1_235200_484800 0 1.465661e-07
I5884 n1_m1_235200_489600 0 2.198491e-07
I5885 n1_m1_235200_494400 0 1.465661e-07
I5886 n1_m1_235200_499200 0 1.440411e-07
I5887 n1_m1_235200_504000 0 2.098560e-07
I5888 n1_m1_235200_508800 0 1.399040e-07
I5889 n1_m1_235200_513600 0 2.106917e-07
I5890 n1_m1_235200_518400 0 1.450487e-07
I5891 n1_m1_235200_523200 0 1.417854e-07
I5892 n1_m1_235200_528000 0 2.271064e-07
I5893 n1_m1_235200_532800 0 1.396100e-07
I5894 n1_m1_235200_537600 0 2.078466e-07
I5895 n1_m1_235200_542400 0 1.589064e-07
I5896 n1_m1_235200_547200 0 1.951325e-07
I5897 n1_m1_235200_552000 0 3.291719e-07
I5898 n1_m1_235200_556800 0 1.791869e-07
I5899 n1_m1_235200_561600 0 8.774253e-08
I5900 n1_m1_240000_0 0 4.338232e-07
I5901 n1_m1_240000_4800 0 6.499234e-07
I5902 n1_m1_240000_9600 0 1.454814e-06
I5903 n1_m1_240000_14400 0 8.700101e-07
I5904 n1_m1_240000_19200 0 4.901963e-07
I5905 n1_m1_240000_24000 0 3.977984e-07
I5906 n1_m1_240000_28800 0 2.473269e-07
I5907 n1_m1_240000_33600 0 3.964439e-07
I5908 n1_m1_240000_38400 0 2.371540e-07
I5909 n1_m1_240000_43200 0 2.266179e-07
I5910 n1_m1_240000_48000 0 3.327854e-07
I5911 n1_m1_240000_52800 0 2.248468e-07
I5912 n1_m1_240000_57600 0 3.409485e-07
I5913 n1_m1_240000_62400 0 2.415060e-07
I5914 n1_m1_240000_67200 0 2.610009e-07
I5915 n1_m1_240000_72000 0 3.536816e-07
I5916 n1_m1_240000_76800 0 2.286639e-07
I5917 n1_m1_240000_81600 0 3.437197e-07
I5918 n1_m1_240000_86400 0 2.422229e-07
I5919 n1_m1_240000_91200 0 2.460333e-07
I5920 n1_m1_240000_96000 0 3.657026e-07
I5921 n1_m1_240000_100800 0 2.393463e-07
I5922 n1_m1_240000_105600 0 3.471604e-07
I5923 n1_m1_240000_110400 0 2.331584e-07
I5924 n1_m1_240000_115200 0 2.362371e-07
I5925 n1_m1_240000_120000 0 4.112732e-07
I5926 n1_m1_240000_124800 0 3.476267e-07
I5927 n1_m1_240000_129600 0 8.158292e-07
I5928 n1_m1_240000_134400 0 1.126524e-06
I5929 n1_m1_240000_139200 0 1.893514e-06
I5930 n1_m1_240000_144000 0 2.962674e-06
I5931 n1_m1_240000_148800 0 1.864366e-06
I5932 n1_m1_240000_153600 0 1.675941e-06
I5933 n1_m1_240000_158400 0 1.030668e-06
I5934 n1_m1_240000_163200 0 4.707094e-07
I5935 n1_m1_240000_168000 0 6.536503e-07
I5936 n1_m1_240000_172800 0 3.246841e-07
I5937 n1_m1_240000_177600 0 4.287719e-07
I5938 n1_m1_240000_182400 0 2.501550e-07
I5939 n1_m1_240000_187200 0 2.719091e-07
I5940 n1_m1_240000_192000 0 4.260478e-07
I5941 n1_m1_240000_196800 0 3.333267e-07
I5942 n1_m1_240000_201600 0 7.255623e-07
I5943 n1_m1_240000_206400 0 9.578098e-07
I5944 n1_m1_240000_211200 0 1.149797e-06
I5945 n1_m1_240000_216000 0 1.880880e-06
I5946 n1_m1_240000_220800 0 8.036186e-07
I5947 n1_m1_240000_225600 0 1.350458e-06
I5948 n1_m1_240000_230400 0 9.775274e-07
I5949 n1_m1_240000_235200 0 7.299998e-07
I5950 n1_m1_240000_240000 0 7.684561e-07
I5951 n1_m1_240000_244800 0 5.009826e-07
I5952 n1_m1_240000_249600 0 5.169181e-07
I5953 n1_m1_240000_254400 0 2.778876e-07
I5954 n1_m1_240000_259200 0 2.643744e-07
I5955 n1_m1_240000_264000 0 3.486389e-07
I5956 n1_m1_240000_268800 0 2.225512e-07
I5957 n1_m1_240000_273600 0 3.493154e-07
I5958 n1_m1_240000_278400 0 2.214498e-07
I5959 n1_m1_240000_283200 0 2.243446e-07
I5960 n1_m1_240000_288000 0 3.299722e-07
I5961 n1_m1_240000_292800 0 2.244545e-07
I5962 n1_m1_240000_297600 0 3.448708e-07
I5963 n1_m1_240000_302400 0 2.327178e-07
I5964 n1_m1_240000_307200 0 3.011521e-07
I5965 n1_m1_240000_312000 0 4.905642e-07
I5966 n1_m1_240000_316800 0 3.663773e-07
I5967 n1_m1_240000_321600 0 7.896181e-07
I5968 n1_m1_240000_326400 0 6.129009e-07
I5969 n1_m1_240000_331200 0 3.450770e-07
I5970 n1_m1_240000_336000 0 4.992298e-07
I5971 n1_m1_240000_340800 0 2.218557e-07
I5972 n1_m1_240000_345600 0 3.379353e-07
I5973 n1_m1_240000_350400 0 2.188809e-07
I5974 n1_m1_240000_355200 0 2.124422e-07
I5975 n1_m1_240000_360000 0 3.251795e-07
I5976 n1_m1_240000_364800 0 2.232050e-07
I5977 n1_m1_240000_369600 0 3.372777e-07
I5978 n1_m1_240000_374400 0 2.303257e-07
I5979 n1_m1_240000_379200 0 2.349641e-07
I5980 n1_m1_240000_384000 0 3.648215e-07
I5981 n1_m1_240000_388800 0 2.384965e-07
I5982 n1_m1_240000_393600 0 3.313843e-07
I5983 n1_m1_240000_398400 0 2.923881e-07
I5984 n1_m1_240000_403200 0 2.845883e-07
I5985 n1_m1_240000_408000 0 1.173394e-06
I5986 n1_m1_240000_412800 0 9.496546e-07
I5987 n1_m1_240000_417600 0 1.340185e-06
I5988 n1_m1_240000_422400 0 4.867640e-07
I5989 n1_m1_240000_427200 0 2.624153e-07
I5990 n1_m1_240000_432000 0 3.724312e-07
I5991 n1_m1_240000_436800 0 2.167174e-07
I5992 n1_m1_240000_441600 0 3.305137e-07
I5993 n1_m1_240000_446400 0 2.170497e-07
I5994 n1_m1_240000_451200 0 2.161382e-07
I5995 n1_m1_240000_456000 0 3.216161e-07
I5996 n1_m1_240000_460800 0 2.157357e-07
I5997 n1_m1_240000_465600 0 3.242237e-07
I5998 n1_m1_240000_470400 0 2.191898e-07
I5999 n1_m1_240000_475200 0 2.196452e-07
I6000 n1_m1_240000_480000 0 3.297294e-07
I6001 n1_m1_240000_484800 0 2.189891e-07
I6002 n1_m1_240000_489600 0 3.238633e-07
I6003 n1_m1_240000_494400 0 2.176606e-07
I6004 n1_m1_240000_499200 0 2.160617e-07
I6005 n1_m1_240000_504000 0 3.179788e-07
I6006 n1_m1_240000_508800 0 2.139694e-07
I6007 n1_m1_240000_513600 0 3.178161e-07
I6008 n1_m1_240000_518400 0 2.175731e-07
I6009 n1_m1_240000_523200 0 2.118479e-07
I6010 n1_m1_240000_528000 0 3.170693e-07
I6011 n1_m1_240000_532800 0 2.103831e-07
I6012 n1_m1_240000_537600 0 3.326394e-07
I6013 n1_m1_240000_542400 0 2.909032e-07
I6014 n1_m1_240000_547200 0 4.169028e-07
I6015 n1_m1_240000_552000 0 6.887800e-07
I6016 n1_m1_240000_556800 0 3.049018e-07
I6017 n1_m1_240000_561600 0 1.448029e-07
I6018 n1_m1_244800_0 0 2.626613e-07
I6019 n1_m1_244800_4800 0 4.081359e-07
I6020 n1_m1_244800_9600 0 5.855156e-07
I6021 n1_m1_244800_14400 0 2.464829e-07
I6022 n1_m1_244800_19200 0 1.782485e-07
I6023 n1_m1_244800_24000 0 2.442558e-07
I6024 n1_m1_244800_28800 0 1.546646e-07
I6025 n1_m1_244800_33600 0 2.218027e-07
I6026 n1_m1_244800_38400 0 1.511631e-07
I6027 n1_m1_244800_43200 0 1.484490e-07
I6028 n1_m1_244800_48000 0 2.173171e-07
I6029 n1_m1_244800_52800 0 1.458455e-07
I6030 n1_m1_244800_57600 0 2.162814e-07
I6031 n1_m1_244800_62400 0 1.473134e-07
I6032 n1_m1_244800_67200 0 1.517108e-07
I6033 n1_m1_244800_72000 0 2.220580e-07
I6034 n1_m1_244800_76800 0 1.487740e-07
I6035 n1_m1_244800_81600 0 2.238188e-07
I6036 n1_m1_244800_86400 0 1.551389e-07
I6037 n1_m1_244800_91200 0 1.553235e-07
I6038 n1_m1_244800_96000 0 2.273666e-07
I6039 n1_m1_244800_100800 0 1.500868e-07
I6040 n1_m1_244800_105600 0 2.311609e-07
I6041 n1_m1_244800_110400 0 1.497718e-07
I6042 n1_m1_244800_115200 0 1.499429e-07
I6043 n1_m1_244800_120000 0 2.660432e-07
I6044 n1_m1_244800_124800 0 2.034609e-07
I6045 n1_m1_244800_129600 0 4.635630e-07
I6046 n1_m1_244800_134400 0 6.170390e-07
I6047 n1_m1_244800_139200 0 1.077267e-06
I6048 n1_m1_244800_144000 0 1.926640e-06
I6049 n1_m1_244800_148800 0 1.201942e-06
I6050 n1_m1_244800_153600 0 1.148423e-06
I6051 n1_m1_244800_158400 0 8.406196e-07
I6052 n1_m1_244800_163200 0 3.339203e-07
I6053 n1_m1_244800_168000 0 3.550558e-07
I6054 n1_m1_244800_172800 0 3.021809e-07
I6055 n1_m1_244800_177600 0 3.080407e-07
I6056 n1_m1_244800_182400 0 2.279079e-07
I6057 n1_m1_244800_187200 0 3.258834e-07
I6058 n1_m1_244800_192000 0 4.207521e-07
I6059 n1_m1_244800_196800 0 6.217912e-07
I6060 n1_m1_244800_201600 0 1.230883e-06
I6061 n1_m1_244800_206400 0 1.068930e-06
I6062 n1_m1_244800_211200 0 1.205594e-06
I6063 n1_m1_244800_216000 0 1.609918e-06
I6064 n1_m1_244800_220800 0 7.218781e-07
I6065 n1_m1_244800_225600 0 1.503147e-06
I6066 n1_m1_244800_230400 0 8.347996e-07
I6067 n1_m1_244800_235200 0 4.211821e-07
I6068 n1_m1_244800_240000 0 5.698295e-07
I6069 n1_m1_244800_244800 0 3.260140e-07
I6070 n1_m1_244800_249600 0 5.859501e-07
I6071 n1_m1_244800_254400 0 3.413957e-07
I6072 n1_m1_244800_259200 0 2.139462e-07
I6073 n1_m1_244800_264000 0 2.539038e-07
I6074 n1_m1_244800_268800 0 1.524202e-07
I6075 n1_m1_244800_273600 0 2.256601e-07
I6076 n1_m1_244800_278400 0 1.545660e-07
I6077 n1_m1_244800_283200 0 1.563263e-07
I6078 n1_m1_244800_288000 0 2.248389e-07
I6079 n1_m1_244800_292800 0 1.509832e-07
I6080 n1_m1_244800_297600 0 2.316704e-07
I6081 n1_m1_244800_302400 0 1.624264e-07
I6082 n1_m1_244800_307200 0 2.166361e-07
I6083 n1_m1_244800_312000 0 5.446405e-07
I6084 n1_m1_244800_316800 0 4.507293e-07
I6085 n1_m1_244800_321600 0 7.702121e-07
I6086 n1_m1_244800_326400 0 5.654322e-07
I6087 n1_m1_244800_331200 0 4.497278e-07
I6088 n1_m1_244800_336000 0 3.491011e-07
I6089 n1_m1_244800_340800 0 1.493350e-07
I6090 n1_m1_244800_345600 0 2.219822e-07
I6091 n1_m1_244800_350400 0 1.527469e-07
I6092 n1_m1_244800_355200 0 1.472649e-07
I6093 n1_m1_244800_360000 0 2.135618e-07
I6094 n1_m1_244800_364800 0 1.484805e-07
I6095 n1_m1_244800_369600 0 2.261587e-07
I6096 n1_m1_244800_374400 0 1.576444e-07
I6097 n1_m1_244800_379200 0 1.613035e-07
I6098 n1_m1_244800_384000 0 2.413796e-07
I6099 n1_m1_244800_388800 0 1.700440e-07
I6100 n1_m1_244800_393600 0 2.205297e-07
I6101 n1_m1_244800_398400 0 1.998920e-07
I6102 n1_m1_244800_403200 0 2.228334e-07
I6103 n1_m1_244800_408000 0 5.846073e-07
I6104 n1_m1_244800_412800 0 6.201370e-07
I6105 n1_m1_244800_417600 0 7.459587e-07
I6106 n1_m1_244800_422400 0 2.581281e-07
I6107 n1_m1_244800_427200 0 1.736305e-07
I6108 n1_m1_244800_432000 0 2.564427e-07
I6109 n1_m1_244800_436800 0 1.578260e-07
I6110 n1_m1_244800_441600 0 2.229204e-07
I6111 n1_m1_244800_446400 0 1.482486e-07
I6112 n1_m1_244800_451200 0 1.497074e-07
I6113 n1_m1_244800_456000 0 2.280873e-07
I6114 n1_m1_244800_460800 0 1.488874e-07
I6115 n1_m1_244800_465600 0 2.163609e-07
I6116 n1_m1_244800_470400 0 1.443004e-07
I6117 n1_m1_244800_475200 0 1.519442e-07
I6118 n1_m1_244800_480000 0 2.274606e-07
I6119 n1_m1_244800_484800 0 1.433220e-07
I6120 n1_m1_244800_489600 0 2.131522e-07
I6121 n1_m1_244800_494400 0 1.413741e-07
I6122 n1_m1_244800_499200 0 1.418548e-07
I6123 n1_m1_244800_504000 0 2.122958e-07
I6124 n1_m1_244800_508800 0 1.430454e-07
I6125 n1_m1_244800_513600 0 2.153671e-07
I6126 n1_m1_244800_518400 0 1.458506e-07
I6127 n1_m1_244800_523200 0 1.437826e-07
I6128 n1_m1_244800_528000 0 2.082319e-07
I6129 n1_m1_244800_532800 0 1.466444e-07
I6130 n1_m1_244800_537600 0 3.051734e-07
I6131 n1_m1_244800_542400 0 3.731446e-07
I6132 n1_m1_244800_547200 0 5.065552e-07
I6133 n1_m1_244800_552000 0 6.346094e-07
I6134 n1_m1_244800_556800 0 2.276282e-07
I6135 n1_m1_244800_561600 0 1.052218e-07
I6136 n1_m1_249600_0 0 3.823866e-07
I6137 n1_m1_249600_4800 0 6.590655e-07
I6138 n1_m1_249600_9600 0 1.495681e-06
I6139 n1_m1_249600_14400 0 3.648114e-07
I6140 n1_m1_249600_19200 0 2.732903e-07
I6141 n1_m1_249600_24000 0 5.161077e-07
I6142 n1_m1_249600_28800 0 2.288511e-07
I6143 n1_m1_249600_33600 0 3.436509e-07
I6144 n1_m1_249600_38400 0 2.225371e-07
I6145 n1_m1_249600_43200 0 2.237790e-07
I6146 n1_m1_249600_48000 0 3.267770e-07
I6147 n1_m1_249600_52800 0 2.184669e-07
I6148 n1_m1_249600_57600 0 3.225229e-07
I6149 n1_m1_249600_62400 0 2.313261e-07
I6150 n1_m1_249600_67200 0 2.342631e-07
I6151 n1_m1_249600_72000 0 3.307010e-07
I6152 n1_m1_249600_76800 0 2.109406e-07
I6153 n1_m1_249600_81600 0 3.182780e-07
I6154 n1_m1_249600_86400 0 2.290065e-07
I6155 n1_m1_249600_91200 0 2.333908e-07
I6156 n1_m1_249600_96000 0 3.409688e-07
I6157 n1_m1_249600_100800 0 2.188960e-07
I6158 n1_m1_249600_105600 0 3.369161e-07
I6159 n1_m1_249600_110400 0 2.175484e-07
I6160 n1_m1_249600_115200 0 2.169967e-07
I6161 n1_m1_249600_120000 0 3.628245e-07
I6162 n1_m1_249600_124800 0 2.593683e-07
I6163 n1_m1_249600_129600 0 5.423363e-07
I6164 n1_m1_249600_134400 0 6.404376e-07
I6165 n1_m1_249600_139200 0 1.166574e-06
I6166 n1_m1_249600_144000 0 2.631943e-06
I6167 n1_m1_249600_148800 0 1.660296e-06
I6168 n1_m1_249600_153600 0 1.483322e-06
I6169 n1_m1_249600_158400 0 9.990735e-07
I6170 n1_m1_249600_163200 0 4.383724e-07
I6171 n1_m1_249600_168000 0 6.107477e-07
I6172 n1_m1_249600_172800 0 4.245760e-07
I6173 n1_m1_249600_177600 0 6.997283e-07
I6174 n1_m1_249600_182400 0 6.528201e-07
I6175 n1_m1_249600_187200 0 4.913440e-07
I6176 n1_m1_249600_192000 0 9.274909e-07
I6177 n1_m1_249600_196800 0 1.365607e-06
I6178 n1_m1_249600_201600 0 2.365951e-06
I6179 n1_m1_249600_206400 0 1.286682e-06
I6180 n1_m1_249600_211200 0 1.285094e-06
I6181 n1_m1_249600_216000 0 2.086188e-06
I6182 n1_m1_249600_220800 0 1.242797e-06
I6183 n1_m1_249600_225600 0 1.893201e-06
I6184 n1_m1_249600_230400 0 9.163274e-07
I6185 n1_m1_249600_235200 0 6.960671e-07
I6186 n1_m1_249600_240000 0 1.142043e-06
I6187 n1_m1_249600_244800 0 4.249827e-07
I6188 n1_m1_249600_249600 0 9.410247e-07
I6189 n1_m1_249600_254400 0 5.848116e-07
I6190 n1_m1_249600_259200 0 3.455140e-07
I6191 n1_m1_249600_264000 0 4.097528e-07
I6192 n1_m1_249600_268800 0 2.442128e-07
I6193 n1_m1_249600_273600 0 3.420587e-07
I6194 n1_m1_249600_278400 0 2.479969e-07
I6195 n1_m1_249600_283200 0 2.392613e-07
I6196 n1_m1_249600_288000 0 3.475720e-07
I6197 n1_m1_249600_292800 0 2.322495e-07
I6198 n1_m1_249600_297600 0 3.591301e-07
I6199 n1_m1_249600_302400 0 3.297895e-07
I6200 n1_m1_249600_307200 0 4.087583e-07
I6201 n1_m1_249600_312000 0 1.052414e-06
I6202 n1_m1_249600_316800 0 8.397573e-07
I6203 n1_m1_249600_321600 0 1.373912e-06
I6204 n1_m1_249600_326400 0 9.386200e-07
I6205 n1_m1_249600_331200 0 8.823005e-07
I6206 n1_m1_249600_336000 0 5.948066e-07
I6207 n1_m1_249600_340800 0 2.422201e-07
I6208 n1_m1_249600_345600 0 3.461566e-07
I6209 n1_m1_249600_350400 0 2.252588e-07
I6210 n1_m1_249600_355200 0 2.182430e-07
I6211 n1_m1_249600_360000 0 3.403595e-07
I6212 n1_m1_249600_364800 0 2.421510e-07
I6213 n1_m1_249600_369600 0 3.452594e-07
I6214 n1_m1_249600_374400 0 2.353759e-07
I6215 n1_m1_249600_379200 0 2.397854e-07
I6216 n1_m1_249600_384000 0 3.421808e-07
I6217 n1_m1_249600_388800 0 2.314680e-07
I6218 n1_m1_249600_393600 0 3.534938e-07
I6219 n1_m1_249600_398400 0 2.492447e-07
I6220 n1_m1_249600_403200 0 2.643812e-07
I6221 n1_m1_249600_408000 0 7.489110e-07
I6222 n1_m1_249600_412800 0 9.225404e-07
I6223 n1_m1_249600_417600 0 8.543912e-07
I6224 n1_m1_249600_422400 0 3.287452e-07
I6225 n1_m1_249600_427200 0 2.560791e-07
I6226 n1_m1_249600_432000 0 3.548278e-07
I6227 n1_m1_249600_436800 0 2.296204e-07
I6228 n1_m1_249600_441600 0 3.210194e-07
I6229 n1_m1_249600_446400 0 2.202946e-07
I6230 n1_m1_249600_451200 0 2.257428e-07
I6231 n1_m1_249600_456000 0 3.376284e-07
I6232 n1_m1_249600_460800 0 2.290418e-07
I6233 n1_m1_249600_465600 0 3.444734e-07
I6234 n1_m1_249600_470400 0 2.150352e-07
I6235 n1_m1_249600_475200 0 2.247826e-07
I6236 n1_m1_249600_480000 0 3.395533e-07
I6237 n1_m1_249600_484800 0 2.187333e-07
I6238 n1_m1_249600_489600 0 3.329423e-07
I6239 n1_m1_249600_494400 0 2.231920e-07
I6240 n1_m1_249600_499200 0 2.230370e-07
I6241 n1_m1_249600_504000 0 3.293132e-07
I6242 n1_m1_249600_508800 0 2.162555e-07
I6243 n1_m1_249600_513600 0 3.281591e-07
I6244 n1_m1_249600_518400 0 2.198491e-07
I6245 n1_m1_249600_523200 0 2.199412e-07
I6246 n1_m1_249600_528000 0 3.310153e-07
I6247 n1_m1_249600_532800 0 2.176943e-07
I6248 n1_m1_249600_537600 0 4.366098e-07
I6249 n1_m1_249600_542400 0 5.865531e-07
I6250 n1_m1_249600_547200 0 8.539451e-07
I6251 n1_m1_249600_552000 0 1.030871e-06
I6252 n1_m1_249600_556800 0 3.473652e-07
I6253 n1_m1_249600_561600 0 1.594639e-07
I6254 n1_m1_254400_0 0 1.281154e-07
I6255 n1_m1_254400_4800 0 2.098406e-07
I6256 n1_m1_254400_9600 0 4.497909e-07
I6257 n1_m1_254400_14400 0 1.130564e-07
I6258 n1_m1_254400_19200 0 8.685724e-08
I6259 n1_m1_254400_24000 0 1.553814e-07
I6260 n1_m1_254400_28800 0 7.182163e-08
I6261 n1_m1_254400_33600 0 1.131006e-07
I6262 n1_m1_254400_38400 0 7.520935e-08
I6263 n1_m1_254400_43200 0 7.420506e-08
I6264 n1_m1_254400_48000 0 1.086960e-07
I6265 n1_m1_254400_52800 0 7.296310e-08
I6266 n1_m1_254400_57600 0 1.098110e-07
I6267 n1_m1_254400_62400 0 7.962815e-08
I6268 n1_m1_254400_67200 0 8.092290e-08
I6269 n1_m1_254400_72000 0 1.120490e-07
I6270 n1_m1_254400_76800 0 6.906885e-08
I6271 n1_m1_254400_81600 0 1.042256e-07
I6272 n1_m1_254400_86400 0 7.509081e-08
I6273 n1_m1_254400_91200 0 7.574004e-08
I6274 n1_m1_254400_96000 0 1.091173e-07
I6275 n1_m1_254400_100800 0 7.032942e-08
I6276 n1_m1_254400_105600 0 1.066490e-07
I6277 n1_m1_254400_110400 0 7.433652e-08
I6278 n1_m1_254400_115200 0 7.302520e-08
I6279 n1_m1_254400_120000 0 1.195480e-07
I6280 n1_m1_254400_124800 0 1.024091e-07
I6281 n1_m1_254400_129600 0 2.196724e-07
I6282 n1_m1_254400_134400 0 1.395463e-07
I6283 n1_m1_254400_139200 0 2.469251e-07
I6284 n1_m1_254400_144000 0 7.141685e-07
I6285 n1_m1_254400_148800 0 5.521760e-07
I6286 n1_m1_254400_153600 0 5.514420e-07
I6287 n1_m1_254400_158400 0 3.239816e-07
I6288 n1_m1_254400_163200 0 1.389615e-07
I6289 n1_m1_254400_168000 0 1.820953e-07
I6290 n1_m1_254400_172800 0 1.115281e-07
I6291 n1_m1_254400_177600 0 3.198896e-07
I6292 n1_m1_254400_182400 0 2.676235e-07
I6293 n1_m1_254400_187200 0 1.086770e-07
I6294 n1_m1_254400_192000 0 2.923148e-07
I6295 n1_m1_254400_196800 0 3.818907e-07
I6296 n1_m1_254400_201600 0 5.971184e-07
I6297 n1_m1_254400_206400 0 3.134031e-07
I6298 n1_m1_254400_211200 0 3.107661e-07
I6299 n1_m1_254400_216000 0 5.546402e-07
I6300 n1_m1_254400_220800 0 3.577990e-07
I6301 n1_m1_254400_225600 0 3.669718e-07
I6302 n1_m1_254400_230400 0 2.935526e-07
I6303 n1_m1_254400_235200 0 3.701182e-07
I6304 n1_m1_254400_240000 0 3.274252e-07
I6305 n1_m1_254400_244800 0 1.156965e-07
I6306 n1_m1_254400_249600 0 2.401430e-07
I6307 n1_m1_254400_254400 0 1.618822e-07
I6308 n1_m1_254400_259200 0 1.170745e-07
I6309 n1_m1_254400_264000 0 1.417075e-07
I6310 n1_m1_254400_268800 0 8.524555e-08
I6311 n1_m1_254400_273600 0 1.190321e-07
I6312 n1_m1_254400_278400 0 8.265616e-08
I6313 n1_m1_254400_283200 0 8.268977e-08
I6314 n1_m1_254400_288000 0 1.208808e-07
I6315 n1_m1_254400_292800 0 8.070248e-08
I6316 n1_m1_254400_297600 0 1.266158e-07
I6317 n1_m1_254400_302400 0 1.268170e-07
I6318 n1_m1_254400_307200 0 1.564503e-07
I6319 n1_m1_254400_312000 0 3.262840e-07
I6320 n1_m1_254400_316800 0 2.442040e-07
I6321 n1_m1_254400_321600 0 4.219752e-07
I6322 n1_m1_254400_326400 0 2.623644e-07
I6323 n1_m1_254400_331200 0 2.559314e-07
I6324 n1_m1_254400_336000 0 2.342349e-07
I6325 n1_m1_254400_340800 0 8.637131e-08
I6326 n1_m1_254400_345600 0 1.213661e-07
I6327 n1_m1_254400_350400 0 7.490114e-08
I6328 n1_m1_254400_355200 0 7.268379e-08
I6329 n1_m1_254400_360000 0 1.176847e-07
I6330 n1_m1_254400_364800 0 8.520336e-08
I6331 n1_m1_254400_369600 0 1.176519e-07
I6332 n1_m1_254400_374400 0 7.870920e-08
I6333 n1_m1_254400_379200 0 7.935955e-08
I6334 n1_m1_254400_384000 0 1.277806e-07
I6335 n1_m1_254400_388800 0 9.526147e-08
I6336 n1_m1_254400_393600 0 1.173512e-07
I6337 n1_m1_254400_398400 0 8.820259e-08
I6338 n1_m1_254400_403200 0 8.335473e-08
I6339 n1_m1_254400_408000 0 3.458497e-07
I6340 n1_m1_254400_412800 0 3.014406e-07
I6341 n1_m1_254400_417600 0 2.433315e-07
I6342 n1_m1_254400_422400 0 1.022385e-07
I6343 n1_m1_254400_427200 0 8.233572e-08
I6344 n1_m1_254400_432000 0 1.136103e-07
I6345 n1_m1_254400_436800 0 7.385291e-08
I6346 n1_m1_254400_441600 0 1.050823e-07
I6347 n1_m1_254400_446400 0 7.352012e-08
I6348 n1_m1_254400_451200 0 7.489342e-08
I6349 n1_m1_254400_456000 0 1.069478e-07
I6350 n1_m1_254400_460800 0 7.756675e-08
I6351 n1_m1_254400_465600 0 1.191301e-07
I6352 n1_m1_254400_470400 0 7.443857e-08
I6353 n1_m1_254400_475200 0 7.377134e-08
I6354 n1_m1_254400_480000 0 1.179640e-07
I6355 n1_m1_254400_484800 0 8.095231e-08
I6356 n1_m1_254400_489600 0 1.211920e-07
I6357 n1_m1_254400_494400 0 8.046672e-08
I6358 n1_m1_254400_499200 0 7.973664e-08
I6359 n1_m1_254400_504000 0 1.152234e-07
I6360 n1_m1_254400_508800 0 7.394456e-08
I6361 n1_m1_254400_513600 0 1.099246e-07
I6362 n1_m1_254400_518400 0 7.328303e-08
I6363 n1_m1_254400_523200 0 7.340454e-08
I6364 n1_m1_254400_528000 0 1.126451e-07
I6365 n1_m1_254400_532800 0 7.054789e-08
I6366 n1_m1_254400_537600 0 1.177981e-07
I6367 n1_m1_254400_542400 0 1.547678e-07
I6368 n1_m1_254400_547200 0 2.577970e-07
I6369 n1_m1_254400_552000 0 3.335736e-07
I6370 n1_m1_254400_556800 0 1.110581e-07
I6371 n1_m1_254400_561600 0 5.107575e-08
I6372 n1_m1_259200_0 0 4.107747e-07
I6373 n1_m1_259200_4800 0 5.845969e-07
I6374 n1_m1_259200_9600 0 6.957835e-07
I6375 n1_m1_259200_14400 0 3.159455e-07
I6376 n1_m1_259200_19200 0 2.162711e-07
I6377 n1_m1_259200_24000 0 2.396780e-07
I6378 n1_m1_259200_28800 0 1.622007e-07
I6379 n1_m1_259200_33600 0 2.344279e-07
I6380 n1_m1_259200_38400 0 1.532282e-07
I6381 n1_m1_259200_43200 0 1.472642e-07
I6382 n1_m1_259200_48000 0 2.129595e-07
I6383 n1_m1_259200_52800 0 1.455418e-07
I6384 n1_m1_259200_57600 0 2.224689e-07
I6385 n1_m1_259200_62400 0 1.606230e-07
I6386 n1_m1_259200_67200 0 1.680070e-07
I6387 n1_m1_259200_72000 0 2.297952e-07
I6388 n1_m1_259200_76800 0 1.441815e-07
I6389 n1_m1_259200_81600 0 2.196421e-07
I6390 n1_m1_259200_86400 0 1.549589e-07
I6391 n1_m1_259200_91200 0 1.528150e-07
I6392 n1_m1_259200_96000 0 2.140879e-07
I6393 n1_m1_259200_100800 0 1.399040e-07
I6394 n1_m1_259200_105600 0 2.101790e-07
I6395 n1_m1_259200_110400 0 1.524714e-07
I6396 n1_m1_259200_115200 0 1.622516e-07
I6397 n1_m1_259200_120000 0 2.865552e-07
I6398 n1_m1_259200_124800 0 2.762976e-07
I6399 n1_m1_259200_129600 0 6.140818e-07
I6400 n1_m1_259200_134400 0 2.621440e-07
I6401 n1_m1_259200_139200 0 6.142345e-07
I6402 n1_m1_259200_144000 0 1.741960e-06
I6403 n1_m1_259200_148800 0 1.261229e-06
I6404 n1_m1_259200_153600 0 1.394730e-06
I6405 n1_m1_259200_158400 0 8.105838e-07
I6406 n1_m1_259200_163200 0 4.663475e-07
I6407 n1_m1_259200_168000 0 9.886829e-07
I6408 n1_m1_259200_172800 0 4.846351e-07
I6409 n1_m1_259200_177600 0 4.157972e-07
I6410 n1_m1_259200_182400 0 3.193759e-07
I6411 n1_m1_259200_187200 0 3.416257e-07
I6412 n1_m1_259200_192000 0 9.474275e-07
I6413 n1_m1_259200_196800 0 6.711972e-07
I6414 n1_m1_259200_201600 0 6.767591e-07
I6415 n1_m1_259200_206400 0 5.719290e-07
I6416 n1_m1_259200_211200 0 5.295205e-07
I6417 n1_m1_259200_216000 0 7.664494e-07
I6418 n1_m1_259200_220800 0 5.570320e-07
I6419 n1_m1_259200_225600 0 6.902850e-07
I6420 n1_m1_259200_230400 0 5.670318e-07
I6421 n1_m1_259200_235200 0 5.040943e-07
I6422 n1_m1_259200_240000 0 3.960419e-07
I6423 n1_m1_259200_244800 0 3.039823e-07
I6424 n1_m1_259200_249600 0 4.710130e-07
I6425 n1_m1_259200_254400 0 3.223524e-07
I6426 n1_m1_259200_259200 0 2.742713e-07
I6427 n1_m1_259200_264000 0 2.986556e-07
I6428 n1_m1_259200_268800 0 1.780118e-07
I6429 n1_m1_259200_273600 0 2.567633e-07
I6430 n1_m1_259200_278400 0 1.635177e-07
I6431 n1_m1_259200_283200 0 1.729181e-07
I6432 n1_m1_259200_288000 0 2.593394e-07
I6433 n1_m1_259200_292800 0 2.924978e-07
I6434 n1_m1_259200_297600 0 6.643637e-07
I6435 n1_m1_259200_302400 0 5.921560e-07
I6436 n1_m1_259200_307200 0 7.086124e-07
I6437 n1_m1_259200_312000 0 1.374825e-06
I6438 n1_m1_259200_316800 0 9.854155e-07
I6439 n1_m1_259200_321600 0 1.566945e-06
I6440 n1_m1_259200_326400 0 9.840978e-07
I6441 n1_m1_259200_331200 0 9.283883e-07
I6442 n1_m1_259200_336000 0 1.067514e-06
I6443 n1_m1_259200_340800 0 3.891226e-07
I6444 n1_m1_259200_345600 0 4.942061e-07
I6445 n1_m1_259200_350400 0 4.058877e-07
I6446 n1_m1_259200_355200 0 3.136830e-07
I6447 n1_m1_259200_360000 0 2.880855e-07
I6448 n1_m1_259200_364800 0 1.955565e-07
I6449 n1_m1_259200_369600 0 3.987934e-07
I6450 n1_m1_259200_374400 0 3.650189e-07
I6451 n1_m1_259200_379200 0 3.487489e-07
I6452 n1_m1_259200_384000 0 3.392482e-07
I6453 n1_m1_259200_388800 0 2.104434e-07
I6454 n1_m1_259200_393600 0 3.005222e-07
I6455 n1_m1_259200_398400 0 2.957810e-07
I6456 n1_m1_259200_403200 0 5.423447e-07
I6457 n1_m1_259200_408000 0 1.109442e-06
I6458 n1_m1_259200_412800 0 4.038580e-07
I6459 n1_m1_259200_417600 0 4.400200e-07
I6460 n1_m1_259200_422400 0 1.925697e-07
I6461 n1_m1_259200_427200 0 1.589115e-07
I6462 n1_m1_259200_432000 0 2.351320e-07
I6463 n1_m1_259200_436800 0 1.628897e-07
I6464 n1_m1_259200_441600 0 2.247192e-07
I6465 n1_m1_259200_446400 0 1.514775e-07
I6466 n1_m1_259200_451200 0 1.472773e-07
I6467 n1_m1_259200_456000 0 2.222042e-07
I6468 n1_m1_259200_460800 0 1.562360e-07
I6469 n1_m1_259200_465600 0 2.260142e-07
I6470 n1_m1_259200_470400 0 1.637611e-07
I6471 n1_m1_259200_475200 0 1.593267e-07
I6472 n1_m1_259200_480000 0 2.633196e-07
I6473 n1_m1_259200_484800 0 1.863337e-07
I6474 n1_m1_259200_489600 0 2.654236e-07
I6475 n1_m1_259200_494400 0 1.665524e-07
I6476 n1_m1_259200_499200 0 1.640274e-07
I6477 n1_m1_259200_504000 0 2.346610e-07
I6478 n1_m1_259200_508800 0 1.488539e-07
I6479 n1_m1_259200_513600 0 2.147488e-07
I6480 n1_m1_259200_518400 0 1.421756e-07
I6481 n1_m1_259200_523200 0 1.455468e-07
I6482 n1_m1_259200_528000 0 2.153872e-07
I6483 n1_m1_259200_532800 0 1.409391e-07
I6484 n1_m1_259200_537600 0 2.328582e-07
I6485 n1_m1_259200_542400 0 2.999287e-07
I6486 n1_m1_259200_547200 0 5.086310e-07
I6487 n1_m1_259200_552000 0 6.595017e-07
I6488 n1_m1_259200_556800 0 2.130287e-07
I6489 n1_m1_259200_561600 0 9.786114e-08
I6490 n1_m1_264000_0 0 4.346112e-07
I6491 n1_m1_264000_4800 0 7.452269e-07
I6492 n1_m1_264000_9600 0 1.951757e-06
I6493 n1_m1_264000_14400 0 6.645958e-07
I6494 n1_m1_264000_19200 0 3.025264e-07
I6495 n1_m1_264000_24000 0 3.474635e-07
I6496 n1_m1_264000_28800 0 2.274483e-07
I6497 n1_m1_264000_33600 0 3.528241e-07
I6498 n1_m1_264000_38400 0 2.229597e-07
I6499 n1_m1_264000_43200 0 2.207805e-07
I6500 n1_m1_264000_48000 0 3.207491e-07
I6501 n1_m1_264000_52800 0 2.128395e-07
I6502 n1_m1_264000_57600 0 3.237819e-07
I6503 n1_m1_264000_62400 0 2.337696e-07
I6504 n1_m1_264000_67200 0 2.457656e-07
I6505 n1_m1_264000_72000 0 3.363584e-07
I6506 n1_m1_264000_76800 0 2.195741e-07
I6507 n1_m1_264000_81600 0 3.352121e-07
I6508 n1_m1_264000_86400 0 2.306239e-07
I6509 n1_m1_264000_91200 0 2.226847e-07
I6510 n1_m1_264000_96000 0 3.165383e-07
I6511 n1_m1_264000_100800 0 2.153522e-07
I6512 n1_m1_264000_105600 0 3.365043e-07
I6513 n1_m1_264000_110400 0 2.339999e-07
I6514 n1_m1_264000_115200 0 2.319906e-07
I6515 n1_m1_264000_120000 0 4.045980e-07
I6516 n1_m1_264000_124800 0 4.669304e-07
I6517 n1_m1_264000_129600 0 1.344832e-06
I6518 n1_m1_264000_134400 0 1.039261e-06
I6519 n1_m1_264000_139200 0 1.639793e-06
I6520 n1_m1_264000_144000 0 2.807443e-06
I6521 n1_m1_264000_148800 0 1.630052e-06
I6522 n1_m1_264000_153600 0 1.530178e-06
I6523 n1_m1_264000_158400 0 9.745123e-07
I6524 n1_m1_264000_163200 0 6.192916e-07
I6525 n1_m1_264000_168000 0 1.280325e-06
I6526 n1_m1_264000_172800 0 4.681152e-07
I6527 n1_m1_264000_177600 0 4.758833e-07
I6528 n1_m1_264000_182400 0 3.202053e-07
I6529 n1_m1_264000_187200 0 6.316040e-07
I6530 n1_m1_264000_192000 0 1.765030e-06
I6531 n1_m1_264000_196800 0 7.778116e-07
I6532 n1_m1_264000_201600 0 7.993314e-07
I6533 n1_m1_264000_206400 0 6.441872e-07
I6534 n1_m1_264000_211200 0 4.828403e-07
I6535 n1_m1_264000_216000 0 9.847136e-07
I6536 n1_m1_264000_220800 0 5.593971e-07
I6537 n1_m1_264000_225600 0 7.209966e-07
I6538 n1_m1_264000_230400 0 5.166364e-07
I6539 n1_m1_264000_235200 0 3.389587e-07
I6540 n1_m1_264000_240000 0 6.761761e-07
I6541 n1_m1_264000_244800 0 5.615852e-07
I6542 n1_m1_264000_249600 0 5.980915e-07
I6543 n1_m1_264000_254400 0 3.926515e-07
I6544 n1_m1_264000_259200 0 3.386338e-07
I6545 n1_m1_264000_264000 0 4.140485e-07
I6546 n1_m1_264000_268800 0 2.709044e-07
I6547 n1_m1_264000_273600 0 4.234786e-07
I6548 n1_m1_264000_278400 0 2.611548e-07
I6549 n1_m1_264000_283200 0 2.752668e-07
I6550 n1_m1_264000_288000 0 4.433992e-07
I6551 n1_m1_264000_292800 0 7.201614e-07
I6552 n1_m1_264000_297600 0 1.677847e-06
I6553 n1_m1_264000_302400 0 1.176046e-06
I6554 n1_m1_264000_307200 0 1.384349e-06
I6555 n1_m1_264000_312000 0 2.662473e-06
I6556 n1_m1_264000_316800 0 1.608556e-06
I6557 n1_m1_264000_321600 0 2.635523e-06
I6558 n1_m1_264000_326400 0 1.726355e-06
I6559 n1_m1_264000_331200 0 1.647678e-06
I6560 n1_m1_264000_336000 0 1.896695e-06
I6561 n1_m1_264000_340800 0 7.324318e-07
I6562 n1_m1_264000_345600 0 1.030090e-06
I6563 n1_m1_264000_350400 0 8.262459e-07
I6564 n1_m1_264000_355200 0 6.374245e-07
I6565 n1_m1_264000_360000 0 6.007307e-07
I6566 n1_m1_264000_364800 0 4.410569e-07
I6567 n1_m1_264000_369600 0 8.690932e-07
I6568 n1_m1_264000_374400 0 7.585718e-07
I6569 n1_m1_264000_379200 0 7.192836e-07
I6570 n1_m1_264000_384000 0 6.514042e-07
I6571 n1_m1_264000_388800 0 4.298350e-07
I6572 n1_m1_264000_393600 0 8.931363e-07
I6573 n1_m1_264000_398400 0 5.735625e-07
I6574 n1_m1_264000_403200 0 9.216651e-07
I6575 n1_m1_264000_408000 0 1.188248e-06
I6576 n1_m1_264000_412800 0 6.624287e-07
I6577 n1_m1_264000_417600 0 1.194052e-06
I6578 n1_m1_264000_422400 0 4.294778e-07
I6579 n1_m1_264000_427200 0 2.825438e-07
I6580 n1_m1_264000_432000 0 3.591509e-07
I6581 n1_m1_264000_436800 0 2.379574e-07
I6582 n1_m1_264000_441600 0 3.325936e-07
I6583 n1_m1_264000_446400 0 2.293399e-07
I6584 n1_m1_264000_451200 0 2.278576e-07
I6585 n1_m1_264000_456000 0 3.261954e-07
I6586 n1_m1_264000_460800 0 2.246930e-07
I6587 n1_m1_264000_465600 0 4.295178e-07
I6588 n1_m1_264000_470400 0 5.968891e-07
I6589 n1_m1_264000_475200 0 3.347370e-07
I6590 n1_m1_264000_480000 0 3.690975e-07
I6591 n1_m1_264000_484800 0 2.546147e-07
I6592 n1_m1_264000_489600 0 3.790977e-07
I6593 n1_m1_264000_494400 0 2.337601e-07
I6594 n1_m1_264000_499200 0 2.328211e-07
I6595 n1_m1_264000_504000 0 3.391622e-07
I6596 n1_m1_264000_508800 0 2.196627e-07
I6597 n1_m1_264000_513600 0 3.186563e-07
I6598 n1_m1_264000_518400 0 2.100565e-07
I6599 n1_m1_264000_523200 0 2.118071e-07
I6600 n1_m1_264000_528000 0 3.166909e-07
I6601 n1_m1_264000_532800 0 2.122811e-07
I6602 n1_m1_264000_537600 0 3.472066e-07
I6603 n1_m1_264000_542400 0 3.743259e-07
I6604 n1_m1_264000_547200 0 6.037304e-07
I6605 n1_m1_264000_552000 0 9.022622e-07
I6606 n1_m1_264000_556800 0 3.349836e-07
I6607 n1_m1_264000_561600 0 1.543158e-07
I6608 n1_m1_268800_0 0 3.295255e-07
I6609 n1_m1_268800_4800 0 7.481571e-07
I6610 n1_m1_268800_9600 0 1.506203e-06
I6611 n1_m1_268800_14400 0 4.211083e-07
I6612 n1_m1_268800_19200 0 1.858811e-07
I6613 n1_m1_268800_24000 0 2.544587e-07
I6614 n1_m1_268800_28800 0 1.517166e-07
I6615 n1_m1_268800_33600 0 2.205210e-07
I6616 n1_m1_268800_38400 0 1.501582e-07
I6617 n1_m1_268800_43200 0 1.532242e-07
I6618 n1_m1_268800_48000 0 2.260274e-07
I6619 n1_m1_268800_52800 0 1.481514e-07
I6620 n1_m1_268800_57600 0 2.215424e-07
I6621 n1_m1_268800_62400 0 1.537406e-07
I6622 n1_m1_268800_67200 0 1.571294e-07
I6623 n1_m1_268800_72000 0 2.169994e-07
I6624 n1_m1_268800_76800 0 1.453985e-07
I6625 n1_m1_268800_81600 0 2.203470e-07
I6626 n1_m1_268800_86400 0 1.504361e-07
I6627 n1_m1_268800_91200 0 1.443721e-07
I6628 n1_m1_268800_96000 0 2.100338e-07
I6629 n1_m1_268800_100800 0 1.453179e-07
I6630 n1_m1_268800_105600 0 2.265201e-07
I6631 n1_m1_268800_110400 0 1.533618e-07
I6632 n1_m1_268800_115200 0 1.493301e-07
I6633 n1_m1_268800_120000 0 2.702857e-07
I6634 n1_m1_268800_124800 0 3.757110e-07
I6635 n1_m1_268800_129600 0 1.133471e-06
I6636 n1_m1_268800_134400 0 8.651273e-07
I6637 n1_m1_268800_139200 0 1.200475e-06
I6638 n1_m1_268800_144000 0 1.793557e-06
I6639 n1_m1_268800_148800 0 1.151131e-06
I6640 n1_m1_268800_153600 0 1.219969e-06
I6641 n1_m1_268800_158400 0 7.775015e-07
I6642 n1_m1_268800_163200 0 3.804877e-07
I6643 n1_m1_268800_168000 0 5.914974e-07
I6644 n1_m1_268800_172800 0 3.231522e-07
I6645 n1_m1_268800_177600 0 5.821946e-07
I6646 n1_m1_268800_182400 0 2.325322e-07
I6647 n1_m1_268800_187200 0 3.274251e-07
I6648 n1_m1_268800_192000 0 5.053441e-07
I6649 n1_m1_268800_196800 0 4.160202e-07
I6650 n1_m1_268800_201600 0 6.231778e-07
I6651 n1_m1_268800_206400 0 4.149727e-07
I6652 n1_m1_268800_211200 0 3.025338e-07
I6653 n1_m1_268800_216000 0 6.584920e-07
I6654 n1_m1_268800_220800 0 2.502184e-07
I6655 n1_m1_268800_225600 0 5.254104e-07
I6656 n1_m1_268800_230400 0 3.997972e-07
I6657 n1_m1_268800_235200 0 1.905510e-07
I6658 n1_m1_268800_240000 0 3.881878e-07
I6659 n1_m1_268800_244800 0 3.047748e-07
I6660 n1_m1_268800_249600 0 4.753312e-07
I6661 n1_m1_268800_254400 0 2.880248e-07
I6662 n1_m1_268800_259200 0 2.087088e-07
I6663 n1_m1_268800_264000 0 2.647140e-07
I6664 n1_m1_268800_268800 0 1.742537e-07
I6665 n1_m1_268800_273600 0 2.622938e-07
I6666 n1_m1_268800_278400 0 1.804386e-07
I6667 n1_m1_268800_283200 0 1.949234e-07
I6668 n1_m1_268800_288000 0 2.804324e-07
I6669 n1_m1_268800_292800 0 4.224006e-07
I6670 n1_m1_268800_297600 0 8.336885e-07
I6671 n1_m1_268800_302400 0 4.505502e-07
I6672 n1_m1_268800_307200 0 5.696429e-07
I6673 n1_m1_268800_312000 0 1.493073e-06
I6674 n1_m1_268800_316800 0 7.735239e-07
I6675 n1_m1_268800_321600 0 1.336381e-06
I6676 n1_m1_268800_326400 0 9.336528e-07
I6677 n1_m1_268800_331200 0 9.178182e-07
I6678 n1_m1_268800_336000 0 9.869133e-07
I6679 n1_m1_268800_340800 0 3.862541e-07
I6680 n1_m1_268800_345600 0 5.542542e-07
I6681 n1_m1_268800_350400 0 2.950678e-07
I6682 n1_m1_268800_355200 0 2.275723e-07
I6683 n1_m1_268800_360000 0 3.804463e-07
I6684 n1_m1_268800_364800 0 3.319949e-07
I6685 n1_m1_268800_369600 0 4.285067e-07
I6686 n1_m1_268800_374400 0 2.811822e-07
I6687 n1_m1_268800_379200 0 2.849334e-07
I6688 n1_m1_268800_384000 0 3.594300e-07
I6689 n1_m1_268800_388800 0 3.607000e-07
I6690 n1_m1_268800_393600 0 5.733118e-07
I6691 n1_m1_268800_398400 0 2.844147e-07
I6692 n1_m1_268800_403200 0 3.379297e-07
I6693 n1_m1_268800_408000 0 5.978394e-07
I6694 n1_m1_268800_412800 0 1.020275e-06
I6695 n1_m1_268800_417600 0 1.519026e-06
I6696 n1_m1_268800_422400 0 6.589996e-07
I6697 n1_m1_268800_427200 0 3.729817e-07
I6698 n1_m1_268800_432000 0 2.833820e-07
I6699 n1_m1_268800_436800 0 1.516664e-07
I6700 n1_m1_268800_441600 0 2.114553e-07
I6701 n1_m1_268800_446400 0 1.474199e-07
I6702 n1_m1_268800_451200 0 1.499415e-07
I6703 n1_m1_268800_456000 0 2.169258e-07
I6704 n1_m1_268800_460800 0 1.902619e-07
I6705 n1_m1_268800_465600 0 5.437569e-07
I6706 n1_m1_268800_470400 0 8.757372e-07
I6707 n1_m1_268800_475200 0 3.794235e-07
I6708 n1_m1_268800_480000 0 2.593797e-07
I6709 n1_m1_268800_484800 0 1.694727e-07
I6710 n1_m1_268800_489600 0 2.451325e-07
I6711 n1_m1_268800_494400 0 1.473425e-07
I6712 n1_m1_268800_499200 0 1.470617e-07
I6713 n1_m1_268800_504000 0 2.153035e-07
I6714 n1_m1_268800_508800 0 1.406804e-07
I6715 n1_m1_268800_513600 0 2.101917e-07
I6716 n1_m1_268800_518400 0 1.399040e-07
I6717 n1_m1_268800_523200 0 1.401457e-07
I6718 n1_m1_268800_528000 0 2.180176e-07
I6719 n1_m1_268800_532800 0 1.449330e-07
I6720 n1_m1_268800_537600 0 2.191584e-07
I6721 n1_m1_268800_542400 0 1.773490e-07
I6722 n1_m1_268800_547200 0 2.680048e-07
I6723 n1_m1_268800_552000 0 5.410319e-07
I6724 n1_m1_268800_556800 0 2.381004e-07
I6725 n1_m1_268800_561600 0 1.099577e-07
I6726 n1_m1_273600_0 0 5.155474e-07
I6727 n1_m1_273600_4800 0 9.568026e-07
I6728 n1_m1_273600_9600 0 1.268793e-06
I6729 n1_m1_273600_14400 0 3.630304e-07
I6730 n1_m1_273600_19200 0 2.462898e-07
I6731 n1_m1_273600_24000 0 3.645799e-07
I6732 n1_m1_273600_28800 0 2.403603e-07
I6733 n1_m1_273600_33600 0 3.289843e-07
I6734 n1_m1_273600_38400 0 2.274168e-07
I6735 n1_m1_273600_43200 0 2.415499e-07
I6736 n1_m1_273600_48000 0 3.841787e-07
I6737 n1_m1_273600_52800 0 2.530654e-07
I6738 n1_m1_273600_57600 0 3.523739e-07
I6739 n1_m1_273600_62400 0 2.301063e-07
I6740 n1_m1_273600_67200 0 2.297385e-07
I6741 n1_m1_273600_72000 0 3.337558e-07
I6742 n1_m1_273600_76800 0 2.249741e-07
I6743 n1_m1_273600_81600 0 3.513750e-07
I6744 n1_m1_273600_86400 0 2.351733e-07
I6745 n1_m1_273600_91200 0 2.250005e-07
I6746 n1_m1_273600_96000 0 3.225153e-07
I6747 n1_m1_273600_100800 0 2.302604e-07
I6748 n1_m1_273600_105600 0 3.368281e-07
I6749 n1_m1_273600_110400 0 2.386423e-07
I6750 n1_m1_273600_115200 0 2.208964e-07
I6751 n1_m1_273600_120000 0 4.871116e-07
I6752 n1_m1_273600_124800 0 8.559419e-07
I6753 n1_m1_273600_129600 0 2.222042e-06
I6754 n1_m1_273600_134400 0 1.379870e-06
I6755 n1_m1_273600_139200 0 1.822547e-06
I6756 n1_m1_273600_144000 0 2.850172e-06
I6757 n1_m1_273600_148800 0 1.861548e-06
I6758 n1_m1_273600_153600 0 2.087853e-06
I6759 n1_m1_273600_158400 0 1.354456e-06
I6760 n1_m1_273600_163200 0 6.024430e-07
I6761 n1_m1_273600_168000 0 9.185361e-07
I6762 n1_m1_273600_172800 0 7.856274e-07
I6763 n1_m1_273600_177600 0 9.270233e-07
I6764 n1_m1_273600_182400 0 5.207756e-07
I6765 n1_m1_273600_187200 0 5.343323e-07
I6766 n1_m1_273600_192000 0 5.490764e-07
I6767 n1_m1_273600_196800 0 8.122371e-07
I6768 n1_m1_273600_201600 0 9.500495e-07
I6769 n1_m1_273600_206400 0 7.834745e-07
I6770 n1_m1_273600_211200 0 6.239868e-07
I6771 n1_m1_273600_216000 0 1.132729e-06
I6772 n1_m1_273600_220800 0 5.460847e-07
I6773 n1_m1_273600_225600 0 1.211055e-06
I6774 n1_m1_273600_230400 0 7.447433e-07
I6775 n1_m1_273600_235200 0 3.970221e-07
I6776 n1_m1_273600_240000 0 6.485423e-07
I6777 n1_m1_273600_244800 0 4.558613e-07
I6778 n1_m1_273600_249600 0 9.281537e-07
I6779 n1_m1_273600_254400 0 5.974596e-07
I6780 n1_m1_273600_259200 0 3.792993e-07
I6781 n1_m1_273600_264000 0 4.901909e-07
I6782 n1_m1_273600_268800 0 2.903118e-07
I6783 n1_m1_273600_273600 0 3.987742e-07
I6784 n1_m1_273600_278400 0 2.905908e-07
I6785 n1_m1_273600_283200 0 2.721882e-07
I6786 n1_m1_273600_288000 0 4.314816e-07
I6787 n1_m1_273600_292800 0 4.278803e-07
I6788 n1_m1_273600_297600 0 7.115130e-07
I6789 n1_m1_273600_302400 0 4.862262e-07
I6790 n1_m1_273600_307200 0 7.163147e-07
I6791 n1_m1_273600_312000 0 1.963288e-06
I6792 n1_m1_273600_316800 0 1.428370e-06
I6793 n1_m1_273600_321600 0 2.356468e-06
I6794 n1_m1_273600_326400 0 1.657284e-06
I6795 n1_m1_273600_331200 0 1.643806e-06
I6796 n1_m1_273600_336000 0 1.695127e-06
I6797 n1_m1_273600_340800 0 6.719242e-07
I6798 n1_m1_273600_345600 0 7.790074e-07
I6799 n1_m1_273600_350400 0 3.413675e-07
I6800 n1_m1_273600_355200 0 2.936061e-07
I6801 n1_m1_273600_360000 0 5.639378e-07
I6802 n1_m1_273600_364800 0 4.893390e-07
I6803 n1_m1_273600_369600 0 5.673816e-07
I6804 n1_m1_273600_374400 0 3.408533e-07
I6805 n1_m1_273600_379200 0 3.543580e-07
I6806 n1_m1_273600_384000 0 4.412163e-07
I6807 n1_m1_273600_388800 0 3.241445e-07
I6808 n1_m1_273600_393600 0 5.081726e-07
I6809 n1_m1_273600_398400 0 5.162812e-07
I6810 n1_m1_273600_403200 0 6.840599e-07
I6811 n1_m1_273600_408000 0 1.524208e-06
I6812 n1_m1_273600_412800 0 1.586749e-06
I6813 n1_m1_273600_417600 0 1.741436e-06
I6814 n1_m1_273600_422400 0 1.040942e-06
I6815 n1_m1_273600_427200 0 6.304106e-07
I6816 n1_m1_273600_432000 0 4.552921e-07
I6817 n1_m1_273600_436800 0 2.349731e-07
I6818 n1_m1_273600_441600 0 3.192922e-07
I6819 n1_m1_273600_446400 0 2.181892e-07
I6820 n1_m1_273600_451200 0 2.188652e-07
I6821 n1_m1_273600_456000 0 3.528089e-07
I6822 n1_m1_273600_460800 0 5.497159e-07
I6823 n1_m1_273600_465600 0 1.158025e-06
I6824 n1_m1_273600_470400 0 1.432625e-06
I6825 n1_m1_273600_475200 0 6.235797e-07
I6826 n1_m1_273600_480000 0 4.929636e-07
I6827 n1_m1_273600_484800 0 3.687948e-07
I6828 n1_m1_273600_489600 0 3.714536e-07
I6829 n1_m1_273600_494400 0 2.211294e-07
I6830 n1_m1_273600_499200 0 2.173803e-07
I6831 n1_m1_273600_504000 0 3.173005e-07
I6832 n1_m1_273600_508800 0 2.098560e-07
I6833 n1_m1_273600_513600 0 3.147839e-07
I6834 n1_m1_273600_518400 0 2.098560e-07
I6835 n1_m1_273600_523200 0 2.103703e-07
I6836 n1_m1_273600_528000 0 3.315949e-07
I6837 n1_m1_273600_532800 0 2.191568e-07
I6838 n1_m1_273600_537600 0 3.366502e-07
I6839 n1_m1_273600_542400 0 3.077308e-07
I6840 n1_m1_273600_547200 0 5.054826e-07
I6841 n1_m1_273600_552000 0 9.481300e-07
I6842 n1_m1_273600_556800 0 3.666775e-07
I6843 n1_m1_273600_561600 0 1.659476e-07
I6844 n1_m1_278400_0 0 3.164893e-07
I6845 n1_m1_278400_4800 0 3.736057e-07
I6846 n1_m1_278400_9600 0 9.421314e-07
I6847 n1_m1_278400_14400 0 3.853342e-07
I6848 n1_m1_278400_19200 0 1.982993e-07
I6849 n1_m1_278400_24000 0 2.494871e-07
I6850 n1_m1_278400_28800 0 1.513972e-07
I6851 n1_m1_278400_33600 0 2.416315e-07
I6852 n1_m1_278400_38400 0 1.550047e-07
I6853 n1_m1_278400_43200 0 1.640776e-07
I6854 n1_m1_278400_48000 0 2.662088e-07
I6855 n1_m1_278400_52800 0 1.746822e-07
I6856 n1_m1_278400_57600 0 2.451258e-07
I6857 n1_m1_278400_62400 0 1.586228e-07
I6858 n1_m1_278400_67200 0 1.572687e-07
I6859 n1_m1_278400_72000 0 2.389898e-07
I6860 n1_m1_278400_76800 0 1.648675e-07
I6861 n1_m1_278400_81600 0 2.585113e-07
I6862 n1_m1_278400_86400 0 1.705832e-07
I6863 n1_m1_278400_91200 0 1.656122e-07
I6864 n1_m1_278400_96000 0 2.594787e-07
I6865 n1_m1_278400_100800 0 1.910708e-07
I6866 n1_m1_278400_105600 0 2.505944e-07
I6867 n1_m1_278400_110400 0 1.736037e-07
I6868 n1_m1_278400_115200 0 1.717408e-07
I6869 n1_m1_278400_120000 0 4.559257e-07
I6870 n1_m1_278400_124800 0 7.149461e-07
I6871 n1_m1_278400_129600 0 1.699300e-06
I6872 n1_m1_278400_134400 0 9.440151e-07
I6873 n1_m1_278400_139200 0 1.091752e-06
I6874 n1_m1_278400_144000 0 1.805043e-06
I6875 n1_m1_278400_148800 0 1.171780e-06
I6876 n1_m1_278400_153600 0 1.584515e-06
I6877 n1_m1_278400_158400 0 1.142593e-06
I6878 n1_m1_278400_163200 0 5.308150e-07
I6879 n1_m1_278400_168000 0 6.091173e-07
I6880 n1_m1_278400_172800 0 3.209338e-07
I6881 n1_m1_278400_177600 0 8.900404e-07
I6882 n1_m1_278400_182400 0 6.066475e-07
I6883 n1_m1_278400_187200 0 2.664965e-07
I6884 n1_m1_278400_192000 0 4.738963e-07
I6885 n1_m1_278400_196800 0 3.052377e-07
I6886 n1_m1_278400_201600 0 5.855947e-07
I6887 n1_m1_278400_206400 0 8.798769e-07
I6888 n1_m1_278400_211200 0 7.559952e-07
I6889 n1_m1_278400_216000 0 8.689929e-07
I6890 n1_m1_278400_220800 0 3.395947e-07
I6891 n1_m1_278400_225600 0 5.905180e-07
I6892 n1_m1_278400_230400 0 6.597591e-07
I6893 n1_m1_278400_235200 0 7.100257e-07
I6894 n1_m1_278400_240000 0 5.971389e-07
I6895 n1_m1_278400_244800 0 2.518826e-07
I6896 n1_m1_278400_249600 0 6.816127e-07
I6897 n1_m1_278400_254400 0 4.913829e-07
I6898 n1_m1_278400_259200 0 5.141826e-07
I6899 n1_m1_278400_264000 0 7.348695e-07
I6900 n1_m1_278400_268800 0 2.797380e-07
I6901 n1_m1_278400_273600 0 5.077252e-07
I6902 n1_m1_278400_278400 0 3.774779e-07
I6903 n1_m1_278400_283200 0 3.399854e-07
I6904 n1_m1_278400_288000 0 5.329716e-07
I6905 n1_m1_278400_292800 0 2.508924e-07
I6906 n1_m1_278400_297600 0 3.574938e-07
I6907 n1_m1_278400_302400 0 3.397522e-07
I6908 n1_m1_278400_307200 0 4.682133e-07
I6909 n1_m1_278400_312000 0 1.116027e-06
I6910 n1_m1_278400_316800 0 7.676287e-07
I6911 n1_m1_278400_321600 0 1.126359e-06
I6912 n1_m1_278400_326400 0 8.031909e-07
I6913 n1_m1_278400_331200 0 8.529115e-07
I6914 n1_m1_278400_336000 0 8.409017e-07
I6915 n1_m1_278400_340800 0 3.461904e-07
I6916 n1_m1_278400_345600 0 3.647073e-07
I6917 n1_m1_278400_350400 0 2.334927e-07
I6918 n1_m1_278400_355200 0 2.309998e-07
I6919 n1_m1_278400_360000 0 3.304215e-07
I6920 n1_m1_278400_364800 0 2.028791e-07
I6921 n1_m1_278400_369600 0 2.993796e-07
I6922 n1_m1_278400_374400 0 2.536054e-07
I6923 n1_m1_278400_379200 0 2.534309e-07
I6924 n1_m1_278400_384000 0 2.758716e-07
I6925 n1_m1_278400_388800 0 1.992464e-07
I6926 n1_m1_278400_393600 0 3.299525e-07
I6927 n1_m1_278400_398400 0 2.968423e-07
I6928 n1_m1_278400_403200 0 3.775777e-07
I6929 n1_m1_278400_408000 0 8.262752e-07
I6930 n1_m1_278400_412800 0 5.439610e-07
I6931 n1_m1_278400_417600 0 5.675637e-07
I6932 n1_m1_278400_422400 0 3.293790e-07
I6933 n1_m1_278400_427200 0 1.967662e-07
I6934 n1_m1_278400_432000 0 2.378590e-07
I6935 n1_m1_278400_436800 0 1.501635e-07
I6936 n1_m1_278400_441600 0 2.199915e-07
I6937 n1_m1_278400_446400 0 1.491628e-07
I6938 n1_m1_278400_451200 0 1.492491e-07
I6939 n1_m1_278400_456000 0 2.427747e-07
I6940 n1_m1_278400_460800 0 3.354268e-07
I6941 n1_m1_278400_465600 0 5.153229e-07
I6942 n1_m1_278400_470400 0 6.277700e-07
I6943 n1_m1_278400_475200 0 2.773659e-07
I6944 n1_m1_278400_480000 0 3.565990e-07
I6945 n1_m1_278400_484800 0 2.934980e-07
I6946 n1_m1_278400_489600 0 2.402012e-07
I6947 n1_m1_278400_494400 0 1.491456e-07
I6948 n1_m1_278400_499200 0 1.465661e-07
I6949 n1_m1_278400_504000 0 2.146747e-07
I6950 n1_m1_278400_508800 0 1.399040e-07
I6951 n1_m1_278400_513600 0 2.100835e-07
I6952 n1_m1_278400_518400 0 1.414514e-07
I6953 n1_m1_278400_523200 0 1.417838e-07
I6954 n1_m1_278400_528000 0 2.147247e-07
I6955 n1_m1_278400_532800 0 1.441374e-07
I6956 n1_m1_278400_537600 0 2.503971e-07
I6957 n1_m1_278400_542400 0 3.034745e-07
I6958 n1_m1_278400_547200 0 4.788532e-07
I6959 n1_m1_278400_552000 0 6.530167e-07
I6960 n1_m1_278400_556800 0 2.256039e-07
I6961 n1_m1_278400_561600 0 1.026261e-07
I6962 n1_m1_283200_0 0 1.340022e-07
I6963 n1_m1_283200_4800 0 2.483606e-07
I6964 n1_m1_283200_9600 0 6.322195e-07
I6965 n1_m1_283200_14400 0 2.969022e-07
I6966 n1_m1_283200_19200 0 1.066560e-07
I6967 n1_m1_283200_24000 0 1.124664e-07
I6968 n1_m1_283200_28800 0 7.343069e-08
I6969 n1_m1_283200_33600 0 1.150143e-07
I6970 n1_m1_283200_38400 0 7.788708e-08
I6971 n1_m1_283200_43200 0 7.857616e-08
I6972 n1_m1_283200_48000 0 1.260131e-07
I6973 n1_m1_283200_52800 0 7.936493e-08
I6974 n1_m1_283200_57600 0 1.235713e-07
I6975 n1_m1_283200_62400 0 8.544897e-08
I6976 n1_m1_283200_67200 0 8.370474e-08
I6977 n1_m1_283200_72000 0 1.309742e-07
I6978 n1_m1_283200_76800 0 9.260700e-08
I6979 n1_m1_283200_81600 0 1.353021e-07
I6980 n1_m1_283200_86400 0 8.652681e-08
I6981 n1_m1_283200_91200 0 8.921295e-08
I6982 n1_m1_283200_96000 0 1.663278e-07
I6983 n1_m1_283200_100800 0 1.246822e-07
I6984 n1_m1_283200_105600 0 1.369243e-07
I6985 n1_m1_283200_110400 0 8.852508e-08
I6986 n1_m1_283200_115200 0 1.150152e-07
I6987 n1_m1_283200_120000 0 3.625962e-07
I6988 n1_m1_283200_124800 0 3.873934e-07
I6989 n1_m1_283200_129600 0 7.832180e-07
I6990 n1_m1_283200_134400 0 3.187570e-07
I6991 n1_m1_283200_139200 0 3.449306e-07
I6992 n1_m1_283200_144000 0 7.872038e-07
I6993 n1_m1_283200_148800 0 5.675602e-07
I6994 n1_m1_283200_153600 0 9.930490e-07
I6995 n1_m1_283200_158400 0 6.222943e-07
I6996 n1_m1_283200_163200 0 2.145008e-07
I6997 n1_m1_283200_168000 0 4.800996e-07
I6998 n1_m1_283200_172800 0 1.933173e-07
I6999 n1_m1_283200_177600 0 5.603742e-07
I7000 n1_m1_283200_182400 0 4.540391e-07
I7001 n1_m1_283200_187200 0 2.122852e-07
I7002 n1_m1_283200_192000 0 2.884319e-07
I7003 n1_m1_283200_196800 0 1.358119e-07
I7004 n1_m1_283200_201600 0 3.559832e-07
I7005 n1_m1_283200_206400 0 5.788727e-07
I7006 n1_m1_283200_211200 0 4.834700e-07
I7007 n1_m1_283200_216000 0 4.536624e-07
I7008 n1_m1_283200_220800 0 2.219372e-07
I7009 n1_m1_283200_225600 0 3.676056e-07
I7010 n1_m1_283200_230400 0 4.691014e-07
I7011 n1_m1_283200_235200 0 5.585342e-07
I7012 n1_m1_283200_240000 0 3.551257e-07
I7013 n1_m1_283200_244800 0 1.410594e-07
I7014 n1_m1_283200_249600 0 4.088621e-07
I7015 n1_m1_283200_254400 0 3.218267e-07
I7016 n1_m1_283200_259200 0 5.182583e-07
I7017 n1_m1_283200_264000 0 6.767950e-07
I7018 n1_m1_283200_268800 0 1.678596e-07
I7019 n1_m1_283200_273600 0 4.892907e-07
I7020 n1_m1_283200_278400 0 3.370851e-07
I7021 n1_m1_283200_283200 0 3.339915e-07
I7022 n1_m1_283200_288000 0 4.733928e-07
I7023 n1_m1_283200_292800 0 1.753809e-07
I7024 n1_m1_283200_297600 0 2.439617e-07
I7025 n1_m1_283200_302400 0 2.492208e-07
I7026 n1_m1_283200_307200 0 2.984224e-07
I7027 n1_m1_283200_312000 0 7.401052e-07
I7028 n1_m1_283200_316800 0 4.409679e-07
I7029 n1_m1_283200_321600 0 5.333646e-07
I7030 n1_m1_283200_326400 0 3.021270e-07
I7031 n1_m1_283200_331200 0 3.102270e-07
I7032 n1_m1_283200_336000 0 3.936246e-07
I7033 n1_m1_283200_340800 0 1.892339e-07
I7034 n1_m1_283200_345600 0 1.974069e-07
I7035 n1_m1_283200_350400 0 1.278429e-07
I7036 n1_m1_283200_355200 0 1.412003e-07
I7037 n1_m1_283200_360000 0 2.383207e-07
I7038 n1_m1_283200_364800 0 1.037520e-07
I7039 n1_m1_283200_369600 0 1.502851e-07
I7040 n1_m1_283200_374400 0 1.706808e-07
I7041 n1_m1_283200_379200 0 1.769276e-07
I7042 n1_m1_283200_384000 0 1.502150e-07
I7043 n1_m1_283200_388800 0 9.962320e-08
I7044 n1_m1_283200_393600 0 1.665617e-07
I7045 n1_m1_283200_398400 0 9.852693e-08
I7046 n1_m1_283200_403200 0 1.022354e-07
I7047 n1_m1_283200_408000 0 3.119560e-07
I7048 n1_m1_283200_412800 0 1.947579e-07
I7049 n1_m1_283200_417600 0 1.616200e-07
I7050 n1_m1_283200_422400 0 9.091531e-08
I7051 n1_m1_283200_427200 0 8.393525e-08
I7052 n1_m1_283200_432000 0 1.151327e-07
I7053 n1_m1_283200_436800 0 7.339298e-08
I7054 n1_m1_283200_441600 0 1.099289e-07
I7055 n1_m1_283200_446400 0 7.336240e-08
I7056 n1_m1_283200_451200 0 7.336503e-08
I7057 n1_m1_283200_456000 0 1.134355e-07
I7058 n1_m1_283200_460800 0 8.671228e-08
I7059 n1_m1_283200_465600 0 1.932566e-07
I7060 n1_m1_283200_470400 0 1.737884e-07
I7061 n1_m1_283200_475200 0 1.084103e-07
I7062 n1_m1_283200_480000 0 1.341318e-07
I7063 n1_m1_283200_484800 0 8.832177e-08
I7064 n1_m1_283200_489600 0 1.140886e-07
I7065 n1_m1_283200_494400 0 7.336187e-08
I7066 n1_m1_283200_499200 0 7.328303e-08
I7067 n1_m1_283200_504000 0 1.073374e-07
I7068 n1_m1_283200_508800 0 6.995199e-08
I7069 n1_m1_283200_513600 0 1.053273e-07
I7070 n1_m1_283200_518400 0 7.266762e-08
I7071 n1_m1_283200_523200 0 7.325096e-08
I7072 n1_m1_283200_528000 0 1.116349e-07
I7073 n1_m1_283200_532800 0 6.799456e-08
I7074 n1_m1_283200_537600 0 1.395310e-07
I7075 n1_m1_283200_542400 0 1.813174e-07
I7076 n1_m1_283200_547200 0 2.156701e-07
I7077 n1_m1_283200_552000 0 2.058511e-07
I7078 n1_m1_283200_556800 0 9.904867e-08
I7079 n1_m1_283200_561600 0 4.791116e-08
I7080 n1_m1_288000_0 0 2.374080e-07
I7081 n1_m1_288000_4800 0 3.923093e-07
I7082 n1_m1_288000_9600 0 1.001593e-06
I7083 n1_m1_288000_14400 0 5.283695e-07
I7084 n1_m1_288000_19200 0 2.346541e-07
I7085 n1_m1_288000_24000 0 2.696039e-07
I7086 n1_m1_288000_28800 0 1.665707e-07
I7087 n1_m1_288000_33600 0 2.240349e-07
I7088 n1_m1_288000_38400 0 1.491622e-07
I7089 n1_m1_288000_43200 0 1.500394e-07
I7090 n1_m1_288000_48000 0 2.483037e-07
I7091 n1_m1_288000_52800 0 1.712806e-07
I7092 n1_m1_288000_57600 0 3.140366e-07
I7093 n1_m1_288000_62400 0 2.920312e-07
I7094 n1_m1_288000_67200 0 2.673564e-07
I7095 n1_m1_288000_72000 0 3.319599e-07
I7096 n1_m1_288000_76800 0 1.820349e-07
I7097 n1_m1_288000_81600 0 2.505572e-07
I7098 n1_m1_288000_86400 0 1.648773e-07
I7099 n1_m1_288000_91200 0 1.722968e-07
I7100 n1_m1_288000_96000 0 2.652434e-07
I7101 n1_m1_288000_100800 0 1.631267e-07
I7102 n1_m1_288000_105600 0 2.723800e-07
I7103 n1_m1_288000_110400 0 1.631819e-07
I7104 n1_m1_288000_115200 0 2.131093e-07
I7105 n1_m1_288000_120000 0 8.391084e-07
I7106 n1_m1_288000_124800 0 4.445966e-07
I7107 n1_m1_288000_129600 0 7.998342e-07
I7108 n1_m1_288000_134400 0 7.648695e-07
I7109 n1_m1_288000_139200 0 1.194862e-06
I7110 n1_m1_288000_144000 0 1.961060e-06
I7111 n1_m1_288000_148800 0 1.327648e-06
I7112 n1_m1_288000_153600 0 1.515580e-06
I7113 n1_m1_288000_158400 0 1.221680e-06
I7114 n1_m1_288000_163200 0 1.364591e-06
I7115 n1_m1_288000_168000 0 1.980154e-06
I7116 n1_m1_288000_172800 0 1.241339e-06
I7117 n1_m1_288000_177600 0 1.570084e-06
I7118 n1_m1_288000_182400 0 1.066702e-06
I7119 n1_m1_288000_187200 0 1.263925e-06
I7120 n1_m1_288000_192000 0 1.770416e-06
I7121 n1_m1_288000_196800 0 1.161386e-06
I7122 n1_m1_288000_201600 0 1.880974e-06
I7123 n1_m1_288000_206400 0 1.291545e-06
I7124 n1_m1_288000_211200 0 1.254891e-06
I7125 n1_m1_288000_216000 0 2.122968e-06
I7126 n1_m1_288000_220800 0 1.269271e-06
I7127 n1_m1_288000_225600 0 1.949230e-06
I7128 n1_m1_288000_230400 0 1.379345e-06
I7129 n1_m1_288000_235200 0 1.290271e-06
I7130 n1_m1_288000_240000 0 1.991495e-06
I7131 n1_m1_288000_244800 0 1.325864e-06
I7132 n1_m1_288000_249600 0 1.947283e-06
I7133 n1_m1_288000_254400 0 1.417251e-06
I7134 n1_m1_288000_259200 0 1.366414e-06
I7135 n1_m1_288000_264000 0 1.996813e-06
I7136 n1_m1_288000_268800 0 1.362955e-06
I7137 n1_m1_288000_273600 0 1.934567e-06
I7138 n1_m1_288000_278400 0 1.442582e-06
I7139 n1_m1_288000_283200 0 1.384092e-06
I7140 n1_m1_288000_288000 0 1.952389e-06
I7141 n1_m1_288000_292800 0 1.191640e-06
I7142 n1_m1_288000_297600 0 1.904801e-06
I7143 n1_m1_288000_302400 0 1.288806e-06
I7144 n1_m1_288000_307200 0 1.360998e-06
I7145 n1_m1_288000_312000 0 2.038786e-06
I7146 n1_m1_288000_316800 0 1.333222e-06
I7147 n1_m1_288000_321600 0 2.052268e-06
I7148 n1_m1_288000_326400 0 1.288765e-06
I7149 n1_m1_288000_331200 0 1.375953e-06
I7150 n1_m1_288000_336000 0 1.814366e-06
I7151 n1_m1_288000_340800 0 1.122587e-06
I7152 n1_m1_288000_345600 0 1.822533e-06
I7153 n1_m1_288000_350400 0 1.035624e-06
I7154 n1_m1_288000_355200 0 7.441476e-07
I7155 n1_m1_288000_360000 0 8.170446e-07
I7156 n1_m1_288000_364800 0 6.464025e-07
I7157 n1_m1_288000_369600 0 1.123901e-06
I7158 n1_m1_288000_374400 0 8.967182e-07
I7159 n1_m1_288000_379200 0 8.802872e-07
I7160 n1_m1_288000_384000 0 8.709299e-07
I7161 n1_m1_288000_388800 0 3.186174e-07
I7162 n1_m1_288000_393600 0 3.599927e-07
I7163 n1_m1_288000_398400 0 2.069985e-07
I7164 n1_m1_288000_403200 0 2.001758e-07
I7165 n1_m1_288000_408000 0 3.175425e-07
I7166 n1_m1_288000_412800 0 1.814443e-07
I7167 n1_m1_288000_417600 0 2.414896e-07
I7168 n1_m1_288000_422400 0 1.583878e-07
I7169 n1_m1_288000_427200 0 1.532765e-07
I7170 n1_m1_288000_432000 0 2.209693e-07
I7171 n1_m1_288000_436800 0 1.475111e-07
I7172 n1_m1_288000_441600 0 2.293969e-07
I7173 n1_m1_288000_446400 0 1.533230e-07
I7174 n1_m1_288000_451200 0 1.502290e-07
I7175 n1_m1_288000_456000 0 2.222020e-07
I7176 n1_m1_288000_460800 0 1.465661e-07
I7177 n1_m1_288000_465600 0 2.326627e-07
I7178 n1_m1_288000_470400 0 1.682452e-07
I7179 n1_m1_288000_475200 0 1.584824e-07
I7180 n1_m1_288000_480000 0 2.324945e-07
I7181 n1_m1_288000_484800 0 1.574927e-07
I7182 n1_m1_288000_489600 0 2.244431e-07
I7183 n1_m1_288000_494400 0 1.501105e-07
I7184 n1_m1_288000_499200 0 1.465661e-07
I7185 n1_m1_288000_504000 0 2.198491e-07
I7186 n1_m1_288000_508800 0 1.421918e-07
I7187 n1_m1_288000_513600 0 2.106917e-07
I7188 n1_m1_288000_518400 0 1.455881e-07
I7189 n1_m1_288000_523200 0 1.460800e-07
I7190 n1_m1_288000_528000 0 2.085996e-07
I7191 n1_m1_288000_532800 0 1.629787e-07
I7192 n1_m1_288000_537600 0 4.894975e-07
I7193 n1_m1_288000_542400 0 7.022345e-07
I7194 n1_m1_288000_547200 0 7.665394e-07
I7195 n1_m1_288000_552000 0 7.387320e-07
I7196 n1_m1_288000_556800 0 2.450065e-07
I7197 n1_m1_288000_561600 0 1.087514e-07
I7198 n1_m1_292800_0 0 2.441856e-07
I7199 n1_m1_292800_4800 0 3.825719e-07
I7200 n1_m1_292800_9600 0 9.253718e-07
I7201 n1_m1_292800_14400 0 5.008564e-07
I7202 n1_m1_292800_19200 0 2.439792e-07
I7203 n1_m1_292800_24000 0 2.771511e-07
I7204 n1_m1_292800_28800 0 1.645274e-07
I7205 n1_m1_292800_33600 0 2.214517e-07
I7206 n1_m1_292800_38400 0 1.503586e-07
I7207 n1_m1_292800_43200 0 1.516401e-07
I7208 n1_m1_292800_48000 0 2.502199e-07
I7209 n1_m1_292800_52800 0 1.737548e-07
I7210 n1_m1_292800_57600 0 3.375333e-07
I7211 n1_m1_292800_62400 0 3.446546e-07
I7212 n1_m1_292800_67200 0 3.260466e-07
I7213 n1_m1_292800_72000 0 3.531560e-07
I7214 n1_m1_292800_76800 0 1.781695e-07
I7215 n1_m1_292800_81600 0 2.415305e-07
I7216 n1_m1_292800_86400 0 1.587693e-07
I7217 n1_m1_292800_91200 0 1.634347e-07
I7218 n1_m1_292800_96000 0 2.445171e-07
I7219 n1_m1_292800_100800 0 1.502862e-07
I7220 n1_m1_292800_105600 0 2.395142e-07
I7221 n1_m1_292800_110400 0 1.654001e-07
I7222 n1_m1_292800_115200 0 2.066223e-07
I7223 n1_m1_292800_120000 0 6.786913e-07
I7224 n1_m1_292800_124800 0 5.354225e-07
I7225 n1_m1_292800_129600 0 1.289033e-06
I7226 n1_m1_292800_134400 0 9.331388e-07
I7227 n1_m1_292800_139200 0 1.175422e-06
I7228 n1_m1_292800_144000 0 1.905765e-06
I7229 n1_m1_292800_148800 0 1.100383e-06
I7230 n1_m1_292800_153600 0 1.129070e-06
I7231 n1_m1_292800_158400 0 1.135397e-06
I7232 n1_m1_292800_163200 0 1.160825e-06
I7233 n1_m1_292800_168000 0 1.905595e-06
I7234 n1_m1_292800_172800 0 1.249396e-06
I7235 n1_m1_292800_177600 0 1.676905e-06
I7236 n1_m1_292800_182400 0 1.063528e-06
I7237 n1_m1_292800_187200 0 1.145392e-06
I7238 n1_m1_292800_192000 0 1.511129e-06
I7239 n1_m1_292800_196800 0 1.117568e-06
I7240 n1_m1_292800_201600 0 1.764118e-06
I7241 n1_m1_292800_206400 0 1.255758e-06
I7242 n1_m1_292800_211200 0 1.247570e-06
I7243 n1_m1_292800_216000 0 2.035689e-06
I7244 n1_m1_292800_220800 0 1.313227e-06
I7245 n1_m1_292800_225600 0 2.000497e-06
I7246 n1_m1_292800_230400 0 1.336089e-06
I7247 n1_m1_292800_235200 0 1.256004e-06
I7248 n1_m1_292800_240000 0 1.994258e-06
I7249 n1_m1_292800_244800 0 1.341893e-06
I7250 n1_m1_292800_249600 0 2.046782e-06
I7251 n1_m1_292800_254400 0 1.366481e-06
I7252 n1_m1_292800_259200 0 1.304650e-06
I7253 n1_m1_292800_264000 0 1.920794e-06
I7254 n1_m1_292800_268800 0 1.286346e-06
I7255 n1_m1_292800_273600 0 2.005323e-06
I7256 n1_m1_292800_278400 0 1.402751e-06
I7257 n1_m1_292800_283200 0 1.364649e-06
I7258 n1_m1_292800_288000 0 1.933978e-06
I7259 n1_m1_292800_292800 0 1.328505e-06
I7260 n1_m1_292800_297600 0 2.001761e-06
I7261 n1_m1_292800_302400 0 1.341047e-06
I7262 n1_m1_292800_307200 0 1.345556e-06
I7263 n1_m1_292800_312000 0 1.959950e-06
I7264 n1_m1_292800_316800 0 1.264219e-06
I7265 n1_m1_292800_321600 0 1.879844e-06
I7266 n1_m1_292800_326400 0 1.313750e-06
I7267 n1_m1_292800_331200 0 1.377735e-06
I7268 n1_m1_292800_336000 0 1.809681e-06
I7269 n1_m1_292800_340800 0 1.094877e-06
I7270 n1_m1_292800_345600 0 1.506075e-06
I7271 n1_m1_292800_350400 0 9.733273e-07
I7272 n1_m1_292800_355200 0 7.080012e-07
I7273 n1_m1_292800_360000 0 8.814289e-07
I7274 n1_m1_292800_364800 0 7.169477e-07
I7275 n1_m1_292800_369600 0 8.184371e-07
I7276 n1_m1_292800_374400 0 7.648452e-07
I7277 n1_m1_292800_379200 0 8.960228e-07
I7278 n1_m1_292800_384000 0 7.003126e-07
I7279 n1_m1_292800_388800 0 3.748753e-07
I7280 n1_m1_292800_393600 0 3.842585e-07
I7281 n1_m1_292800_398400 0 2.104879e-07
I7282 n1_m1_292800_403200 0 2.061070e-07
I7283 n1_m1_292800_408000 0 3.409776e-07
I7284 n1_m1_292800_412800 0 1.889033e-07
I7285 n1_m1_292800_417600 0 2.443865e-07
I7286 n1_m1_292800_422400 0 1.539988e-07
I7287 n1_m1_292800_427200 0 1.528543e-07
I7288 n1_m1_292800_432000 0 2.250585e-07
I7289 n1_m1_292800_436800 0 1.513552e-07
I7290 n1_m1_292800_441600 0 2.364953e-07
I7291 n1_m1_292800_446400 0 1.563221e-07
I7292 n1_m1_292800_451200 0 1.518569e-07
I7293 n1_m1_292800_456000 0 2.247267e-07
I7294 n1_m1_292800_460800 0 1.474128e-07
I7295 n1_m1_292800_465600 0 2.214821e-07
I7296 n1_m1_292800_470400 0 1.548968e-07
I7297 n1_m1_292800_475200 0 1.516386e-07
I7298 n1_m1_292800_480000 0 2.369297e-07
I7299 n1_m1_292800_484800 0 1.651950e-07
I7300 n1_m1_292800_489600 0 2.277174e-07
I7301 n1_m1_292800_494400 0 1.501105e-07
I7302 n1_m1_292800_499200 0 1.465661e-07
I7303 n1_m1_292800_504000 0 2.198491e-07
I7304 n1_m1_292800_508800 0 1.421918e-07
I7305 n1_m1_292800_513600 0 2.106917e-07
I7306 n1_m1_292800_518400 0 1.455881e-07
I7307 n1_m1_292800_523200 0 1.464160e-07
I7308 n1_m1_292800_528000 0 2.234657e-07
I7309 n1_m1_292800_532800 0 1.858099e-07
I7310 n1_m1_292800_537600 0 5.099226e-07
I7311 n1_m1_292800_542400 0 7.051598e-07
I7312 n1_m1_292800_547200 0 8.138487e-07
I7313 n1_m1_292800_552000 0 9.370164e-07
I7314 n1_m1_292800_556800 0 3.064181e-07
I7315 n1_m1_292800_561600 0 1.306321e-07
I7316 n1_m1_297600_0 0 4.111024e-07
I7317 n1_m1_297600_4800 0 6.688475e-07
I7318 n1_m1_297600_9600 0 1.598590e-06
I7319 n1_m1_297600_14400 0 8.174127e-07
I7320 n1_m1_297600_19200 0 3.607023e-07
I7321 n1_m1_297600_24000 0 3.925760e-07
I7322 n1_m1_297600_28800 0 2.390750e-07
I7323 n1_m1_297600_33600 0 3.399667e-07
I7324 n1_m1_297600_38400 0 2.297171e-07
I7325 n1_m1_297600_43200 0 2.269611e-07
I7326 n1_m1_297600_48000 0 3.630575e-07
I7327 n1_m1_297600_52800 0 2.395038e-07
I7328 n1_m1_297600_57600 0 4.229281e-07
I7329 n1_m1_297600_62400 0 3.758590e-07
I7330 n1_m1_297600_67200 0 3.597888e-07
I7331 n1_m1_297600_72000 0 4.348412e-07
I7332 n1_m1_297600_76800 0 2.531456e-07
I7333 n1_m1_297600_81600 0 3.537549e-07
I7334 n1_m1_297600_86400 0 2.266899e-07
I7335 n1_m1_297600_91200 0 2.259323e-07
I7336 n1_m1_297600_96000 0 3.392094e-07
I7337 n1_m1_297600_100800 0 2.299711e-07
I7338 n1_m1_297600_105600 0 3.433812e-07
I7339 n1_m1_297600_110400 0 2.498545e-07
I7340 n1_m1_297600_115200 0 3.016506e-07
I7341 n1_m1_297600_120000 0 8.209883e-07
I7342 n1_m1_297600_124800 0 7.669700e-07
I7343 n1_m1_297600_129600 0 2.084582e-06
I7344 n1_m1_297600_134400 0 1.417250e-06
I7345 n1_m1_297600_139200 0 1.720575e-06
I7346 n1_m1_297600_144000 0 2.961379e-06
I7347 n1_m1_297600_148800 0 1.651116e-06
I7348 n1_m1_297600_153600 0 1.876759e-06
I7349 n1_m1_297600_158400 0 1.777968e-06
I7350 n1_m1_297600_163200 0 1.457987e-06
I7351 n1_m1_297600_168000 0 2.597653e-06
I7352 n1_m1_297600_172800 0 1.974224e-06
I7353 n1_m1_297600_177600 0 2.416243e-06
I7354 n1_m1_297600_182400 0 1.395842e-06
I7355 n1_m1_297600_187200 0 1.433860e-06
I7356 n1_m1_297600_192000 0 1.355580e-06
I7357 n1_m1_297600_196800 0 1.397587e-06
I7358 n1_m1_297600_201600 0 1.955406e-06
I7359 n1_m1_297600_206400 0 1.235473e-06
I7360 n1_m1_297600_211200 0 1.704642e-06
I7361 n1_m1_297600_216000 0 3.033323e-06
I7362 n1_m1_297600_220800 0 1.976222e-06
I7363 n1_m1_297600_225600 0 3.103304e-06
I7364 n1_m1_297600_230400 0 1.988476e-06
I7365 n1_m1_297600_235200 0 1.886826e-06
I7366 n1_m1_297600_240000 0 2.951477e-06
I7367 n1_m1_297600_244800 0 1.935343e-06
I7368 n1_m1_297600_249600 0 3.097550e-06
I7369 n1_m1_297600_254400 0 1.990139e-06
I7370 n1_m1_297600_259200 0 1.777871e-06
I7371 n1_m1_297600_264000 0 2.690485e-06
I7372 n1_m1_297600_268800 0 1.803169e-06
I7373 n1_m1_297600_273600 0 2.913445e-06
I7374 n1_m1_297600_278400 0 2.075855e-06
I7375 n1_m1_297600_283200 0 2.034485e-06
I7376 n1_m1_297600_288000 0 2.889268e-06
I7377 n1_m1_297600_292800 0 2.023967e-06
I7378 n1_m1_297600_297600 0 2.983897e-06
I7379 n1_m1_297600_302400 0 2.085427e-06
I7380 n1_m1_297600_307200 0 1.964980e-06
I7381 n1_m1_297600_312000 0 2.617719e-06
I7382 n1_m1_297600_316800 0 1.467220e-06
I7383 n1_m1_297600_321600 0 2.184975e-06
I7384 n1_m1_297600_326400 0 1.795162e-06
I7385 n1_m1_297600_331200 0 1.956804e-06
I7386 n1_m1_297600_336000 0 2.382191e-06
I7387 n1_m1_297600_340800 0 1.452786e-06
I7388 n1_m1_297600_345600 0 1.747275e-06
I7389 n1_m1_297600_350400 0 1.105851e-06
I7390 n1_m1_297600_355200 0 1.229929e-06
I7391 n1_m1_297600_360000 0 1.444130e-06
I7392 n1_m1_297600_364800 0 5.611052e-07
I7393 n1_m1_297600_369600 0 5.103689e-07
I7394 n1_m1_297600_374400 0 4.822630e-07
I7395 n1_m1_297600_379200 0 5.811900e-07
I7396 n1_m1_297600_384000 0 5.366828e-07
I7397 n1_m1_297600_388800 0 4.113630e-07
I7398 n1_m1_297600_393600 0 5.184111e-07
I7399 n1_m1_297600_398400 0 2.823981e-07
I7400 n1_m1_297600_403200 0 2.957381e-07
I7401 n1_m1_297600_408000 0 8.488849e-07
I7402 n1_m1_297600_412800 0 4.880534e-07
I7403 n1_m1_297600_417600 0 4.215133e-07
I7404 n1_m1_297600_422400 0 2.360796e-07
I7405 n1_m1_297600_427200 0 2.307252e-07
I7406 n1_m1_297600_432000 0 3.447943e-07
I7407 n1_m1_297600_436800 0 2.323731e-07
I7408 n1_m1_297600_441600 0 3.556764e-07
I7409 n1_m1_297600_446400 0 2.287730e-07
I7410 n1_m1_297600_451200 0 2.222664e-07
I7411 n1_m1_297600_456000 0 3.431565e-07
I7412 n1_m1_297600_460800 0 2.242579e-07
I7413 n1_m1_297600_465600 0 3.306486e-07
I7414 n1_m1_297600_470400 0 2.232222e-07
I7415 n1_m1_297600_475200 0 2.209833e-07
I7416 n1_m1_297600_480000 0 3.461320e-07
I7417 n1_m1_297600_484800 0 2.425973e-07
I7418 n1_m1_297600_489600 0 3.374040e-07
I7419 n1_m1_297600_494400 0 2.220754e-07
I7420 n1_m1_297600_499200 0 2.198491e-07
I7421 n1_m1_297600_504000 0 3.297737e-07
I7422 n1_m1_297600_508800 0 2.132878e-07
I7423 n1_m1_297600_513600 0 3.160375e-07
I7424 n1_m1_297600_518400 0 2.183821e-07
I7425 n1_m1_297600_523200 0 2.197832e-07
I7426 n1_m1_297600_528000 0 3.380451e-07
I7427 n1_m1_297600_532800 0 2.629602e-07
I7428 n1_m1_297600_537600 0 5.095144e-07
I7429 n1_m1_297600_542400 0 6.604021e-07
I7430 n1_m1_297600_547200 0 9.169209e-07
I7431 n1_m1_297600_552000 0 1.283709e-06
I7432 n1_m1_297600_556800 0 4.593462e-07
I7433 n1_m1_297600_561600 0 1.956509e-07
I7434 n1_m1_302400_0 0 2.536930e-07
I7435 n1_m1_302400_4800 0 4.487748e-07
I7436 n1_m1_302400_9600 0 1.153247e-06
I7437 n1_m1_302400_14400 0 5.574678e-07
I7438 n1_m1_302400_19200 0 2.164593e-07
I7439 n1_m1_302400_24000 0 2.337062e-07
I7440 n1_m1_302400_28800 0 1.511202e-07
I7441 n1_m1_302400_33600 0 2.252247e-07
I7442 n1_m1_302400_38400 0 1.494348e-07
I7443 n1_m1_302400_43200 0 1.425550e-07
I7444 n1_m1_302400_48000 0 2.210938e-07
I7445 n1_m1_302400_52800 0 1.473831e-07
I7446 n1_m1_302400_57600 0 2.291369e-07
I7447 n1_m1_302400_62400 0 1.647076e-07
I7448 n1_m1_302400_67200 0 1.613406e-07
I7449 n1_m1_302400_72000 0 2.439232e-07
I7450 n1_m1_302400_76800 0 1.598665e-07
I7451 n1_m1_302400_81600 0 2.315273e-07
I7452 n1_m1_302400_86400 0 1.496126e-07
I7453 n1_m1_302400_91200 0 1.465661e-07
I7454 n1_m1_302400_96000 0 2.287958e-07
I7455 n1_m1_302400_100800 0 1.697470e-07
I7456 n1_m1_302400_105600 0 2.465188e-07
I7457 n1_m1_302400_110400 0 1.632005e-07
I7458 n1_m1_302400_115200 0 2.001473e-07
I7459 n1_m1_302400_120000 0 5.859875e-07
I7460 n1_m1_302400_124800 0 5.530814e-07
I7461 n1_m1_302400_129600 0 1.568563e-06
I7462 n1_m1_302400_134400 0 1.166435e-06
I7463 n1_m1_302400_139200 0 1.356906e-06
I7464 n1_m1_302400_144000 0 2.104658e-06
I7465 n1_m1_302400_148800 0 1.253130e-06
I7466 n1_m1_302400_153600 0 1.541452e-06
I7467 n1_m1_302400_158400 0 1.260482e-06
I7468 n1_m1_302400_163200 0 1.243892e-06
I7469 n1_m1_302400_168000 0 1.883215e-06
I7470 n1_m1_302400_172800 0 1.121202e-06
I7471 n1_m1_302400_177600 0 1.809910e-06
I7472 n1_m1_302400_182400 0 1.181108e-06
I7473 n1_m1_302400_187200 0 1.158358e-06
I7474 n1_m1_302400_192000 0 1.503351e-06
I7475 n1_m1_302400_196800 0 6.533345e-07
I7476 n1_m1_302400_201600 0 6.369052e-07
I7477 n1_m1_302400_206400 0 7.318134e-07
I7478 n1_m1_302400_211200 0 1.109342e-06
I7479 n1_m1_302400_216000 0 2.040270e-06
I7480 n1_m1_302400_220800 0 1.333394e-06
I7481 n1_m1_302400_225600 0 2.090008e-06
I7482 n1_m1_302400_230400 0 1.360372e-06
I7483 n1_m1_302400_235200 0 1.316788e-06
I7484 n1_m1_302400_240000 0 2.030995e-06
I7485 n1_m1_302400_244800 0 1.399865e-06
I7486 n1_m1_302400_249600 0 1.998920e-06
I7487 n1_m1_302400_254400 0 1.157402e-06
I7488 n1_m1_302400_259200 0 1.095808e-06
I7489 n1_m1_302400_264000 0 1.544825e-06
I7490 n1_m1_302400_268800 0 1.109822e-06
I7491 n1_m1_302400_273600 0 1.758737e-06
I7492 n1_m1_302400_278400 0 1.061513e-06
I7493 n1_m1_302400_283200 0 1.268244e-06
I7494 n1_m1_302400_288000 0 2.001363e-06
I7495 n1_m1_302400_292800 0 1.368220e-06
I7496 n1_m1_302400_297600 0 2.075422e-06
I7497 n1_m1_302400_302400 0 1.380178e-06
I7498 n1_m1_302400_307200 0 1.256946e-06
I7499 n1_m1_302400_312000 0 1.350516e-06
I7500 n1_m1_302400_316800 0 5.855555e-07
I7501 n1_m1_302400_321600 0 8.448898e-07
I7502 n1_m1_302400_326400 0 9.925016e-07
I7503 n1_m1_302400_331200 0 1.103881e-06
I7504 n1_m1_302400_336000 0 1.181424e-06
I7505 n1_m1_302400_340800 0 9.531938e-07
I7506 n1_m1_302400_345600 0 1.618516e-06
I7507 n1_m1_302400_350400 0 1.108447e-06
I7508 n1_m1_302400_355200 0 1.120951e-06
I7509 n1_m1_302400_360000 0 9.762176e-07
I7510 n1_m1_302400_364800 0 2.322246e-07
I7511 n1_m1_302400_369600 0 3.208522e-07
I7512 n1_m1_302400_374400 0 1.794027e-07
I7513 n1_m1_302400_379200 0 1.719537e-07
I7514 n1_m1_302400_384000 0 3.287603e-07
I7515 n1_m1_302400_388800 0 1.762057e-07
I7516 n1_m1_302400_393600 0 2.709194e-07
I7517 n1_m1_302400_398400 0 1.703615e-07
I7518 n1_m1_302400_403200 0 1.836010e-07
I7519 n1_m1_302400_408000 0 6.861534e-07
I7520 n1_m1_302400_412800 0 4.347094e-07
I7521 n1_m1_302400_417600 0 3.131759e-07
I7522 n1_m1_302400_422400 0 1.639579e-07
I7523 n1_m1_302400_427200 0 1.584595e-07
I7524 n1_m1_302400_432000 0 2.306695e-07
I7525 n1_m1_302400_436800 0 1.536778e-07
I7526 n1_m1_302400_441600 0 2.313166e-07
I7527 n1_m1_302400_446400 0 1.522949e-07
I7528 n1_m1_302400_451200 0 1.492884e-07
I7529 n1_m1_302400_456000 0 2.351225e-07
I7530 n1_m1_302400_460800 0 1.515977e-07
I7531 n1_m1_302400_465600 0 2.254339e-07
I7532 n1_m1_302400_470400 0 1.503564e-07
I7533 n1_m1_302400_475200 0 1.435417e-07
I7534 n1_m1_302400_480000 0 2.212035e-07
I7535 n1_m1_302400_484800 0 1.520280e-07
I7536 n1_m1_302400_489600 0 2.160514e-07
I7537 n1_m1_302400_494400 0 1.465661e-07
I7538 n1_m1_302400_499200 0 1.465661e-07
I7539 n1_m1_302400_504000 0 2.198491e-07
I7540 n1_m1_302400_508800 0 1.421918e-07
I7541 n1_m1_302400_513600 0 2.106917e-07
I7542 n1_m1_302400_518400 0 1.455881e-07
I7543 n1_m1_302400_523200 0 1.461436e-07
I7544 n1_m1_302400_528000 0 2.089938e-07
I7545 n1_m1_302400_532800 0 1.494384e-07
I7546 n1_m1_302400_537600 0 2.395709e-07
I7547 n1_m1_302400_542400 0 2.998500e-07
I7548 n1_m1_302400_547200 0 4.748208e-07
I7549 n1_m1_302400_552000 0 6.744382e-07
I7550 n1_m1_302400_556800 0 2.501967e-07
I7551 n1_m1_302400_561600 0 1.093155e-07
I7552 n1_m1_307200_0 0 2.434659e-07
I7553 n1_m1_307200_4800 0 4.448973e-07
I7554 n1_m1_307200_9600 0 1.177734e-06
I7555 n1_m1_307200_14400 0 5.619724e-07
I7556 n1_m1_307200_19200 0 2.057069e-07
I7557 n1_m1_307200_24000 0 2.178289e-07
I7558 n1_m1_307200_28800 0 1.415808e-07
I7559 n1_m1_307200_33600 0 2.175020e-07
I7560 n1_m1_307200_38400 0 1.460062e-07
I7561 n1_m1_307200_43200 0 1.421598e-07
I7562 n1_m1_307200_48000 0 2.220574e-07
I7563 n1_m1_307200_52800 0 1.441525e-07
I7564 n1_m1_307200_57600 0 2.212140e-07
I7565 n1_m1_307200_62400 0 1.572108e-07
I7566 n1_m1_307200_67200 0 1.514042e-07
I7567 n1_m1_307200_72000 0 2.349625e-07
I7568 n1_m1_307200_76800 0 1.506175e-07
I7569 n1_m1_307200_81600 0 2.261454e-07
I7570 n1_m1_307200_86400 0 1.519608e-07
I7571 n1_m1_307200_91200 0 1.528561e-07
I7572 n1_m1_307200_96000 0 2.410903e-07
I7573 n1_m1_307200_100800 0 1.788334e-07
I7574 n1_m1_307200_105600 0 3.164943e-07
I7575 n1_m1_307200_110400 0 2.025598e-07
I7576 n1_m1_307200_115200 0 2.218891e-07
I7577 n1_m1_307200_120000 0 5.942492e-07
I7578 n1_m1_307200_124800 0 6.212742e-07
I7579 n1_m1_307200_129600 0 1.677524e-06
I7580 n1_m1_307200_134400 0 1.154163e-06
I7581 n1_m1_307200_139200 0 1.302275e-06
I7582 n1_m1_307200_144000 0 1.960558e-06
I7583 n1_m1_307200_148800 0 9.878475e-07
I7584 n1_m1_307200_153600 0 1.285975e-06
I7585 n1_m1_307200_158400 0 1.225323e-06
I7586 n1_m1_307200_163200 0 1.322118e-06
I7587 n1_m1_307200_168000 0 1.964746e-06
I7588 n1_m1_307200_172800 0 9.005832e-07
I7589 n1_m1_307200_177600 0 1.885188e-06
I7590 n1_m1_307200_182400 0 1.219448e-06
I7591 n1_m1_307200_187200 0 1.076785e-06
I7592 n1_m1_307200_192000 0 1.847842e-06
I7593 n1_m1_307200_196800 0 5.884675e-07
I7594 n1_m1_307200_201600 0 4.802725e-07
I7595 n1_m1_307200_206400 0 9.177787e-07
I7596 n1_m1_307200_211200 0 8.681873e-07
I7597 n1_m1_307200_216000 0 1.882640e-06
I7598 n1_m1_307200_220800 0 1.311540e-06
I7599 n1_m1_307200_225600 0 1.759490e-06
I7600 n1_m1_307200_230400 0 1.358483e-06
I7601 n1_m1_307200_235200 0 1.404422e-06
I7602 n1_m1_307200_240000 0 1.973534e-06
I7603 n1_m1_307200_244800 0 1.372760e-06
I7604 n1_m1_307200_249600 0 1.727730e-06
I7605 n1_m1_307200_254400 0 9.355467e-07
I7606 n1_m1_307200_259200 0 9.871708e-07
I7607 n1_m1_307200_264000 0 1.284889e-06
I7608 n1_m1_307200_268800 0 9.338239e-07
I7609 n1_m1_307200_273600 0 1.463863e-06
I7610 n1_m1_307200_278400 0 6.977592e-07
I7611 n1_m1_307200_283200 0 9.267967e-07
I7612 n1_m1_307200_288000 0 1.855896e-06
I7613 n1_m1_307200_292800 0 1.328920e-06
I7614 n1_m1_307200_297600 0 2.041580e-06
I7615 n1_m1_307200_302400 0 1.322831e-06
I7616 n1_m1_307200_307200 0 9.012522e-07
I7617 n1_m1_307200_312000 0 1.162028e-06
I7618 n1_m1_307200_316800 0 4.809341e-07
I7619 n1_m1_307200_321600 0 5.488125e-07
I7620 n1_m1_307200_326400 0 6.959951e-07
I7621 n1_m1_307200_331200 0 6.123636e-07
I7622 n1_m1_307200_336000 0 1.070940e-06
I7623 n1_m1_307200_340800 0 1.187602e-06
I7624 n1_m1_307200_345600 0 1.415351e-06
I7625 n1_m1_307200_350400 0 9.722877e-07
I7626 n1_m1_307200_355200 0 8.196446e-07
I7627 n1_m1_307200_360000 0 6.246560e-07
I7628 n1_m1_307200_364800 0 2.669673e-07
I7629 n1_m1_307200_369600 0 2.876437e-07
I7630 n1_m1_307200_374400 0 1.623833e-07
I7631 n1_m1_307200_379200 0 1.693563e-07
I7632 n1_m1_307200_384000 0 2.721054e-07
I7633 n1_m1_307200_388800 0 1.649893e-07
I7634 n1_m1_307200_393600 0 2.524159e-07
I7635 n1_m1_307200_398400 0 1.679274e-07
I7636 n1_m1_307200_403200 0 1.756162e-07
I7637 n1_m1_307200_408000 0 5.446502e-07
I7638 n1_m1_307200_412800 0 3.252012e-07
I7639 n1_m1_307200_417600 0 2.837082e-07
I7640 n1_m1_307200_422400 0 1.649197e-07
I7641 n1_m1_307200_427200 0 1.562289e-07
I7642 n1_m1_307200_432000 0 2.244723e-07
I7643 n1_m1_307200_436800 0 1.500177e-07
I7644 n1_m1_307200_441600 0 2.297152e-07
I7645 n1_m1_307200_446400 0 1.555455e-07
I7646 n1_m1_307200_451200 0 1.545795e-07
I7647 n1_m1_307200_456000 0 2.394492e-07
I7648 n1_m1_307200_460800 0 1.552118e-07
I7649 n1_m1_307200_465600 0 2.444152e-07
I7650 n1_m1_307200_470400 0 1.670276e-07
I7651 n1_m1_307200_475200 0 1.485372e-07
I7652 n1_m1_307200_480000 0 2.224473e-07
I7653 n1_m1_307200_484800 0 1.554685e-07
I7654 n1_m1_307200_489600 0 2.222956e-07
I7655 n1_m1_307200_494400 0 1.465661e-07
I7656 n1_m1_307200_499200 0 1.465661e-07
I7657 n1_m1_307200_504000 0 2.198491e-07
I7658 n1_m1_307200_508800 0 1.421918e-07
I7659 n1_m1_307200_513600 0 2.106917e-07
I7660 n1_m1_307200_518400 0 1.455881e-07
I7661 n1_m1_307200_523200 0 1.460800e-07
I7662 n1_m1_307200_528000 0 2.060389e-07
I7663 n1_m1_307200_532800 0 1.446990e-07
I7664 n1_m1_307200_537600 0 2.587280e-07
I7665 n1_m1_307200_542400 0 3.572745e-07
I7666 n1_m1_307200_547200 0 5.294364e-07
I7667 n1_m1_307200_552000 0 6.686344e-07
I7668 n1_m1_307200_556800 0 2.406649e-07
I7669 n1_m1_307200_561600 0 1.063009e-07
I7670 n1_m1_312000_0 0 4.244524e-07
I7671 n1_m1_312000_4800 0 7.941958e-07
I7672 n1_m1_312000_9600 0 1.911710e-06
I7673 n1_m1_312000_14400 0 9.131411e-07
I7674 n1_m1_312000_19200 0 3.238727e-07
I7675 n1_m1_312000_24000 0 3.337217e-07
I7676 n1_m1_312000_28800 0 2.169564e-07
I7677 n1_m1_312000_33600 0 3.265298e-07
I7678 n1_m1_312000_38400 0 2.227682e-07
I7679 n1_m1_312000_43200 0 2.216730e-07
I7680 n1_m1_312000_48000 0 3.517535e-07
I7681 n1_m1_312000_52800 0 2.236081e-07
I7682 n1_m1_312000_57600 0 3.436791e-07
I7683 n1_m1_312000_62400 0 2.433455e-07
I7684 n1_m1_312000_67200 0 2.333163e-07
I7685 n1_m1_312000_72000 0 3.603658e-07
I7686 n1_m1_312000_76800 0 2.146233e-07
I7687 n1_m1_312000_81600 0 3.270698e-07
I7688 n1_m1_312000_86400 0 2.339086e-07
I7689 n1_m1_312000_91200 0 2.510859e-07
I7690 n1_m1_312000_96000 0 3.861261e-07
I7691 n1_m1_312000_100800 0 2.686419e-07
I7692 n1_m1_312000_105600 0 4.387878e-07
I7693 n1_m1_312000_110400 0 3.042490e-07
I7694 n1_m1_312000_115200 0 4.735668e-07
I7695 n1_m1_312000_120000 0 1.492942e-06
I7696 n1_m1_312000_124800 0 1.197327e-06
I7697 n1_m1_312000_129600 0 2.396875e-06
I7698 n1_m1_312000_134400 0 1.489576e-06
I7699 n1_m1_312000_139200 0 1.765569e-06
I7700 n1_m1_312000_144000 0 2.903925e-06
I7701 n1_m1_312000_148800 0 1.488500e-06
I7702 n1_m1_312000_153600 0 1.335270e-06
I7703 n1_m1_312000_158400 0 1.604291e-06
I7704 n1_m1_312000_163200 0 1.437945e-06
I7705 n1_m1_312000_168000 0 2.039271e-06
I7706 n1_m1_312000_172800 0 1.589728e-06
I7707 n1_m1_312000_177600 0 1.902369e-06
I7708 n1_m1_312000_182400 0 1.154549e-06
I7709 n1_m1_312000_187200 0 1.300460e-06
I7710 n1_m1_312000_192000 0 1.570925e-06
I7711 n1_m1_312000_196800 0 9.400071e-07
I7712 n1_m1_312000_201600 0 1.184143e-06
I7713 n1_m1_312000_206400 0 1.127583e-06
I7714 n1_m1_312000_211200 0 1.061473e-06
I7715 n1_m1_312000_216000 0 1.775660e-06
I7716 n1_m1_312000_220800 0 1.232073e-06
I7717 n1_m1_312000_225600 0 2.578807e-06
I7718 n1_m1_312000_230400 0 1.815361e-06
I7719 n1_m1_312000_235200 0 1.590671e-06
I7720 n1_m1_312000_240000 0 2.471470e-06
I7721 n1_m1_312000_244800 0 1.291786e-06
I7722 n1_m1_312000_249600 0 1.990235e-06
I7723 n1_m1_312000_254400 0 1.334467e-06
I7724 n1_m1_312000_259200 0 1.103110e-06
I7725 n1_m1_312000_264000 0 1.652708e-06
I7726 n1_m1_312000_268800 0 9.039870e-07
I7727 n1_m1_312000_273600 0 1.401956e-06
I7728 n1_m1_312000_278400 0 1.602297e-06
I7729 n1_m1_312000_283200 0 1.674952e-06
I7730 n1_m1_312000_288000 0 2.751581e-06
I7731 n1_m1_312000_292800 0 1.924401e-06
I7732 n1_m1_312000_297600 0 2.349273e-06
I7733 n1_m1_312000_302400 0 1.471548e-06
I7734 n1_m1_312000_307200 0 1.485613e-06
I7735 n1_m1_312000_312000 0 1.513844e-06
I7736 n1_m1_312000_316800 0 6.314679e-07
I7737 n1_m1_312000_321600 0 5.954706e-07
I7738 n1_m1_312000_326400 0 6.703942e-07
I7739 n1_m1_312000_331200 0 1.171343e-06
I7740 n1_m1_312000_336000 0 1.346100e-06
I7741 n1_m1_312000_340800 0 8.983925e-07
I7742 n1_m1_312000_345600 0 1.111288e-06
I7743 n1_m1_312000_350400 0 6.515947e-07
I7744 n1_m1_312000_355200 0 6.053213e-07
I7745 n1_m1_312000_360000 0 8.723082e-07
I7746 n1_m1_312000_364800 0 5.013808e-07
I7747 n1_m1_312000_369600 0 4.309723e-07
I7748 n1_m1_312000_374400 0 2.563573e-07
I7749 n1_m1_312000_379200 0 2.720613e-07
I7750 n1_m1_312000_384000 0 3.742682e-07
I7751 n1_m1_312000_388800 0 2.639953e-07
I7752 n1_m1_312000_393600 0 3.863578e-07
I7753 n1_m1_312000_398400 0 2.607238e-07
I7754 n1_m1_312000_403200 0 2.626812e-07
I7755 n1_m1_312000_408000 0 4.885229e-07
I7756 n1_m1_312000_412800 0 2.968821e-07
I7757 n1_m1_312000_417600 0 3.924738e-07
I7758 n1_m1_312000_422400 0 2.415813e-07
I7759 n1_m1_312000_427200 0 2.296724e-07
I7760 n1_m1_312000_432000 0 3.313175e-07
I7761 n1_m1_312000_436800 0 2.222179e-07
I7762 n1_m1_312000_441600 0 3.476884e-07
I7763 n1_m1_312000_446400 0 2.410127e-07
I7764 n1_m1_312000_451200 0 2.436061e-07
I7765 n1_m1_312000_456000 0 3.571777e-07
I7766 n1_m1_312000_460800 0 2.314573e-07
I7767 n1_m1_312000_465600 0 3.845923e-07
I7768 n1_m1_312000_470400 0 2.665140e-07
I7769 n1_m1_312000_475200 0 2.337037e-07
I7770 n1_m1_312000_480000 0 3.371574e-07
I7771 n1_m1_312000_484800 0 2.359639e-07
I7772 n1_m1_312000_489600 0 3.424946e-07
I7773 n1_m1_312000_494400 0 2.231759e-07
I7774 n1_m1_312000_499200 0 2.198491e-07
I7775 n1_m1_312000_504000 0 3.297737e-07
I7776 n1_m1_312000_508800 0 2.132878e-07
I7777 n1_m1_312000_513600 0 3.168026e-07
I7778 n1_m1_312000_518400 0 2.185013e-07
I7779 n1_m1_312000_523200 0 2.196651e-07
I7780 n1_m1_312000_528000 0 3.233500e-07
I7781 n1_m1_312000_532800 0 2.136310e-07
I7782 n1_m1_312000_537600 0 3.964508e-07
I7783 n1_m1_312000_542400 0 5.671403e-07
I7784 n1_m1_312000_547200 0 8.337881e-07
I7785 n1_m1_312000_552000 0 1.011472e-06
I7786 n1_m1_312000_556800 0 3.648852e-07
I7787 n1_m1_312000_561600 0 1.625231e-07
I7788 n1_m1_316800_0 0 2.558571e-07
I7789 n1_m1_316800_4800 0 4.407400e-07
I7790 n1_m1_316800_9600 0 9.460477e-07
I7791 n1_m1_316800_14400 0 4.334314e-07
I7792 n1_m1_316800_19200 0 1.968355e-07
I7793 n1_m1_316800_24000 0 2.215006e-07
I7794 n1_m1_316800_28800 0 1.393573e-07
I7795 n1_m1_316800_33600 0 2.184319e-07
I7796 n1_m1_316800_38400 0 1.546216e-07
I7797 n1_m1_316800_43200 0 1.468466e-07
I7798 n1_m1_316800_48000 0 2.204577e-07
I7799 n1_m1_316800_52800 0 1.557946e-07
I7800 n1_m1_316800_57600 0 2.461471e-07
I7801 n1_m1_316800_62400 0 1.700691e-07
I7802 n1_m1_316800_67200 0 1.647344e-07
I7803 n1_m1_316800_72000 0 2.359692e-07
I7804 n1_m1_316800_76800 0 1.525888e-07
I7805 n1_m1_316800_81600 0 2.249792e-07
I7806 n1_m1_316800_86400 0 1.545003e-07
I7807 n1_m1_316800_91200 0 1.848844e-07
I7808 n1_m1_316800_96000 0 2.725984e-07
I7809 n1_m1_316800_100800 0 1.854567e-07
I7810 n1_m1_316800_105600 0 2.712826e-07
I7811 n1_m1_316800_110400 0 1.930865e-07
I7812 n1_m1_316800_115200 0 3.049335e-07
I7813 n1_m1_316800_120000 0 1.307256e-06
I7814 n1_m1_316800_124800 0 9.249497e-07
I7815 n1_m1_316800_129600 0 1.778796e-06
I7816 n1_m1_316800_134400 0 1.168372e-06
I7817 n1_m1_316800_139200 0 1.274943e-06
I7818 n1_m1_316800_144000 0 2.063470e-06
I7819 n1_m1_316800_148800 0 1.250045e-06
I7820 n1_m1_316800_153600 0 9.415058e-07
I7821 n1_m1_316800_158400 0 8.221643e-07
I7822 n1_m1_316800_163200 0 7.006405e-07
I7823 n1_m1_316800_168000 0 8.930595e-07
I7824 n1_m1_316800_172800 0 1.080548e-06
I7825 n1_m1_316800_177600 0 9.307998e-07
I7826 n1_m1_316800_182400 0 5.189943e-07
I7827 n1_m1_316800_187200 0 6.529424e-07
I7828 n1_m1_316800_192000 0 6.113087e-07
I7829 n1_m1_316800_196800 0 7.912025e-07
I7830 n1_m1_316800_201600 0 8.981208e-07
I7831 n1_m1_316800_206400 0 4.869569e-07
I7832 n1_m1_316800_211200 0 4.879738e-07
I7833 n1_m1_316800_216000 0 5.324932e-07
I7834 n1_m1_316800_220800 0 5.280688e-07
I7835 n1_m1_316800_225600 0 1.780253e-06
I7836 n1_m1_316800_230400 0 1.001462e-06
I7837 n1_m1_316800_235200 0 7.193125e-07
I7838 n1_m1_316800_240000 0 1.448648e-06
I7839 n1_m1_316800_244800 0 8.297238e-07
I7840 n1_m1_316800_249600 0 1.617032e-06
I7841 n1_m1_316800_254400 0 1.038084e-06
I7842 n1_m1_316800_259200 0 6.246089e-07
I7843 n1_m1_316800_264000 0 8.910746e-07
I7844 n1_m1_316800_268800 0 5.330828e-07
I7845 n1_m1_316800_273600 0 9.819780e-07
I7846 n1_m1_316800_278400 0 1.275371e-06
I7847 n1_m1_316800_283200 0 1.132035e-06
I7848 n1_m1_316800_288000 0 1.647471e-06
I7849 n1_m1_316800_292800 0 1.301804e-06
I7850 n1_m1_316800_297600 0 1.682795e-06
I7851 n1_m1_316800_302400 0 1.228711e-06
I7852 n1_m1_316800_307200 0 1.224461e-06
I7853 n1_m1_316800_312000 0 1.101719e-06
I7854 n1_m1_316800_316800 0 6.322909e-07
I7855 n1_m1_316800_321600 0 7.235577e-07
I7856 n1_m1_316800_326400 0 6.378287e-07
I7857 n1_m1_316800_331200 0 1.064848e-06
I7858 n1_m1_316800_336000 0 7.565885e-07
I7859 n1_m1_316800_340800 0 3.462554e-07
I7860 n1_m1_316800_345600 0 6.878627e-07
I7861 n1_m1_316800_350400 0 3.433182e-07
I7862 n1_m1_316800_355200 0 4.049488e-07
I7863 n1_m1_316800_360000 0 6.729650e-07
I7864 n1_m1_316800_364800 0 2.352625e-07
I7865 n1_m1_316800_369600 0 2.742545e-07
I7866 n1_m1_316800_374400 0 1.762246e-07
I7867 n1_m1_316800_379200 0 1.850219e-07
I7868 n1_m1_316800_384000 0 2.716783e-07
I7869 n1_m1_316800_388800 0 1.851985e-07
I7870 n1_m1_316800_393600 0 2.866504e-07
I7871 n1_m1_316800_398400 0 1.773997e-07
I7872 n1_m1_316800_403200 0 1.736872e-07
I7873 n1_m1_316800_408000 0 2.736742e-07
I7874 n1_m1_316800_412800 0 1.805756e-07
I7875 n1_m1_316800_417600 0 2.472740e-07
I7876 n1_m1_316800_422400 0 1.539262e-07
I7877 n1_m1_316800_427200 0 1.482874e-07
I7878 n1_m1_316800_432000 0 2.200175e-07
I7879 n1_m1_316800_436800 0 1.468245e-07
I7880 n1_m1_316800_441600 0 2.251610e-07
I7881 n1_m1_316800_446400 0 1.542507e-07
I7882 n1_m1_316800_451200 0 1.521878e-07
I7883 n1_m1_316800_456000 0 2.267197e-07
I7884 n1_m1_316800_460800 0 1.527125e-07
I7885 n1_m1_316800_465600 0 2.337769e-07
I7886 n1_m1_316800_470400 0 1.570329e-07
I7887 n1_m1_316800_475200 0 1.534308e-07
I7888 n1_m1_316800_480000 0 2.268910e-07
I7889 n1_m1_316800_484800 0 1.484187e-07
I7890 n1_m1_316800_489600 0 2.214149e-07
I7891 n1_m1_316800_494400 0 1.470990e-07
I7892 n1_m1_316800_499200 0 1.465661e-07
I7893 n1_m1_316800_504000 0 2.198491e-07
I7894 n1_m1_316800_508800 0 1.421918e-07
I7895 n1_m1_316800_513600 0 2.160248e-07
I7896 n1_m1_316800_518400 0 1.464190e-07
I7897 n1_m1_316800_523200 0 1.467349e-07
I7898 n1_m1_316800_528000 0 2.254442e-07
I7899 n1_m1_316800_532800 0 1.484426e-07
I7900 n1_m1_316800_537600 0 2.325305e-07
I7901 n1_m1_316800_542400 0 3.280950e-07
I7902 n1_m1_316800_547200 0 5.691673e-07
I7903 n1_m1_316800_552000 0 7.262633e-07
I7904 n1_m1_316800_556800 0 2.264067e-07
I7905 n1_m1_316800_561600 0 1.030110e-07
I7906 n1_m1_321600_0 0 4.528983e-07
I7907 n1_m1_321600_4800 0 7.841361e-07
I7908 n1_m1_321600_9600 0 1.564824e-06
I7909 n1_m1_321600_14400 0 6.707897e-07
I7910 n1_m1_321600_19200 0 2.959428e-07
I7911 n1_m1_321600_24000 0 3.307872e-07
I7912 n1_m1_321600_28800 0 2.071817e-07
I7913 n1_m1_321600_33600 0 3.234671e-07
I7914 n1_m1_321600_38400 0 2.291543e-07
I7915 n1_m1_321600_43200 0 2.184861e-07
I7916 n1_m1_321600_48000 0 3.247544e-07
I7917 n1_m1_321600_52800 0 2.289426e-07
I7918 n1_m1_321600_57600 0 3.675957e-07
I7919 n1_m1_321600_62400 0 2.506830e-07
I7920 n1_m1_321600_67200 0 2.509454e-07
I7921 n1_m1_321600_72000 0 3.771179e-07
I7922 n1_m1_321600_76800 0 2.321423e-07
I7923 n1_m1_321600_81600 0 3.404231e-07
I7924 n1_m1_321600_86400 0 2.271493e-07
I7925 n1_m1_321600_91200 0 2.457138e-07
I7926 n1_m1_321600_96000 0 3.683579e-07
I7927 n1_m1_321600_100800 0 3.447937e-07
I7928 n1_m1_321600_105600 0 4.548450e-07
I7929 n1_m1_321600_110400 0 2.942723e-07
I7930 n1_m1_321600_115200 0 3.846895e-07
I7931 n1_m1_321600_120000 0 1.223959e-06
I7932 n1_m1_321600_124800 0 9.426506e-07
I7933 n1_m1_321600_129600 0 2.913814e-06
I7934 n1_m1_321600_134400 0 1.964764e-06
I7935 n1_m1_321600_139200 0 1.959823e-06
I7936 n1_m1_321600_144000 0 3.045447e-06
I7937 n1_m1_321600_148800 0 1.905665e-06
I7938 n1_m1_321600_153600 0 1.993048e-06
I7939 n1_m1_321600_158400 0 1.589558e-06
I7940 n1_m1_321600_163200 0 8.143933e-07
I7941 n1_m1_321600_168000 0 1.500243e-06
I7942 n1_m1_321600_172800 0 7.372091e-07
I7943 n1_m1_321600_177600 0 1.373158e-06
I7944 n1_m1_321600_182400 0 1.206166e-06
I7945 n1_m1_321600_187200 0 7.999827e-07
I7946 n1_m1_321600_192000 0 9.555957e-07
I7947 n1_m1_321600_196800 0 7.477330e-07
I7948 n1_m1_321600_201600 0 1.135431e-06
I7949 n1_m1_321600_206400 0 8.226317e-07
I7950 n1_m1_321600_211200 0 6.210852e-07
I7951 n1_m1_321600_216000 0 9.390992e-07
I7952 n1_m1_321600_220800 0 6.963013e-07
I7953 n1_m1_321600_225600 0 1.485668e-06
I7954 n1_m1_321600_230400 0 1.313594e-06
I7955 n1_m1_321600_235200 0 1.723798e-06
I7956 n1_m1_321600_240000 0 2.350235e-06
I7957 n1_m1_321600_244800 0 1.597289e-06
I7958 n1_m1_321600_249600 0 2.430043e-06
I7959 n1_m1_321600_254400 0 1.730833e-06
I7960 n1_m1_321600_259200 0 1.443107e-06
I7961 n1_m1_321600_264000 0 1.726728e-06
I7962 n1_m1_321600_268800 0 7.247821e-07
I7963 n1_m1_321600_273600 0 1.931917e-06
I7964 n1_m1_321600_278400 0 8.913422e-07
I7965 n1_m1_321600_283200 0 1.183660e-06
I7966 n1_m1_321600_288000 0 2.757815e-06
I7967 n1_m1_321600_292800 0 1.820627e-06
I7968 n1_m1_321600_297600 0 2.980945e-06
I7969 n1_m1_321600_302400 0 1.962319e-06
I7970 n1_m1_321600_307200 0 1.681282e-06
I7971 n1_m1_321600_312000 0 2.308740e-06
I7972 n1_m1_321600_316800 0 1.211185e-06
I7973 n1_m1_321600_321600 0 1.125712e-06
I7974 n1_m1_321600_326400 0 1.323745e-06
I7975 n1_m1_321600_331200 0 1.207080e-06
I7976 n1_m1_321600_336000 0 1.341605e-06
I7977 n1_m1_321600_340800 0 9.423798e-07
I7978 n1_m1_321600_345600 0 1.021079e-06
I7979 n1_m1_321600_350400 0 6.733104e-07
I7980 n1_m1_321600_355200 0 6.149503e-07
I7981 n1_m1_321600_360000 0 8.286237e-07
I7982 n1_m1_321600_364800 0 3.312221e-07
I7983 n1_m1_321600_369600 0 5.432732e-07
I7984 n1_m1_321600_374400 0 2.632350e-07
I7985 n1_m1_321600_379200 0 2.656207e-07
I7986 n1_m1_321600_384000 0 3.891924e-07
I7987 n1_m1_321600_388800 0 2.502075e-07
I7988 n1_m1_321600_393600 0 3.927035e-07
I7989 n1_m1_321600_398400 0 2.575628e-07
I7990 n1_m1_321600_403200 0 2.650426e-07
I7991 n1_m1_321600_408000 0 4.796849e-07
I7992 n1_m1_321600_412800 0 2.983910e-07
I7993 n1_m1_321600_417600 0 3.710597e-07
I7994 n1_m1_321600_422400 0 2.291488e-07
I7995 n1_m1_321600_427200 0 2.210849e-07
I7996 n1_m1_321600_432000 0 3.297737e-07
I7997 n1_m1_321600_436800 0 2.198491e-07
I7998 n1_m1_321600_441600 0 3.305844e-07
I7999 n1_m1_321600_446400 0 2.200996e-07
I8000 n1_m1_321600_451200 0 2.156016e-07
I8001 n1_m1_321600_456000 0 3.253016e-07
I8002 n1_m1_321600_460800 0 2.211471e-07
I8003 n1_m1_321600_465600 0 3.317207e-07
I8004 n1_m1_321600_470400 0 2.209227e-07
I8005 n1_m1_321600_475200 0 2.194992e-07
I8006 n1_m1_321600_480000 0 3.284242e-07
I8007 n1_m1_321600_484800 0 2.179174e-07
I8008 n1_m1_321600_489600 0 3.279291e-07
I8009 n1_m1_321600_494400 0 2.198491e-07
I8010 n1_m1_321600_499200 0 2.198491e-07
I8011 n1_m1_321600_504000 0 3.297737e-07
I8012 n1_m1_321600_508800 0 2.132878e-07
I8013 n1_m1_321600_513600 0 3.254528e-07
I8014 n1_m1_321600_518400 0 2.198491e-07
I8015 n1_m1_321600_523200 0 2.196506e-07
I8016 n1_m1_321600_528000 0 3.229384e-07
I8017 n1_m1_321600_532800 0 2.136102e-07
I8018 n1_m1_321600_537600 0 3.302083e-07
I8019 n1_m1_321600_542400 0 3.926345e-07
I8020 n1_m1_321600_547200 0 6.742485e-07
I8021 n1_m1_321600_552000 0 8.873481e-07
I8022 n1_m1_321600_556800 0 2.861889e-07
I8023 n1_m1_321600_561600 0 1.358179e-07
I8024 n1_m1_326400_0 0 2.621328e-07
I8025 n1_m1_326400_4800 0 4.891839e-07
I8026 n1_m1_326400_9600 0 1.059371e-06
I8027 n1_m1_326400_14400 0 4.560808e-07
I8028 n1_m1_326400_19200 0 1.981914e-07
I8029 n1_m1_326400_24000 0 2.211322e-07
I8030 n1_m1_326400_28800 0 1.413186e-07
I8031 n1_m1_326400_33600 0 2.203607e-07
I8032 n1_m1_326400_38400 0 1.492092e-07
I8033 n1_m1_326400_43200 0 1.431297e-07
I8034 n1_m1_326400_48000 0 2.164529e-07
I8035 n1_m1_326400_52800 0 1.518897e-07
I8036 n1_m1_326400_57600 0 2.390079e-07
I8037 n1_m1_326400_62400 0 1.647230e-07
I8038 n1_m1_326400_67200 0 1.644198e-07
I8039 n1_m1_326400_72000 0 2.389710e-07
I8040 n1_m1_326400_76800 0 1.591366e-07
I8041 n1_m1_326400_81600 0 2.343479e-07
I8042 n1_m1_326400_86400 0 1.550726e-07
I8043 n1_m1_326400_91200 0 1.698391e-07
I8044 n1_m1_326400_96000 0 2.520662e-07
I8045 n1_m1_326400_100800 0 2.021900e-07
I8046 n1_m1_326400_105600 0 3.206275e-07
I8047 n1_m1_326400_110400 0 2.731469e-07
I8048 n1_m1_326400_115200 0 3.802501e-07
I8049 n1_m1_326400_120000 0 8.756958e-07
I8050 n1_m1_326400_124800 0 7.423867e-07
I8051 n1_m1_326400_129600 0 1.690294e-06
I8052 n1_m1_326400_134400 0 1.118095e-06
I8053 n1_m1_326400_139200 0 1.271297e-06
I8054 n1_m1_326400_144000 0 2.075977e-06
I8055 n1_m1_326400_148800 0 1.287746e-06
I8056 n1_m1_326400_153600 0 1.702377e-06
I8057 n1_m1_326400_158400 0 1.113675e-06
I8058 n1_m1_326400_163200 0 5.226271e-07
I8059 n1_m1_326400_168000 0 1.158028e-06
I8060 n1_m1_326400_172800 0 3.485349e-07
I8061 n1_m1_326400_177600 0 8.561180e-07
I8062 n1_m1_326400_182400 0 8.598375e-07
I8063 n1_m1_326400_187200 0 6.054534e-07
I8064 n1_m1_326400_192000 0 9.026257e-07
I8065 n1_m1_326400_196800 0 7.339681e-07
I8066 n1_m1_326400_201600 0 1.082700e-06
I8067 n1_m1_326400_206400 0 9.344271e-07
I8068 n1_m1_326400_211200 0 4.476699e-07
I8069 n1_m1_326400_216000 0 6.697991e-07
I8070 n1_m1_326400_220800 0 6.609942e-07
I8071 n1_m1_326400_225600 0 8.293277e-07
I8072 n1_m1_326400_230400 0 1.078452e-06
I8073 n1_m1_326400_235200 0 1.117631e-06
I8074 n1_m1_326400_240000 0 1.073790e-06
I8075 n1_m1_326400_244800 0 8.873507e-07
I8076 n1_m1_326400_249600 0 1.770601e-06
I8077 n1_m1_326400_254400 0 1.295169e-06
I8078 n1_m1_326400_259200 0 1.228860e-06
I8079 n1_m1_326400_264000 0 1.601481e-06
I8080 n1_m1_326400_268800 0 6.527725e-07
I8081 n1_m1_326400_273600 0 1.012539e-06
I8082 n1_m1_326400_278400 0 5.398092e-07
I8083 n1_m1_326400_283200 0 7.521982e-07
I8084 n1_m1_326400_288000 0 1.576845e-06
I8085 n1_m1_326400_292800 0 1.104044e-06
I8086 n1_m1_326400_297600 0 1.974643e-06
I8087 n1_m1_326400_302400 0 1.318683e-06
I8088 n1_m1_326400_307200 0 1.259133e-06
I8089 n1_m1_326400_312000 0 1.729723e-06
I8090 n1_m1_326400_316800 0 7.484265e-07
I8091 n1_m1_326400_321600 0 9.139235e-07
I8092 n1_m1_326400_326400 0 8.949289e-07
I8093 n1_m1_326400_331200 0 7.918953e-07
I8094 n1_m1_326400_336000 0 1.017426e-06
I8095 n1_m1_326400_340800 0 6.140523e-07
I8096 n1_m1_326400_345600 0 6.899157e-07
I8097 n1_m1_326400_350400 0 6.862733e-07
I8098 n1_m1_326400_355200 0 5.577839e-07
I8099 n1_m1_326400_360000 0 4.974479e-07
I8100 n1_m1_326400_364800 0 2.298718e-07
I8101 n1_m1_326400_369600 0 2.842873e-07
I8102 n1_m1_326400_374400 0 1.626914e-07
I8103 n1_m1_326400_379200 0 1.873127e-07
I8104 n1_m1_326400_384000 0 2.884299e-07
I8105 n1_m1_326400_388800 0 1.752772e-07
I8106 n1_m1_326400_393600 0 2.869548e-07
I8107 n1_m1_326400_398400 0 1.864114e-07
I8108 n1_m1_326400_403200 0 1.988307e-07
I8109 n1_m1_326400_408000 0 4.045517e-07
I8110 n1_m1_326400_412800 0 2.249246e-07
I8111 n1_m1_326400_417600 0 2.516103e-07
I8112 n1_m1_326400_422400 0 1.552044e-07
I8113 n1_m1_326400_427200 0 1.488584e-07
I8114 n1_m1_326400_432000 0 2.200913e-07
I8115 n1_m1_326400_436800 0 1.465661e-07
I8116 n1_m1_326400_441600 0 2.198491e-07
I8117 n1_m1_326400_446400 0 1.438106e-07
I8118 n1_m1_326400_451200 0 1.407436e-07
I8119 n1_m1_326400_456000 0 2.155697e-07
I8120 n1_m1_326400_460800 0 1.465661e-07
I8121 n1_m1_326400_465600 0 2.196197e-07
I8122 n1_m1_326400_470400 0 1.446981e-07
I8123 n1_m1_326400_475200 0 1.407912e-07
I8124 n1_m1_326400_480000 0 2.099715e-07
I8125 n1_m1_326400_484800 0 1.399810e-07
I8126 n1_m1_326400_489600 0 2.136390e-07
I8127 n1_m1_326400_494400 0 1.465661e-07
I8128 n1_m1_326400_499200 0 1.460202e-07
I8129 n1_m1_326400_504000 0 2.188073e-07
I8130 n1_m1_326400_508800 0 1.421918e-07
I8131 n1_m1_326400_513600 0 2.169685e-07
I8132 n1_m1_326400_518400 0 1.465661e-07
I8133 n1_m1_326400_523200 0 1.465633e-07
I8134 n1_m1_326400_528000 0 2.200688e-07
I8135 n1_m1_326400_532800 0 1.464471e-07
I8136 n1_m1_326400_537600 0 2.178965e-07
I8137 n1_m1_326400_542400 0 2.329180e-07
I8138 n1_m1_326400_547200 0 3.871279e-07
I8139 n1_m1_326400_552000 0 5.344602e-07
I8140 n1_m1_326400_556800 0 1.884136e-07
I8141 n1_m1_326400_561600 0 9.050295e-08
I8142 n1_m1_331200_0 0 2.598537e-07
I8143 n1_m1_331200_4800 0 4.817780e-07
I8144 n1_m1_331200_9600 0 1.076067e-06
I8145 n1_m1_331200_14400 0 4.647010e-07
I8146 n1_m1_331200_19200 0 1.990799e-07
I8147 n1_m1_331200_24000 0 2.231768e-07
I8148 n1_m1_331200_28800 0 1.458120e-07
I8149 n1_m1_331200_33600 0 2.233584e-07
I8150 n1_m1_331200_38400 0 1.491622e-07
I8151 n1_m1_331200_43200 0 1.430928e-07
I8152 n1_m1_331200_48000 0 2.163867e-07
I8153 n1_m1_331200_52800 0 1.509900e-07
I8154 n1_m1_331200_57600 0 2.364856e-07
I8155 n1_m1_331200_62400 0 1.599749e-07
I8156 n1_m1_331200_67200 0 1.590325e-07
I8157 n1_m1_331200_72000 0 2.342732e-07
I8158 n1_m1_331200_76800 0 1.554889e-07
I8159 n1_m1_331200_81600 0 2.439879e-07
I8160 n1_m1_331200_86400 0 1.599742e-07
I8161 n1_m1_331200_91200 0 1.612394e-07
I8162 n1_m1_331200_96000 0 2.745262e-07
I8163 n1_m1_331200_100800 0 4.605648e-07
I8164 n1_m1_331200_105600 0 6.645267e-07
I8165 n1_m1_331200_110400 0 4.495308e-07
I8166 n1_m1_331200_115200 0 4.408325e-07
I8167 n1_m1_331200_120000 0 1.173727e-06
I8168 n1_m1_331200_124800 0 6.647625e-07
I8169 n1_m1_331200_129600 0 1.052747e-06
I8170 n1_m1_331200_134400 0 9.858005e-07
I8171 n1_m1_331200_139200 0 1.345820e-06
I8172 n1_m1_331200_144000 0 2.020977e-06
I8173 n1_m1_331200_148800 0 1.083509e-06
I8174 n1_m1_331200_153600 0 1.150762e-06
I8175 n1_m1_331200_158400 0 1.041637e-06
I8176 n1_m1_331200_163200 0 7.758192e-07
I8177 n1_m1_331200_168000 0 8.428426e-07
I8178 n1_m1_331200_172800 0 5.777897e-07
I8179 n1_m1_331200_177600 0 4.611807e-07
I8180 n1_m1_331200_182400 0 3.131865e-07
I8181 n1_m1_331200_187200 0 4.584395e-07
I8182 n1_m1_331200_192000 0 1.452646e-06
I8183 n1_m1_331200_196800 0 1.016346e-06
I8184 n1_m1_331200_201600 0 1.086821e-06
I8185 n1_m1_331200_206400 0 8.633789e-07
I8186 n1_m1_331200_211200 0 5.461139e-07
I8187 n1_m1_331200_216000 0 8.490272e-07
I8188 n1_m1_331200_220800 0 5.903320e-07
I8189 n1_m1_331200_225600 0 1.229309e-06
I8190 n1_m1_331200_230400 0 9.020756e-07
I8191 n1_m1_331200_235200 0 5.850692e-07
I8192 n1_m1_331200_240000 0 1.323320e-06
I8193 n1_m1_331200_244800 0 1.238186e-06
I8194 n1_m1_331200_249600 0 1.741740e-06
I8195 n1_m1_331200_254400 0 1.133769e-06
I8196 n1_m1_331200_259200 0 1.124367e-06
I8197 n1_m1_331200_264000 0 1.694864e-06
I8198 n1_m1_331200_268800 0 8.402159e-07
I8199 n1_m1_331200_273600 0 7.559011e-07
I8200 n1_m1_331200_278400 0 6.398723e-07
I8201 n1_m1_331200_283200 0 5.032532e-07
I8202 n1_m1_331200_288000 0 9.012812e-07
I8203 n1_m1_331200_292800 0 1.052517e-06
I8204 n1_m1_331200_297600 0 2.023488e-06
I8205 n1_m1_331200_302400 0 1.251388e-06
I8206 n1_m1_331200_307200 0 1.214640e-06
I8207 n1_m1_331200_312000 0 1.527793e-06
I8208 n1_m1_331200_316800 0 7.270804e-07
I8209 n1_m1_331200_321600 0 9.733498e-07
I8210 n1_m1_331200_326400 0 8.564648e-07
I8211 n1_m1_331200_331200 0 9.889897e-07
I8212 n1_m1_331200_336000 0 1.018621e-06
I8213 n1_m1_331200_340800 0 5.313251e-07
I8214 n1_m1_331200_345600 0 1.024890e-06
I8215 n1_m1_331200_350400 0 8.645419e-07
I8216 n1_m1_331200_355200 0 6.175680e-07
I8217 n1_m1_331200_360000 0 6.348906e-07
I8218 n1_m1_331200_364800 0 3.267157e-07
I8219 n1_m1_331200_369600 0 3.234439e-07
I8220 n1_m1_331200_374400 0 1.787298e-07
I8221 n1_m1_331200_379200 0 2.452978e-07
I8222 n1_m1_331200_384000 0 3.538618e-07
I8223 n1_m1_331200_388800 0 1.957920e-07
I8224 n1_m1_331200_393600 0 3.644011e-07
I8225 n1_m1_331200_398400 0 2.259230e-07
I8226 n1_m1_331200_403200 0 2.252486e-07
I8227 n1_m1_331200_408000 0 3.993308e-07
I8228 n1_m1_331200_412800 0 2.081167e-07
I8229 n1_m1_331200_417600 0 2.488890e-07
I8230 n1_m1_331200_422400 0 1.634130e-07
I8231 n1_m1_331200_427200 0 1.538017e-07
I8232 n1_m1_331200_432000 0 2.209065e-07
I8233 n1_m1_331200_436800 0 1.465661e-07
I8234 n1_m1_331200_441600 0 2.198491e-07
I8235 n1_m1_331200_446400 0 1.457534e-07
I8236 n1_m1_331200_451200 0 1.427510e-07
I8237 n1_m1_331200_456000 0 2.155697e-07
I8238 n1_m1_331200_460800 0 1.465661e-07
I8239 n1_m1_331200_465600 0 2.190298e-07
I8240 n1_m1_331200_470400 0 1.419598e-07
I8241 n1_m1_331200_475200 0 1.411067e-07
I8242 n1_m1_331200_480000 0 2.115719e-07
I8243 n1_m1_331200_484800 0 1.408087e-07
I8244 n1_m1_331200_489600 0 2.136386e-07
I8245 n1_m1_331200_494400 0 1.465661e-07
I8246 n1_m1_331200_499200 0 1.441826e-07
I8247 n1_m1_331200_504000 0 2.153004e-07
I8248 n1_m1_331200_508800 0 1.421918e-07
I8249 n1_m1_331200_513600 0 2.169685e-07
I8250 n1_m1_331200_518400 0 1.465661e-07
I8251 n1_m1_331200_523200 0 1.465243e-07
I8252 n1_m1_331200_528000 0 2.197940e-07
I8253 n1_m1_331200_532800 0 1.493114e-07
I8254 n1_m1_331200_537600 0 2.205980e-07
I8255 n1_m1_331200_542400 0 2.384676e-07
I8256 n1_m1_331200_547200 0 3.838492e-07
I8257 n1_m1_331200_552000 0 5.098043e-07
I8258 n1_m1_331200_556800 0 1.847606e-07
I8259 n1_m1_331200_561600 0 8.891991e-08
I8260 n1_m1_336000_0 0 4.365291e-07
I8261 n1_m1_336000_4800 0 8.157534e-07
I8262 n1_m1_336000_9600 0 1.700090e-06
I8263 n1_m1_336000_14400 0 7.217274e-07
I8264 n1_m1_336000_19200 0 2.987208e-07
I8265 n1_m1_336000_24000 0 3.345812e-07
I8266 n1_m1_336000_28800 0 2.178158e-07
I8267 n1_m1_336000_33600 0 3.319976e-07
I8268 n1_m1_336000_38400 0 2.237432e-07
I8269 n1_m1_336000_43200 0 2.146392e-07
I8270 n1_m1_336000_48000 0 3.241401e-07
I8271 n1_m1_336000_52800 0 2.205086e-07
I8272 n1_m1_336000_57600 0 3.440712e-07
I8273 n1_m1_336000_62400 0 2.352311e-07
I8274 n1_m1_336000_67200 0 2.331474e-07
I8275 n1_m1_336000_72000 0 3.606999e-07
I8276 n1_m1_336000_76800 0 2.257067e-07
I8277 n1_m1_336000_81600 0 3.557083e-07
I8278 n1_m1_336000_86400 0 2.426567e-07
I8279 n1_m1_336000_91200 0 2.989012e-07
I8280 n1_m1_336000_96000 0 8.242585e-07
I8281 n1_m1_336000_100800 0 1.509443e-06
I8282 n1_m1_336000_105600 0 2.035230e-06
I8283 n1_m1_336000_110400 0 7.580291e-07
I8284 n1_m1_336000_115200 0 6.847726e-07
I8285 n1_m1_336000_120000 0 1.782559e-06
I8286 n1_m1_336000_124800 0 1.103854e-06
I8287 n1_m1_336000_129600 0 1.912354e-06
I8288 n1_m1_336000_134400 0 1.476815e-06
I8289 n1_m1_336000_139200 0 1.744057e-06
I8290 n1_m1_336000_144000 0 2.325257e-06
I8291 n1_m1_336000_148800 0 9.511089e-07
I8292 n1_m1_336000_153600 0 1.306496e-06
I8293 n1_m1_336000_158400 0 1.464423e-06
I8294 n1_m1_336000_163200 0 9.704467e-07
I8295 n1_m1_336000_168000 0 1.596912e-06
I8296 n1_m1_336000_172800 0 6.601216e-07
I8297 n1_m1_336000_177600 0 6.715759e-07
I8298 n1_m1_336000_182400 0 4.361852e-07
I8299 n1_m1_336000_187200 0 8.359632e-07
I8300 n1_m1_336000_192000 0 1.996984e-06
I8301 n1_m1_336000_196800 0 9.501914e-07
I8302 n1_m1_336000_201600 0 1.553730e-06
I8303 n1_m1_336000_206400 0 1.569144e-06
I8304 n1_m1_336000_211200 0 7.540357e-07
I8305 n1_m1_336000_216000 0 9.432886e-07
I8306 n1_m1_336000_220800 0 4.723122e-07
I8307 n1_m1_336000_225600 0 9.720258e-07
I8308 n1_m1_336000_230400 0 7.360450e-07
I8309 n1_m1_336000_235200 0 8.531398e-07
I8310 n1_m1_336000_240000 0 2.016746e-06
I8311 n1_m1_336000_244800 0 1.592863e-06
I8312 n1_m1_336000_249600 0 1.650758e-06
I8313 n1_m1_336000_254400 0 1.043709e-06
I8314 n1_m1_336000_259200 0 1.068237e-06
I8315 n1_m1_336000_264000 0 1.465561e-06
I8316 n1_m1_336000_268800 0 5.678377e-07
I8317 n1_m1_336000_273600 0 8.241787e-07
I8318 n1_m1_336000_278400 0 6.888420e-07
I8319 n1_m1_336000_283200 0 6.061099e-07
I8320 n1_m1_336000_288000 0 9.662649e-07
I8321 n1_m1_336000_292800 0 1.175146e-06
I8322 n1_m1_336000_297600 0 2.454166e-06
I8323 n1_m1_336000_302400 0 1.264523e-06
I8324 n1_m1_336000_307200 0 1.155422e-06
I8325 n1_m1_336000_312000 0 1.484631e-06
I8326 n1_m1_336000_316800 0 7.739414e-07
I8327 n1_m1_336000_321600 0 8.334971e-07
I8328 n1_m1_336000_326400 0 8.374613e-07
I8329 n1_m1_336000_331200 0 1.169461e-06
I8330 n1_m1_336000_336000 0 9.923501e-07
I8331 n1_m1_336000_340800 0 6.080323e-07
I8332 n1_m1_336000_345600 0 1.339898e-06
I8333 n1_m1_336000_350400 0 9.631813e-07
I8334 n1_m1_336000_355200 0 7.008952e-07
I8335 n1_m1_336000_360000 0 1.105239e-06
I8336 n1_m1_336000_364800 0 5.484486e-07
I8337 n1_m1_336000_369600 0 4.863829e-07
I8338 n1_m1_336000_374400 0 2.535113e-07
I8339 n1_m1_336000_379200 0 2.965674e-07
I8340 n1_m1_336000_384000 0 3.843920e-07
I8341 n1_m1_336000_388800 0 2.730963e-07
I8342 n1_m1_336000_393600 0 5.256919e-07
I8343 n1_m1_336000_398400 0 3.506666e-07
I8344 n1_m1_336000_403200 0 3.263951e-07
I8345 n1_m1_336000_408000 0 5.340287e-07
I8346 n1_m1_336000_412800 0 3.156530e-07
I8347 n1_m1_336000_417600 0 3.846288e-07
I8348 n1_m1_336000_422400 0 2.411375e-07
I8349 n1_m1_336000_427200 0 2.276639e-07
I8350 n1_m1_336000_432000 0 3.266352e-07
I8351 n1_m1_336000_436800 0 2.166366e-07
I8352 n1_m1_336000_441600 0 3.249549e-07
I8353 n1_m1_336000_446400 0 2.133637e-07
I8354 n1_m1_336000_451200 0 2.102266e-07
I8355 n1_m1_336000_456000 0 3.261098e-07
I8356 n1_m1_336000_460800 0 2.230616e-07
I8357 n1_m1_336000_465600 0 3.308388e-07
I8358 n1_m1_336000_470400 0 2.192550e-07
I8359 n1_m1_336000_475200 0 2.191793e-07
I8360 n1_m1_336000_480000 0 3.287690e-07
I8361 n1_m1_336000_484800 0 2.179017e-07
I8362 n1_m1_336000_489600 0 3.237651e-07
I8363 n1_m1_336000_494400 0 2.198491e-07
I8364 n1_m1_336000_499200 0 2.160617e-07
I8365 n1_m1_336000_504000 0 3.200504e-07
I8366 n1_m1_336000_508800 0 2.121845e-07
I8367 n1_m1_336000_513600 0 3.254528e-07
I8368 n1_m1_336000_518400 0 2.198491e-07
I8369 n1_m1_336000_523200 0 2.195090e-07
I8370 n1_m1_336000_528000 0 3.209633e-07
I8371 n1_m1_336000_532800 0 2.211693e-07
I8372 n1_m1_336000_537600 0 3.353064e-07
I8373 n1_m1_336000_542400 0 3.543208e-07
I8374 n1_m1_336000_547200 0 5.442250e-07
I8375 n1_m1_336000_552000 0 6.792255e-07
I8376 n1_m1_336000_556800 0 2.531168e-07
I8377 n1_m1_336000_561600 0 1.233975e-07
I8378 n1_m1_340800_0 0 1.188968e-07
I8379 n1_m1_340800_4800 0 2.062246e-07
I8380 n1_m1_340800_9600 0 4.373237e-07
I8381 n1_m1_340800_14400 0 1.861282e-07
I8382 n1_m1_340800_19200 0 9.067169e-08
I8383 n1_m1_340800_24000 0 1.118333e-07
I8384 n1_m1_340800_28800 0 7.535160e-08
I8385 n1_m1_340800_33600 0 1.139204e-07
I8386 n1_m1_340800_38400 0 7.458108e-08
I8387 n1_m1_340800_43200 0 7.154639e-08
I8388 n1_m1_340800_48000 0 1.079142e-07
I8389 n1_m1_340800_52800 0 7.170245e-08
I8390 n1_m1_340800_57600 0 1.112589e-07
I8391 n1_m1_340800_62400 0 7.645765e-08
I8392 n1_m1_340800_67200 0 7.616871e-08
I8393 n1_m1_340800_72000 0 1.115937e-07
I8394 n1_m1_340800_76800 0 7.868265e-08
I8395 n1_m1_340800_81600 0 1.146132e-07
I8396 n1_m1_340800_86400 0 9.623084e-08
I8397 n1_m1_340800_91200 0 2.344233e-07
I8398 n1_m1_340800_96000 0 5.678534e-07
I8399 n1_m1_340800_100800 0 3.896918e-07
I8400 n1_m1_340800_105600 0 4.970583e-07
I8401 n1_m1_340800_110400 0 5.233347e-07
I8402 n1_m1_340800_115200 0 3.026127e-07
I8403 n1_m1_340800_120000 0 5.988897e-07
I8404 n1_m1_340800_124800 0 4.758832e-07
I8405 n1_m1_340800_129600 0 7.103032e-07
I8406 n1_m1_340800_134400 0 5.266276e-07
I8407 n1_m1_340800_139200 0 5.200973e-07
I8408 n1_m1_340800_144000 0 9.692855e-07
I8409 n1_m1_340800_148800 0 5.799728e-07
I8410 n1_m1_340800_153600 0 4.938826e-07
I8411 n1_m1_340800_158400 0 4.598907e-07
I8412 n1_m1_340800_163200 0 5.435464e-07
I8413 n1_m1_340800_168000 0 7.342206e-07
I8414 n1_m1_340800_172800 0 4.340562e-07
I8415 n1_m1_340800_177600 0 4.115226e-07
I8416 n1_m1_340800_182400 0 2.332538e-07
I8417 n1_m1_340800_187200 0 2.418353e-07
I8418 n1_m1_340800_192000 0 2.598463e-07
I8419 n1_m1_340800_196800 0 4.049538e-07
I8420 n1_m1_340800_201600 0 6.392101e-07
I8421 n1_m1_340800_206400 0 4.005419e-07
I8422 n1_m1_340800_211200 0 3.913795e-07
I8423 n1_m1_340800_216000 0 6.737524e-07
I8424 n1_m1_340800_220800 0 3.589876e-07
I8425 n1_m1_340800_225600 0 6.532469e-07
I8426 n1_m1_340800_230400 0 4.850408e-07
I8427 n1_m1_340800_235200 0 4.343157e-07
I8428 n1_m1_340800_240000 0 8.427084e-07
I8429 n1_m1_340800_244800 0 4.067652e-07
I8430 n1_m1_340800_249600 0 7.465361e-07
I8431 n1_m1_340800_254400 0 4.717186e-07
I8432 n1_m1_340800_259200 0 2.423341e-07
I8433 n1_m1_340800_264000 0 4.371955e-07
I8434 n1_m1_340800_268800 0 3.640784e-07
I8435 n1_m1_340800_273600 0 2.532045e-07
I8436 n1_m1_340800_278400 0 1.616241e-07
I8437 n1_m1_340800_283200 0 1.603497e-07
I8438 n1_m1_340800_288000 0 3.042540e-07
I8439 n1_m1_340800_292800 0 3.349092e-07
I8440 n1_m1_340800_297600 0 5.450470e-07
I8441 n1_m1_340800_302400 0 5.437647e-07
I8442 n1_m1_340800_307200 0 5.704842e-07
I8443 n1_m1_340800_312000 0 7.243102e-07
I8444 n1_m1_340800_316800 0 4.721233e-07
I8445 n1_m1_340800_321600 0 6.742699e-07
I8446 n1_m1_340800_326400 0 4.480050e-07
I8447 n1_m1_340800_331200 0 5.650222e-07
I8448 n1_m1_340800_336000 0 6.335970e-07
I8449 n1_m1_340800_340800 0 3.962311e-07
I8450 n1_m1_340800_345600 0 5.088382e-07
I8451 n1_m1_340800_350400 0 3.473212e-07
I8452 n1_m1_340800_355200 0 3.694179e-07
I8453 n1_m1_340800_360000 0 4.875802e-07
I8454 n1_m1_340800_364800 0 1.459816e-07
I8455 n1_m1_340800_369600 0 1.432290e-07
I8456 n1_m1_340800_374400 0 8.171138e-08
I8457 n1_m1_340800_379200 0 8.913823e-08
I8458 n1_m1_340800_384000 0 1.280372e-07
I8459 n1_m1_340800_388800 0 8.185198e-08
I8460 n1_m1_340800_393600 0 1.354195e-07
I8461 n1_m1_340800_398400 0 9.516928e-08
I8462 n1_m1_340800_403200 0 1.152539e-07
I8463 n1_m1_340800_408000 0 2.537183e-07
I8464 n1_m1_340800_412800 0 1.579591e-07
I8465 n1_m1_340800_417600 0 1.464854e-07
I8466 n1_m1_340800_422400 0 7.660310e-08
I8467 n1_m1_340800_427200 0 7.175080e-08
I8468 n1_m1_340800_432000 0 1.051403e-07
I8469 n1_m1_340800_436800 0 6.995199e-08
I8470 n1_m1_340800_441600 0 1.062199e-07
I8471 n1_m1_340800_446400 0 7.091266e-08
I8472 n1_m1_340800_451200 0 6.995199e-08
I8473 n1_m1_340800_456000 0 1.106417e-07
I8474 n1_m1_340800_460800 0 7.661408e-08
I8475 n1_m1_340800_465600 0 1.111396e-07
I8476 n1_m1_340800_470400 0 7.328303e-08
I8477 n1_m1_340800_475200 0 7.328303e-08
I8478 n1_m1_340800_480000 0 1.099246e-07
I8479 n1_m1_340800_484800 0 7.328303e-08
I8480 n1_m1_340800_489600 0 1.099246e-07
I8481 n1_m1_340800_494400 0 7.328303e-08
I8482 n1_m1_340800_499200 0 7.202056e-08
I8483 n1_m1_340800_504000 0 1.049280e-07
I8484 n1_m1_340800_508800 0 6.995199e-08
I8485 n1_m1_340800_513600 0 1.084843e-07
I8486 n1_m1_340800_518400 0 7.328303e-08
I8487 n1_m1_340800_523200 0 7.316153e-08
I8488 n1_m1_340800_528000 0 1.076586e-07
I8489 n1_m1_340800_532800 0 7.727799e-08
I8490 n1_m1_340800_537600 0 1.153381e-07
I8491 n1_m1_340800_542400 0 1.118300e-07
I8492 n1_m1_340800_547200 0 1.618581e-07
I8493 n1_m1_340800_552000 0 2.071674e-07
I8494 n1_m1_340800_556800 0 8.527095e-08
I8495 n1_m1_340800_561600 0 4.208555e-08
I8496 n1_m1_345600_0 0 3.642215e-07
I8497 n1_m1_345600_4800 0 6.168186e-07
I8498 n1_m1_345600_9600 0 1.227089e-06
I8499 n1_m1_345600_14400 0 5.125364e-07
I8500 n1_m1_345600_19200 0 2.683623e-07
I8501 n1_m1_345600_24000 0 3.350550e-07
I8502 n1_m1_345600_28800 0 2.227566e-07
I8503 n1_m1_345600_33600 0 3.363343e-07
I8504 n1_m1_345600_38400 0 2.237432e-07
I8505 n1_m1_345600_43200 0 2.146392e-07
I8506 n1_m1_345600_48000 0 3.188738e-07
I8507 n1_m1_345600_52800 0 2.109920e-07
I8508 n1_m1_345600_57600 0 3.288401e-07
I8509 n1_m1_345600_62400 0 2.290865e-07
I8510 n1_m1_345600_67200 0 2.305524e-07
I8511 n1_m1_345600_72000 0 3.510103e-07
I8512 n1_m1_345600_76800 0 2.320213e-07
I8513 n1_m1_345600_81600 0 3.670042e-07
I8514 n1_m1_345600_86400 0 3.522541e-07
I8515 n1_m1_345600_91200 0 6.584913e-07
I8516 n1_m1_345600_96000 0 1.244736e-06
I8517 n1_m1_345600_100800 0 8.278793e-07
I8518 n1_m1_345600_105600 0 1.395277e-06
I8519 n1_m1_345600_110400 0 1.242967e-06
I8520 n1_m1_345600_115200 0 1.025605e-06
I8521 n1_m1_345600_120000 0 1.672190e-06
I8522 n1_m1_345600_124800 0 1.397949e-06
I8523 n1_m1_345600_129600 0 2.362261e-06
I8524 n1_m1_345600_134400 0 1.730250e-06
I8525 n1_m1_345600_139200 0 1.806720e-06
I8526 n1_m1_345600_144000 0 2.991410e-06
I8527 n1_m1_345600_148800 0 1.963012e-06
I8528 n1_m1_345600_153600 0 2.197880e-06
I8529 n1_m1_345600_158400 0 1.557295e-06
I8530 n1_m1_345600_163200 0 1.405057e-06
I8531 n1_m1_345600_168000 0 2.498049e-06
I8532 n1_m1_345600_172800 0 1.254091e-06
I8533 n1_m1_345600_177600 0 1.769514e-06
I8534 n1_m1_345600_182400 0 8.991901e-07
I8535 n1_m1_345600_187200 0 5.340464e-07
I8536 n1_m1_345600_192000 0 8.009664e-07
I8537 n1_m1_345600_196800 0 9.527496e-07
I8538 n1_m1_345600_201600 0 1.492433e-06
I8539 n1_m1_345600_206400 0 1.374481e-06
I8540 n1_m1_345600_211200 0 1.490989e-06
I8541 n1_m1_345600_216000 0 2.446110e-06
I8542 n1_m1_345600_220800 0 1.589274e-06
I8543 n1_m1_345600_225600 0 2.245245e-06
I8544 n1_m1_345600_230400 0 1.743660e-06
I8545 n1_m1_345600_235200 0 1.631291e-06
I8546 n1_m1_345600_240000 0 2.742947e-06
I8547 n1_m1_345600_244800 0 1.734467e-06
I8548 n1_m1_345600_249600 0 2.529637e-06
I8549 n1_m1_345600_254400 0 1.786662e-06
I8550 n1_m1_345600_259200 0 1.173508e-06
I8551 n1_m1_345600_264000 0 1.585888e-06
I8552 n1_m1_345600_268800 0 9.242719e-07
I8553 n1_m1_345600_273600 0 6.120740e-07
I8554 n1_m1_345600_278400 0 3.530639e-07
I8555 n1_m1_345600_283200 0 3.865764e-07
I8556 n1_m1_345600_288000 0 8.747842e-07
I8557 n1_m1_345600_292800 0 8.896242e-07
I8558 n1_m1_345600_297600 0 1.865922e-06
I8559 n1_m1_345600_302400 0 1.842790e-06
I8560 n1_m1_345600_307200 0 2.061976e-06
I8561 n1_m1_345600_312000 0 2.886336e-06
I8562 n1_m1_345600_316800 0 1.867394e-06
I8563 n1_m1_345600_321600 0 2.313731e-06
I8564 n1_m1_345600_326400 0 1.719285e-06
I8565 n1_m1_345600_331200 0 1.655512e-06
I8566 n1_m1_345600_336000 0 1.894830e-06
I8567 n1_m1_345600_340800 0 1.223938e-06
I8568 n1_m1_345600_345600 0 1.638231e-06
I8569 n1_m1_345600_350400 0 1.000919e-06
I8570 n1_m1_345600_355200 0 9.626283e-07
I8571 n1_m1_345600_360000 0 1.131139e-06
I8572 n1_m1_345600_364800 0 3.458610e-07
I8573 n1_m1_345600_369600 0 4.369156e-07
I8574 n1_m1_345600_374400 0 2.403760e-07
I8575 n1_m1_345600_379200 0 2.474382e-07
I8576 n1_m1_345600_384000 0 3.713676e-07
I8577 n1_m1_345600_388800 0 2.360415e-07
I8578 n1_m1_345600_393600 0 3.620506e-07
I8579 n1_m1_345600_398400 0 2.498997e-07
I8580 n1_m1_345600_403200 0 3.251501e-07
I8581 n1_m1_345600_408000 0 8.242708e-07
I8582 n1_m1_345600_412800 0 4.910001e-07
I8583 n1_m1_345600_417600 0 4.286766e-07
I8584 n1_m1_345600_422400 0 2.291945e-07
I8585 n1_m1_345600_427200 0 2.169867e-07
I8586 n1_m1_345600_432000 0 3.227589e-07
I8587 n1_m1_345600_436800 0 2.151726e-07
I8588 n1_m1_345600_441600 0 3.290002e-07
I8589 n1_m1_345600_446400 0 2.226611e-07
I8590 n1_m1_345600_451200 0 2.181147e-07
I8591 n1_m1_345600_456000 0 3.307805e-07
I8592 n1_m1_345600_460800 0 2.245256e-07
I8593 n1_m1_345600_465600 0 3.314795e-07
I8594 n1_m1_345600_470400 0 2.198491e-07
I8595 n1_m1_345600_475200 0 2.198491e-07
I8596 n1_m1_345600_480000 0 3.282884e-07
I8597 n1_m1_345600_484800 0 2.157434e-07
I8598 n1_m1_345600_489600 0 3.294378e-07
I8599 n1_m1_345600_494400 0 2.198491e-07
I8600 n1_m1_345600_499200 0 2.160617e-07
I8601 n1_m1_345600_504000 0 3.147839e-07
I8602 n1_m1_345600_508800 0 2.098560e-07
I8603 n1_m1_345600_513600 0 3.204436e-07
I8604 n1_m1_345600_518400 0 2.186382e-07
I8605 n1_m1_345600_523200 0 2.151849e-07
I8606 n1_m1_345600_528000 0 3.146647e-07
I8607 n1_m1_345600_532800 0 2.253364e-07
I8608 n1_m1_345600_537600 0 3.326878e-07
I8609 n1_m1_345600_542400 0 2.803507e-07
I8610 n1_m1_345600_547200 0 3.684267e-07
I8611 n1_m1_345600_552000 0 5.156041e-07
I8612 n1_m1_345600_556800 0 2.495956e-07
I8613 n1_m1_345600_561600 0 1.230419e-07
I8614 n1_m1_350400_0 0 2.667743e-07
I8615 n1_m1_350400_4800 0 4.899269e-07
I8616 n1_m1_350400_9600 0 9.850767e-07
I8617 n1_m1_350400_14400 0 3.859517e-07
I8618 n1_m1_350400_19200 0 1.855940e-07
I8619 n1_m1_350400_24000 0 2.243476e-07
I8620 n1_m1_350400_28800 0 1.517924e-07
I8621 n1_m1_350400_33600 0 2.330690e-07
I8622 n1_m1_350400_38400 0 1.563588e-07
I8623 n1_m1_350400_43200 0 1.497009e-07
I8624 n1_m1_350400_48000 0 2.126511e-07
I8625 n1_m1_350400_52800 0 1.434441e-07
I8626 n1_m1_350400_57600 0 2.214016e-07
I8627 n1_m1_350400_62400 0 1.575354e-07
I8628 n1_m1_350400_67200 0 1.613756e-07
I8629 n1_m1_350400_72000 0 2.401580e-07
I8630 n1_m1_350400_76800 0 1.623210e-07
I8631 n1_m1_350400_81600 0 2.613782e-07
I8632 n1_m1_350400_86400 0 2.313620e-07
I8633 n1_m1_350400_91200 0 3.367153e-07
I8634 n1_m1_350400_96000 0 5.803203e-07
I8635 n1_m1_350400_100800 0 8.296236e-07
I8636 n1_m1_350400_105600 0 1.164914e-06
I8637 n1_m1_350400_110400 0 5.647930e-07
I8638 n1_m1_350400_115200 0 7.187502e-07
I8639 n1_m1_350400_120000 0 1.239039e-06
I8640 n1_m1_350400_124800 0 1.119323e-06
I8641 n1_m1_350400_129600 0 1.924179e-06
I8642 n1_m1_350400_134400 0 1.101307e-06
I8643 n1_m1_350400_139200 0 1.093593e-06
I8644 n1_m1_350400_144000 0 1.900296e-06
I8645 n1_m1_350400_148800 0 1.142517e-06
I8646 n1_m1_350400_153600 0 1.633233e-06
I8647 n1_m1_350400_158400 0 1.110650e-06
I8648 n1_m1_350400_163200 0 6.070130e-07
I8649 n1_m1_350400_168000 0 1.212259e-06
I8650 n1_m1_350400_172800 0 7.839587e-07
I8651 n1_m1_350400_177600 0 1.305463e-06
I8652 n1_m1_350400_182400 0 8.065262e-07
I8653 n1_m1_350400_187200 0 2.820569e-07
I8654 n1_m1_350400_192000 0 3.457487e-07
I8655 n1_m1_350400_196800 0 2.356026e-07
I8656 n1_m1_350400_201600 0 6.422248e-07
I8657 n1_m1_350400_206400 0 1.064876e-06
I8658 n1_m1_350400_211200 0 8.329375e-07
I8659 n1_m1_350400_216000 0 9.246200e-07
I8660 n1_m1_350400_220800 0 9.209294e-07
I8661 n1_m1_350400_225600 0 1.308386e-06
I8662 n1_m1_350400_230400 0 1.248604e-06
I8663 n1_m1_350400_235200 0 1.358660e-06
I8664 n1_m1_350400_240000 0 1.863627e-06
I8665 n1_m1_350400_244800 0 1.195284e-06
I8666 n1_m1_350400_249600 0 1.698589e-06
I8667 n1_m1_350400_254400 0 1.320452e-06
I8668 n1_m1_350400_259200 0 1.180348e-06
I8669 n1_m1_350400_264000 0 9.032872e-07
I8670 n1_m1_350400_268800 0 2.280474e-07
I8671 n1_m1_350400_273600 0 3.016180e-07
I8672 n1_m1_350400_278400 0 2.054934e-07
I8673 n1_m1_350400_283200 0 2.805749e-07
I8674 n1_m1_350400_288000 0 4.691482e-07
I8675 n1_m1_350400_292800 0 4.866131e-07
I8676 n1_m1_350400_297600 0 1.221665e-06
I8677 n1_m1_350400_302400 0 1.193899e-06
I8678 n1_m1_350400_307200 0 1.324627e-06
I8679 n1_m1_350400_312000 0 2.019622e-06
I8680 n1_m1_350400_316800 0 1.152978e-06
I8681 n1_m1_350400_321600 0 1.129348e-06
I8682 n1_m1_350400_326400 0 1.184865e-06
I8683 n1_m1_350400_331200 0 8.787282e-07
I8684 n1_m1_350400_336000 0 1.053582e-06
I8685 n1_m1_350400_340800 0 8.181419e-07
I8686 n1_m1_350400_345600 0 8.190261e-07
I8687 n1_m1_350400_350400 0 5.364730e-07
I8688 n1_m1_350400_355200 0 4.250800e-07
I8689 n1_m1_350400_360000 0 4.788879e-07
I8690 n1_m1_350400_364800 0 1.857913e-07
I8691 n1_m1_350400_369600 0 2.439909e-07
I8692 n1_m1_350400_374400 0 1.542365e-07
I8693 n1_m1_350400_379200 0 1.543695e-07
I8694 n1_m1_350400_384000 0 2.240448e-07
I8695 n1_m1_350400_388800 0 1.487591e-07
I8696 n1_m1_350400_393600 0 2.262519e-07
I8697 n1_m1_350400_398400 0 1.545510e-07
I8698 n1_m1_350400_403200 0 1.804448e-07
I8699 n1_m1_350400_408000 0 4.597505e-07
I8700 n1_m1_350400_412800 0 2.826562e-07
I8701 n1_m1_350400_417600 0 2.701562e-07
I8702 n1_m1_350400_422400 0 1.631194e-07
I8703 n1_m1_350400_427200 0 1.499783e-07
I8704 n1_m1_350400_432000 0 2.286520e-07
I8705 n1_m1_350400_436800 0 1.454130e-07
I8706 n1_m1_350400_441600 0 2.258111e-07
I8707 n1_m1_350400_446400 0 1.549856e-07
I8708 n1_m1_350400_451200 0 1.457837e-07
I8709 n1_m1_350400_456000 0 2.131455e-07
I8710 n1_m1_350400_460800 0 1.420970e-07
I8711 n1_m1_350400_465600 0 2.131455e-07
I8712 n1_m1_350400_470400 0 1.420970e-07
I8713 n1_m1_350400_475200 0 1.420970e-07
I8714 n1_m1_350400_480000 0 2.125329e-07
I8715 n1_m1_350400_484800 0 1.404035e-07
I8716 n1_m1_350400_489600 0 2.130070e-07
I8717 n1_m1_350400_494400 0 1.420970e-07
I8718 n1_m1_350400_499200 0 1.412658e-07
I8719 n1_m1_350400_504000 0 2.098560e-07
I8720 n1_m1_350400_508800 0 1.399040e-07
I8721 n1_m1_350400_513600 0 2.101311e-07
I8722 n1_m1_350400_518400 0 1.415975e-07
I8723 n1_m1_350400_523200 0 1.402435e-07
I8724 n1_m1_350400_528000 0 2.110111e-07
I8725 n1_m1_350400_532800 0 1.518360e-07
I8726 n1_m1_350400_537600 0 2.168155e-07
I8727 n1_m1_350400_542400 0 1.652492e-07
I8728 n1_m1_350400_547200 0 1.885615e-07
I8729 n1_m1_350400_552000 0 2.821574e-07
I8730 n1_m1_350400_556800 0 1.703813e-07
I8731 n1_m1_350400_561600 0 8.380369e-08
I8732 n1_m1_355200_0 0 2.661168e-07
I8733 n1_m1_355200_4800 0 5.003232e-07
I8734 n1_m1_355200_9600 0 1.035093e-06
I8735 n1_m1_355200_14400 0 4.036291e-07
I8736 n1_m1_355200_19200 0 1.908391e-07
I8737 n1_m1_355200_24000 0 2.327216e-07
I8738 n1_m1_355200_28800 0 1.619078e-07
I8739 n1_m1_355200_33600 0 2.456499e-07
I8740 n1_m1_355200_38400 0 1.614008e-07
I8741 n1_m1_355200_43200 0 1.549646e-07
I8742 n1_m1_355200_48000 0 2.162230e-07
I8743 n1_m1_355200_52800 0 1.451894e-07
I8744 n1_m1_355200_57600 0 2.279213e-07
I8745 n1_m1_355200_62400 0 1.685352e-07
I8746 n1_m1_355200_67200 0 1.813958e-07
I8747 n1_m1_355200_72000 0 3.404834e-07
I8748 n1_m1_355200_76800 0 3.096327e-07
I8749 n1_m1_355200_81600 0 3.672295e-07
I8750 n1_m1_355200_86400 0 3.516571e-07
I8751 n1_m1_355200_91200 0 5.815638e-07
I8752 n1_m1_355200_96000 0 8.577067e-07
I8753 n1_m1_355200_100800 0 8.187534e-07
I8754 n1_m1_355200_105600 0 1.092100e-06
I8755 n1_m1_355200_110400 0 9.016224e-07
I8756 n1_m1_355200_115200 0 1.009623e-06
I8757 n1_m1_355200_120000 0 1.609526e-06
I8758 n1_m1_355200_124800 0 1.164119e-06
I8759 n1_m1_355200_129600 0 1.597716e-06
I8760 n1_m1_355200_134400 0 9.360684e-07
I8761 n1_m1_355200_139200 0 1.008628e-06
I8762 n1_m1_355200_144000 0 1.848140e-06
I8763 n1_m1_355200_148800 0 1.001218e-06
I8764 n1_m1_355200_153600 0 1.130284e-06
I8765 n1_m1_355200_158400 0 7.775916e-07
I8766 n1_m1_355200_163200 0 7.471386e-07
I8767 n1_m1_355200_168000 0 1.500876e-06
I8768 n1_m1_355200_172800 0 9.789365e-07
I8769 n1_m1_355200_177600 0 1.421573e-06
I8770 n1_m1_355200_182400 0 6.112732e-07
I8771 n1_m1_355200_187200 0 3.707804e-07
I8772 n1_m1_355200_192000 0 6.088871e-07
I8773 n1_m1_355200_196800 0 2.697555e-07
I8774 n1_m1_355200_201600 0 5.207069e-07
I8775 n1_m1_355200_206400 0 6.223696e-07
I8776 n1_m1_355200_211200 0 4.453043e-07
I8777 n1_m1_355200_216000 0 1.006258e-06
I8778 n1_m1_355200_220800 0 1.068011e-06
I8779 n1_m1_355200_225600 0 1.673831e-06
I8780 n1_m1_355200_230400 0 1.337290e-06
I8781 n1_m1_355200_235200 0 1.376023e-06
I8782 n1_m1_355200_240000 0 2.054231e-06
I8783 n1_m1_355200_244800 0 1.259709e-06
I8784 n1_m1_355200_249600 0 1.854772e-06
I8785 n1_m1_355200_254400 0 1.294642e-06
I8786 n1_m1_355200_259200 0 1.210200e-06
I8787 n1_m1_355200_264000 0 9.046463e-07
I8788 n1_m1_355200_268800 0 3.015892e-07
I8789 n1_m1_355200_273600 0 3.048676e-07
I8790 n1_m1_355200_278400 0 1.848030e-07
I8791 n1_m1_355200_283200 0 2.351636e-07
I8792 n1_m1_355200_288000 0 5.126934e-07
I8793 n1_m1_355200_292800 0 6.750152e-07
I8794 n1_m1_355200_297600 0 1.579708e-06
I8795 n1_m1_355200_302400 0 1.283051e-06
I8796 n1_m1_355200_307200 0 1.352719e-06
I8797 n1_m1_355200_312000 0 1.984028e-06
I8798 n1_m1_355200_316800 0 1.201364e-06
I8799 n1_m1_355200_321600 0 1.611500e-06
I8800 n1_m1_355200_326400 0 1.257899e-06
I8801 n1_m1_355200_331200 0 1.096380e-06
I8802 n1_m1_355200_336000 0 1.534360e-06
I8803 n1_m1_355200_340800 0 1.102876e-06
I8804 n1_m1_355200_345600 0 1.382553e-06
I8805 n1_m1_355200_350400 0 9.513729e-07
I8806 n1_m1_355200_355200 0 6.494331e-07
I8807 n1_m1_355200_360000 0 4.581489e-07
I8808 n1_m1_355200_364800 0 1.731767e-07
I8809 n1_m1_355200_369600 0 2.408299e-07
I8810 n1_m1_355200_374400 0 1.608314e-07
I8811 n1_m1_355200_379200 0 1.581508e-07
I8812 n1_m1_355200_384000 0 2.216391e-07
I8813 n1_m1_355200_388800 0 1.465661e-07
I8814 n1_m1_355200_393600 0 2.271904e-07
I8815 n1_m1_355200_398400 0 1.617809e-07
I8816 n1_m1_355200_403200 0 1.740132e-07
I8817 n1_m1_355200_408000 0 4.248980e-07
I8818 n1_m1_355200_412800 0 2.413764e-07
I8819 n1_m1_355200_417600 0 2.621151e-07
I8820 n1_m1_355200_422400 0 1.720764e-07
I8821 n1_m1_355200_427200 0 1.555283e-07
I8822 n1_m1_355200_432000 0 2.439490e-07
I8823 n1_m1_355200_436800 0 1.525999e-07
I8824 n1_m1_355200_441600 0 2.383240e-07
I8825 n1_m1_355200_446400 0 1.636006e-07
I8826 n1_m1_355200_451200 0 1.513433e-07
I8827 n1_m1_355200_456000 0 2.181604e-07
I8828 n1_m1_355200_460800 0 1.437803e-07
I8829 n1_m1_355200_465600 0 2.206883e-07
I8830 n1_m1_355200_470400 0 1.510950e-07
I8831 n1_m1_355200_475200 0 1.512606e-07
I8832 n1_m1_355200_480000 0 2.211850e-07
I8833 n1_m1_355200_484800 0 1.430423e-07
I8834 n1_m1_355200_489600 0 2.101008e-07
I8835 n1_m1_355200_494400 0 1.399040e-07
I8836 n1_m1_355200_499200 0 1.399040e-07
I8837 n1_m1_355200_504000 0 2.098560e-07
I8838 n1_m1_355200_508800 0 1.399040e-07
I8839 n1_m1_355200_513600 0 2.098560e-07
I8840 n1_m1_355200_518400 0 1.399040e-07
I8841 n1_m1_355200_523200 0 1.399040e-07
I8842 n1_m1_355200_528000 0 2.150998e-07
I8843 n1_m1_355200_532800 0 1.583317e-07
I8844 n1_m1_355200_537600 0 2.167931e-07
I8845 n1_m1_355200_542400 0 1.642398e-07
I8846 n1_m1_355200_547200 0 1.844641e-07
I8847 n1_m1_355200_552000 0 2.717212e-07
I8848 n1_m1_355200_556800 0 1.708910e-07
I8849 n1_m1_355200_561600 0 8.405856e-08
I8850 n1_m1_360000_0 0 3.864412e-07
I8851 n1_m1_360000_4800 0 7.247216e-07
I8852 n1_m1_360000_9600 0 1.609195e-06
I8853 n1_m1_360000_14400 0 7.457900e-07
I8854 n1_m1_360000_19200 0 3.993431e-07
I8855 n1_m1_360000_24000 0 4.766741e-07
I8856 n1_m1_360000_28800 0 2.998954e-07
I8857 n1_m1_360000_33600 0 3.923609e-07
I8858 n1_m1_360000_38400 0 2.503442e-07
I8859 n1_m1_360000_43200 0 2.377915e-07
I8860 n1_m1_360000_48000 0 3.328738e-07
I8861 n1_m1_360000_52800 0 2.246310e-07
I8862 n1_m1_360000_57600 0 3.824465e-07
I8863 n1_m1_360000_62400 0 3.312733e-07
I8864 n1_m1_360000_67200 0 4.149805e-07
I8865 n1_m1_360000_72000 0 1.080670e-06
I8866 n1_m1_360000_76800 0 1.142396e-06
I8867 n1_m1_360000_81600 0 1.169932e-06
I8868 n1_m1_360000_86400 0 8.833024e-07
I8869 n1_m1_360000_91200 0 1.339058e-06
I8870 n1_m1_360000_96000 0 1.998606e-06
I8871 n1_m1_360000_100800 0 1.460070e-06
I8872 n1_m1_360000_105600 0 2.239910e-06
I8873 n1_m1_360000_110400 0 1.847231e-06
I8874 n1_m1_360000_115200 0 1.886257e-06
I8875 n1_m1_360000_120000 0 2.414437e-06
I8876 n1_m1_360000_124800 0 1.486859e-06
I8877 n1_m1_360000_129600 0 2.123576e-06
I8878 n1_m1_360000_134400 0 1.276729e-06
I8879 n1_m1_360000_139200 0 1.474932e-06
I8880 n1_m1_360000_144000 0 2.051187e-06
I8881 n1_m1_360000_148800 0 1.038488e-06
I8882 n1_m1_360000_153600 0 1.074189e-06
I8883 n1_m1_360000_158400 0 9.225426e-07
I8884 n1_m1_360000_163200 0 1.580603e-06
I8885 n1_m1_360000_168000 0 2.656175e-06
I8886 n1_m1_360000_172800 0 1.338146e-06
I8887 n1_m1_360000_177600 0 2.125791e-06
I8888 n1_m1_360000_182400 0 9.206026e-07
I8889 n1_m1_360000_187200 0 7.844995e-07
I8890 n1_m1_360000_192000 0 1.284928e-06
I8891 n1_m1_360000_196800 0 3.733551e-07
I8892 n1_m1_360000_201600 0 7.197436e-07
I8893 n1_m1_360000_206400 0 7.043058e-07
I8894 n1_m1_360000_211200 0 5.842705e-07
I8895 n1_m1_360000_216000 0 2.227075e-06
I8896 n1_m1_360000_220800 0 1.714213e-06
I8897 n1_m1_360000_225600 0 2.543471e-06
I8898 n1_m1_360000_230400 0 1.972169e-06
I8899 n1_m1_360000_235200 0 2.001114e-06
I8900 n1_m1_360000_240000 0 2.935055e-06
I8901 n1_m1_360000_244800 0 1.716612e-06
I8902 n1_m1_360000_249600 0 1.926924e-06
I8903 n1_m1_360000_254400 0 1.695310e-06
I8904 n1_m1_360000_259200 0 1.577329e-06
I8905 n1_m1_360000_264000 0 1.378131e-06
I8906 n1_m1_360000_268800 0 8.355162e-07
I8907 n1_m1_360000_273600 0 5.803921e-07
I8908 n1_m1_360000_278400 0 3.584264e-07
I8909 n1_m1_360000_283200 0 4.568727e-07
I8910 n1_m1_360000_288000 0 1.323401e-06
I8911 n1_m1_360000_292800 0 1.296316e-06
I8912 n1_m1_360000_297600 0 2.690485e-06
I8913 n1_m1_360000_302400 0 1.917215e-06
I8914 n1_m1_360000_307200 0 1.949578e-06
I8915 n1_m1_360000_312000 0 2.783800e-06
I8916 n1_m1_360000_316800 0 1.901866e-06
I8917 n1_m1_360000_321600 0 2.935078e-06
I8918 n1_m1_360000_326400 0 1.905693e-06
I8919 n1_m1_360000_331200 0 1.996300e-06
I8920 n1_m1_360000_336000 0 2.861818e-06
I8921 n1_m1_360000_340800 0 1.700631e-06
I8922 n1_m1_360000_345600 0 2.058112e-06
I8923 n1_m1_360000_350400 0 1.434323e-06
I8924 n1_m1_360000_355200 0 9.323564e-07
I8925 n1_m1_360000_360000 0 6.921115e-07
I8926 n1_m1_360000_364800 0 2.885902e-07
I8927 n1_m1_360000_369600 0 3.794380e-07
I8928 n1_m1_360000_374400 0 2.301625e-07
I8929 n1_m1_360000_379200 0 2.276685e-07
I8930 n1_m1_360000_384000 0 3.399629e-07
I8931 n1_m1_360000_388800 0 2.179243e-07
I8932 n1_m1_360000_393600 0 3.495446e-07
I8933 n1_m1_360000_398400 0 3.013080e-07
I8934 n1_m1_360000_403200 0 3.052456e-07
I8935 n1_m1_360000_408000 0 8.571021e-07
I8936 n1_m1_360000_412800 0 3.987108e-07
I8937 n1_m1_360000_417600 0 4.178392e-07
I8938 n1_m1_360000_422400 0 2.654049e-07
I8939 n1_m1_360000_427200 0 2.443913e-07
I8940 n1_m1_360000_432000 0 3.989872e-07
I8941 n1_m1_360000_436800 0 2.558299e-07
I8942 n1_m1_360000_441600 0 3.855796e-07
I8943 n1_m1_360000_446400 0 2.633288e-07
I8944 n1_m1_360000_451200 0 2.512311e-07
I8945 n1_m1_360000_456000 0 3.552512e-07
I8946 n1_m1_360000_460800 0 2.318409e-07
I8947 n1_m1_360000_465600 0 3.702769e-07
I8948 n1_m1_360000_470400 0 2.585503e-07
I8949 n1_m1_360000_475200 0 2.585121e-07
I8950 n1_m1_360000_480000 0 3.633219e-07
I8951 n1_m1_360000_484800 0 2.246848e-07
I8952 n1_m1_360000_489600 0 3.216532e-07
I8953 n1_m1_360000_494400 0 2.098560e-07
I8954 n1_m1_360000_499200 0 2.098560e-07
I8955 n1_m1_360000_504000 0 3.147839e-07
I8956 n1_m1_360000_508800 0 2.098560e-07
I8957 n1_m1_360000_513600 0 3.147839e-07
I8958 n1_m1_360000_518400 0 2.098560e-07
I8959 n1_m1_360000_523200 0 2.098774e-07
I8960 n1_m1_360000_528000 0 3.255008e-07
I8961 n1_m1_360000_532800 0 2.455131e-07
I8962 n1_m1_360000_537600 0 3.246709e-07
I8963 n1_m1_360000_542400 0 2.409708e-07
I8964 n1_m1_360000_547200 0 2.694947e-07
I8965 n1_m1_360000_552000 0 3.943445e-07
I8966 n1_m1_360000_556800 0 2.455432e-07
I8967 n1_m1_360000_561600 0 1.206912e-07
I8968 n1_m1_364800_0 0 2.475096e-07
I8969 n1_m1_364800_4800 0 4.453794e-07
I8970 n1_m1_364800_9600 0 1.020478e-06
I8971 n1_m1_364800_14400 0 4.958994e-07
I8972 n1_m1_364800_19200 0 2.720007e-07
I8973 n1_m1_364800_24000 0 2.965675e-07
I8974 n1_m1_364800_28800 0 1.743056e-07
I8975 n1_m1_364800_33600 0 2.438918e-07
I8976 n1_m1_364800_38400 0 1.687448e-07
I8977 n1_m1_364800_43200 0 1.594667e-07
I8978 n1_m1_364800_48000 0 2.240159e-07
I8979 n1_m1_364800_52800 0 1.520587e-07
I8980 n1_m1_364800_57600 0 2.629296e-07
I8981 n1_m1_364800_62400 0 2.292915e-07
I8982 n1_m1_364800_67200 0 2.825534e-07
I8983 n1_m1_364800_72000 0 5.864274e-07
I8984 n1_m1_364800_76800 0 7.300709e-07
I8985 n1_m1_364800_81600 0 6.453040e-07
I8986 n1_m1_364800_86400 0 4.714267e-07
I8987 n1_m1_364800_91200 0 8.519691e-07
I8988 n1_m1_364800_96000 0 1.400476e-06
I8989 n1_m1_364800_100800 0 1.090057e-06
I8990 n1_m1_364800_105600 0 1.782828e-06
I8991 n1_m1_364800_110400 0 1.218978e-06
I8992 n1_m1_364800_115200 0 1.183755e-06
I8993 n1_m1_364800_120000 0 1.723355e-06
I8994 n1_m1_364800_124800 0 9.337125e-07
I8995 n1_m1_364800_129600 0 1.413728e-06
I8996 n1_m1_364800_134400 0 7.958419e-07
I8997 n1_m1_364800_139200 0 5.765738e-07
I8998 n1_m1_364800_144000 0 1.375608e-06
I8999 n1_m1_364800_148800 0 6.638198e-07
I9000 n1_m1_364800_153600 0 8.934775e-07
I9001 n1_m1_364800_158400 0 9.331057e-07
I9002 n1_m1_364800_163200 0 6.805390e-07
I9003 n1_m1_364800_168000 0 1.600384e-06
I9004 n1_m1_364800_172800 0 1.021334e-06
I9005 n1_m1_364800_177600 0 9.961274e-07
I9006 n1_m1_364800_182400 0 6.539146e-07
I9007 n1_m1_364800_187200 0 5.116291e-07
I9008 n1_m1_364800_192000 0 4.661751e-07
I9009 n1_m1_364800_196800 0 2.709619e-07
I9010 n1_m1_364800_201600 0 6.173502e-07
I9011 n1_m1_364800_206400 0 9.142395e-07
I9012 n1_m1_364800_211200 0 8.657026e-07
I9013 n1_m1_364800_216000 0 1.255149e-06
I9014 n1_m1_364800_220800 0 9.977323e-07
I9015 n1_m1_364800_225600 0 1.764033e-06
I9016 n1_m1_364800_230400 0 1.184726e-06
I9017 n1_m1_364800_235200 0 1.100571e-06
I9018 n1_m1_364800_240000 0 1.550953e-06
I9019 n1_m1_364800_244800 0 6.585228e-07
I9020 n1_m1_364800_249600 0 1.080010e-06
I9021 n1_m1_364800_254400 0 9.311775e-07
I9022 n1_m1_364800_259200 0 7.763272e-07
I9023 n1_m1_364800_264000 0 8.959323e-07
I9024 n1_m1_364800_268800 0 3.433770e-07
I9025 n1_m1_364800_273600 0 5.454890e-07
I9026 n1_m1_364800_278400 0 2.938971e-07
I9027 n1_m1_364800_283200 0 3.959381e-07
I9028 n1_m1_364800_288000 0 8.249685e-07
I9029 n1_m1_364800_292800 0 6.253459e-07
I9030 n1_m1_364800_297600 0 1.161158e-06
I9031 n1_m1_364800_302400 0 1.110628e-06
I9032 n1_m1_364800_307200 0 1.058800e-06
I9033 n1_m1_364800_312000 0 1.452569e-06
I9034 n1_m1_364800_316800 0 1.022611e-06
I9035 n1_m1_364800_321600 0 1.293312e-06
I9036 n1_m1_364800_326400 0 1.095710e-06
I9037 n1_m1_364800_331200 0 1.330203e-06
I9038 n1_m1_364800_336000 0 1.762030e-06
I9039 n1_m1_364800_340800 0 8.217066e-07
I9040 n1_m1_364800_345600 0 5.727079e-07
I9041 n1_m1_364800_350400 0 3.397200e-07
I9042 n1_m1_364800_355200 0 2.640413e-07
I9043 n1_m1_364800_360000 0 5.505382e-07
I9044 n1_m1_364800_364800 0 2.273470e-07
I9045 n1_m1_364800_369600 0 2.300671e-07
I9046 n1_m1_364800_374400 0 1.434762e-07
I9047 n1_m1_364800_379200 0 1.481009e-07
I9048 n1_m1_364800_384000 0 2.244699e-07
I9049 n1_m1_364800_388800 0 1.477823e-07
I9050 n1_m1_364800_393600 0 2.392277e-07
I9051 n1_m1_364800_398400 0 2.281690e-07
I9052 n1_m1_364800_403200 0 2.305247e-07
I9053 n1_m1_364800_408000 0 9.725515e-07
I9054 n1_m1_364800_412800 0 4.678829e-07
I9055 n1_m1_364800_417600 0 3.905855e-07
I9056 n1_m1_364800_422400 0 1.831020e-07
I9057 n1_m1_364800_427200 0 1.648869e-07
I9058 n1_m1_364800_432000 0 2.739781e-07
I9059 n1_m1_364800_436800 0 1.796753e-07
I9060 n1_m1_364800_441600 0 2.585874e-07
I9061 n1_m1_364800_446400 0 1.733863e-07
I9062 n1_m1_364800_451200 0 1.696259e-07
I9063 n1_m1_364800_456000 0 2.470992e-07
I9064 n1_m1_364800_460800 0 1.632777e-07
I9065 n1_m1_364800_465600 0 2.571934e-07
I9066 n1_m1_364800_470400 0 1.782853e-07
I9067 n1_m1_364800_475200 0 1.780892e-07
I9068 n1_m1_364800_480000 0 2.479484e-07
I9069 n1_m1_364800_484800 0 1.518491e-07
I9070 n1_m1_364800_489600 0 2.165412e-07
I9071 n1_m1_364800_494400 0 1.399040e-07
I9072 n1_m1_364800_499200 0 1.399040e-07
I9073 n1_m1_364800_504000 0 2.098560e-07
I9074 n1_m1_364800_508800 0 1.399040e-07
I9075 n1_m1_364800_513600 0 2.098560e-07
I9076 n1_m1_364800_518400 0 1.399040e-07
I9077 n1_m1_364800_523200 0 1.401022e-07
I9078 n1_m1_364800_528000 0 2.216150e-07
I9079 n1_m1_364800_532800 0 1.626684e-07
I9080 n1_m1_364800_537600 0 2.207852e-07
I9081 n1_m1_364800_542400 0 1.578424e-07
I9082 n1_m1_364800_547200 0 1.726573e-07
I9083 n1_m1_364800_552000 0 2.556101e-07
I9084 n1_m1_364800_556800 0 1.614432e-07
I9085 n1_m1_364800_561600 0 7.933463e-08
I9086 n1_m1_369600_0 0 3.065111e-07
I9087 n1_m1_369600_4800 0 5.172357e-07
I9088 n1_m1_369600_9600 0 9.470383e-07
I9089 n1_m1_369600_14400 0 3.548018e-07
I9090 n1_m1_369600_19200 0 1.913250e-07
I9091 n1_m1_369600_24000 0 2.438026e-07
I9092 n1_m1_369600_28800 0 1.528372e-07
I9093 n1_m1_369600_33600 0 2.277287e-07
I9094 n1_m1_369600_38400 0 1.583871e-07
I9095 n1_m1_369600_43200 0 1.556964e-07
I9096 n1_m1_369600_48000 0 2.239285e-07
I9097 n1_m1_369600_52800 0 1.506813e-07
I9098 n1_m1_369600_57600 0 2.361500e-07
I9099 n1_m1_369600_62400 0 1.686196e-07
I9100 n1_m1_369600_67200 0 1.735293e-07
I9101 n1_m1_369600_72000 0 3.239210e-07
I9102 n1_m1_369600_76800 0 3.083967e-07
I9103 n1_m1_369600_81600 0 2.957380e-07
I9104 n1_m1_369600_86400 0 3.776076e-07
I9105 n1_m1_369600_91200 0 7.255164e-07
I9106 n1_m1_369600_96000 0 9.771526e-07
I9107 n1_m1_369600_100800 0 7.258615e-07
I9108 n1_m1_369600_105600 0 1.377032e-06
I9109 n1_m1_369600_110400 0 1.149138e-06
I9110 n1_m1_369600_115200 0 9.007410e-07
I9111 n1_m1_369600_120000 0 1.781184e-06
I9112 n1_m1_369600_124800 0 1.068070e-06
I9113 n1_m1_369600_129600 0 1.201747e-06
I9114 n1_m1_369600_134400 0 9.455124e-07
I9115 n1_m1_369600_139200 0 7.903574e-07
I9116 n1_m1_369600_144000 0 1.601039e-06
I9117 n1_m1_369600_148800 0 1.065788e-06
I9118 n1_m1_369600_153600 0 7.737399e-07
I9119 n1_m1_369600_158400 0 4.814283e-07
I9120 n1_m1_369600_163200 0 5.217230e-07
I9121 n1_m1_369600_168000 0 1.057356e-06
I9122 n1_m1_369600_172800 0 1.017598e-06
I9123 n1_m1_369600_177600 0 8.473172e-07
I9124 n1_m1_369600_182400 0 3.109952e-07
I9125 n1_m1_369600_187200 0 2.877429e-07
I9126 n1_m1_369600_192000 0 2.780076e-07
I9127 n1_m1_369600_196800 0 4.776881e-07
I9128 n1_m1_369600_201600 0 5.646523e-07
I9129 n1_m1_369600_206400 0 6.237570e-07
I9130 n1_m1_369600_211200 0 5.278978e-07
I9131 n1_m1_369600_216000 0 1.500500e-06
I9132 n1_m1_369600_220800 0 9.488282e-07
I9133 n1_m1_369600_225600 0 1.914795e-06
I9134 n1_m1_369600_230400 0 1.213931e-06
I9135 n1_m1_369600_235200 0 1.079698e-06
I9136 n1_m1_369600_240000 0 1.823653e-06
I9137 n1_m1_369600_244800 0 1.048897e-06
I9138 n1_m1_369600_249600 0 1.542935e-06
I9139 n1_m1_369600_254400 0 9.058734e-07
I9140 n1_m1_369600_259200 0 5.438413e-07
I9141 n1_m1_369600_264000 0 5.772152e-07
I9142 n1_m1_369600_268800 0 2.951045e-07
I9143 n1_m1_369600_273600 0 4.718656e-07
I9144 n1_m1_369600_278400 0 4.628271e-07
I9145 n1_m1_369600_283200 0 3.507131e-07
I9146 n1_m1_369600_288000 0 5.782228e-07
I9147 n1_m1_369600_292800 0 2.564722e-07
I9148 n1_m1_369600_297600 0 6.645159e-07
I9149 n1_m1_369600_302400 0 8.592347e-07
I9150 n1_m1_369600_307200 0 7.425787e-07
I9151 n1_m1_369600_312000 0 7.639999e-07
I9152 n1_m1_369600_316800 0 4.907212e-07
I9153 n1_m1_369600_321600 0 7.136308e-07
I9154 n1_m1_369600_326400 0 7.973562e-07
I9155 n1_m1_369600_331200 0 1.095126e-06
I9156 n1_m1_369600_336000 0 1.336883e-06
I9157 n1_m1_369600_340800 0 7.651919e-07
I9158 n1_m1_369600_345600 0 7.747029e-07
I9159 n1_m1_369600_350400 0 5.854132e-07
I9160 n1_m1_369600_355200 0 4.298934e-07
I9161 n1_m1_369600_360000 0 3.865645e-07
I9162 n1_m1_369600_364800 0 1.697485e-07
I9163 n1_m1_369600_369600 0 2.272624e-07
I9164 n1_m1_369600_374400 0 1.599093e-07
I9165 n1_m1_369600_379200 0 1.648943e-07
I9166 n1_m1_369600_384000 0 2.221244e-07
I9167 n1_m1_369600_388800 0 1.491084e-07
I9168 n1_m1_369600_393600 0 2.346956e-07
I9169 n1_m1_369600_398400 0 1.782202e-07
I9170 n1_m1_369600_403200 0 2.058389e-07
I9171 n1_m1_369600_408000 0 1.272238e-06
I9172 n1_m1_369600_412800 0 7.624221e-07
I9173 n1_m1_369600_417600 0 6.169673e-07
I9174 n1_m1_369600_422400 0 2.150762e-07
I9175 n1_m1_369600_427200 0 1.619220e-07
I9176 n1_m1_369600_432000 0 2.501423e-07
I9177 n1_m1_369600_436800 0 1.604980e-07
I9178 n1_m1_369600_441600 0 2.353176e-07
I9179 n1_m1_369600_446400 0 1.564051e-07
I9180 n1_m1_369600_451200 0 1.531926e-07
I9181 n1_m1_369600_456000 0 2.366051e-07
I9182 n1_m1_369600_460800 0 1.583831e-07
I9183 n1_m1_369600_465600 0 2.358690e-07
I9184 n1_m1_369600_470400 0 1.567111e-07
I9185 n1_m1_369600_475200 0 1.553556e-07
I9186 n1_m1_369600_480000 0 2.268885e-07
I9187 n1_m1_369600_484800 0 1.466671e-07
I9188 n1_m1_369600_489600 0 2.161391e-07
I9189 n1_m1_369600_494400 0 1.399040e-07
I9190 n1_m1_369600_499200 0 1.399040e-07
I9191 n1_m1_369600_504000 0 2.098560e-07
I9192 n1_m1_369600_508800 0 1.399040e-07
I9193 n1_m1_369600_513600 0 2.098560e-07
I9194 n1_m1_369600_518400 0 1.399040e-07
I9195 n1_m1_369600_523200 0 1.401470e-07
I9196 n1_m1_369600_528000 0 2.229492e-07
I9197 n1_m1_369600_532800 0 1.631675e-07
I9198 n1_m1_369600_537600 0 2.234130e-07
I9199 n1_m1_369600_542400 0 1.653430e-07
I9200 n1_m1_369600_547200 0 1.849821e-07
I9201 n1_m1_369600_552000 0 2.633603e-07
I9202 n1_m1_369600_556800 0 1.620644e-07
I9203 n1_m1_369600_561600 0 7.954037e-08
I9204 n1_m1_374400_0 0 2.496759e-07
I9205 n1_m1_374400_4800 0 4.249576e-07
I9206 n1_m1_374400_9600 0 7.775179e-07
I9207 n1_m1_374400_14400 0 2.883311e-07
I9208 n1_m1_374400_19200 0 1.741192e-07
I9209 n1_m1_374400_24000 0 2.372132e-07
I9210 n1_m1_374400_28800 0 1.625079e-07
I9211 n1_m1_374400_33600 0 2.358070e-07
I9212 n1_m1_374400_38400 0 1.535304e-07
I9213 n1_m1_374400_43200 0 1.527394e-07
I9214 n1_m1_374400_48000 0 2.229584e-07
I9215 n1_m1_374400_52800 0 1.468076e-07
I9216 n1_m1_374400_57600 0 2.217987e-07
I9217 n1_m1_374400_62400 0 1.523463e-07
I9218 n1_m1_374400_67200 0 1.513033e-07
I9219 n1_m1_374400_72000 0 2.214512e-07
I9220 n1_m1_374400_76800 0 1.541897e-07
I9221 n1_m1_374400_81600 0 2.303312e-07
I9222 n1_m1_374400_86400 0 1.794720e-07
I9223 n1_m1_374400_91200 0 3.222505e-07
I9224 n1_m1_374400_96000 0 5.176607e-07
I9225 n1_m1_374400_100800 0 5.752007e-07
I9226 n1_m1_374400_105600 0 1.112074e-06
I9227 n1_m1_374400_110400 0 1.033270e-06
I9228 n1_m1_374400_115200 0 8.175512e-07
I9229 n1_m1_374400_120000 0 1.319258e-06
I9230 n1_m1_374400_124800 0 1.219190e-06
I9231 n1_m1_374400_129600 0 1.723373e-06
I9232 n1_m1_374400_134400 0 1.012247e-06
I9233 n1_m1_374400_139200 0 9.232722e-07
I9234 n1_m1_374400_144000 0 1.078202e-06
I9235 n1_m1_374400_148800 0 6.304803e-07
I9236 n1_m1_374400_153600 0 1.047417e-06
I9237 n1_m1_374400_158400 0 4.684400e-07
I9238 n1_m1_374400_163200 0 4.879894e-07
I9239 n1_m1_374400_168000 0 1.387578e-06
I9240 n1_m1_374400_172800 0 4.530167e-07
I9241 n1_m1_374400_177600 0 9.080264e-07
I9242 n1_m1_374400_182400 0 5.873422e-07
I9243 n1_m1_374400_187200 0 2.381012e-07
I9244 n1_m1_374400_192000 0 3.097340e-07
I9245 n1_m1_374400_196800 0 2.237187e-07
I9246 n1_m1_374400_201600 0 3.316310e-07
I9247 n1_m1_374400_206400 0 3.385787e-07
I9248 n1_m1_374400_211200 0 3.794914e-07
I9249 n1_m1_374400_216000 0 1.355313e-06
I9250 n1_m1_374400_220800 0 1.172167e-06
I9251 n1_m1_374400_225600 0 1.656644e-06
I9252 n1_m1_374400_230400 0 1.261595e-06
I9253 n1_m1_374400_235200 0 1.305537e-06
I9254 n1_m1_374400_240000 0 1.873844e-06
I9255 n1_m1_374400_244800 0 1.087559e-06
I9256 n1_m1_374400_249600 0 1.038251e-06
I9257 n1_m1_374400_254400 0 1.134999e-06
I9258 n1_m1_374400_259200 0 7.602298e-07
I9259 n1_m1_374400_264000 0 6.926460e-07
I9260 n1_m1_374400_268800 0 2.973768e-07
I9261 n1_m1_374400_273600 0 5.663724e-07
I9262 n1_m1_374400_278400 0 3.745311e-07
I9263 n1_m1_374400_283200 0 4.949043e-07
I9264 n1_m1_374400_288000 0 1.048712e-06
I9265 n1_m1_374400_292800 0 3.711368e-07
I9266 n1_m1_374400_297600 0 7.314859e-07
I9267 n1_m1_374400_302400 0 4.155246e-07
I9268 n1_m1_374400_307200 0 4.822899e-07
I9269 n1_m1_374400_312000 0 5.850636e-07
I9270 n1_m1_374400_316800 0 3.968958e-07
I9271 n1_m1_374400_321600 0 5.842387e-07
I9272 n1_m1_374400_326400 0 6.779196e-07
I9273 n1_m1_374400_331200 0 7.647318e-07
I9274 n1_m1_374400_336000 0 1.387768e-06
I9275 n1_m1_374400_340800 0 9.896731e-07
I9276 n1_m1_374400_345600 0 6.919948e-07
I9277 n1_m1_374400_350400 0 6.826164e-07
I9278 n1_m1_374400_355200 0 4.715342e-07
I9279 n1_m1_374400_360000 0 2.803821e-07
I9280 n1_m1_374400_364800 0 1.566257e-07
I9281 n1_m1_374400_369600 0 2.416257e-07
I9282 n1_m1_374400_374400 0 1.520922e-07
I9283 n1_m1_374400_379200 0 1.527573e-07
I9284 n1_m1_374400_384000 0 2.276335e-07
I9285 n1_m1_374400_388800 0 1.512512e-07
I9286 n1_m1_374400_393600 0 2.287143e-07
I9287 n1_m1_374400_398400 0 1.640343e-07
I9288 n1_m1_374400_403200 0 1.803280e-07
I9289 n1_m1_374400_408000 0 1.251786e-06
I9290 n1_m1_374400_412800 0 7.919499e-07
I9291 n1_m1_374400_417600 0 7.807582e-07
I9292 n1_m1_374400_422400 0 3.098553e-07
I9293 n1_m1_374400_427200 0 1.752209e-07
I9294 n1_m1_374400_432000 0 2.357948e-07
I9295 n1_m1_374400_436800 0 1.508208e-07
I9296 n1_m1_374400_441600 0 2.237929e-07
I9297 n1_m1_374400_446400 0 1.460457e-07
I9298 n1_m1_374400_451200 0 1.422689e-07
I9299 n1_m1_374400_456000 0 2.243630e-07
I9300 n1_m1_374400_460800 0 1.514354e-07
I9301 n1_m1_374400_465600 0 2.208100e-07
I9302 n1_m1_374400_470400 0 1.453651e-07
I9303 n1_m1_374400_475200 0 1.419613e-07
I9304 n1_m1_374400_480000 0 2.174175e-07
I9305 n1_m1_374400_484800 0 1.456107e-07
I9306 n1_m1_374400_489600 0 2.160620e-07
I9307 n1_m1_374400_494400 0 1.399040e-07
I9308 n1_m1_374400_499200 0 1.399040e-07
I9309 n1_m1_374400_504000 0 2.098560e-07
I9310 n1_m1_374400_508800 0 1.399040e-07
I9311 n1_m1_374400_513600 0 2.098560e-07
I9312 n1_m1_374400_518400 0 1.399040e-07
I9313 n1_m1_374400_523200 0 1.401470e-07
I9314 n1_m1_374400_528000 0 2.245487e-07
I9315 n1_m1_374400_532800 0 1.692142e-07
I9316 n1_m1_374400_537600 0 2.334623e-07
I9317 n1_m1_374400_542400 0 1.939907e-07
I9318 n1_m1_374400_547200 0 2.241552e-07
I9319 n1_m1_374400_552000 0 2.805322e-07
I9320 n1_m1_374400_556800 0 1.652723e-07
I9321 n1_m1_374400_561600 0 8.080787e-08
I9322 n1_m1_379200_0 0 2.588661e-07
I9323 n1_m1_379200_4800 0 4.306704e-07
I9324 n1_m1_379200_9600 0 9.042038e-07
I9325 n1_m1_379200_14400 0 4.162068e-07
I9326 n1_m1_379200_19200 0 2.515209e-07
I9327 n1_m1_379200_24000 0 2.795775e-07
I9328 n1_m1_379200_28800 0 1.531481e-07
I9329 n1_m1_379200_33600 0 2.219065e-07
I9330 n1_m1_379200_38400 0 1.532282e-07
I9331 n1_m1_379200_43200 0 1.505459e-07
I9332 n1_m1_379200_48000 0 2.199069e-07
I9333 n1_m1_379200_52800 0 1.463691e-07
I9334 n1_m1_379200_57600 0 2.199668e-07
I9335 n1_m1_379200_62400 0 1.463367e-07
I9336 n1_m1_379200_67200 0 1.436167e-07
I9337 n1_m1_379200_72000 0 2.248465e-07
I9338 n1_m1_379200_76800 0 1.530802e-07
I9339 n1_m1_379200_81600 0 2.556174e-07
I9340 n1_m1_379200_86400 0 1.687789e-07
I9341 n1_m1_379200_91200 0 3.223187e-07
I9342 n1_m1_379200_96000 0 6.078549e-07
I9343 n1_m1_379200_100800 0 6.521271e-07
I9344 n1_m1_379200_105600 0 9.457634e-07
I9345 n1_m1_379200_110400 0 8.416048e-07
I9346 n1_m1_379200_115200 0 7.771533e-07
I9347 n1_m1_379200_120000 0 1.173171e-06
I9348 n1_m1_379200_124800 0 1.233336e-06
I9349 n1_m1_379200_129600 0 1.592976e-06
I9350 n1_m1_379200_134400 0 7.509853e-07
I9351 n1_m1_379200_139200 0 7.091047e-07
I9352 n1_m1_379200_144000 0 8.856762e-07
I9353 n1_m1_379200_148800 0 6.335730e-07
I9354 n1_m1_379200_153600 0 1.406048e-06
I9355 n1_m1_379200_158400 0 6.139106e-07
I9356 n1_m1_379200_163200 0 5.117512e-07
I9357 n1_m1_379200_168000 0 1.613229e-06
I9358 n1_m1_379200_172800 0 5.520933e-07
I9359 n1_m1_379200_177600 0 1.034253e-06
I9360 n1_m1_379200_182400 0 7.261513e-07
I9361 n1_m1_379200_187200 0 2.257221e-07
I9362 n1_m1_379200_192000 0 3.520364e-07
I9363 n1_m1_379200_196800 0 2.413394e-07
I9364 n1_m1_379200_201600 0 4.267675e-07
I9365 n1_m1_379200_206400 0 2.700395e-07
I9366 n1_m1_379200_211200 0 2.094239e-07
I9367 n1_m1_379200_216000 0 1.421331e-06
I9368 n1_m1_379200_220800 0 1.188633e-06
I9369 n1_m1_379200_225600 0 1.627879e-06
I9370 n1_m1_379200_230400 0 1.255447e-06
I9371 n1_m1_379200_235200 0 1.295422e-06
I9372 n1_m1_379200_240000 0 1.685732e-06
I9373 n1_m1_379200_244800 0 1.019738e-06
I9374 n1_m1_379200_249600 0 1.111679e-06
I9375 n1_m1_379200_254400 0 1.047972e-06
I9376 n1_m1_379200_259200 0 1.133804e-06
I9377 n1_m1_379200_264000 0 8.710719e-07
I9378 n1_m1_379200_268800 0 3.560182e-07
I9379 n1_m1_379200_273600 0 8.519160e-07
I9380 n1_m1_379200_278400 0 4.547543e-07
I9381 n1_m1_379200_283200 0 5.475498e-07
I9382 n1_m1_379200_288000 0 1.206151e-06
I9383 n1_m1_379200_292800 0 4.919025e-07
I9384 n1_m1_379200_297600 0 8.162627e-07
I9385 n1_m1_379200_302400 0 3.308740e-07
I9386 n1_m1_379200_307200 0 3.485725e-07
I9387 n1_m1_379200_312000 0 5.136750e-07
I9388 n1_m1_379200_316800 0 4.080178e-07
I9389 n1_m1_379200_321600 0 4.337550e-07
I9390 n1_m1_379200_326400 0 6.140710e-07
I9391 n1_m1_379200_331200 0 7.586118e-07
I9392 n1_m1_379200_336000 0 1.285491e-06
I9393 n1_m1_379200_340800 0 1.033808e-06
I9394 n1_m1_379200_345600 0 6.118391e-07
I9395 n1_m1_379200_350400 0 4.502967e-07
I9396 n1_m1_379200_355200 0 3.304147e-07
I9397 n1_m1_379200_360000 0 2.946164e-07
I9398 n1_m1_379200_364800 0 1.711473e-07
I9399 n1_m1_379200_369600 0 2.407611e-07
I9400 n1_m1_379200_374400 0 1.451585e-07
I9401 n1_m1_379200_379200 0 1.496228e-07
I9402 n1_m1_379200_384000 0 2.311707e-07
I9403 n1_m1_379200_388800 0 1.537792e-07
I9404 n1_m1_379200_393600 0 2.208036e-07
I9405 n1_m1_379200_398400 0 1.654109e-07
I9406 n1_m1_379200_403200 0 1.724128e-07
I9407 n1_m1_379200_408000 0 1.126500e-06
I9408 n1_m1_379200_412800 0 6.632399e-07
I9409 n1_m1_379200_417600 0 9.536352e-07
I9410 n1_m1_379200_422400 0 4.591490e-07
I9411 n1_m1_379200_427200 0 2.013184e-07
I9412 n1_m1_379200_432000 0 2.296565e-07
I9413 n1_m1_379200_436800 0 1.454458e-07
I9414 n1_m1_379200_441600 0 2.188973e-07
I9415 n1_m1_379200_446400 0 1.428444e-07
I9416 n1_m1_379200_451200 0 1.372263e-07
I9417 n1_m1_379200_456000 0 2.153767e-07
I9418 n1_m1_379200_460800 0 1.416015e-07
I9419 n1_m1_379200_465600 0 2.106372e-07
I9420 n1_m1_379200_470400 0 1.404339e-07
I9421 n1_m1_379200_475200 0 1.400403e-07
I9422 n1_m1_379200_480000 0 2.106330e-07
I9423 n1_m1_379200_484800 0 1.415783e-07
I9424 n1_m1_379200_489600 0 2.149473e-07
I9425 n1_m1_379200_494400 0 1.399040e-07
I9426 n1_m1_379200_499200 0 1.399040e-07
I9427 n1_m1_379200_504000 0 2.098560e-07
I9428 n1_m1_379200_508800 0 1.399040e-07
I9429 n1_m1_379200_513600 0 2.098560e-07
I9430 n1_m1_379200_518400 0 1.399040e-07
I9431 n1_m1_379200_523200 0 1.402140e-07
I9432 n1_m1_379200_528000 0 2.310730e-07
I9433 n1_m1_379200_532800 0 1.877285e-07
I9434 n1_m1_379200_537600 0 2.611603e-07
I9435 n1_m1_379200_542400 0 2.492618e-07
I9436 n1_m1_379200_547200 0 2.988598e-07
I9437 n1_m1_379200_552000 0 3.099044e-07
I9438 n1_m1_379200_556800 0 1.697039e-07
I9439 n1_m1_379200_561600 0 8.293891e-08
I9440 n1_m1_384000_0 0 6.264162e-07
I9441 n1_m1_384000_4800 0 1.013344e-06
I9442 n1_m1_384000_9600 0 1.977134e-06
I9443 n1_m1_384000_14400 0 1.116060e-06
I9444 n1_m1_384000_19200 0 8.009718e-07
I9445 n1_m1_384000_24000 0 6.563801e-07
I9446 n1_m1_384000_28800 0 2.412876e-07
I9447 n1_m1_384000_33600 0 3.361323e-07
I9448 n1_m1_384000_38400 0 2.298422e-07
I9449 n1_m1_384000_43200 0 2.279356e-07
I9450 n1_m1_384000_48000 0 3.254133e-07
I9451 n1_m1_384000_52800 0 2.179352e-07
I9452 n1_m1_384000_57600 0 3.325726e-07
I9453 n1_m1_384000_62400 0 2.203420e-07
I9454 n1_m1_384000_67200 0 2.219819e-07
I9455 n1_m1_384000_72000 0 3.344535e-07
I9456 n1_m1_384000_76800 0 2.141503e-07
I9457 n1_m1_384000_81600 0 4.055124e-07
I9458 n1_m1_384000_86400 0 2.886132e-07
I9459 n1_m1_384000_91200 0 5.328038e-07
I9460 n1_m1_384000_96000 0 8.843064e-07
I9461 n1_m1_384000_100800 0 8.097351e-07
I9462 n1_m1_384000_105600 0 1.949650e-06
I9463 n1_m1_384000_110400 0 1.593034e-06
I9464 n1_m1_384000_115200 0 1.205511e-06
I9465 n1_m1_384000_120000 0 2.239284e-06
I9466 n1_m1_384000_124800 0 1.387541e-06
I9467 n1_m1_384000_129600 0 1.379264e-06
I9468 n1_m1_384000_134400 0 1.241300e-06
I9469 n1_m1_384000_139200 0 1.509161e-06
I9470 n1_m1_384000_144000 0 2.266021e-06
I9471 n1_m1_384000_148800 0 1.402344e-06
I9472 n1_m1_384000_153600 0 1.450227e-06
I9473 n1_m1_384000_158400 0 1.095835e-06
I9474 n1_m1_384000_163200 0 1.429017e-06
I9475 n1_m1_384000_168000 0 2.747672e-06
I9476 n1_m1_384000_172800 0 1.856767e-06
I9477 n1_m1_384000_177600 0 1.643316e-06
I9478 n1_m1_384000_182400 0 4.458866e-07
I9479 n1_m1_384000_187200 0 4.820659e-07
I9480 n1_m1_384000_192000 0 9.061751e-07
I9481 n1_m1_384000_196800 0 5.708843e-07
I9482 n1_m1_384000_201600 0 6.591767e-07
I9483 n1_m1_384000_206400 0 4.472551e-07
I9484 n1_m1_384000_211200 0 4.575402e-07
I9485 n1_m1_384000_216000 0 2.040294e-06
I9486 n1_m1_384000_220800 0 1.591486e-06
I9487 n1_m1_384000_225600 0 2.860628e-06
I9488 n1_m1_384000_230400 0 1.574577e-06
I9489 n1_m1_384000_235200 0 1.471984e-06
I9490 n1_m1_384000_240000 0 2.977797e-06
I9491 n1_m1_384000_244800 0 1.877386e-06
I9492 n1_m1_384000_249600 0 2.001803e-06
I9493 n1_m1_384000_254400 0 1.306816e-06
I9494 n1_m1_384000_259200 0 1.007438e-06
I9495 n1_m1_384000_264000 0 1.876864e-06
I9496 n1_m1_384000_268800 0 8.700975e-07
I9497 n1_m1_384000_273600 0 2.011011e-06
I9498 n1_m1_384000_278400 0 1.259183e-06
I9499 n1_m1_384000_283200 0 5.830896e-07
I9500 n1_m1_384000_288000 0 1.125848e-06
I9501 n1_m1_384000_292800 0 6.413784e-07
I9502 n1_m1_384000_297600 0 1.578999e-06
I9503 n1_m1_384000_302400 0 9.733581e-07
I9504 n1_m1_384000_307200 0 5.799520e-07
I9505 n1_m1_384000_312000 0 6.145068e-07
I9506 n1_m1_384000_316800 0 6.372085e-07
I9507 n1_m1_384000_321600 0 6.299328e-07
I9508 n1_m1_384000_326400 0 9.343753e-07
I9509 n1_m1_384000_331200 0 1.649301e-06
I9510 n1_m1_384000_336000 0 1.954187e-06
I9511 n1_m1_384000_340800 0 1.796057e-06
I9512 n1_m1_384000_345600 0 1.917370e-06
I9513 n1_m1_384000_350400 0 9.322378e-07
I9514 n1_m1_384000_355200 0 5.708064e-07
I9515 n1_m1_384000_360000 0 5.981400e-07
I9516 n1_m1_384000_364800 0 2.795985e-07
I9517 n1_m1_384000_369600 0 3.390434e-07
I9518 n1_m1_384000_374400 0 2.302763e-07
I9519 n1_m1_384000_379200 0 2.382834e-07
I9520 n1_m1_384000_384000 0 3.462810e-07
I9521 n1_m1_384000_388800 0 2.323559e-07
I9522 n1_m1_384000_393600 0 3.419965e-07
I9523 n1_m1_384000_398400 0 2.437758e-07
I9524 n1_m1_384000_403200 0 2.489411e-07
I9525 n1_m1_384000_408000 0 1.041792e-06
I9526 n1_m1_384000_412800 0 6.508339e-07
I9527 n1_m1_384000_417600 0 1.762052e-06
I9528 n1_m1_384000_422400 0 8.505147e-07
I9529 n1_m1_384000_427200 0 3.320786e-07
I9530 n1_m1_384000_432000 0 3.542263e-07
I9531 n1_m1_384000_436800 0 2.200328e-07
I9532 n1_m1_384000_441600 0 3.317029e-07
I9533 n1_m1_384000_446400 0 2.150684e-07
I9534 n1_m1_384000_451200 0 2.108565e-07
I9535 n1_m1_384000_456000 0 3.218605e-07
I9536 n1_m1_384000_460800 0 2.065287e-07
I9537 n1_m1_384000_465600 0 3.166158e-07
I9538 n1_m1_384000_470400 0 2.123010e-07
I9539 n1_m1_384000_475200 0 2.102909e-07
I9540 n1_m1_384000_480000 0 3.147839e-07
I9541 n1_m1_384000_484800 0 2.106206e-07
I9542 n1_m1_384000_489600 0 3.180017e-07
I9543 n1_m1_384000_494400 0 2.111485e-07
I9544 n1_m1_384000_499200 0 2.115712e-07
I9545 n1_m1_384000_504000 0 3.147839e-07
I9546 n1_m1_384000_508800 0 2.098560e-07
I9547 n1_m1_384000_513600 0 3.147839e-07
I9548 n1_m1_384000_518400 0 2.098560e-07
I9549 n1_m1_384000_523200 0 2.106827e-07
I9550 n1_m1_384000_528000 0 3.673216e-07
I9551 n1_m1_384000_532800 0 3.217027e-07
I9552 n1_m1_384000_537600 0 4.348919e-07
I9553 n1_m1_384000_542400 0 4.116125e-07
I9554 n1_m1_384000_547200 0 4.822495e-07
I9555 n1_m1_384000_552000 0 5.116134e-07
I9556 n1_m1_384000_556800 0 2.513983e-07
I9557 n1_m1_384000_561600 0 1.226773e-07
I9558 n1_m1_388800_0 0 2.328635e-07
I9559 n1_m1_388800_4800 0 3.797717e-07
I9560 n1_m1_388800_9600 0 6.582158e-07
I9561 n1_m1_388800_14400 0 2.318341e-07
I9562 n1_m1_388800_19200 0 2.836228e-07
I9563 n1_m1_388800_24000 0 2.618309e-07
I9564 n1_m1_388800_28800 0 1.480136e-07
I9565 n1_m1_388800_33600 0 2.245612e-07
I9566 n1_m1_388800_38400 0 1.532282e-07
I9567 n1_m1_388800_43200 0 1.497549e-07
I9568 n1_m1_388800_48000 0 2.140227e-07
I9569 n1_m1_388800_52800 0 1.451976e-07
I9570 n1_m1_388800_57600 0 2.239753e-07
I9571 n1_m1_388800_62400 0 1.462441e-07
I9572 n1_m1_388800_67200 0 1.526511e-07
I9573 n1_m1_388800_72000 0 2.349646e-07
I9574 n1_m1_388800_76800 0 1.523268e-07
I9575 n1_m1_388800_81600 0 2.308376e-07
I9576 n1_m1_388800_86400 0 1.702384e-07
I9577 n1_m1_388800_91200 0 2.146252e-07
I9578 n1_m1_388800_96000 0 3.971540e-07
I9579 n1_m1_388800_100800 0 7.919820e-07
I9580 n1_m1_388800_105600 0 1.387384e-06
I9581 n1_m1_388800_110400 0 9.944170e-07
I9582 n1_m1_388800_115200 0 7.038416e-07
I9583 n1_m1_388800_120000 0 1.153873e-06
I9584 n1_m1_388800_124800 0 6.522659e-07
I9585 n1_m1_388800_129600 0 7.881263e-07
I9586 n1_m1_388800_134400 0 8.483771e-07
I9587 n1_m1_388800_139200 0 9.837721e-07
I9588 n1_m1_388800_144000 0 1.180115e-06
I9589 n1_m1_388800_148800 0 6.310347e-07
I9590 n1_m1_388800_153600 0 1.003693e-06
I9591 n1_m1_388800_158400 0 7.632957e-07
I9592 n1_m1_388800_163200 0 6.555527e-07
I9593 n1_m1_388800_168000 0 1.498606e-06
I9594 n1_m1_388800_172800 0 1.149212e-06
I9595 n1_m1_388800_177600 0 1.090295e-06
I9596 n1_m1_388800_182400 0 5.295291e-07
I9597 n1_m1_388800_187200 0 6.141357e-07
I9598 n1_m1_388800_192000 0 8.169523e-07
I9599 n1_m1_388800_196800 0 2.860464e-07
I9600 n1_m1_388800_201600 0 4.150723e-07
I9601 n1_m1_388800_206400 0 5.615558e-07
I9602 n1_m1_388800_211200 0 4.683572e-07
I9603 n1_m1_388800_216000 0 8.927190e-07
I9604 n1_m1_388800_220800 0 6.778233e-07
I9605 n1_m1_388800_225600 0 1.797348e-06
I9606 n1_m1_388800_230400 0 1.090087e-06
I9607 n1_m1_388800_235200 0 1.180057e-06
I9608 n1_m1_388800_240000 0 2.030626e-06
I9609 n1_m1_388800_244800 0 1.271367e-06
I9610 n1_m1_388800_249600 0 1.267695e-06
I9611 n1_m1_388800_254400 0 7.885667e-07
I9612 n1_m1_388800_259200 0 5.347288e-07
I9613 n1_m1_388800_264000 0 7.882287e-07
I9614 n1_m1_388800_268800 0 3.476225e-07
I9615 n1_m1_388800_273600 0 7.600729e-07
I9616 n1_m1_388800_278400 0 6.286375e-07
I9617 n1_m1_388800_283200 0 4.856455e-07
I9618 n1_m1_388800_288000 0 1.066173e-06
I9619 n1_m1_388800_292800 0 6.116991e-07
I9620 n1_m1_388800_297600 0 1.170799e-06
I9621 n1_m1_388800_302400 0 6.629156e-07
I9622 n1_m1_388800_307200 0 4.605254e-07
I9623 n1_m1_388800_312000 0 4.692272e-07
I9624 n1_m1_388800_316800 0 4.167260e-07
I9625 n1_m1_388800_321600 0 4.915590e-07
I9626 n1_m1_388800_326400 0 6.568586e-07
I9627 n1_m1_388800_331200 0 1.198520e-06
I9628 n1_m1_388800_336000 0 1.733815e-06
I9629 n1_m1_388800_340800 0 1.290422e-06
I9630 n1_m1_388800_345600 0 1.621910e-06
I9631 n1_m1_388800_350400 0 9.048092e-07
I9632 n1_m1_388800_355200 0 4.966212e-07
I9633 n1_m1_388800_360000 0 4.976960e-07
I9634 n1_m1_388800_364800 0 2.115512e-07
I9635 n1_m1_388800_369600 0 2.612158e-07
I9636 n1_m1_388800_374400 0 1.536168e-07
I9637 n1_m1_388800_379200 0 1.564050e-07
I9638 n1_m1_388800_384000 0 2.268464e-07
I9639 n1_m1_388800_388800 0 1.500944e-07
I9640 n1_m1_388800_393600 0 2.385722e-07
I9641 n1_m1_388800_398400 0 1.553045e-07
I9642 n1_m1_388800_403200 0 1.736468e-07
I9643 n1_m1_388800_408000 0 2.945279e-07
I9644 n1_m1_388800_412800 0 2.351525e-07
I9645 n1_m1_388800_417600 0 1.159859e-06
I9646 n1_m1_388800_422400 0 4.205069e-07
I9647 n1_m1_388800_427200 0 1.916753e-07
I9648 n1_m1_388800_432000 0 2.464950e-07
I9649 n1_m1_388800_436800 0 1.563382e-07
I9650 n1_m1_388800_441600 0 2.258477e-07
I9651 n1_m1_388800_446400 0 1.459265e-07
I9652 n1_m1_388800_451200 0 1.475445e-07
I9653 n1_m1_388800_456000 0 2.284079e-07
I9654 n1_m1_388800_460800 0 1.465661e-07
I9655 n1_m1_388800_465600 0 2.223118e-07
I9656 n1_m1_388800_470400 0 1.479708e-07
I9657 n1_m1_388800_475200 0 1.431224e-07
I9658 n1_m1_388800_480000 0 2.131100e-07
I9659 n1_m1_388800_484800 0 1.430126e-07
I9660 n1_m1_388800_489600 0 2.158549e-07
I9661 n1_m1_388800_494400 0 1.420065e-07
I9662 n1_m1_388800_499200 0 1.426940e-07
I9663 n1_m1_388800_504000 0 2.098560e-07
I9664 n1_m1_388800_508800 0 1.399040e-07
I9665 n1_m1_388800_513600 0 2.098560e-07
I9666 n1_m1_388800_518400 0 1.399040e-07
I9667 n1_m1_388800_523200 0 1.400679e-07
I9668 n1_m1_388800_528000 0 2.169639e-07
I9669 n1_m1_388800_532800 0 1.514966e-07
I9670 n1_m1_388800_537600 0 2.383501e-07
I9671 n1_m1_388800_542400 0 1.819029e-07
I9672 n1_m1_388800_547200 0 2.164833e-07
I9673 n1_m1_388800_552000 0 3.198229e-07
I9674 n1_m1_388800_556800 0 1.659359e-07
I9675 n1_m1_388800_561600 0 8.158102e-08
I9676 n1_m1_393600_0 0 2.573974e-07
I9677 n1_m1_393600_4800 0 4.830444e-07
I9678 n1_m1_393600_9600 0 8.905557e-07
I9679 n1_m1_393600_14400 0 2.268856e-07
I9680 n1_m1_393600_19200 0 1.900826e-07
I9681 n1_m1_393600_24000 0 2.388357e-07
I9682 n1_m1_393600_28800 0 1.515388e-07
I9683 n1_m1_393600_33600 0 2.233114e-07
I9684 n1_m1_393600_38400 0 1.532282e-07
I9685 n1_m1_393600_43200 0 1.497549e-07
I9686 n1_m1_393600_48000 0 2.139316e-07
I9687 n1_m1_393600_52800 0 1.438991e-07
I9688 n1_m1_393600_57600 0 2.164843e-07
I9689 n1_m1_393600_62400 0 1.420758e-07
I9690 n1_m1_393600_67200 0 1.500709e-07
I9691 n1_m1_393600_72000 0 2.335654e-07
I9692 n1_m1_393600_76800 0 1.679156e-07
I9693 n1_m1_393600_81600 0 2.293620e-07
I9694 n1_m1_393600_86400 0 1.616426e-07
I9695 n1_m1_393600_91200 0 3.009898e-07
I9696 n1_m1_393600_96000 0 5.139699e-07
I9697 n1_m1_393600_100800 0 4.461908e-07
I9698 n1_m1_393600_105600 0 9.762048e-07
I9699 n1_m1_393600_110400 0 1.123851e-06
I9700 n1_m1_393600_115200 0 8.401763e-07
I9701 n1_m1_393600_120000 0 1.456622e-06
I9702 n1_m1_393600_124800 0 9.631978e-07
I9703 n1_m1_393600_129600 0 9.852853e-07
I9704 n1_m1_393600_134400 0 7.051791e-07
I9705 n1_m1_393600_139200 0 5.090168e-07
I9706 n1_m1_393600_144000 0 1.280980e-06
I9707 n1_m1_393600_148800 0 9.388092e-07
I9708 n1_m1_393600_153600 0 1.026179e-06
I9709 n1_m1_393600_158400 0 6.156286e-07
I9710 n1_m1_393600_163200 0 7.694232e-07
I9711 n1_m1_393600_168000 0 1.400451e-06
I9712 n1_m1_393600_172800 0 1.192328e-06
I9713 n1_m1_393600_177600 0 1.500443e-06
I9714 n1_m1_393600_182400 0 8.127176e-07
I9715 n1_m1_393600_187200 0 6.346034e-07
I9716 n1_m1_393600_192000 0 5.812789e-07
I9717 n1_m1_393600_196800 0 4.144663e-07
I9718 n1_m1_393600_201600 0 6.237359e-07
I9719 n1_m1_393600_206400 0 5.176377e-07
I9720 n1_m1_393600_211200 0 2.988924e-07
I9721 n1_m1_393600_216000 0 8.810333e-07
I9722 n1_m1_393600_220800 0 6.773000e-07
I9723 n1_m1_393600_225600 0 1.856525e-06
I9724 n1_m1_393600_230400 0 1.261167e-06
I9725 n1_m1_393600_235200 0 1.259486e-06
I9726 n1_m1_393600_240000 0 1.979301e-06
I9727 n1_m1_393600_244800 0 1.294211e-06
I9728 n1_m1_393600_249600 0 1.850974e-06
I9729 n1_m1_393600_254400 0 1.089012e-06
I9730 n1_m1_393600_259200 0 5.948646e-07
I9731 n1_m1_393600_264000 0 6.071152e-07
I9732 n1_m1_393600_268800 0 3.529103e-07
I9733 n1_m1_393600_273600 0 5.782764e-07
I9734 n1_m1_393600_278400 0 7.618594e-07
I9735 n1_m1_393600_283200 0 5.884294e-07
I9736 n1_m1_393600_288000 0 1.148728e-06
I9737 n1_m1_393600_292800 0 6.526468e-07
I9738 n1_m1_393600_297600 0 9.202898e-07
I9739 n1_m1_393600_302400 0 6.978133e-07
I9740 n1_m1_393600_307200 0 7.764774e-07
I9741 n1_m1_393600_312000 0 7.393010e-07
I9742 n1_m1_393600_316800 0 4.046632e-07
I9743 n1_m1_393600_321600 0 5.836466e-07
I9744 n1_m1_393600_326400 0 7.489143e-07
I9745 n1_m1_393600_331200 0 1.249530e-06
I9746 n1_m1_393600_336000 0 1.768675e-06
I9747 n1_m1_393600_340800 0 1.167114e-06
I9748 n1_m1_393600_345600 0 1.336342e-06
I9749 n1_m1_393600_350400 0 6.163771e-07
I9750 n1_m1_393600_355200 0 4.179989e-07
I9751 n1_m1_393600_360000 0 7.703079e-07
I9752 n1_m1_393600_364800 0 2.499702e-07
I9753 n1_m1_393600_369600 0 3.076338e-07
I9754 n1_m1_393600_374400 0 1.603457e-07
I9755 n1_m1_393600_379200 0 1.591487e-07
I9756 n1_m1_393600_384000 0 2.249761e-07
I9757 n1_m1_393600_388800 0 1.548048e-07
I9758 n1_m1_393600_393600 0 2.357498e-07
I9759 n1_m1_393600_398400 0 1.698295e-07
I9760 n1_m1_393600_403200 0 1.791657e-07
I9761 n1_m1_393600_408000 0 3.344742e-07
I9762 n1_m1_393600_412800 0 1.969533e-07
I9763 n1_m1_393600_417600 0 5.495469e-07
I9764 n1_m1_393600_422400 0 2.306600e-07
I9765 n1_m1_393600_427200 0 1.692167e-07
I9766 n1_m1_393600_432000 0 2.367863e-07
I9767 n1_m1_393600_436800 0 1.628295e-07
I9768 n1_m1_393600_441600 0 2.195079e-07
I9769 n1_m1_393600_446400 0 1.466783e-07
I9770 n1_m1_393600_451200 0 1.512769e-07
I9771 n1_m1_393600_456000 0 2.253697e-07
I9772 n1_m1_393600_460800 0 1.465661e-07
I9773 n1_m1_393600_465600 0 2.274121e-07
I9774 n1_m1_393600_470400 0 1.524636e-07
I9775 n1_m1_393600_475200 0 1.476152e-07
I9776 n1_m1_393600_480000 0 2.198491e-07
I9777 n1_m1_393600_484800 0 1.465661e-07
I9778 n1_m1_393600_489600 0 2.161387e-07
I9779 n1_m1_393600_494400 0 1.399040e-07
I9780 n1_m1_393600_499200 0 1.399040e-07
I9781 n1_m1_393600_504000 0 2.098560e-07
I9782 n1_m1_393600_508800 0 1.399040e-07
I9783 n1_m1_393600_513600 0 2.098560e-07
I9784 n1_m1_393600_518400 0 1.399040e-07
I9785 n1_m1_393600_523200 0 1.399040e-07
I9786 n1_m1_393600_528000 0 2.113200e-07
I9787 n1_m1_393600_532800 0 1.459400e-07
I9788 n1_m1_393600_537600 0 2.208970e-07
I9789 n1_m1_393600_542400 0 1.590220e-07
I9790 n1_m1_393600_547200 0 1.757938e-07
I9791 n1_m1_393600_552000 0 2.723143e-07
I9792 n1_m1_393600_556800 0 1.614432e-07
I9793 n1_m1_393600_561600 0 7.933463e-08
I9794 n1_m1_398400_0 0 2.184030e-07
I9795 n1_m1_398400_4800 0 2.953606e-07
I9796 n1_m1_398400_9600 0 7.575690e-07
I9797 n1_m1_398400_14400 0 5.013494e-07
I9798 n1_m1_398400_19200 0 4.992065e-07
I9799 n1_m1_398400_24000 0 3.226633e-07
I9800 n1_m1_398400_28800 0 1.599329e-07
I9801 n1_m1_398400_33600 0 2.316791e-07
I9802 n1_m1_398400_38400 0 1.547941e-07
I9803 n1_m1_398400_43200 0 1.497549e-07
I9804 n1_m1_398400_48000 0 2.136375e-07
I9805 n1_m1_398400_52800 0 1.399576e-07
I9806 n1_m1_398400_57600 0 2.139282e-07
I9807 n1_m1_398400_62400 0 1.412214e-07
I9808 n1_m1_398400_67200 0 1.450487e-07
I9809 n1_m1_398400_72000 0 2.184786e-07
I9810 n1_m1_398400_76800 0 1.579907e-07
I9811 n1_m1_398400_81600 0 2.249913e-07
I9812 n1_m1_398400_86400 0 1.534539e-07
I9813 n1_m1_398400_91200 0 2.352292e-07
I9814 n1_m1_398400_96000 0 4.037561e-07
I9815 n1_m1_398400_100800 0 5.333506e-07
I9816 n1_m1_398400_105600 0 1.248261e-06
I9817 n1_m1_398400_110400 0 1.187670e-06
I9818 n1_m1_398400_115200 0 1.119942e-06
I9819 n1_m1_398400_120000 0 1.658610e-06
I9820 n1_m1_398400_124800 0 1.195920e-06
I9821 n1_m1_398400_129600 0 1.467796e-06
I9822 n1_m1_398400_134400 0 7.509230e-07
I9823 n1_m1_398400_139200 0 4.736259e-07
I9824 n1_m1_398400_144000 0 9.427544e-07
I9825 n1_m1_398400_148800 0 8.642364e-07
I9826 n1_m1_398400_153600 0 1.293087e-06
I9827 n1_m1_398400_158400 0 1.057985e-06
I9828 n1_m1_398400_163200 0 1.198378e-06
I9829 n1_m1_398400_168000 0 1.654436e-06
I9830 n1_m1_398400_172800 0 1.115207e-06
I9831 n1_m1_398400_177600 0 1.760710e-06
I9832 n1_m1_398400_182400 0 1.081979e-06
I9833 n1_m1_398400_187200 0 1.037243e-06
I9834 n1_m1_398400_192000 0 1.661837e-06
I9835 n1_m1_398400_196800 0 8.309366e-07
I9836 n1_m1_398400_201600 0 6.027150e-07
I9837 n1_m1_398400_206400 0 7.329060e-07
I9838 n1_m1_398400_211200 0 6.142731e-07
I9839 n1_m1_398400_216000 0 1.583967e-06
I9840 n1_m1_398400_220800 0 9.954233e-07
I9841 n1_m1_398400_225600 0 1.608183e-06
I9842 n1_m1_398400_230400 0 1.248741e-06
I9843 n1_m1_398400_235200 0 1.281602e-06
I9844 n1_m1_398400_240000 0 2.058047e-06
I9845 n1_m1_398400_244800 0 1.366603e-06
I9846 n1_m1_398400_249600 0 1.825631e-06
I9847 n1_m1_398400_254400 0 1.130937e-06
I9848 n1_m1_398400_259200 0 5.620955e-07
I9849 n1_m1_398400_264000 0 1.000124e-06
I9850 n1_m1_398400_268800 0 5.788437e-07
I9851 n1_m1_398400_273600 0 5.315788e-07
I9852 n1_m1_398400_278400 0 5.198779e-07
I9853 n1_m1_398400_283200 0 6.804753e-07
I9854 n1_m1_398400_288000 0 1.483053e-06
I9855 n1_m1_398400_292800 0 1.079287e-06
I9856 n1_m1_398400_297600 0 1.703149e-06
I9857 n1_m1_398400_302400 0 1.254676e-06
I9858 n1_m1_398400_307200 0 9.430623e-07
I9859 n1_m1_398400_312000 0 1.149284e-06
I9860 n1_m1_398400_316800 0 8.540824e-07
I9861 n1_m1_398400_321600 0 9.550602e-07
I9862 n1_m1_398400_326400 0 1.079360e-06
I9863 n1_m1_398400_331200 0 1.132272e-06
I9864 n1_m1_398400_336000 0 1.637838e-06
I9865 n1_m1_398400_340800 0 1.144512e-06
I9866 n1_m1_398400_345600 0 1.020416e-06
I9867 n1_m1_398400_350400 0 7.710275e-07
I9868 n1_m1_398400_355200 0 5.964559e-07
I9869 n1_m1_398400_360000 0 5.804995e-07
I9870 n1_m1_398400_364800 0 2.791190e-07
I9871 n1_m1_398400_369600 0 2.882006e-07
I9872 n1_m1_398400_374400 0 1.712315e-07
I9873 n1_m1_398400_379200 0 1.602540e-07
I9874 n1_m1_398400_384000 0 2.657473e-07
I9875 n1_m1_398400_388800 0 2.386819e-07
I9876 n1_m1_398400_393600 0 5.121523e-07
I9877 n1_m1_398400_398400 0 3.650960e-07
I9878 n1_m1_398400_403200 0 3.890177e-07
I9879 n1_m1_398400_408000 0 9.531668e-07
I9880 n1_m1_398400_412800 0 5.231285e-07
I9881 n1_m1_398400_417600 0 8.250518e-07
I9882 n1_m1_398400_422400 0 6.023112e-07
I9883 n1_m1_398400_427200 0 3.092231e-07
I9884 n1_m1_398400_432000 0 2.692094e-07
I9885 n1_m1_398400_436800 0 1.546198e-07
I9886 n1_m1_398400_441600 0 2.336136e-07
I9887 n1_m1_398400_446400 0 1.590960e-07
I9888 n1_m1_398400_451200 0 1.575383e-07
I9889 n1_m1_398400_456000 0 2.241789e-07
I9890 n1_m1_398400_460800 0 1.505847e-07
I9891 n1_m1_398400_465600 0 2.334400e-07
I9892 n1_m1_398400_470400 0 1.564822e-07
I9893 n1_m1_398400_475200 0 1.513513e-07
I9894 n1_m1_398400_480000 0 2.195381e-07
I9895 n1_m1_398400_484800 0 1.434627e-07
I9896 n1_m1_398400_489600 0 2.181230e-07
I9897 n1_m1_398400_494400 0 1.439226e-07
I9898 n1_m1_398400_499200 0 1.423995e-07
I9899 n1_m1_398400_504000 0 2.098560e-07
I9900 n1_m1_398400_508800 0 1.399040e-07
I9901 n1_m1_398400_513600 0 2.098560e-07
I9902 n1_m1_398400_518400 0 1.399040e-07
I9903 n1_m1_398400_523200 0 1.399040e-07
I9904 n1_m1_398400_528000 0 2.113200e-07
I9905 n1_m1_398400_532800 0 1.450487e-07
I9906 n1_m1_398400_537600 0 2.137619e-07
I9907 n1_m1_398400_542400 0 1.519005e-07
I9908 n1_m1_398400_547200 0 1.640392e-07
I9909 n1_m1_398400_552000 0 2.570618e-07
I9910 n1_m1_398400_556800 0 1.597914e-07
I9911 n1_m1_398400_561600 0 7.878762e-08
I9912 n1_m1_403200_0 0 2.174013e-07
I9913 n1_m1_403200_4800 0 3.016878e-07
I9914 n1_m1_403200_9600 0 1.018219e-06
I9915 n1_m1_403200_14400 0 7.825782e-07
I9916 n1_m1_403200_19200 0 6.628869e-07
I9917 n1_m1_403200_24000 0 3.397206e-07
I9918 n1_m1_403200_28800 0 1.597637e-07
I9919 n1_m1_403200_33600 0 2.422585e-07
I9920 n1_m1_403200_38400 0 1.592501e-07
I9921 n1_m1_403200_43200 0 1.531807e-07
I9922 n1_m1_403200_48000 0 2.189744e-07
I9923 n1_m1_403200_52800 0 1.460644e-07
I9924 n1_m1_403200_57600 0 2.227394e-07
I9925 n1_m1_403200_62400 0 1.443260e-07
I9926 n1_m1_403200_67200 0 1.458290e-07
I9927 n1_m1_403200_72000 0 2.178193e-07
I9928 n1_m1_403200_76800 0 1.498526e-07
I9929 n1_m1_403200_81600 0 2.313553e-07
I9930 n1_m1_403200_86400 0 1.582207e-07
I9931 n1_m1_403200_91200 0 1.684012e-07
I9932 n1_m1_403200_96000 0 2.908372e-07
I9933 n1_m1_403200_100800 0 6.911474e-07
I9934 n1_m1_403200_105600 0 1.270445e-06
I9935 n1_m1_403200_110400 0 1.151414e-06
I9936 n1_m1_403200_115200 0 1.210866e-06
I9937 n1_m1_403200_120000 0 1.628976e-06
I9938 n1_m1_403200_124800 0 1.204223e-06
I9939 n1_m1_403200_129600 0 1.727773e-06
I9940 n1_m1_403200_134400 0 6.815719e-07
I9941 n1_m1_403200_139200 0 4.673711e-07
I9942 n1_m1_403200_144000 0 6.337544e-07
I9943 n1_m1_403200_148800 0 7.781526e-07
I9944 n1_m1_403200_153600 0 1.682739e-06
I9945 n1_m1_403200_158400 0 9.759217e-07
I9946 n1_m1_403200_163200 0 8.378005e-07
I9947 n1_m1_403200_168000 0 1.416162e-06
I9948 n1_m1_403200_172800 0 9.120791e-07
I9949 n1_m1_403200_177600 0 1.813718e-06
I9950 n1_m1_403200_182400 0 1.181360e-06
I9951 n1_m1_403200_187200 0 1.088073e-06
I9952 n1_m1_403200_192000 0 1.794736e-06
I9953 n1_m1_403200_196800 0 9.731249e-07
I9954 n1_m1_403200_201600 0 9.335641e-07
I9955 n1_m1_403200_206400 0 1.059687e-06
I9956 n1_m1_403200_211200 0 8.230788e-07
I9957 n1_m1_403200_216000 0 1.686529e-06
I9958 n1_m1_403200_220800 0 1.079952e-06
I9959 n1_m1_403200_225600 0 1.306812e-06
I9960 n1_m1_403200_230400 0 1.276801e-06
I9961 n1_m1_403200_235200 0 1.419837e-06
I9962 n1_m1_403200_240000 0 1.990056e-06
I9963 n1_m1_403200_244800 0 1.354937e-06
I9964 n1_m1_403200_249600 0 1.614407e-06
I9965 n1_m1_403200_254400 0 1.100047e-06
I9966 n1_m1_403200_259200 0 7.487487e-07
I9967 n1_m1_403200_264000 0 8.286199e-07
I9968 n1_m1_403200_268800 0 2.909051e-07
I9969 n1_m1_403200_273600 0 4.502068e-07
I9970 n1_m1_403200_278400 0 4.684498e-07
I9971 n1_m1_403200_283200 0 8.525891e-07
I9972 n1_m1_403200_288000 0 1.838432e-06
I9973 n1_m1_403200_292800 0 1.172328e-06
I9974 n1_m1_403200_297600 0 1.756323e-06
I9975 n1_m1_403200_302400 0 9.294258e-07
I9976 n1_m1_403200_307200 0 8.138425e-07
I9977 n1_m1_403200_312000 0 1.520378e-06
I9978 n1_m1_403200_316800 0 8.661079e-07
I9979 n1_m1_403200_321600 0 8.372002e-07
I9980 n1_m1_403200_326400 0 1.046263e-06
I9981 n1_m1_403200_331200 0 9.721471e-07
I9982 n1_m1_403200_336000 0 1.392526e-06
I9983 n1_m1_403200_340800 0 1.100158e-06
I9984 n1_m1_403200_345600 0 7.789737e-07
I9985 n1_m1_403200_350400 0 7.016474e-07
I9986 n1_m1_403200_355200 0 4.966320e-07
I9987 n1_m1_403200_360000 0 5.756259e-07
I9988 n1_m1_403200_364800 0 7.197161e-07
I9989 n1_m1_403200_369600 0 4.796433e-07
I9990 n1_m1_403200_374400 0 2.387348e-07
I9991 n1_m1_403200_379200 0 1.783074e-07
I9992 n1_m1_403200_384000 0 3.541991e-07
I9993 n1_m1_403200_388800 0 4.245301e-07
I9994 n1_m1_403200_393600 0 1.054836e-06
I9995 n1_m1_403200_398400 0 6.366581e-07
I9996 n1_m1_403200_403200 0 7.772881e-07
I9997 n1_m1_403200_408000 0 1.604471e-06
I9998 n1_m1_403200_412800 0 7.248570e-07
I9999 n1_m1_403200_417600 0 9.673856e-07
I10000 n1_m1_403200_422400 0 5.840625e-07
I10001 n1_m1_403200_427200 0 2.931038e-07
I10002 n1_m1_403200_432000 0 3.801727e-07
I10003 n1_m1_403200_436800 0 1.514722e-07
I10004 n1_m1_403200_441600 0 2.343405e-07
I10005 n1_m1_403200_446400 0 1.562612e-07
I10006 n1_m1_403200_451200 0 1.532790e-07
I10007 n1_m1_403200_456000 0 2.364563e-07
I10008 n1_m1_403200_460800 0 1.635058e-07
I10009 n1_m1_403200_465600 0 2.483870e-07
I10010 n1_m1_403200_470400 0 1.625454e-07
I10011 n1_m1_403200_475200 0 1.543485e-07
I10012 n1_m1_403200_480000 0 2.202905e-07
I10013 n1_m1_403200_484800 0 1.440669e-07
I10014 n1_m1_403200_489600 0 2.196447e-07
I10015 n1_m1_403200_494400 0 1.465661e-07
I10016 n1_m1_403200_499200 0 1.453395e-07
I10017 n1_m1_403200_504000 0 2.123339e-07
I10018 n1_m1_403200_508800 0 1.399040e-07
I10019 n1_m1_403200_513600 0 2.098560e-07
I10020 n1_m1_403200_518400 0 1.399040e-07
I10021 n1_m1_403200_523200 0 1.399040e-07
I10022 n1_m1_403200_528000 0 2.113200e-07
I10023 n1_m1_403200_532800 0 1.462496e-07
I10024 n1_m1_403200_537600 0 2.250515e-07
I10025 n1_m1_403200_542400 0 1.608066e-07
I10026 n1_m1_403200_547200 0 1.708910e-07
I10027 n1_m1_403200_552000 0 2.609022e-07
I10028 n1_m1_403200_556800 0 1.587048e-07
I10029 n1_m1_403200_561600 0 7.842778e-08
I10030 n1_m1_408000_0 0 3.307458e-07
I10031 n1_m1_408000_4800 0 5.284919e-07
I10032 n1_m1_408000_9600 0 1.708217e-06
I10033 n1_m1_408000_14400 0 1.039499e-06
I10034 n1_m1_408000_19200 0 7.593180e-07
I10035 n1_m1_408000_24000 0 5.262347e-07
I10036 n1_m1_408000_28800 0 2.822591e-07
I10037 n1_m1_408000_33600 0 3.570484e-07
I10038 n1_m1_408000_38400 0 2.474917e-07
I10039 n1_m1_408000_43200 0 2.406012e-07
I10040 n1_m1_408000_48000 0 3.392966e-07
I10041 n1_m1_408000_52800 0 2.274156e-07
I10042 n1_m1_408000_57600 0 3.423273e-07
I10043 n1_m1_408000_62400 0 2.215153e-07
I10044 n1_m1_408000_67200 0 2.253119e-07
I10045 n1_m1_408000_72000 0 3.492578e-07
I10046 n1_m1_408000_76800 0 2.493655e-07
I10047 n1_m1_408000_81600 0 3.596901e-07
I10048 n1_m1_408000_86400 0 2.447663e-07
I10049 n1_m1_408000_91200 0 2.816874e-07
I10050 n1_m1_408000_96000 0 4.506686e-07
I10051 n1_m1_408000_100800 0 8.154191e-07
I10052 n1_m1_408000_105600 0 1.578641e-06
I10053 n1_m1_408000_110400 0 1.745138e-06
I10054 n1_m1_408000_115200 0 1.872469e-06
I10055 n1_m1_408000_120000 0 2.751525e-06
I10056 n1_m1_408000_124800 0 1.701778e-06
I10057 n1_m1_408000_129600 0 2.178605e-06
I10058 n1_m1_408000_134400 0 1.178921e-06
I10059 n1_m1_408000_139200 0 1.076163e-06
I10060 n1_m1_408000_144000 0 1.344415e-06
I10061 n1_m1_408000_148800 0 1.077249e-06
I10062 n1_m1_408000_153600 0 1.557548e-06
I10063 n1_m1_408000_158400 0 6.384863e-07
I10064 n1_m1_408000_163200 0 4.590640e-07
I10065 n1_m1_408000_168000 0 1.265247e-06
I10066 n1_m1_408000_172800 0 1.539411e-06
I10067 n1_m1_408000_177600 0 2.461386e-06
I10068 n1_m1_408000_182400 0 1.468208e-06
I10069 n1_m1_408000_187200 0 9.925645e-07
I10070 n1_m1_408000_192000 0 1.807375e-06
I10071 n1_m1_408000_196800 0 1.350652e-06
I10072 n1_m1_408000_201600 0 1.573484e-06
I10073 n1_m1_408000_206400 0 1.265746e-06
I10074 n1_m1_408000_211200 0 1.043435e-06
I10075 n1_m1_408000_216000 0 2.628782e-06
I10076 n1_m1_408000_220800 0 1.642684e-06
I10077 n1_m1_408000_225600 0 2.530497e-06
I10078 n1_m1_408000_230400 0 1.827548e-06
I10079 n1_m1_408000_235200 0 1.760699e-06
I10080 n1_m1_408000_240000 0 2.887662e-06
I10081 n1_m1_408000_244800 0 1.941939e-06
I10082 n1_m1_408000_249600 0 2.695061e-06
I10083 n1_m1_408000_254400 0 1.801913e-06
I10084 n1_m1_408000_259200 0 9.799737e-07
I10085 n1_m1_408000_264000 0 6.400112e-07
I10086 n1_m1_408000_268800 0 2.983579e-07
I10087 n1_m1_408000_273600 0 1.028172e-06
I10088 n1_m1_408000_278400 0 1.252537e-06
I10089 n1_m1_408000_283200 0 9.746618e-07
I10090 n1_m1_408000_288000 0 1.939759e-06
I10091 n1_m1_408000_292800 0 1.392402e-06
I10092 n1_m1_408000_297600 0 2.407101e-06
I10093 n1_m1_408000_302400 0 1.430197e-06
I10094 n1_m1_408000_307200 0 1.352197e-06
I10095 n1_m1_408000_312000 0 1.777100e-06
I10096 n1_m1_408000_316800 0 1.012878e-06
I10097 n1_m1_408000_321600 0 1.304245e-06
I10098 n1_m1_408000_326400 0 1.493576e-06
I10099 n1_m1_408000_331200 0 1.649552e-06
I10100 n1_m1_408000_336000 0 2.045973e-06
I10101 n1_m1_408000_340800 0 1.438531e-06
I10102 n1_m1_408000_345600 0 8.245644e-07
I10103 n1_m1_408000_350400 0 9.547172e-07
I10104 n1_m1_408000_355200 0 7.018359e-07
I10105 n1_m1_408000_360000 0 1.529453e-06
I10106 n1_m1_408000_364800 0 1.451243e-06
I10107 n1_m1_408000_369600 0 1.058223e-06
I10108 n1_m1_408000_374400 0 4.472894e-07
I10109 n1_m1_408000_379200 0 7.844930e-07
I10110 n1_m1_408000_384000 0 1.483735e-06
I10111 n1_m1_408000_388800 0 1.211949e-06
I10112 n1_m1_408000_393600 0 2.253058e-06
I10113 n1_m1_408000_398400 0 1.064451e-06
I10114 n1_m1_408000_403200 0 1.439889e-06
I10115 n1_m1_408000_408000 0 2.841771e-06
I10116 n1_m1_408000_412800 0 1.049641e-06
I10117 n1_m1_408000_417600 0 1.107622e-06
I10118 n1_m1_408000_422400 0 6.361365e-07
I10119 n1_m1_408000_427200 0 4.495360e-07
I10120 n1_m1_408000_432000 0 1.633382e-06
I10121 n1_m1_408000_436800 0 6.293289e-07
I10122 n1_m1_408000_441600 0 7.815312e-07
I10123 n1_m1_408000_446400 0 3.545113e-07
I10124 n1_m1_408000_451200 0 3.152085e-07
I10125 n1_m1_408000_456000 0 4.936491e-07
I10126 n1_m1_408000_460800 0 2.656243e-07
I10127 n1_m1_408000_465600 0 3.898472e-07
I10128 n1_m1_408000_470400 0 2.483438e-07
I10129 n1_m1_408000_475200 0 2.322557e-07
I10130 n1_m1_408000_480000 0 3.323622e-07
I10131 n1_m1_408000_484800 0 2.217786e-07
I10132 n1_m1_408000_489600 0 3.355613e-07
I10133 n1_m1_408000_494400 0 2.198491e-07
I10134 n1_m1_408000_499200 0 2.198491e-07
I10135 n1_m1_408000_504000 0 3.222929e-07
I10136 n1_m1_408000_508800 0 2.099801e-07
I10137 n1_m1_408000_513600 0 3.140107e-07
I10138 n1_m1_408000_518400 0 2.046259e-07
I10139 n1_m1_408000_523200 0 2.044338e-07
I10140 n1_m1_408000_528000 0 3.251179e-07
I10141 n1_m1_408000_532800 0 2.344595e-07
I10142 n1_m1_408000_537600 0 3.775571e-07
I10143 n1_m1_408000_542400 0 2.657962e-07
I10144 n1_m1_408000_547200 0 2.741731e-07
I10145 n1_m1_408000_552000 0 4.032491e-07
I10146 n1_m1_408000_556800 0 2.408039e-07
I10147 n1_m1_408000_561600 0 1.186123e-07
I10148 n1_m1_412800_0 0 2.700901e-07
I10149 n1_m1_412800_4800 0 3.794799e-07
I10150 n1_m1_412800_9600 0 1.025532e-06
I10151 n1_m1_412800_14400 0 5.422369e-07
I10152 n1_m1_412800_19200 0 5.069944e-07
I10153 n1_m1_412800_24000 0 7.260438e-07
I10154 n1_m1_412800_28800 0 3.668264e-07
I10155 n1_m1_412800_33600 0 2.338875e-07
I10156 n1_m1_412800_38400 0 1.664872e-07
I10157 n1_m1_412800_43200 0 1.602976e-07
I10158 n1_m1_412800_48000 0 2.244411e-07
I10159 n1_m1_412800_52800 0 1.476425e-07
I10160 n1_m1_412800_57600 0 2.217101e-07
I10161 n1_m1_412800_62400 0 1.476391e-07
I10162 n1_m1_412800_67200 0 1.529810e-07
I10163 n1_m1_412800_72000 0 2.608786e-07
I10164 n1_m1_412800_76800 0 2.115759e-07
I10165 n1_m1_412800_81600 0 2.472190e-07
I10166 n1_m1_412800_86400 0 1.612482e-07
I10167 n1_m1_412800_91200 0 2.707575e-07
I10168 n1_m1_412800_96000 0 4.318684e-07
I10169 n1_m1_412800_100800 0 4.170938e-07
I10170 n1_m1_412800_105600 0 1.106191e-06
I10171 n1_m1_412800_110400 0 1.312355e-06
I10172 n1_m1_412800_115200 0 1.180463e-06
I10173 n1_m1_412800_120000 0 1.790361e-06
I10174 n1_m1_412800_124800 0 1.006119e-06
I10175 n1_m1_412800_129600 0 1.640018e-06
I10176 n1_m1_412800_134400 0 9.539873e-07
I10177 n1_m1_412800_139200 0 8.355226e-07
I10178 n1_m1_412800_144000 0 1.062723e-06
I10179 n1_m1_412800_148800 0 7.030496e-07
I10180 n1_m1_412800_153600 0 7.710411e-07
I10181 n1_m1_412800_158400 0 2.431767e-07
I10182 n1_m1_412800_163200 0 2.529331e-07
I10183 n1_m1_412800_168000 0 7.993121e-07
I10184 n1_m1_412800_172800 0 8.102663e-07
I10185 n1_m1_412800_177600 0 1.171678e-06
I10186 n1_m1_412800_182400 0 9.846764e-07
I10187 n1_m1_412800_187200 0 8.308555e-07
I10188 n1_m1_412800_192000 0 1.244083e-06
I10189 n1_m1_412800_196800 0 6.216220e-07
I10190 n1_m1_412800_201600 0 6.433005e-07
I10191 n1_m1_412800_206400 0 6.814986e-07
I10192 n1_m1_412800_211200 0 7.299844e-07
I10193 n1_m1_412800_216000 0 1.894239e-06
I10194 n1_m1_412800_220800 0 1.288387e-06
I10195 n1_m1_412800_225600 0 1.972208e-06
I10196 n1_m1_412800_230400 0 1.214284e-06
I10197 n1_m1_412800_235200 0 1.209457e-06
I10198 n1_m1_412800_240000 0 1.901314e-06
I10199 n1_m1_412800_244800 0 1.278568e-06
I10200 n1_m1_412800_249600 0 1.649702e-06
I10201 n1_m1_412800_254400 0 9.036682e-07
I10202 n1_m1_412800_259200 0 5.016931e-07
I10203 n1_m1_412800_264000 0 3.414006e-07
I10204 n1_m1_412800_268800 0 2.106626e-07
I10205 n1_m1_412800_273600 0 9.443670e-07
I10206 n1_m1_412800_278400 0 1.092410e-06
I10207 n1_m1_412800_283200 0 7.756426e-07
I10208 n1_m1_412800_288000 0 1.524300e-06
I10209 n1_m1_412800_292800 0 1.008478e-06
I10210 n1_m1_412800_297600 0 1.842694e-06
I10211 n1_m1_412800_302400 0 1.216250e-06
I10212 n1_m1_412800_307200 0 1.244736e-06
I10213 n1_m1_412800_312000 0 1.350506e-06
I10214 n1_m1_412800_316800 0 1.035276e-06
I10215 n1_m1_412800_321600 0 1.582359e-06
I10216 n1_m1_412800_326400 0 1.263017e-06
I10217 n1_m1_412800_331200 0 1.377128e-06
I10218 n1_m1_412800_336000 0 1.759272e-06
I10219 n1_m1_412800_340800 0 1.067281e-06
I10220 n1_m1_412800_345600 0 9.500492e-07
I10221 n1_m1_412800_350400 0 9.090546e-07
I10222 n1_m1_412800_355200 0 7.686571e-07
I10223 n1_m1_412800_360000 0 1.202326e-06
I10224 n1_m1_412800_364800 0 5.698601e-07
I10225 n1_m1_412800_369600 0 4.651860e-07
I10226 n1_m1_412800_374400 0 3.379461e-07
I10227 n1_m1_412800_379200 0 7.911876e-07
I10228 n1_m1_412800_384000 0 1.662481e-06
I10229 n1_m1_412800_388800 0 1.108696e-06
I10230 n1_m1_412800_393600 0 1.626496e-06
I10231 n1_m1_412800_398400 0 7.044474e-07
I10232 n1_m1_412800_403200 0 9.166929e-07
I10233 n1_m1_412800_408000 0 1.898431e-06
I10234 n1_m1_412800_412800 0 9.175798e-07
I10235 n1_m1_412800_417600 0 1.122113e-06
I10236 n1_m1_412800_422400 0 6.018693e-07
I10237 n1_m1_412800_427200 0 4.768326e-07
I10238 n1_m1_412800_432000 0 1.457895e-06
I10239 n1_m1_412800_436800 0 5.729322e-07
I10240 n1_m1_412800_441600 0 7.152190e-07
I10241 n1_m1_412800_446400 0 2.801928e-07
I10242 n1_m1_412800_451200 0 2.409331e-07
I10243 n1_m1_412800_456000 0 3.501283e-07
I10244 n1_m1_412800_460800 0 1.746014e-07
I10245 n1_m1_412800_465600 0 2.532781e-07
I10246 n1_m1_412800_470400 0 1.611062e-07
I10247 n1_m1_412800_475200 0 1.543936e-07
I10248 n1_m1_412800_480000 0 2.294127e-07
I10249 n1_m1_412800_484800 0 1.572195e-07
I10250 n1_m1_412800_489600 0 2.310682e-07
I10251 n1_m1_412800_494400 0 1.465661e-07
I10252 n1_m1_412800_499200 0 1.465661e-07
I10253 n1_m1_412800_504000 0 2.186706e-07
I10254 n1_m1_412800_508800 0 1.417136e-07
I10255 n1_m1_412800_513600 0 2.090566e-07
I10256 n1_m1_412800_518400 0 1.346920e-07
I10257 n1_m1_412800_523200 0 1.379561e-07
I10258 n1_m1_412800_528000 0 2.274259e-07
I10259 n1_m1_412800_532800 0 1.658767e-07
I10260 n1_m1_412800_537600 0 2.597198e-07
I10261 n1_m1_412800_542400 0 1.772425e-07
I10262 n1_m1_412800_547200 0 1.812186e-07
I10263 n1_m1_412800_552000 0 2.663941e-07
I10264 n1_m1_412800_556800 0 1.644465e-07
I10265 n1_m1_412800_561600 0 8.119783e-08
I10266 n1_m1_417600_0 0 3.314897e-07
I10267 n1_m1_417600_4800 0 4.485241e-07
I10268 n1_m1_417600_9600 0 1.361452e-06
I10269 n1_m1_417600_14400 0 7.557733e-07
I10270 n1_m1_417600_19200 0 5.315698e-07
I10271 n1_m1_417600_24000 0 5.828690e-07
I10272 n1_m1_417600_28800 0 3.214887e-07
I10273 n1_m1_417600_33600 0 3.392873e-07
I10274 n1_m1_417600_38400 0 2.379565e-07
I10275 n1_m1_417600_43200 0 2.288777e-07
I10276 n1_m1_417600_48000 0 3.226956e-07
I10277 n1_m1_417600_52800 0 2.119426e-07
I10278 n1_m1_417600_57600 0 3.261267e-07
I10279 n1_m1_417600_62400 0 2.159786e-07
I10280 n1_m1_417600_67200 0 2.279165e-07
I10281 n1_m1_417600_72000 0 3.834384e-07
I10282 n1_m1_417600_76800 0 2.989037e-07
I10283 n1_m1_417600_81600 0 3.889310e-07
I10284 n1_m1_417600_86400 0 2.568393e-07
I10285 n1_m1_417600_91200 0 4.181720e-07
I10286 n1_m1_417600_96000 0 7.461099e-07
I10287 n1_m1_417600_100800 0 8.535036e-07
I10288 n1_m1_417600_105600 0 1.645905e-06
I10289 n1_m1_417600_110400 0 1.789415e-06
I10290 n1_m1_417600_115200 0 1.469437e-06
I10291 n1_m1_417600_120000 0 2.563267e-06
I10292 n1_m1_417600_124800 0 1.340792e-06
I10293 n1_m1_417600_129600 0 1.920708e-06
I10294 n1_m1_417600_134400 0 1.258131e-06
I10295 n1_m1_417600_139200 0 1.391503e-06
I10296 n1_m1_417600_144000 0 1.850317e-06
I10297 n1_m1_417600_148800 0 1.260198e-06
I10298 n1_m1_417600_153600 0 1.061007e-06
I10299 n1_m1_417600_158400 0 5.627183e-07
I10300 n1_m1_417600_163200 0 3.347740e-07
I10301 n1_m1_417600_168000 0 5.908398e-07
I10302 n1_m1_417600_172800 0 5.198015e-07
I10303 n1_m1_417600_177600 0 9.457363e-07
I10304 n1_m1_417600_182400 0 8.056979e-07
I10305 n1_m1_417600_187200 0 5.030308e-07
I10306 n1_m1_417600_192000 0 7.614154e-07
I10307 n1_m1_417600_196800 0 4.019105e-07
I10308 n1_m1_417600_201600 0 5.178222e-07
I10309 n1_m1_417600_206400 0 5.920597e-07
I10310 n1_m1_417600_211200 0 7.339855e-07
I10311 n1_m1_417600_216000 0 2.451133e-06
I10312 n1_m1_417600_220800 0 1.841921e-06
I10313 n1_m1_417600_225600 0 2.990801e-06
I10314 n1_m1_417600_230400 0 1.837057e-06
I10315 n1_m1_417600_235200 0 1.879674e-06
I10316 n1_m1_417600_240000 0 2.830211e-06
I10317 n1_m1_417600_244800 0 1.871913e-06
I10318 n1_m1_417600_249600 0 2.485892e-06
I10319 n1_m1_417600_254400 0 1.539615e-06
I10320 n1_m1_417600_259200 0 7.426609e-07
I10321 n1_m1_417600_264000 0 9.422993e-07
I10322 n1_m1_417600_268800 0 3.467333e-07
I10323 n1_m1_417600_273600 0 1.012059e-06
I10324 n1_m1_417600_278400 0 1.196015e-06
I10325 n1_m1_417600_283200 0 1.061975e-06
I10326 n1_m1_417600_288000 0 2.685380e-06
I10327 n1_m1_417600_292800 0 1.778340e-06
I10328 n1_m1_417600_297600 0 2.842636e-06
I10329 n1_m1_417600_302400 0 1.960616e-06
I10330 n1_m1_417600_307200 0 1.920350e-06
I10331 n1_m1_417600_312000 0 2.661259e-06
I10332 n1_m1_417600_316800 0 1.833366e-06
I10333 n1_m1_417600_321600 0 2.451590e-06
I10334 n1_m1_417600_326400 0 1.955196e-06
I10335 n1_m1_417600_331200 0 1.918729e-06
I10336 n1_m1_417600_336000 0 2.660843e-06
I10337 n1_m1_417600_340800 0 1.797595e-06
I10338 n1_m1_417600_345600 0 1.948676e-06
I10339 n1_m1_417600_350400 0 1.439938e-06
I10340 n1_m1_417600_355200 0 1.214825e-06
I10341 n1_m1_417600_360000 0 1.336343e-06
I10342 n1_m1_417600_364800 0 5.027252e-07
I10343 n1_m1_417600_369600 0 8.638116e-07
I10344 n1_m1_417600_374400 0 5.196068e-07
I10345 n1_m1_417600_379200 0 7.458866e-07
I10346 n1_m1_417600_384000 0 1.839485e-06
I10347 n1_m1_417600_388800 0 1.075603e-06
I10348 n1_m1_417600_393600 0 1.906012e-06
I10349 n1_m1_417600_398400 0 9.893998e-07
I10350 n1_m1_417600_403200 0 1.243157e-06
I10351 n1_m1_417600_408000 0 2.695219e-06
I10352 n1_m1_417600_412800 0 1.743624e-06
I10353 n1_m1_417600_417600 0 2.423045e-06
I10354 n1_m1_417600_422400 0 1.211262e-06
I10355 n1_m1_417600_427200 0 7.183601e-07
I10356 n1_m1_417600_432000 0 1.265210e-06
I10357 n1_m1_417600_436800 0 4.128022e-07
I10358 n1_m1_417600_441600 0 6.859663e-07
I10359 n1_m1_417600_446400 0 4.138098e-07
I10360 n1_m1_417600_451200 0 3.826060e-07
I10361 n1_m1_417600_456000 0 4.257000e-07
I10362 n1_m1_417600_460800 0 2.529616e-07
I10363 n1_m1_417600_465600 0 3.644594e-07
I10364 n1_m1_417600_470400 0 2.325785e-07
I10365 n1_m1_417600_475200 0 2.300636e-07
I10366 n1_m1_417600_480000 0 3.469634e-07
I10367 n1_m1_417600_484800 0 2.438863e-07
I10368 n1_m1_417600_489600 0 3.576433e-07
I10369 n1_m1_417600_494400 0 2.191648e-07
I10370 n1_m1_417600_499200 0 2.203366e-07
I10371 n1_m1_417600_504000 0 3.264779e-07
I10372 n1_m1_417600_508800 0 2.166807e-07
I10373 n1_m1_417600_513600 0 3.192123e-07
I10374 n1_m1_417600_518400 0 2.085160e-07
I10375 n1_m1_417600_523200 0 2.104048e-07
I10376 n1_m1_417600_528000 0 3.508359e-07
I10377 n1_m1_417600_532800 0 2.531234e-07
I10378 n1_m1_417600_537600 0 3.786563e-07
I10379 n1_m1_417600_542400 0 2.497721e-07
I10380 n1_m1_417600_547200 0 2.553975e-07
I10381 n1_m1_417600_552000 0 3.867744e-07
I10382 n1_m1_417600_556800 0 2.413231e-07
I10383 n1_m1_417600_561600 0 1.192746e-07
I10384 n1_m1_422400_0 0 1.099351e-07
I10385 n1_m1_422400_4800 0 1.710701e-07
I10386 n1_m1_422400_9600 0 3.461703e-07
I10387 n1_m1_422400_14400 0 1.586985e-07
I10388 n1_m1_422400_19200 0 1.072075e-07
I10389 n1_m1_422400_24000 0 1.251369e-07
I10390 n1_m1_422400_28800 0 7.673315e-08
I10391 n1_m1_422400_33600 0 1.127144e-07
I10392 n1_m1_422400_38400 0 7.153453e-08
I10393 n1_m1_422400_43200 0 7.098449e-08
I10394 n1_m1_422400_48000 0 1.052274e-07
I10395 n1_m1_422400_52800 0 6.999644e-08
I10396 n1_m1_422400_57600 0 1.088547e-07
I10397 n1_m1_422400_62400 0 7.295592e-08
I10398 n1_m1_422400_67200 0 7.434423e-08
I10399 n1_m1_422400_72000 0 1.212082e-07
I10400 n1_m1_422400_76800 0 8.439526e-08
I10401 n1_m1_422400_81600 0 1.214939e-07
I10402 n1_m1_422400_86400 0 8.836816e-08
I10403 n1_m1_422400_91200 0 9.924426e-08
I10404 n1_m1_422400_96000 0 1.564596e-07
I10405 n1_m1_422400_100800 0 1.619429e-07
I10406 n1_m1_422400_105600 0 4.756988e-07
I10407 n1_m1_422400_110400 0 5.145771e-07
I10408 n1_m1_422400_115200 0 4.962871e-07
I10409 n1_m1_422400_120000 0 8.926400e-07
I10410 n1_m1_422400_124800 0 5.637980e-07
I10411 n1_m1_422400_129600 0 8.359340e-07
I10412 n1_m1_422400_134400 0 5.865599e-07
I10413 n1_m1_422400_139200 0 5.757190e-07
I10414 n1_m1_422400_144000 0 6.921949e-07
I10415 n1_m1_422400_148800 0 3.152546e-07
I10416 n1_m1_422400_153600 0 2.306676e-07
I10417 n1_m1_422400_158400 0 1.103488e-07
I10418 n1_m1_422400_163200 0 8.797792e-08
I10419 n1_m1_422400_168000 0 1.247642e-07
I10420 n1_m1_422400_172800 0 8.992307e-08
I10421 n1_m1_422400_177600 0 1.541432e-07
I10422 n1_m1_422400_182400 0 1.096395e-07
I10423 n1_m1_422400_187200 0 8.780680e-08
I10424 n1_m1_422400_192000 0 1.338672e-07
I10425 n1_m1_422400_196800 0 8.861591e-08
I10426 n1_m1_422400_201600 0 1.332097e-07
I10427 n1_m1_422400_206400 0 1.020480e-07
I10428 n1_m1_422400_211200 0 1.320446e-07
I10429 n1_m1_422400_216000 0 5.235363e-07
I10430 n1_m1_422400_220800 0 5.321368e-07
I10431 n1_m1_422400_225600 0 9.924560e-07
I10432 n1_m1_422400_230400 0 6.417942e-07
I10433 n1_m1_422400_235200 0 6.644785e-07
I10434 n1_m1_422400_240000 0 9.939481e-07
I10435 n1_m1_422400_244800 0 6.547770e-07
I10436 n1_m1_422400_249600 0 9.046620e-07
I10437 n1_m1_422400_254400 0 4.566549e-07
I10438 n1_m1_422400_259200 0 2.295521e-07
I10439 n1_m1_422400_264000 0 1.926760e-07
I10440 n1_m1_422400_268800 0 9.761573e-08
I10441 n1_m1_422400_273600 0 2.415027e-07
I10442 n1_m1_422400_278400 0 2.808998e-07
I10443 n1_m1_422400_283200 0 3.402588e-07
I10444 n1_m1_422400_288000 0 9.523529e-07
I10445 n1_m1_422400_292800 0 6.352862e-07
I10446 n1_m1_422400_297600 0 9.795446e-07
I10447 n1_m1_422400_302400 0 6.827610e-07
I10448 n1_m1_422400_307200 0 6.787890e-07
I10449 n1_m1_422400_312000 0 9.679992e-07
I10450 n1_m1_422400_316800 0 6.479403e-07
I10451 n1_m1_422400_321600 0 8.839604e-07
I10452 n1_m1_422400_326400 0 6.537007e-07
I10453 n1_m1_422400_331200 0 6.368931e-07
I10454 n1_m1_422400_336000 0 9.420936e-07
I10455 n1_m1_422400_340800 0 6.385774e-07
I10456 n1_m1_422400_345600 0 7.874115e-07
I10457 n1_m1_422400_350400 0 5.627674e-07
I10458 n1_m1_422400_355200 0 5.119649e-07
I10459 n1_m1_422400_360000 0 4.869070e-07
I10460 n1_m1_422400_364800 0 1.928529e-07
I10461 n1_m1_422400_369600 0 2.161525e-07
I10462 n1_m1_422400_374400 0 1.314811e-07
I10463 n1_m1_422400_379200 0 1.772938e-07
I10464 n1_m1_422400_384000 0 3.345733e-07
I10465 n1_m1_422400_388800 0 2.335431e-07
I10466 n1_m1_422400_393600 0 4.084089e-07
I10467 n1_m1_422400_398400 0 2.838100e-07
I10468 n1_m1_422400_403200 0 4.068111e-07
I10469 n1_m1_422400_408000 0 8.835299e-07
I10470 n1_m1_422400_412800 0 5.918200e-07
I10471 n1_m1_422400_417600 0 8.708574e-07
I10472 n1_m1_422400_422400 0 4.451438e-07
I10473 n1_m1_422400_427200 0 2.446492e-07
I10474 n1_m1_422400_432000 0 2.952425e-07
I10475 n1_m1_422400_436800 0 9.199670e-08
I10476 n1_m1_422400_441600 0 1.430479e-07
I10477 n1_m1_422400_446400 0 9.502576e-08
I10478 n1_m1_422400_451200 0 9.353910e-08
I10479 n1_m1_422400_456000 0 1.223679e-07
I10480 n1_m1_422400_460800 0 8.579038e-08
I10481 n1_m1_422400_465600 0 1.199114e-07
I10482 n1_m1_422400_470400 0 7.667369e-08
I10483 n1_m1_422400_475200 0 7.641704e-08
I10484 n1_m1_422400_480000 0 1.145622e-07
I10485 n1_m1_422400_484800 0 8.320881e-08
I10486 n1_m1_422400_489600 0 1.109948e-07
I10487 n1_m1_422400_494400 0 7.179148e-08
I10488 n1_m1_422400_499200 0 7.434558e-08
I10489 n1_m1_422400_504000 0 1.137201e-07
I10490 n1_m1_422400_508800 0 7.406466e-08
I10491 n1_m1_422400_513600 0 1.090097e-07
I10492 n1_m1_422400_518400 0 7.036354e-08
I10493 n1_m1_422400_523200 0 7.011198e-08
I10494 n1_m1_422400_528000 0 1.112858e-07
I10495 n1_m1_422400_532800 0 7.750272e-08
I10496 n1_m1_422400_537600 0 1.131034e-07
I10497 n1_m1_422400_542400 0 7.711040e-08
I10498 n1_m1_422400_547200 0 8.238288e-08
I10499 n1_m1_422400_552000 0 1.295368e-07
I10500 n1_m1_422400_556800 0 8.215595e-08
I10501 n1_m1_422400_561600 0 4.061566e-08
I10502 n1_m1_427200_0 0 1.717265e-07
I10503 n1_m1_427200_4800 0 2.084342e-07
I10504 n1_m1_427200_9600 0 3.303508e-07
I10505 n1_m1_427200_14400 0 1.801266e-07
I10506 n1_m1_427200_19200 0 1.636826e-07
I10507 n1_m1_427200_24000 0 2.252064e-07
I10508 n1_m1_427200_28800 0 1.428938e-07
I10509 n1_m1_427200_33600 0 2.134644e-07
I10510 n1_m1_427200_38400 0 1.399040e-07
I10511 n1_m1_427200_43200 0 1.399040e-07
I10512 n1_m1_427200_48000 0 2.098560e-07
I10513 n1_m1_427200_52800 0 1.399929e-07
I10514 n1_m1_427200_57600 0 2.179169e-07
I10515 n1_m1_427200_62400 0 1.465661e-07
I10516 n1_m1_427200_67200 0 1.466688e-07
I10517 n1_m1_427200_72000 0 2.237280e-07
I10518 n1_m1_427200_76800 0 1.527073e-07
I10519 n1_m1_427200_81600 0 2.212966e-07
I10520 n1_m1_427200_86400 0 1.560224e-07
I10521 n1_m1_427200_91200 0 1.590956e-07
I10522 n1_m1_427200_96000 0 2.339593e-07
I10523 n1_m1_427200_100800 0 1.782791e-07
I10524 n1_m1_427200_105600 0 3.719568e-07
I10525 n1_m1_427200_110400 0 4.245013e-07
I10526 n1_m1_427200_115200 0 4.507395e-07
I10527 n1_m1_427200_120000 0 1.103802e-06
I10528 n1_m1_427200_124800 0 6.985271e-07
I10529 n1_m1_427200_129600 0 1.070846e-06
I10530 n1_m1_427200_134400 0 7.547248e-07
I10531 n1_m1_427200_139200 0 6.712019e-07
I10532 n1_m1_427200_144000 0 6.711699e-07
I10533 n1_m1_427200_148800 0 2.711381e-07
I10534 n1_m1_427200_153600 0 2.685556e-07
I10535 n1_m1_427200_158400 0 1.568985e-07
I10536 n1_m1_427200_163200 0 1.544065e-07
I10537 n1_m1_427200_168000 0 2.293567e-07
I10538 n1_m1_427200_172800 0 1.530838e-07
I10539 n1_m1_427200_177600 0 2.319465e-07
I10540 n1_m1_427200_182400 0 1.545954e-07
I10541 n1_m1_427200_187200 0 1.550063e-07
I10542 n1_m1_427200_192000 0 2.325095e-07
I10543 n1_m1_427200_196800 0 1.550063e-07
I10544 n1_m1_427200_201600 0 2.329992e-07
I10545 n1_m1_427200_206400 0 1.599541e-07
I10546 n1_m1_427200_211200 0 1.720865e-07
I10547 n1_m1_427200_216000 0 4.659515e-07
I10548 n1_m1_427200_220800 0 4.963188e-07
I10549 n1_m1_427200_225600 0 1.422052e-06
I10550 n1_m1_427200_230400 0 1.099993e-06
I10551 n1_m1_427200_235200 0 1.268098e-06
I10552 n1_m1_427200_240000 0 1.685458e-06
I10553 n1_m1_427200_244800 0 9.080416e-07
I10554 n1_m1_427200_249600 0 9.648857e-07
I10555 n1_m1_427200_254400 0 3.905354e-07
I10556 n1_m1_427200_259200 0 2.437879e-07
I10557 n1_m1_427200_264000 0 2.737654e-07
I10558 n1_m1_427200_268800 0 1.739100e-07
I10559 n1_m1_427200_273600 0 2.815271e-07
I10560 n1_m1_427200_278400 0 2.748713e-07
I10561 n1_m1_427200_283200 0 4.709665e-07
I10562 n1_m1_427200_288000 0 1.246399e-06
I10563 n1_m1_427200_292800 0 9.541620e-07
I10564 n1_m1_427200_297600 0 1.774843e-06
I10565 n1_m1_427200_302400 0 9.743147e-07
I10566 n1_m1_427200_307200 0 1.046763e-06
I10567 n1_m1_427200_312000 0 1.703904e-06
I10568 n1_m1_427200_316800 0 9.350979e-07
I10569 n1_m1_427200_321600 0 1.010472e-06
I10570 n1_m1_427200_326400 0 9.157068e-07
I10571 n1_m1_427200_331200 0 9.810310e-07
I10572 n1_m1_427200_336000 0 1.472710e-06
I10573 n1_m1_427200_340800 0 1.107858e-06
I10574 n1_m1_427200_345600 0 1.200516e-06
I10575 n1_m1_427200_350400 0 8.987342e-07
I10576 n1_m1_427200_355200 0 7.860859e-07
I10577 n1_m1_427200_360000 0 6.701255e-07
I10578 n1_m1_427200_364800 0 2.842611e-07
I10579 n1_m1_427200_369600 0 2.883128e-07
I10580 n1_m1_427200_374400 0 1.760217e-07
I10581 n1_m1_427200_379200 0 1.918850e-07
I10582 n1_m1_427200_384000 0 2.943355e-07
I10583 n1_m1_427200_388800 0 2.070395e-07
I10584 n1_m1_427200_393600 0 3.359252e-07
I10585 n1_m1_427200_398400 0 2.379956e-07
I10586 n1_m1_427200_403200 0 3.737393e-07
I10587 n1_m1_427200_408000 0 1.066143e-06
I10588 n1_m1_427200_412800 0 6.788880e-07
I10589 n1_m1_427200_417600 0 1.085977e-06
I10590 n1_m1_427200_422400 0 5.300781e-07
I10591 n1_m1_427200_427200 0 2.622406e-07
I10592 n1_m1_427200_432000 0 3.460830e-07
I10593 n1_m1_427200_436800 0 1.578510e-07
I10594 n1_m1_427200_441600 0 2.344630e-07
I10595 n1_m1_427200_446400 0 1.526058e-07
I10596 n1_m1_427200_451200 0 1.553318e-07
I10597 n1_m1_427200_456000 0 2.312212e-07
I10598 n1_m1_427200_460800 0 1.645730e-07
I10599 n1_m1_427200_465600 0 2.355565e-07
I10600 n1_m1_427200_470400 0 1.526377e-07
I10601 n1_m1_427200_475200 0 1.488844e-07
I10602 n1_m1_427200_480000 0 2.279631e-07
I10603 n1_m1_427200_484800 0 1.633384e-07
I10604 n1_m1_427200_489600 0 2.140542e-07
I10605 n1_m1_427200_494400 0 1.406585e-07
I10606 n1_m1_427200_499200 0 1.429900e-07
I10607 n1_m1_427200_504000 0 2.200447e-07
I10608 n1_m1_427200_508800 0 1.466109e-07
I10609 n1_m1_427200_513600 0 2.197458e-07
I10610 n1_m1_427200_518400 0 1.453905e-07
I10611 n1_m1_427200_523200 0 1.412637e-07
I10612 n1_m1_427200_528000 0 2.184061e-07
I10613 n1_m1_427200_532800 0 1.470808e-07
I10614 n1_m1_427200_537600 0 2.189560e-07
I10615 n1_m1_427200_542400 0 1.491473e-07
I10616 n1_m1_427200_547200 0 1.598030e-07
I10617 n1_m1_427200_552000 0 2.587322e-07
I10618 n1_m1_427200_556800 0 1.616434e-07
I10619 n1_m1_427200_561600 0 7.954003e-08
I10620 n1_m1_432000_0 0 2.846196e-07
I10621 n1_m1_432000_4800 0 3.548902e-07
I10622 n1_m1_432000_9600 0 4.762374e-07
I10623 n1_m1_432000_14400 0 2.520872e-07
I10624 n1_m1_432000_19200 0 2.466501e-07
I10625 n1_m1_432000_24000 0 3.594331e-07
I10626 n1_m1_432000_28800 0 2.251618e-07
I10627 n1_m1_432000_33600 0 3.303875e-07
I10628 n1_m1_432000_38400 0 2.098560e-07
I10629 n1_m1_432000_43200 0 2.098560e-07
I10630 n1_m1_432000_48000 0 3.147839e-07
I10631 n1_m1_432000_52800 0 2.099893e-07
I10632 n1_m1_432000_57600 0 3.268753e-07
I10633 n1_m1_432000_62400 0 2.198491e-07
I10634 n1_m1_432000_67200 0 2.193916e-07
I10635 n1_m1_432000_72000 0 3.299603e-07
I10636 n1_m1_432000_76800 0 2.271520e-07
I10637 n1_m1_432000_81600 0 3.204184e-07
I10638 n1_m1_432000_86400 0 2.241344e-07
I10639 n1_m1_432000_91200 0 2.287398e-07
I10640 n1_m1_432000_96000 0 3.355860e-07
I10641 n1_m1_432000_100800 0 2.435149e-07
I10642 n1_m1_432000_105600 0 3.765912e-07
I10643 n1_m1_432000_110400 0 3.018394e-07
I10644 n1_m1_432000_115200 0 3.358657e-07
I10645 n1_m1_432000_120000 0 9.805298e-07
I10646 n1_m1_432000_124800 0 6.100893e-07
I10647 n1_m1_432000_129600 0 8.850033e-07
I10648 n1_m1_432000_134400 0 5.461975e-07
I10649 n1_m1_432000_139200 0 4.880859e-07
I10650 n1_m1_432000_144000 0 5.284388e-07
I10651 n1_m1_432000_148800 0 2.719634e-07
I10652 n1_m1_432000_153600 0 3.589207e-07
I10653 n1_m1_432000_158400 0 2.297793e-07
I10654 n1_m1_432000_163200 0 2.241574e-07
I10655 n1_m1_432000_168000 0 3.231956e-07
I10656 n1_m1_432000_172800 0 2.137962e-07
I10657 n1_m1_432000_177600 0 3.273678e-07
I10658 n1_m1_432000_182400 0 2.170816e-07
I10659 n1_m1_432000_187200 0 2.209693e-07
I10660 n1_m1_432000_192000 0 3.314540e-07
I10661 n1_m1_432000_196800 0 2.209693e-07
I10662 n1_m1_432000_201600 0 3.315606e-07
I10663 n1_m1_432000_206400 0 2.223980e-07
I10664 n1_m1_432000_211200 0 2.302030e-07
I10665 n1_m1_432000_216000 0 4.259378e-07
I10666 n1_m1_432000_220800 0 4.928098e-07
I10667 n1_m1_432000_225600 0 1.769562e-06
I10668 n1_m1_432000_230400 0 1.216782e-06
I10669 n1_m1_432000_235200 0 1.407585e-06
I10670 n1_m1_432000_240000 0 1.638208e-06
I10671 n1_m1_432000_244800 0 1.053732e-06
I10672 n1_m1_432000_249600 0 1.132183e-06
I10673 n1_m1_432000_254400 0 3.160981e-07
I10674 n1_m1_432000_259200 0 2.464857e-07
I10675 n1_m1_432000_264000 0 3.701601e-07
I10676 n1_m1_432000_268800 0 2.518691e-07
I10677 n1_m1_432000_273600 0 3.751835e-07
I10678 n1_m1_432000_278400 0 2.938270e-07
I10679 n1_m1_432000_283200 0 4.136853e-07
I10680 n1_m1_432000_288000 0 1.205584e-06
I10681 n1_m1_432000_292800 0 1.014802e-06
I10682 n1_m1_432000_297600 0 1.898365e-06
I10683 n1_m1_432000_302400 0 7.164564e-07
I10684 n1_m1_432000_307200 0 1.146781e-06
I10685 n1_m1_432000_312000 0 1.793251e-06
I10686 n1_m1_432000_316800 0 8.400086e-07
I10687 n1_m1_432000_321600 0 6.579683e-07
I10688 n1_m1_432000_326400 0 7.190990e-07
I10689 n1_m1_432000_331200 0 1.019669e-06
I10690 n1_m1_432000_336000 0 1.316301e-06
I10691 n1_m1_432000_340800 0 1.213412e-06
I10692 n1_m1_432000_345600 0 9.557720e-07
I10693 n1_m1_432000_350400 0 7.644726e-07
I10694 n1_m1_432000_355200 0 6.906935e-07
I10695 n1_m1_432000_360000 0 5.584607e-07
I10696 n1_m1_432000_364800 0 2.770799e-07
I10697 n1_m1_432000_369600 0 3.557928e-07
I10698 n1_m1_432000_374400 0 2.324877e-07
I10699 n1_m1_432000_379200 0 2.433928e-07
I10700 n1_m1_432000_384000 0 3.691187e-07
I10701 n1_m1_432000_388800 0 2.560848e-07
I10702 n1_m1_432000_393600 0 4.085728e-07
I10703 n1_m1_432000_398400 0 2.678945e-07
I10704 n1_m1_432000_403200 0 3.100791e-07
I10705 n1_m1_432000_408000 0 8.501102e-07
I10706 n1_m1_432000_412800 0 5.676977e-07
I10707 n1_m1_432000_417600 0 1.197964e-06
I10708 n1_m1_432000_422400 0 5.178808e-07
I10709 n1_m1_432000_427200 0 2.932788e-07
I10710 n1_m1_432000_432000 0 4.322025e-07
I10711 n1_m1_432000_436800 0 2.318464e-07
I10712 n1_m1_432000_441600 0 3.395378e-07
I10713 n1_m1_432000_446400 0 2.252013e-07
I10714 n1_m1_432000_451200 0 2.298422e-07
I10715 n1_m1_432000_456000 0 3.492717e-07
I10716 n1_m1_432000_460800 0 2.536912e-07
I10717 n1_m1_432000_465600 0 3.565016e-07
I10718 n1_m1_432000_470400 0 2.322947e-07
I10719 n1_m1_432000_475200 0 2.355663e-07
I10720 n1_m1_432000_480000 0 3.767304e-07
I10721 n1_m1_432000_484800 0 2.808428e-07
I10722 n1_m1_432000_489600 0 3.447825e-07
I10723 n1_m1_432000_494400 0 2.145766e-07
I10724 n1_m1_432000_499200 0 2.102805e-07
I10725 n1_m1_432000_504000 0 3.164643e-07
I10726 n1_m1_432000_508800 0 2.168020e-07
I10727 n1_m1_432000_513600 0 3.297737e-07
I10728 n1_m1_432000_518400 0 2.190401e-07
I10729 n1_m1_432000_523200 0 2.121320e-07
I10730 n1_m1_432000_528000 0 3.273376e-07
I10731 n1_m1_432000_532800 0 2.186991e-07
I10732 n1_m1_432000_537600 0 3.194368e-07
I10733 n1_m1_432000_542400 0 2.185293e-07
I10734 n1_m1_432000_547200 0 2.364146e-07
I10735 n1_m1_432000_552000 0 3.763668e-07
I10736 n1_m1_432000_556800 0 2.371563e-07
I10737 n1_m1_432000_561600 0 1.169530e-07
I10738 n1_m1_436800_0 0 2.025327e-07
I10739 n1_m1_436800_4800 0 2.772219e-07
I10740 n1_m1_436800_9600 0 3.896848e-07
I10741 n1_m1_436800_14400 0 1.723264e-07
I10742 n1_m1_436800_19200 0 1.588770e-07
I10743 n1_m1_436800_24000 0 2.187822e-07
I10744 n1_m1_436800_28800 0 1.399040e-07
I10745 n1_m1_436800_33600 0 2.098560e-07
I10746 n1_m1_436800_38400 0 1.399040e-07
I10747 n1_m1_436800_43200 0 1.399040e-07
I10748 n1_m1_436800_48000 0 2.098560e-07
I10749 n1_m1_436800_52800 0 1.399929e-07
I10750 n1_m1_436800_57600 0 2.179169e-07
I10751 n1_m1_436800_62400 0 1.465661e-07
I10752 n1_m1_436800_67200 0 1.469132e-07
I10753 n1_m1_436800_72000 0 2.277312e-07
I10754 n1_m1_436800_76800 0 1.563577e-07
I10755 n1_m1_436800_81600 0 2.201929e-07
I10756 n1_m1_436800_86400 0 1.537972e-07
I10757 n1_m1_436800_91200 0 1.576473e-07
I10758 n1_m1_436800_96000 0 2.312542e-07
I10759 n1_m1_436800_100800 0 1.629724e-07
I10760 n1_m1_436800_105600 0 2.587294e-07
I10761 n1_m1_436800_110400 0 1.904646e-07
I10762 n1_m1_436800_115200 0 2.163988e-07
I10763 n1_m1_436800_120000 0 5.517604e-07
I10764 n1_m1_436800_124800 0 2.848453e-07
I10765 n1_m1_436800_129600 0 3.941148e-07
I10766 n1_m1_436800_134400 0 2.252757e-07
I10767 n1_m1_436800_139200 0 2.303760e-07
I10768 n1_m1_436800_144000 0 2.909115e-07
I10769 n1_m1_436800_148800 0 1.736796e-07
I10770 n1_m1_436800_153600 0 2.397074e-07
I10771 n1_m1_436800_158400 0 1.523626e-07
I10772 n1_m1_436800_163200 0 1.527076e-07
I10773 n1_m1_436800_168000 0 2.224934e-07
I10774 n1_m1_436800_172800 0 1.441602e-07
I10775 n1_m1_436800_177600 0 2.195479e-07
I10776 n1_m1_436800_182400 0 1.465661e-07
I10777 n1_m1_436800_187200 0 1.465661e-07
I10778 n1_m1_436800_192000 0 2.198491e-07
I10779 n1_m1_436800_196800 0 1.465661e-07
I10780 n1_m1_436800_201600 0 2.215802e-07
I10781 n1_m1_436800_206400 0 1.487971e-07
I10782 n1_m1_436800_211200 0 1.564297e-07
I10783 n1_m1_436800_216000 0 3.240484e-07
I10784 n1_m1_436800_220800 0 4.795544e-07
I10785 n1_m1_436800_225600 0 1.464043e-06
I10786 n1_m1_436800_230400 0 6.375676e-07
I10787 n1_m1_436800_235200 0 5.917536e-07
I10788 n1_m1_436800_240000 0 9.882763e-07
I10789 n1_m1_436800_244800 0 8.524520e-07
I10790 n1_m1_436800_249600 0 8.470911e-07
I10791 n1_m1_436800_254400 0 2.052963e-07
I10792 n1_m1_436800_259200 0 1.587167e-07
I10793 n1_m1_436800_264000 0 2.377295e-07
I10794 n1_m1_436800_268800 0 1.576308e-07
I10795 n1_m1_436800_273600 0 2.582243e-07
I10796 n1_m1_436800_278400 0 2.181030e-07
I10797 n1_m1_436800_283200 0 2.413100e-07
I10798 n1_m1_436800_288000 0 5.505678e-07
I10799 n1_m1_436800_292800 0 4.813725e-07
I10800 n1_m1_436800_297600 0 1.106007e-06
I10801 n1_m1_436800_302400 0 6.092129e-07
I10802 n1_m1_436800_307200 0 9.118983e-07
I10803 n1_m1_436800_312000 0 7.335441e-07
I10804 n1_m1_436800_316800 0 3.569395e-07
I10805 n1_m1_436800_321600 0 3.092542e-07
I10806 n1_m1_436800_326400 0 3.272841e-07
I10807 n1_m1_436800_331200 0 6.156959e-07
I10808 n1_m1_436800_336000 0 6.835863e-07
I10809 n1_m1_436800_340800 0 6.753630e-07
I10810 n1_m1_436800_345600 0 4.617084e-07
I10811 n1_m1_436800_350400 0 4.537377e-07
I10812 n1_m1_436800_355200 0 4.175345e-07
I10813 n1_m1_436800_360000 0 3.217107e-07
I10814 n1_m1_436800_364800 0 1.672245e-07
I10815 n1_m1_436800_369600 0 2.244367e-07
I10816 n1_m1_436800_374400 0 1.495843e-07
I10817 n1_m1_436800_379200 0 1.625463e-07
I10818 n1_m1_436800_384000 0 2.469092e-07
I10819 n1_m1_436800_388800 0 1.613458e-07
I10820 n1_m1_436800_393600 0 2.567572e-07
I10821 n1_m1_436800_398400 0 1.620778e-07
I10822 n1_m1_436800_403200 0 1.613957e-07
I10823 n1_m1_436800_408000 0 3.214135e-07
I10824 n1_m1_436800_412800 0 2.458593e-07
I10825 n1_m1_436800_417600 0 8.200345e-07
I10826 n1_m1_436800_422400 0 3.153172e-07
I10827 n1_m1_436800_427200 0 1.909187e-07
I10828 n1_m1_436800_432000 0 3.140166e-07
I10829 n1_m1_436800_436800 0 1.564525e-07
I10830 n1_m1_436800_441600 0 2.243722e-07
I10831 n1_m1_436800_446400 0 1.492136e-07
I10832 n1_m1_436800_451200 0 1.530447e-07
I10833 n1_m1_436800_456000 0 2.397333e-07
I10834 n1_m1_436800_460800 0 1.740088e-07
I10835 n1_m1_436800_465600 0 2.397230e-07
I10836 n1_m1_436800_470400 0 1.589448e-07
I10837 n1_m1_436800_475200 0 1.679492e-07
I10838 n1_m1_436800_480000 0 2.699150e-07
I10839 n1_m1_436800_484800 0 2.105397e-07
I10840 n1_m1_436800_489600 0 2.393244e-07
I10841 n1_m1_436800_494400 0 1.442528e-07
I10842 n1_m1_436800_499200 0 1.409714e-07
I10843 n1_m1_436800_504000 0 2.098560e-07
I10844 n1_m1_436800_508800 0 1.442782e-07
I10845 n1_m1_436800_513600 0 2.198491e-07
I10846 n1_m1_436800_518400 0 1.460267e-07
I10847 n1_m1_436800_523200 0 1.414840e-07
I10848 n1_m1_436800_528000 0 2.203844e-07
I10849 n1_m1_436800_532800 0 1.479837e-07
I10850 n1_m1_436800_537600 0 2.175970e-07
I10851 n1_m1_436800_542400 0 1.462691e-07
I10852 n1_m1_436800_547200 0 1.579124e-07
I10853 n1_m1_436800_552000 0 2.512014e-07
I10854 n1_m1_436800_556800 0 1.547811e-07
I10855 n1_m1_436800_561600 0 7.600359e-08
I10856 n1_m1_441600_0 0 3.172794e-07
I10857 n1_m1_441600_4800 0 4.797721e-07
I10858 n1_m1_441600_9600 0 7.869985e-07
I10859 n1_m1_441600_14400 0 2.912133e-07
I10860 n1_m1_441600_19200 0 2.480128e-07
I10861 n1_m1_441600_24000 0 3.349588e-07
I10862 n1_m1_441600_28800 0 2.167858e-07
I10863 n1_m1_441600_33600 0 3.246789e-07
I10864 n1_m1_441600_38400 0 2.098560e-07
I10865 n1_m1_441600_43200 0 2.098560e-07
I10866 n1_m1_441600_48000 0 3.147839e-07
I10867 n1_m1_441600_52800 0 2.099893e-07
I10868 n1_m1_441600_57600 0 3.268753e-07
I10869 n1_m1_441600_62400 0 2.198491e-07
I10870 n1_m1_441600_67200 0 2.192634e-07
I10871 n1_m1_441600_72000 0 3.329845e-07
I10872 n1_m1_441600_76800 0 2.386974e-07
I10873 n1_m1_441600_81600 0 3.339023e-07
I10874 n1_m1_441600_86400 0 2.329539e-07
I10875 n1_m1_441600_91200 0 2.457954e-07
I10876 n1_m1_441600_96000 0 3.674479e-07
I10877 n1_m1_441600_100800 0 2.538982e-07
I10878 n1_m1_441600_105600 0 3.767155e-07
I10879 n1_m1_441600_110400 0 2.661820e-07
I10880 n1_m1_441600_115200 0 2.881821e-07
I10881 n1_m1_441600_120000 0 5.927440e-07
I10882 n1_m1_441600_124800 0 2.702536e-07
I10883 n1_m1_441600_129600 0 4.144679e-07
I10884 n1_m1_441600_134400 0 3.157756e-07
I10885 n1_m1_441600_139200 0 3.377570e-07
I10886 n1_m1_441600_144000 0 3.957845e-07
I10887 n1_m1_441600_148800 0 2.464516e-07
I10888 n1_m1_441600_153600 0 3.388347e-07
I10889 n1_m1_441600_158400 0 2.209008e-07
I10890 n1_m1_441600_163200 0 2.279952e-07
I10891 n1_m1_441600_168000 0 3.444726e-07
I10892 n1_m1_441600_172800 0 2.277436e-07
I10893 n1_m1_441600_177600 0 3.306706e-07
I10894 n1_m1_441600_182400 0 2.198491e-07
I10895 n1_m1_441600_187200 0 2.198491e-07
I10896 n1_m1_441600_192000 0 3.297737e-07
I10897 n1_m1_441600_196800 0 2.198491e-07
I10898 n1_m1_441600_201600 0 3.358466e-07
I10899 n1_m1_441600_206400 0 2.301995e-07
I10900 n1_m1_441600_211200 0 2.504385e-07
I10901 n1_m1_441600_216000 0 6.220313e-07
I10902 n1_m1_441600_220800 0 8.129511e-07
I10903 n1_m1_441600_225600 0 2.264910e-06
I10904 n1_m1_441600_230400 0 1.112193e-06
I10905 n1_m1_441600_235200 0 1.123108e-06
I10906 n1_m1_441600_240000 0 1.618008e-06
I10907 n1_m1_441600_244800 0 9.321480e-07
I10908 n1_m1_441600_249600 0 7.147085e-07
I10909 n1_m1_441600_254400 0 2.633496e-07
I10910 n1_m1_441600_259200 0 2.411334e-07
I10911 n1_m1_441600_264000 0 3.525615e-07
I10912 n1_m1_441600_268800 0 2.295835e-07
I10913 n1_m1_441600_273600 0 3.489279e-07
I10914 n1_m1_441600_278400 0 2.649010e-07
I10915 n1_m1_441600_283200 0 3.741746e-07
I10916 n1_m1_441600_288000 0 1.034651e-06
I10917 n1_m1_441600_292800 0 1.104074e-06
I10918 n1_m1_441600_297600 0 2.218194e-06
I10919 n1_m1_441600_302400 0 1.453530e-06
I10920 n1_m1_441600_307200 0 1.726116e-06
I10921 n1_m1_441600_312000 0 1.480685e-06
I10922 n1_m1_441600_316800 0 5.843767e-07
I10923 n1_m1_441600_321600 0 5.901659e-07
I10924 n1_m1_441600_326400 0 6.063742e-07
I10925 n1_m1_441600_331200 0 1.027819e-06
I10926 n1_m1_441600_336000 0 1.361815e-06
I10927 n1_m1_441600_340800 0 1.229110e-06
I10928 n1_m1_441600_345600 0 1.037121e-06
I10929 n1_m1_441600_350400 0 7.300955e-07
I10930 n1_m1_441600_355200 0 5.965519e-07
I10931 n1_m1_441600_360000 0 4.544671e-07
I10932 n1_m1_441600_364800 0 2.500489e-07
I10933 n1_m1_441600_369600 0 3.419413e-07
I10934 n1_m1_441600_374400 0 2.251450e-07
I10935 n1_m1_441600_379200 0 2.299047e-07
I10936 n1_m1_441600_384000 0 3.467776e-07
I10937 n1_m1_441600_388800 0 2.396679e-07
I10938 n1_m1_441600_393600 0 3.692779e-07
I10939 n1_m1_441600_398400 0 2.293432e-07
I10940 n1_m1_441600_403200 0 2.266179e-07
I10941 n1_m1_441600_408000 0 4.105966e-07
I10942 n1_m1_441600_412800 0 3.628249e-07
I10943 n1_m1_441600_417600 0 1.544936e-06
I10944 n1_m1_441600_422400 0 4.649234e-07
I10945 n1_m1_441600_427200 0 2.708501e-07
I10946 n1_m1_441600_432000 0 4.279552e-07
I10947 n1_m1_441600_436800 0 2.243722e-07
I10948 n1_m1_441600_441600 0 3.301161e-07
I10949 n1_m1_441600_446400 0 2.244109e-07
I10950 n1_m1_441600_451200 0 2.371179e-07
I10951 n1_m1_441600_456000 0 3.573472e-07
I10952 n1_m1_441600_460800 0 2.518029e-07
I10953 n1_m1_441600_465600 0 3.611876e-07
I10954 n1_m1_441600_470400 0 2.385591e-07
I10955 n1_m1_441600_475200 0 2.428533e-07
I10956 n1_m1_441600_480000 0 3.645367e-07
I10957 n1_m1_441600_484800 0 2.581851e-07
I10958 n1_m1_441600_489600 0 3.382542e-07
I10959 n1_m1_441600_494400 0 2.197576e-07
I10960 n1_m1_441600_499200 0 2.159402e-07
I10961 n1_m1_441600_504000 0 3.180156e-07
I10962 n1_m1_441600_508800 0 2.233101e-07
I10963 n1_m1_441600_513600 0 3.412123e-07
I10964 n1_m1_441600_518400 0 2.202617e-07
I10965 n1_m1_441600_523200 0 2.124894e-07
I10966 n1_m1_441600_528000 0 3.396456e-07
I10967 n1_m1_441600_532800 0 2.279295e-07
I10968 n1_m1_441600_537600 0 3.306281e-07
I10969 n1_m1_441600_542400 0 2.237326e-07
I10970 n1_m1_441600_547200 0 2.391166e-07
I10971 n1_m1_441600_552000 0 3.827175e-07
I10972 n1_m1_441600_556800 0 2.321716e-07
I10973 n1_m1_441600_561600 0 1.140054e-07
I10974 n1_m1_446400_0 0 1.811595e-07
I10975 n1_m1_446400_4800 0 2.483692e-07
I10976 n1_m1_446400_9600 0 4.119599e-07
I10977 n1_m1_446400_14400 0 1.794552e-07
I10978 n1_m1_446400_19200 0 1.587671e-07
I10979 n1_m1_446400_24000 0 2.195137e-07
I10980 n1_m1_446400_28800 0 1.450569e-07
I10981 n1_m1_446400_33600 0 2.172138e-07
I10982 n1_m1_446400_38400 0 1.399040e-07
I10983 n1_m1_446400_43200 0 1.399040e-07
I10984 n1_m1_446400_48000 0 2.098560e-07
I10985 n1_m1_446400_52800 0 1.399929e-07
I10986 n1_m1_446400_57600 0 2.179169e-07
I10987 n1_m1_446400_62400 0 1.465661e-07
I10988 n1_m1_446400_67200 0 1.473343e-07
I10989 n1_m1_446400_72000 0 2.377194e-07
I10990 n1_m1_446400_76800 0 1.737242e-07
I10991 n1_m1_446400_81600 0 2.397805e-07
I10992 n1_m1_446400_86400 0 1.664854e-07
I10993 n1_m1_446400_91200 0 1.867556e-07
I10994 n1_m1_446400_96000 0 2.856189e-07
I10995 n1_m1_446400_100800 0 2.044476e-07
I10996 n1_m1_446400_105600 0 2.741149e-07
I10997 n1_m1_446400_110400 0 1.721395e-07
I10998 n1_m1_446400_115200 0 1.860849e-07
I10999 n1_m1_446400_120000 0 3.349514e-07
I11000 n1_m1_446400_124800 0 1.905935e-07
I11001 n1_m1_446400_129600 0 3.464418e-07
I11002 n1_m1_446400_134400 0 2.573325e-07
I11003 n1_m1_446400_139200 0 3.266837e-07
I11004 n1_m1_446400_144000 0 4.044913e-07
I11005 n1_m1_446400_148800 0 2.071880e-07
I11006 n1_m1_446400_153600 0 2.496353e-07
I11007 n1_m1_446400_158400 0 1.488719e-07
I11008 n1_m1_446400_163200 0 1.490792e-07
I11009 n1_m1_446400_168000 0 2.244900e-07
I11010 n1_m1_446400_172800 0 1.491068e-07
I11011 n1_m1_446400_177600 0 2.201381e-07
I11012 n1_m1_446400_182400 0 1.465661e-07
I11013 n1_m1_446400_187200 0 1.465661e-07
I11014 n1_m1_446400_192000 0 2.198491e-07
I11015 n1_m1_446400_196800 0 1.465661e-07
I11016 n1_m1_446400_201600 0 2.237372e-07
I11017 n1_m1_446400_206400 0 1.531751e-07
I11018 n1_m1_446400_211200 0 1.616024e-07
I11019 n1_m1_446400_216000 0 4.120322e-07
I11020 n1_m1_446400_220800 0 4.813765e-07
I11021 n1_m1_446400_225600 0 1.420027e-06
I11022 n1_m1_446400_230400 0 7.921846e-07
I11023 n1_m1_446400_235200 0 8.136301e-07
I11024 n1_m1_446400_240000 0 6.746850e-07
I11025 n1_m1_446400_244800 0 3.272367e-07
I11026 n1_m1_446400_249600 0 3.804524e-07
I11027 n1_m1_446400_254400 0 1.719317e-07
I11028 n1_m1_446400_259200 0 1.554487e-07
I11029 n1_m1_446400_264000 0 2.256011e-07
I11030 n1_m1_446400_268800 0 1.548269e-07
I11031 n1_m1_446400_273600 0 2.298333e-07
I11032 n1_m1_446400_278400 0 1.689331e-07
I11033 n1_m1_446400_283200 0 2.139897e-07
I11034 n1_m1_446400_288000 0 5.425906e-07
I11035 n1_m1_446400_292800 0 5.617715e-07
I11036 n1_m1_446400_297600 0 1.229110e-06
I11037 n1_m1_446400_302400 0 1.141365e-06
I11038 n1_m1_446400_307200 0 1.241564e-06
I11039 n1_m1_446400_312000 0 9.540683e-07
I11040 n1_m1_446400_316800 0 3.297939e-07
I11041 n1_m1_446400_321600 0 3.905831e-07
I11042 n1_m1_446400_326400 0 2.971831e-07
I11043 n1_m1_446400_331200 0 4.391273e-07
I11044 n1_m1_446400_336000 0 7.150837e-07
I11045 n1_m1_446400_340800 0 6.113568e-07
I11046 n1_m1_446400_345600 0 6.550475e-07
I11047 n1_m1_446400_350400 0 4.658723e-07
I11048 n1_m1_446400_355200 0 3.336779e-07
I11049 n1_m1_446400_360000 0 2.534575e-07
I11050 n1_m1_446400_364800 0 1.585765e-07
I11051 n1_m1_446400_369600 0 2.312626e-07
I11052 n1_m1_446400_374400 0 1.538789e-07
I11053 n1_m1_446400_379200 0 1.550649e-07
I11054 n1_m1_446400_384000 0 2.225062e-07
I11055 n1_m1_446400_388800 0 1.526824e-07
I11056 n1_m1_446400_393600 0 2.294613e-07
I11057 n1_m1_446400_398400 0 1.501105e-07
I11058 n1_m1_446400_403200 0 1.511630e-07
I11059 n1_m1_446400_408000 0 2.617732e-07
I11060 n1_m1_446400_412800 0 2.118595e-07
I11061 n1_m1_446400_417600 0 9.700291e-07
I11062 n1_m1_446400_422400 0 2.956846e-07
I11063 n1_m1_446400_427200 0 1.710234e-07
I11064 n1_m1_446400_432000 0 2.633845e-07
I11065 n1_m1_446400_436800 0 1.465661e-07
I11066 n1_m1_446400_441600 0 2.198491e-07
I11067 n1_m1_446400_446400 0 1.556134e-07
I11068 n1_m1_446400_451200 0 1.678156e-07
I11069 n1_m1_446400_456000 0 2.465877e-07
I11070 n1_m1_446400_460800 0 1.867746e-07
I11071 n1_m1_446400_465600 0 2.710700e-07
I11072 n1_m1_446400_470400 0 1.788436e-07
I11073 n1_m1_446400_475200 0 1.706189e-07
I11074 n1_m1_446400_480000 0 2.388371e-07
I11075 n1_m1_446400_484800 0 1.672695e-07
I11076 n1_m1_446400_489600 0 2.215324e-07
I11077 n1_m1_446400_494400 0 1.465661e-07
I11078 n1_m1_446400_499200 0 1.440411e-07
I11079 n1_m1_446400_504000 0 2.178017e-07
I11080 n1_m1_446400_508800 0 1.588826e-07
I11081 n1_m1_446400_513600 0 2.430685e-07
I11082 n1_m1_446400_518400 0 1.482176e-07
I11083 n1_m1_446400_523200 0 1.387787e-07
I11084 n1_m1_446400_528000 0 2.220261e-07
I11085 n1_m1_446400_532800 0 1.518732e-07
I11086 n1_m1_446400_537600 0 2.187492e-07
I11087 n1_m1_446400_542400 0 1.470937e-07
I11088 n1_m1_446400_547200 0 1.583406e-07
I11089 n1_m1_446400_552000 0 2.499092e-07
I11090 n1_m1_446400_556800 0 1.533145e-07
I11091 n1_m1_446400_561600 0 7.551789e-08
I11092 n1_m1_451200_0 0 8.174748e-08
I11093 n1_m1_451200_4800 0 9.581630e-08
I11094 n1_m1_451200_9600 0 1.378326e-07
I11095 n1_m1_451200_14400 0 7.752525e-08
I11096 n1_m1_451200_19200 0 7.459758e-08
I11097 n1_m1_451200_24000 0 1.079341e-07
I11098 n1_m1_451200_28800 0 7.068102e-08
I11099 n1_m1_451200_33600 0 1.055059e-07
I11100 n1_m1_451200_38400 0 6.995199e-08
I11101 n1_m1_451200_43200 0 6.995199e-08
I11102 n1_m1_451200_48000 0 1.049280e-07
I11103 n1_m1_451200_52800 0 6.999644e-08
I11104 n1_m1_451200_57600 0 1.089584e-07
I11105 n1_m1_451200_62400 0 7.328303e-08
I11106 n1_m1_451200_67200 0 7.400022e-08
I11107 n1_m1_451200_72000 0 1.237973e-07
I11108 n1_m1_451200_76800 0 9.223207e-08
I11109 n1_m1_451200_81600 0 1.269680e-07
I11110 n1_m1_451200_86400 0 8.750961e-08
I11111 n1_m1_451200_91200 0 1.018188e-07
I11112 n1_m1_451200_96000 0 1.553139e-07
I11113 n1_m1_451200_100800 0 1.136527e-07
I11114 n1_m1_451200_105600 0 1.554913e-07
I11115 n1_m1_451200_110400 0 8.892236e-08
I11116 n1_m1_451200_115200 0 9.459601e-08
I11117 n1_m1_451200_120000 0 1.707473e-07
I11118 n1_m1_451200_124800 0 1.085915e-07
I11119 n1_m1_451200_129600 0 2.154401e-07
I11120 n1_m1_451200_134400 0 1.364234e-07
I11121 n1_m1_451200_139200 0 1.885889e-07
I11122 n1_m1_451200_144000 0 2.602990e-07
I11123 n1_m1_451200_148800 0 1.253087e-07
I11124 n1_m1_451200_153600 0 1.383227e-07
I11125 n1_m1_451200_158400 0 7.642198e-08
I11126 n1_m1_451200_163200 0 7.358594e-08
I11127 n1_m1_451200_168000 0 1.108456e-07
I11128 n1_m1_451200_172800 0 7.388170e-08
I11129 n1_m1_451200_177600 0 1.099927e-07
I11130 n1_m1_451200_182400 0 7.328303e-08
I11131 n1_m1_451200_187200 0 7.328303e-08
I11132 n1_m1_451200_192000 0 1.104246e-07
I11133 n1_m1_451200_196800 0 7.401207e-08
I11134 n1_m1_451200_201600 0 1.144423e-07
I11135 n1_m1_451200_206400 0 7.800109e-08
I11136 n1_m1_451200_211200 0 7.923557e-08
I11137 n1_m1_451200_216000 0 1.761510e-07
I11138 n1_m1_451200_220800 0 1.961129e-07
I11139 n1_m1_451200_225600 0 6.014348e-07
I11140 n1_m1_451200_230400 0 3.051829e-07
I11141 n1_m1_451200_235200 0 3.083954e-07
I11142 n1_m1_451200_240000 0 2.296888e-07
I11143 n1_m1_451200_244800 0 1.349187e-07
I11144 n1_m1_451200_249600 0 1.827856e-07
I11145 n1_m1_451200_254400 0 8.733788e-08
I11146 n1_m1_451200_259200 0 7.757547e-08
I11147 n1_m1_451200_264000 0 1.122824e-07
I11148 n1_m1_451200_268800 0 8.020173e-08
I11149 n1_m1_451200_273600 0 1.141692e-07
I11150 n1_m1_451200_278400 0 8.259134e-08
I11151 n1_m1_451200_283200 0 8.870878e-08
I11152 n1_m1_451200_288000 0 1.465148e-07
I11153 n1_m1_451200_292800 0 1.749729e-07
I11154 n1_m1_451200_297600 0 4.887664e-07
I11155 n1_m1_451200_302400 0 5.073835e-07
I11156 n1_m1_451200_307200 0 5.416218e-07
I11157 n1_m1_451200_312000 0 4.341091e-07
I11158 n1_m1_451200_316800 0 1.363780e-07
I11159 n1_m1_451200_321600 0 1.696388e-07
I11160 n1_m1_451200_326400 0 9.756669e-08
I11161 n1_m1_451200_331200 0 1.272319e-07
I11162 n1_m1_451200_336000 0 2.624371e-07
I11163 n1_m1_451200_340800 0 2.235158e-07
I11164 n1_m1_451200_345600 0 2.944729e-07
I11165 n1_m1_451200_350400 0 2.799733e-07
I11166 n1_m1_451200_355200 0 2.131470e-07
I11167 n1_m1_451200_360000 0 1.425631e-07
I11168 n1_m1_451200_364800 0 7.698509e-08
I11169 n1_m1_451200_369600 0 1.139949e-07
I11170 n1_m1_451200_374400 0 7.649258e-08
I11171 n1_m1_451200_379200 0 7.799807e-08
I11172 n1_m1_451200_384000 0 1.103305e-07
I11173 n1_m1_451200_388800 0 7.401207e-08
I11174 n1_m1_451200_393600 0 1.086976e-07
I11175 n1_m1_451200_398400 0 7.313008e-08
I11176 n1_m1_451200_403200 0 7.474111e-08
I11177 n1_m1_451200_408000 0 1.236864e-07
I11178 n1_m1_451200_412800 0 8.885278e-08
I11179 n1_m1_451200_417600 0 4.115295e-07
I11180 n1_m1_451200_422400 0 1.403218e-07
I11181 n1_m1_451200_427200 0 8.491416e-08
I11182 n1_m1_451200_432000 0 1.294507e-07
I11183 n1_m1_451200_436800 0 7.328303e-08
I11184 n1_m1_451200_441600 0 1.094692e-07
I11185 n1_m1_451200_446400 0 7.712527e-08
I11186 n1_m1_451200_451200 0 8.225117e-08
I11187 n1_m1_451200_456000 0 1.230418e-07
I11188 n1_m1_451200_460800 0 1.053520e-07
I11189 n1_m1_451200_465600 0 1.551084e-07
I11190 n1_m1_451200_470400 0 1.008030e-07
I11191 n1_m1_451200_475200 0 8.846051e-08
I11192 n1_m1_451200_480000 0 1.187847e-07
I11193 n1_m1_451200_484800 0 8.305815e-08
I11194 n1_m1_451200_489600 0 1.107202e-07
I11195 n1_m1_451200_494400 0 7.328303e-08
I11196 n1_m1_451200_499200 0 7.229686e-08
I11197 n1_m1_451200_504000 0 1.111959e-07
I11198 n1_m1_451200_508800 0 8.171734e-08
I11199 n1_m1_451200_513600 0 1.246628e-07
I11200 n1_m1_451200_518400 0 7.431765e-08
I11201 n1_m1_451200_523200 0 6.813829e-08
I11202 n1_m1_451200_528000 0 1.088723e-07
I11203 n1_m1_451200_532800 0 7.516464e-08
I11204 n1_m1_451200_537600 0 1.078808e-07
I11205 n1_m1_451200_542400 0 7.232732e-08
I11206 n1_m1_451200_547200 0 7.795954e-08
I11207 n1_m1_451200_552000 0 1.215447e-07
I11208 n1_m1_451200_556800 0 7.572171e-08
I11209 n1_m1_451200_561600 0 3.744913e-08
I11210 n1_m1_456000_0 0 1.783452e-07
I11211 n1_m1_456000_4800 0 2.530754e-07
I11212 n1_m1_456000_9600 0 6.045212e-07
I11213 n1_m1_456000_14400 0 2.835351e-07
I11214 n1_m1_456000_19200 0 1.699012e-07
I11215 n1_m1_456000_24000 0 2.171288e-07
I11216 n1_m1_456000_28800 0 1.430425e-07
I11217 n1_m1_456000_33600 0 2.149209e-07
I11218 n1_m1_456000_38400 0 1.399040e-07
I11219 n1_m1_456000_43200 0 1.399040e-07
I11220 n1_m1_456000_48000 0 2.098560e-07
I11221 n1_m1_456000_52800 0 1.399929e-07
I11222 n1_m1_456000_57600 0 2.179169e-07
I11223 n1_m1_456000_62400 0 1.465661e-07
I11224 n1_m1_456000_67200 0 1.474319e-07
I11225 n1_m1_456000_72000 0 2.348567e-07
I11226 n1_m1_456000_76800 0 1.645628e-07
I11227 n1_m1_456000_81600 0 2.365016e-07
I11228 n1_m1_456000_86400 0 1.581023e-07
I11229 n1_m1_456000_91200 0 1.673443e-07
I11230 n1_m1_456000_96000 0 2.655447e-07
I11231 n1_m1_456000_100800 0 1.918789e-07
I11232 n1_m1_456000_105600 0 2.792340e-07
I11233 n1_m1_456000_110400 0 1.741705e-07
I11234 n1_m1_456000_115200 0 1.768568e-07
I11235 n1_m1_456000_120000 0 3.337599e-07
I11236 n1_m1_456000_124800 0 1.952648e-07
I11237 n1_m1_456000_129600 0 3.397232e-07
I11238 n1_m1_456000_134400 0 2.753443e-07
I11239 n1_m1_456000_139200 0 3.767210e-07
I11240 n1_m1_456000_144000 0 6.130942e-07
I11241 n1_m1_456000_148800 0 3.650956e-07
I11242 n1_m1_456000_153600 0 3.158601e-07
I11243 n1_m1_456000_158400 0 1.620029e-07
I11244 n1_m1_456000_163200 0 1.459845e-07
I11245 n1_m1_456000_168000 0 2.203440e-07
I11246 n1_m1_456000_172800 0 1.477001e-07
I11247 n1_m1_456000_177600 0 2.199104e-07
I11248 n1_m1_456000_182400 0 1.464853e-07
I11249 n1_m1_456000_187200 0 1.465661e-07
I11250 n1_m1_456000_192000 0 2.207964e-07
I11251 n1_m1_456000_196800 0 1.479471e-07
I11252 n1_m1_456000_201600 0 2.239457e-07
I11253 n1_m1_456000_206400 0 1.554672e-07
I11254 n1_m1_456000_211200 0 1.659979e-07
I11255 n1_m1_456000_216000 0 2.420143e-07
I11256 n1_m1_456000_220800 0 1.980732e-07
I11257 n1_m1_456000_225600 0 4.727731e-07
I11258 n1_m1_456000_230400 0 2.031516e-07
I11259 n1_m1_456000_235200 0 1.999386e-07
I11260 n1_m1_456000_240000 0 3.438635e-07
I11261 n1_m1_456000_244800 0 1.827607e-07
I11262 n1_m1_456000_249600 0 2.423040e-07
I11263 n1_m1_456000_254400 0 1.569001e-07
I11264 n1_m1_456000_259200 0 1.541662e-07
I11265 n1_m1_456000_264000 0 2.246433e-07
I11266 n1_m1_456000_268800 0 1.520746e-07
I11267 n1_m1_456000_273600 0 2.210943e-07
I11268 n1_m1_456000_278400 0 1.522718e-07
I11269 n1_m1_456000_283200 0 1.654016e-07
I11270 n1_m1_456000_288000 0 2.550954e-07
I11271 n1_m1_456000_292800 0 3.625532e-07
I11272 n1_m1_456000_297600 0 6.757364e-07
I11273 n1_m1_456000_302400 0 2.825669e-07
I11274 n1_m1_456000_307200 0 3.720143e-07
I11275 n1_m1_456000_312000 0 1.281707e-06
I11276 n1_m1_456000_316800 0 3.369941e-07
I11277 n1_m1_456000_321600 0 2.880644e-07
I11278 n1_m1_456000_326400 0 1.766675e-07
I11279 n1_m1_456000_331200 0 1.871404e-07
I11280 n1_m1_456000_336000 0 6.462082e-07
I11281 n1_m1_456000_340800 0 7.292541e-07
I11282 n1_m1_456000_345600 0 5.375181e-07
I11283 n1_m1_456000_350400 0 5.308104e-07
I11284 n1_m1_456000_355200 0 4.561447e-07
I11285 n1_m1_456000_360000 0 3.277429e-07
I11286 n1_m1_456000_364800 0 1.604665e-07
I11287 n1_m1_456000_369600 0 2.158811e-07
I11288 n1_m1_456000_374400 0 1.434632e-07
I11289 n1_m1_456000_379200 0 1.503364e-07
I11290 n1_m1_456000_384000 0 2.151102e-07
I11291 n1_m1_456000_388800 0 1.479471e-07
I11292 n1_m1_456000_393600 0 2.209586e-07
I11293 n1_m1_456000_398400 0 1.513355e-07
I11294 n1_m1_456000_403200 0 1.545430e-07
I11295 n1_m1_456000_408000 0 2.499955e-07
I11296 n1_m1_456000_412800 0 2.327160e-07
I11297 n1_m1_456000_417600 0 5.950948e-07
I11298 n1_m1_456000_422400 0 2.101686e-07
I11299 n1_m1_456000_427200 0 1.623006e-07
I11300 n1_m1_456000_432000 0 2.288625e-07
I11301 n1_m1_456000_436800 0 1.466672e-07
I11302 n1_m1_456000_441600 0 2.189054e-07
I11303 n1_m1_456000_446400 0 1.457884e-07
I11304 n1_m1_456000_451200 0 1.464906e-07
I11305 n1_m1_456000_456000 0 2.228863e-07
I11306 n1_m1_456000_460800 0 1.729794e-07
I11307 n1_m1_456000_465600 0 2.781651e-07
I11308 n1_m1_456000_470400 0 1.822668e-07
I11309 n1_m1_456000_475200 0 1.653438e-07
I11310 n1_m1_456000_480000 0 2.298500e-07
I11311 n1_m1_456000_484800 0 1.490016e-07
I11312 n1_m1_456000_489600 0 2.126600e-07
I11313 n1_m1_456000_494400 0 1.412850e-07
I11314 n1_m1_456000_499200 0 1.412850e-07
I11315 n1_m1_456000_504000 0 2.140727e-07
I11316 n1_m1_456000_508800 0 1.493280e-07
I11317 n1_m1_456000_513600 0 2.267798e-07
I11318 n1_m1_456000_518400 0 1.426475e-07
I11319 n1_m1_456000_523200 0 1.391520e-07
I11320 n1_m1_456000_528000 0 2.112841e-07
I11321 n1_m1_456000_532800 0 1.411721e-07
I11322 n1_m1_456000_537600 0 2.127118e-07
I11323 n1_m1_456000_542400 0 1.499666e-07
I11324 n1_m1_456000_547200 0 1.612772e-07
I11325 n1_m1_456000_552000 0 2.476388e-07
I11326 n1_m1_456000_556800 0 1.515311e-07
I11327 n1_m1_456000_561600 0 7.492731e-08
I11328 n1_m1_460800_0 0 2.032556e-07
I11329 n1_m1_460800_4800 0 2.646586e-07
I11330 n1_m1_460800_9600 0 4.477178e-07
I11331 n1_m1_460800_14400 0 2.082752e-07
I11332 n1_m1_460800_19200 0 1.551501e-07
I11333 n1_m1_460800_24000 0 2.178139e-07
I11334 n1_m1_460800_28800 0 1.421293e-07
I11335 n1_m1_460800_33600 0 2.074879e-07
I11336 n1_m1_460800_38400 0 1.399040e-07
I11337 n1_m1_460800_43200 0 1.399040e-07
I11338 n1_m1_460800_48000 0 2.098560e-07
I11339 n1_m1_460800_52800 0 1.399929e-07
I11340 n1_m1_460800_57600 0 2.179169e-07
I11341 n1_m1_460800_62400 0 1.465661e-07
I11342 n1_m1_460800_67200 0 1.472833e-07
I11343 n1_m1_460800_72000 0 2.293963e-07
I11344 n1_m1_460800_76800 0 1.545784e-07
I11345 n1_m1_460800_81600 0 2.268420e-07
I11346 n1_m1_460800_86400 0 1.484035e-07
I11347 n1_m1_460800_91200 0 1.492372e-07
I11348 n1_m1_460800_96000 0 2.372037e-07
I11349 n1_m1_460800_100800 0 1.733093e-07
I11350 n1_m1_460800_105600 0 2.451583e-07
I11351 n1_m1_460800_110400 0 1.723538e-07
I11352 n1_m1_460800_115200 0 1.966362e-07
I11353 n1_m1_460800_120000 0 5.391185e-07
I11354 n1_m1_460800_124800 0 3.335656e-07
I11355 n1_m1_460800_129600 0 6.477783e-07
I11356 n1_m1_460800_134400 0 5.929376e-07
I11357 n1_m1_460800_139200 0 7.657065e-07
I11358 n1_m1_460800_144000 0 1.127681e-06
I11359 n1_m1_460800_148800 0 5.274562e-07
I11360 n1_m1_460800_153600 0 3.484619e-07
I11361 n1_m1_460800_158400 0 1.542488e-07
I11362 n1_m1_460800_163200 0 1.433618e-07
I11363 n1_m1_460800_168000 0 2.182725e-07
I11364 n1_m1_460800_172800 0 1.465661e-07
I11365 n1_m1_460800_177600 0 2.174539e-07
I11366 n1_m1_460800_182400 0 1.437073e-07
I11367 n1_m1_460800_187200 0 1.465661e-07
I11368 n1_m1_460800_192000 0 2.198491e-07
I11369 n1_m1_460800_196800 0 1.465661e-07
I11370 n1_m1_460800_201600 0 2.204833e-07
I11371 n1_m1_460800_206400 0 1.528175e-07
I11372 n1_m1_460800_211200 0 1.650267e-07
I11373 n1_m1_460800_216000 0 2.524589e-07
I11374 n1_m1_460800_220800 0 2.255454e-07
I11375 n1_m1_460800_225600 0 6.531133e-07
I11376 n1_m1_460800_230400 0 2.522468e-07
I11377 n1_m1_460800_235200 0 2.170209e-07
I11378 n1_m1_460800_240000 0 2.784283e-07
I11379 n1_m1_460800_244800 0 1.628688e-07
I11380 n1_m1_460800_249600 0 2.370143e-07
I11381 n1_m1_460800_254400 0 1.493392e-07
I11382 n1_m1_460800_259200 0 1.449438e-07
I11383 n1_m1_460800_264000 0 2.187382e-07
I11384 n1_m1_460800_268800 0 1.471026e-07
I11385 n1_m1_460800_273600 0 2.245665e-07
I11386 n1_m1_460800_278400 0 1.480667e-07
I11387 n1_m1_460800_283200 0 1.605020e-07
I11388 n1_m1_460800_288000 0 2.754664e-07
I11389 n1_m1_460800_292800 0 2.599828e-07
I11390 n1_m1_460800_297600 0 4.411472e-07
I11391 n1_m1_460800_302400 0 2.909356e-07
I11392 n1_m1_460800_307200 0 3.257514e-07
I11393 n1_m1_460800_312000 0 6.157108e-07
I11394 n1_m1_460800_316800 0 2.376164e-07
I11395 n1_m1_460800_321600 0 2.551189e-07
I11396 n1_m1_460800_326400 0 1.985335e-07
I11397 n1_m1_460800_331200 0 2.681953e-07
I11398 n1_m1_460800_336000 0 6.383932e-07
I11399 n1_m1_460800_340800 0 6.409897e-07
I11400 n1_m1_460800_345600 0 3.203971e-07
I11401 n1_m1_460800_350400 0 4.302636e-07
I11402 n1_m1_460800_355200 0 3.962294e-07
I11403 n1_m1_460800_360000 0 3.132866e-07
I11404 n1_m1_460800_364800 0 1.614728e-07
I11405 n1_m1_460800_369600 0 2.144436e-07
I11406 n1_m1_460800_374400 0 1.423341e-07
I11407 n1_m1_460800_379200 0 1.508588e-07
I11408 n1_m1_460800_384000 0 2.189966e-07
I11409 n1_m1_460800_388800 0 1.465661e-07
I11410 n1_m1_460800_393600 0 2.198491e-07
I11411 n1_m1_460800_398400 0 1.476744e-07
I11412 n1_m1_460800_403200 0 1.508845e-07
I11413 n1_m1_460800_408000 0 2.591406e-07
I11414 n1_m1_460800_412800 0 2.936821e-07
I11415 n1_m1_460800_417600 0 6.247693e-07
I11416 n1_m1_460800_422400 0 2.057430e-07
I11417 n1_m1_460800_427200 0 1.657996e-07
I11418 n1_m1_460800_432000 0 2.293266e-07
I11419 n1_m1_460800_436800 0 1.501460e-07
I11420 n1_m1_460800_441600 0 2.169775e-07
I11421 n1_m1_460800_446400 0 1.417414e-07
I11422 n1_m1_460800_451200 0 1.438962e-07
I11423 n1_m1_460800_456000 0 2.201218e-07
I11424 n1_m1_460800_460800 0 1.562154e-07
I11425 n1_m1_460800_465600 0 2.491917e-07
I11426 n1_m1_460800_470400 0 1.659954e-07
I11427 n1_m1_460800_475200 0 1.608102e-07
I11428 n1_m1_460800_480000 0 2.369371e-07
I11429 n1_m1_460800_484800 0 1.538482e-07
I11430 n1_m1_460800_489600 0 2.151315e-07
I11431 n1_m1_460800_494400 0 1.399040e-07
I11432 n1_m1_460800_499200 0 1.399040e-07
I11433 n1_m1_460800_504000 0 2.098560e-07
I11434 n1_m1_460800_508800 0 1.442782e-07
I11435 n1_m1_460800_513600 0 2.190134e-07
I11436 n1_m1_460800_518400 0 1.408820e-07
I11437 n1_m1_460800_523200 0 1.399040e-07
I11438 n1_m1_460800_528000 0 2.109162e-07
I11439 n1_m1_460800_532800 0 1.444754e-07
I11440 n1_m1_460800_537600 0 2.179921e-07
I11441 n1_m1_460800_542400 0 1.519005e-07
I11442 n1_m1_460800_547200 0 1.640392e-07
I11443 n1_m1_460800_552000 0 2.540240e-07
I11444 n1_m1_460800_556800 0 1.540258e-07
I11445 n1_m1_460800_561600 0 7.575348e-08
I11446 n1_m1_465600_0 0 2.980823e-07
I11447 n1_m1_465600_4800 0 4.146973e-07
I11448 n1_m1_465600_9600 0 8.272690e-07
I11449 n1_m1_465600_14400 0 3.615903e-07
I11450 n1_m1_465600_19200 0 2.449388e-07
I11451 n1_m1_465600_24000 0 3.215352e-07
I11452 n1_m1_465600_28800 0 2.110219e-07
I11453 n1_m1_465600_33600 0 3.136986e-07
I11454 n1_m1_465600_38400 0 2.098560e-07
I11455 n1_m1_465600_43200 0 2.098560e-07
I11456 n1_m1_465600_48000 0 3.147839e-07
I11457 n1_m1_465600_52800 0 2.099893e-07
I11458 n1_m1_465600_57600 0 3.268753e-07
I11459 n1_m1_465600_62400 0 2.198491e-07
I11460 n1_m1_465600_67200 0 2.201107e-07
I11461 n1_m1_465600_72000 0 3.330189e-07
I11462 n1_m1_465600_76800 0 2.222792e-07
I11463 n1_m1_465600_81600 0 3.271064e-07
I11464 n1_m1_465600_86400 0 2.122861e-07
I11465 n1_m1_465600_91200 0 2.122861e-07
I11466 n1_m1_465600_96000 0 3.351191e-07
I11467 n1_m1_465600_100800 0 2.410726e-07
I11468 n1_m1_465600_105600 0 3.746764e-07
I11469 n1_m1_465600_110400 0 2.992824e-07
I11470 n1_m1_465600_115200 0 4.292704e-07
I11471 n1_m1_465600_120000 0 1.209879e-06
I11472 n1_m1_465600_124800 0 7.434289e-07
I11473 n1_m1_465600_129600 0 1.423312e-06
I11474 n1_m1_465600_134400 0 1.262535e-06
I11475 n1_m1_465600_139200 0 1.421524e-06
I11476 n1_m1_465600_144000 0 1.770246e-06
I11477 n1_m1_465600_148800 0 8.307654e-07
I11478 n1_m1_465600_153600 0 5.532101e-07
I11479 n1_m1_465600_158400 0 2.493228e-07
I11480 n1_m1_465600_163200 0 2.267927e-07
I11481 n1_m1_465600_168000 0 3.448469e-07
I11482 n1_m1_465600_172800 0 2.148007e-07
I11483 n1_m1_465600_177600 0 3.273340e-07
I11484 n1_m1_465600_182400 0 2.177805e-07
I11485 n1_m1_465600_187200 0 2.198491e-07
I11486 n1_m1_465600_192000 0 3.297737e-07
I11487 n1_m1_465600_196800 0 2.237249e-07
I11488 n1_m1_465600_201600 0 3.339297e-07
I11489 n1_m1_465600_206400 0 2.283195e-07
I11490 n1_m1_465600_211200 0 2.338698e-07
I11491 n1_m1_465600_216000 0 4.058725e-07
I11492 n1_m1_465600_220800 0 4.681790e-07
I11493 n1_m1_465600_225600 0 1.679868e-06
I11494 n1_m1_465600_230400 0 7.180660e-07
I11495 n1_m1_465600_235200 0 6.512620e-07
I11496 n1_m1_465600_240000 0 4.914563e-07
I11497 n1_m1_465600_244800 0 2.485373e-07
I11498 n1_m1_465600_249600 0 3.623925e-07
I11499 n1_m1_465600_254400 0 2.285310e-07
I11500 n1_m1_465600_259200 0 2.199461e-07
I11501 n1_m1_465600_264000 0 3.384142e-07
I11502 n1_m1_465600_268800 0 2.334266e-07
I11503 n1_m1_465600_273600 0 3.508987e-07
I11504 n1_m1_465600_278400 0 2.282786e-07
I11505 n1_m1_465600_283200 0 2.647972e-07
I11506 n1_m1_465600_288000 0 5.205997e-07
I11507 n1_m1_465600_292800 0 4.511949e-07
I11508 n1_m1_465600_297600 0 8.425924e-07
I11509 n1_m1_465600_302400 0 5.282238e-07
I11510 n1_m1_465600_307200 0 4.336999e-07
I11511 n1_m1_465600_312000 0 4.881521e-07
I11512 n1_m1_465600_316800 0 4.193703e-07
I11513 n1_m1_465600_321600 0 4.208887e-07
I11514 n1_m1_465600_326400 0 3.838935e-07
I11515 n1_m1_465600_331200 0 7.075382e-07
I11516 n1_m1_465600_336000 0 1.129483e-06
I11517 n1_m1_465600_340800 0 8.555844e-07
I11518 n1_m1_465600_345600 0 4.687418e-07
I11519 n1_m1_465600_350400 0 6.231814e-07
I11520 n1_m1_465600_355200 0 5.448398e-07
I11521 n1_m1_465600_360000 0 4.501267e-07
I11522 n1_m1_465600_364800 0 2.411945e-07
I11523 n1_m1_465600_369600 0 3.214218e-07
I11524 n1_m1_465600_374400 0 2.135011e-07
I11525 n1_m1_465600_379200 0 2.266683e-07
I11526 n1_m1_465600_384000 0 3.373873e-07
I11527 n1_m1_465600_388800 0 2.300498e-07
I11528 n1_m1_465600_393600 0 3.297737e-07
I11529 n1_m1_465600_398400 0 2.198491e-07
I11530 n1_m1_465600_403200 0 2.294227e-07
I11531 n1_m1_465600_408000 0 4.157931e-07
I11532 n1_m1_465600_412800 0 5.042923e-07
I11533 n1_m1_465600_417600 0 9.844129e-07
I11534 n1_m1_465600_422400 0 3.189235e-07
I11535 n1_m1_465600_427200 0 2.571703e-07
I11536 n1_m1_465600_432000 0 3.478043e-07
I11537 n1_m1_465600_436800 0 2.264767e-07
I11538 n1_m1_465600_441600 0 3.237946e-07
I11539 n1_m1_465600_446400 0 2.098560e-07
I11540 n1_m1_465600_451200 0 2.109413e-07
I11541 n1_m1_465600_456000 0 3.271444e-07
I11542 n1_m1_465600_460800 0 2.364451e-07
I11543 n1_m1_465600_465600 0 3.802884e-07
I11544 n1_m1_465600_470400 0 2.504023e-07
I11545 n1_m1_465600_475200 0 2.468872e-07
I11546 n1_m1_465600_480000 0 3.695062e-07
I11547 n1_m1_465600_484800 0 2.437401e-07
I11548 n1_m1_465600_489600 0 3.382570e-07
I11549 n1_m1_465600_494400 0 2.098560e-07
I11550 n1_m1_465600_499200 0 2.098560e-07
I11551 n1_m1_465600_504000 0 3.147839e-07
I11552 n1_m1_465600_508800 0 2.164173e-07
I11553 n1_m1_465600_513600 0 3.275205e-07
I11554 n1_m1_465600_518400 0 2.111672e-07
I11555 n1_m1_465600_523200 0 2.101318e-07
I11556 n1_m1_465600_528000 0 3.248188e-07
I11557 n1_m1_465600_532800 0 2.197215e-07
I11558 n1_m1_465600_537600 0 3.297737e-07
I11559 n1_m1_465600_542400 0 2.274260e-07
I11560 n1_m1_465600_547200 0 2.453283e-07
I11561 n1_m1_465600_552000 0 3.873096e-07
I11562 n1_m1_465600_556800 0 2.392985e-07
I11563 n1_m1_465600_561600 0 1.176425e-07
I11564 n1_m1_470400_0 0 1.775161e-07
I11565 n1_m1_470400_4800 0 2.525646e-07
I11566 n1_m1_470400_9600 0 6.384368e-07
I11567 n1_m1_470400_14400 0 3.019906e-07
I11568 n1_m1_470400_19200 0 1.743644e-07
I11569 n1_m1_470400_24000 0 2.150365e-07
I11570 n1_m1_470400_28800 0 1.426362e-07
I11571 n1_m1_470400_33600 0 2.139342e-07
I11572 n1_m1_470400_38400 0 1.399040e-07
I11573 n1_m1_470400_43200 0 1.399040e-07
I11574 n1_m1_470400_48000 0 2.098560e-07
I11575 n1_m1_470400_52800 0 1.399929e-07
I11576 n1_m1_470400_57600 0 2.179169e-07
I11577 n1_m1_470400_62400 0 1.465661e-07
I11578 n1_m1_470400_67200 0 1.465661e-07
I11579 n1_m1_470400_72000 0 2.201198e-07
I11580 n1_m1_470400_76800 0 1.471280e-07
I11581 n1_m1_470400_81600 0 2.161435e-07
I11582 n1_m1_470400_86400 0 1.402536e-07
I11583 n1_m1_470400_91200 0 1.399040e-07
I11584 n1_m1_470400_96000 0 2.165517e-07
I11585 n1_m1_470400_100800 0 1.559534e-07
I11586 n1_m1_470400_105600 0 2.547541e-07
I11587 n1_m1_470400_110400 0 2.283656e-07
I11588 n1_m1_470400_115200 0 3.091758e-07
I11589 n1_m1_470400_120000 0 7.946625e-07
I11590 n1_m1_470400_124800 0 4.450167e-07
I11591 n1_m1_470400_129600 0 8.581438e-07
I11592 n1_m1_470400_134400 0 8.093042e-07
I11593 n1_m1_470400_139200 0 9.147079e-07
I11594 n1_m1_470400_144000 0 1.186818e-06
I11595 n1_m1_470400_148800 0 6.567227e-07
I11596 n1_m1_470400_153600 0 4.435184e-07
I11597 n1_m1_470400_158400 0 1.804535e-07
I11598 n1_m1_470400_163200 0 1.615645e-07
I11599 n1_m1_470400_168000 0 2.391994e-07
I11600 n1_m1_470400_172800 0 1.428781e-07
I11601 n1_m1_470400_177600 0 2.163645e-07
I11602 n1_m1_470400_182400 0 1.427531e-07
I11603 n1_m1_470400_187200 0 1.458015e-07
I11604 n1_m1_470400_192000 0 2.192267e-07
I11605 n1_m1_470400_196800 0 1.470148e-07
I11606 n1_m1_470400_201600 0 2.207815e-07
I11607 n1_m1_470400_206400 0 1.515358e-07
I11608 n1_m1_470400_211200 0 1.543913e-07
I11609 n1_m1_470400_216000 0 2.644625e-07
I11610 n1_m1_470400_220800 0 3.069919e-07
I11611 n1_m1_470400_225600 0 1.134661e-06
I11612 n1_m1_470400_230400 0 5.396087e-07
I11613 n1_m1_470400_235200 0 4.841763e-07
I11614 n1_m1_470400_240000 0 4.095747e-07
I11615 n1_m1_470400_244800 0 1.702790e-07
I11616 n1_m1_470400_249600 0 2.416508e-07
I11617 n1_m1_470400_254400 0 1.491922e-07
I11618 n1_m1_470400_259200 0 1.460144e-07
I11619 n1_m1_470400_264000 0 2.255915e-07
I11620 n1_m1_470400_268800 0 1.530395e-07
I11621 n1_m1_470400_273600 0 2.298287e-07
I11622 n1_m1_470400_278400 0 1.578463e-07
I11623 n1_m1_470400_283200 0 1.886538e-07
I11624 n1_m1_470400_288000 0 3.407437e-07
I11625 n1_m1_470400_292800 0 3.203174e-07
I11626 n1_m1_470400_297600 0 6.364496e-07
I11627 n1_m1_470400_302400 0 3.757006e-07
I11628 n1_m1_470400_307200 0 3.269897e-07
I11629 n1_m1_470400_312000 0 4.544856e-07
I11630 n1_m1_470400_316800 0 3.420002e-07
I11631 n1_m1_470400_321600 0 2.926750e-07
I11632 n1_m1_470400_326400 0 2.402791e-07
I11633 n1_m1_470400_331200 0 4.183585e-07
I11634 n1_m1_470400_336000 0 6.722243e-07
I11635 n1_m1_470400_340800 0 5.475532e-07
I11636 n1_m1_470400_345600 0 4.084748e-07
I11637 n1_m1_470400_350400 0 4.071311e-07
I11638 n1_m1_470400_355200 0 3.116090e-07
I11639 n1_m1_470400_360000 0 2.704902e-07
I11640 n1_m1_470400_364800 0 1.556803e-07
I11641 n1_m1_470400_369600 0 2.130871e-07
I11642 n1_m1_470400_374400 0 1.423341e-07
I11643 n1_m1_470400_379200 0 1.511122e-07
I11644 n1_m1_470400_384000 0 2.256342e-07
I11645 n1_m1_470400_388800 0 1.545203e-07
I11646 n1_m1_470400_393600 0 2.198491e-07
I11647 n1_m1_470400_398400 0 1.465661e-07
I11648 n1_m1_470400_403200 0 1.560634e-07
I11649 n1_m1_470400_408000 0 2.796608e-07
I11650 n1_m1_470400_412800 0 2.998112e-07
I11651 n1_m1_470400_417600 0 5.288173e-07
I11652 n1_m1_470400_422400 0 1.990682e-07
I11653 n1_m1_470400_427200 0 1.663263e-07
I11654 n1_m1_470400_432000 0 2.238165e-07
I11655 n1_m1_470400_436800 0 1.463600e-07
I11656 n1_m1_470400_441600 0 2.150410e-07
I11657 n1_m1_470400_446400 0 1.399040e-07
I11658 n1_m1_470400_451200 0 1.402455e-07
I11659 n1_m1_470400_456000 0 2.258141e-07
I11660 n1_m1_470400_460800 0 1.672695e-07
I11661 n1_m1_470400_465600 0 2.620858e-07
I11662 n1_m1_470400_470400 0 1.663558e-07
I11663 n1_m1_470400_475200 0 1.601648e-07
I11664 n1_m1_470400_480000 0 2.386707e-07
I11665 n1_m1_470400_484800 0 1.577209e-07
I11666 n1_m1_470400_489600 0 2.221101e-07
I11667 n1_m1_470400_494400 0 1.399040e-07
I11668 n1_m1_470400_499200 0 1.399040e-07
I11669 n1_m1_470400_504000 0 2.098560e-07
I11670 n1_m1_470400_508800 0 1.437762e-07
I11671 n1_m1_470400_513600 0 2.131152e-07
I11672 n1_m1_470400_518400 0 1.400145e-07
I11673 n1_m1_470400_523200 0 1.401470e-07
I11674 n1_m1_470400_528000 0 2.182251e-07
I11675 n1_m1_470400_532800 0 1.464321e-07
I11676 n1_m1_470400_537600 0 2.187764e-07
I11677 n1_m1_470400_542400 0 1.490762e-07
I11678 n1_m1_470400_547200 0 1.597319e-07
I11679 n1_m1_470400_552000 0 2.551377e-07
I11680 n1_m1_470400_556800 0 1.590142e-07
I11681 n1_m1_470400_561600 0 7.853025e-08
I11682 n1_m1_475200_0 0 1.809789e-07
I11683 n1_m1_475200_4800 0 2.015492e-07
I11684 n1_m1_475200_9600 0 3.406123e-07
I11685 n1_m1_475200_14400 0 1.824291e-07
I11686 n1_m1_475200_19200 0 1.530787e-07
I11687 n1_m1_475200_24000 0 2.258685e-07
I11688 n1_m1_475200_28800 0 1.474313e-07
I11689 n1_m1_475200_33600 0 2.106876e-07
I11690 n1_m1_475200_38400 0 1.399040e-07
I11691 n1_m1_475200_43200 0 1.399040e-07
I11692 n1_m1_475200_48000 0 2.098560e-07
I11693 n1_m1_475200_52800 0 1.399929e-07
I11694 n1_m1_475200_57600 0 2.179169e-07
I11695 n1_m1_475200_62400 0 1.465661e-07
I11696 n1_m1_475200_67200 0 1.465661e-07
I11697 n1_m1_475200_72000 0 2.216708e-07
I11698 n1_m1_475200_76800 0 1.503468e-07
I11699 n1_m1_475200_81600 0 2.193192e-07
I11700 n1_m1_475200_86400 0 1.424708e-07
I11701 n1_m1_475200_91200 0 1.396915e-07
I11702 n1_m1_475200_96000 0 2.151000e-07
I11703 n1_m1_475200_100800 0 1.517372e-07
I11704 n1_m1_475200_105600 0 2.313405e-07
I11705 n1_m1_475200_110400 0 1.813731e-07
I11706 n1_m1_475200_115200 0 2.187263e-07
I11707 n1_m1_475200_120000 0 5.713547e-07
I11708 n1_m1_475200_124800 0 3.180066e-07
I11709 n1_m1_475200_129600 0 7.046248e-07
I11710 n1_m1_475200_134400 0 7.312097e-07
I11711 n1_m1_475200_139200 0 9.508117e-07
I11712 n1_m1_475200_144000 0 1.508688e-06
I11713 n1_m1_475200_148800 0 8.518498e-07
I11714 n1_m1_475200_153600 0 5.224838e-07
I11715 n1_m1_475200_158400 0 1.731863e-07
I11716 n1_m1_475200_163200 0 1.494044e-07
I11717 n1_m1_475200_168000 0 2.273025e-07
I11718 n1_m1_475200_172800 0 1.458001e-07
I11719 n1_m1_475200_177600 0 2.164000e-07
I11720 n1_m1_475200_182400 0 1.403315e-07
I11721 n1_m1_475200_187200 0 1.409531e-07
I11722 n1_m1_475200_192000 0 2.149586e-07
I11723 n1_m1_475200_196800 0 1.460978e-07
I11724 n1_m1_475200_201600 0 2.192912e-07
I11725 n1_m1_475200_206400 0 1.481767e-07
I11726 n1_m1_475200_211200 0 1.603155e-07
I11727 n1_m1_475200_216000 0 2.413822e-07
I11728 n1_m1_475200_220800 0 2.308712e-07
I11729 n1_m1_475200_225600 0 6.992342e-07
I11730 n1_m1_475200_230400 0 3.123282e-07
I11731 n1_m1_475200_235200 0 2.492602e-07
I11732 n1_m1_475200_240000 0 3.239420e-07
I11733 n1_m1_475200_244800 0 1.592820e-07
I11734 n1_m1_475200_249600 0 2.343320e-07
I11735 n1_m1_475200_254400 0 1.437625e-07
I11736 n1_m1_475200_259200 0 1.409531e-07
I11737 n1_m1_475200_264000 0 2.139424e-07
I11738 n1_m1_475200_268800 0 1.470676e-07
I11739 n1_m1_475200_273600 0 2.239081e-07
I11740 n1_m1_475200_278400 0 1.568862e-07
I11741 n1_m1_475200_283200 0 1.759210e-07
I11742 n1_m1_475200_288000 0 2.859907e-07
I11743 n1_m1_475200_292800 0 1.981409e-07
I11744 n1_m1_475200_297600 0 3.754964e-07
I11745 n1_m1_475200_302400 0 3.935447e-07
I11746 n1_m1_475200_307200 0 3.915057e-07
I11747 n1_m1_475200_312000 0 3.713519e-07
I11748 n1_m1_475200_316800 0 2.416375e-07
I11749 n1_m1_475200_321600 0 2.662992e-07
I11750 n1_m1_475200_326400 0 1.795734e-07
I11751 n1_m1_475200_331200 0 2.259043e-07
I11752 n1_m1_475200_336000 0 5.130561e-07
I11753 n1_m1_475200_340800 0 4.735235e-07
I11754 n1_m1_475200_345600 0 2.895662e-07
I11755 n1_m1_475200_350400 0 3.411838e-07
I11756 n1_m1_475200_355200 0 2.817274e-07
I11757 n1_m1_475200_360000 0 2.550703e-07
I11758 n1_m1_475200_364800 0 1.540674e-07
I11759 n1_m1_475200_369600 0 2.130206e-07
I11760 n1_m1_475200_374400 0 1.427811e-07
I11761 n1_m1_475200_379200 0 1.515159e-07
I11762 n1_m1_475200_384000 0 2.216769e-07
I11763 n1_m1_475200_388800 0 1.479811e-07
I11764 n1_m1_475200_393600 0 2.198491e-07
I11765 n1_m1_475200_398400 0 1.468485e-07
I11766 n1_m1_475200_403200 0 1.539440e-07
I11767 n1_m1_475200_408000 0 2.639294e-07
I11768 n1_m1_475200_412800 0 2.358939e-07
I11769 n1_m1_475200_417600 0 3.837944e-07
I11770 n1_m1_475200_422400 0 1.796351e-07
I11771 n1_m1_475200_427200 0 1.564666e-07
I11772 n1_m1_475200_432000 0 2.192958e-07
I11773 n1_m1_475200_436800 0 1.409531e-07
I11774 n1_m1_475200_441600 0 2.107744e-07
I11775 n1_m1_475200_446400 0 1.399040e-07
I11776 n1_m1_475200_451200 0 1.424108e-07
I11777 n1_m1_475200_456000 0 2.252486e-07
I11778 n1_m1_475200_460800 0 1.626510e-07
I11779 n1_m1_475200_465600 0 2.497896e-07
I11780 n1_m1_475200_470400 0 1.595191e-07
I11781 n1_m1_475200_475200 0 1.500553e-07
I11782 n1_m1_475200_480000 0 2.224249e-07
I11783 n1_m1_475200_484800 0 1.472626e-07
I11784 n1_m1_475200_489600 0 2.122555e-07
I11785 n1_m1_475200_494400 0 1.399040e-07
I11786 n1_m1_475200_499200 0 1.399040e-07
I11787 n1_m1_475200_504000 0 2.098560e-07
I11788 n1_m1_475200_508800 0 1.405928e-07
I11789 n1_m1_475200_513600 0 2.103096e-07
I11790 n1_m1_475200_518400 0 1.399040e-07
I11791 n1_m1_475200_523200 0 1.401299e-07
I11792 n1_m1_475200_528000 0 2.177397e-07
I11793 n1_m1_475200_532800 0 1.455577e-07
I11794 n1_m1_475200_537600 0 2.119739e-07
I11795 n1_m1_475200_542400 0 1.458675e-07
I11796 n1_m1_475200_547200 0 1.577038e-07
I11797 n1_m1_475200_552000 0 2.503352e-07
I11798 n1_m1_475200_556800 0 1.585124e-07
I11799 n1_m1_475200_561600 0 7.836405e-08
I11800 n1_m1_480000_0 0 2.680097e-07
I11801 n1_m1_480000_4800 0 3.231019e-07
I11802 n1_m1_480000_9600 0 6.083931e-07
I11803 n1_m1_480000_14400 0 2.982168e-07
I11804 n1_m1_480000_19200 0 2.319495e-07
I11805 n1_m1_480000_24000 0 3.315612e-07
I11806 n1_m1_480000_28800 0 2.167992e-07
I11807 n1_m1_480000_33600 0 3.162593e-07
I11808 n1_m1_480000_38400 0 2.098560e-07
I11809 n1_m1_480000_43200 0 2.098560e-07
I11810 n1_m1_480000_48000 0 3.147839e-07
I11811 n1_m1_480000_52800 0 2.099893e-07
I11812 n1_m1_480000_57600 0 3.268753e-07
I11813 n1_m1_480000_62400 0 2.198491e-07
I11814 n1_m1_480000_67200 0 2.198491e-07
I11815 n1_m1_480000_72000 0 3.309091e-07
I11816 n1_m1_480000_76800 0 2.226990e-07
I11817 n1_m1_480000_81600 0 3.314244e-07
I11818 n1_m1_480000_86400 0 2.144258e-07
I11819 n1_m1_480000_91200 0 2.067767e-07
I11820 n1_m1_480000_96000 0 3.118765e-07
I11821 n1_m1_480000_100800 0 2.185096e-07
I11822 n1_m1_480000_105600 0 3.322360e-07
I11823 n1_m1_480000_110400 0 2.320276e-07
I11824 n1_m1_480000_115200 0 2.492454e-07
I11825 n1_m1_480000_120000 0 4.790316e-07
I11826 n1_m1_480000_124800 0 2.941766e-07
I11827 n1_m1_480000_129600 0 6.235862e-07
I11828 n1_m1_480000_134400 0 7.435780e-07
I11829 n1_m1_480000_139200 0 9.914973e-07
I11830 n1_m1_480000_144000 0 1.633327e-06
I11831 n1_m1_480000_148800 0 1.042209e-06
I11832 n1_m1_480000_153600 0 6.913399e-07
I11833 n1_m1_480000_158400 0 2.439558e-07
I11834 n1_m1_480000_163200 0 2.183040e-07
I11835 n1_m1_480000_168000 0 3.292530e-07
I11836 n1_m1_480000_172800 0 2.133279e-07
I11837 n1_m1_480000_177600 0 3.249288e-07
I11838 n1_m1_480000_182400 0 2.117171e-07
I11839 n1_m1_480000_187200 0 2.111243e-07
I11840 n1_m1_480000_192000 0 3.157069e-07
I11841 n1_m1_480000_196800 0 2.112014e-07
I11842 n1_m1_480000_201600 0 3.176254e-07
I11843 n1_m1_480000_206400 0 2.191167e-07
I11844 n1_m1_480000_211200 0 2.320075e-07
I11845 n1_m1_480000_216000 0 3.367052e-07
I11846 n1_m1_480000_220800 0 2.633384e-07
I11847 n1_m1_480000_225600 0 5.818671e-07
I11848 n1_m1_480000_230400 0 2.886864e-07
I11849 n1_m1_480000_235200 0 2.730210e-07
I11850 n1_m1_480000_240000 0 4.349993e-07
I11851 n1_m1_480000_244800 0 2.360009e-07
I11852 n1_m1_480000_249600 0 3.491376e-07
I11853 n1_m1_480000_254400 0 2.140702e-07
I11854 n1_m1_480000_259200 0 2.098560e-07
I11855 n1_m1_480000_264000 0 3.226494e-07
I11856 n1_m1_480000_268800 0 2.187929e-07
I11857 n1_m1_480000_273600 0 3.390469e-07
I11858 n1_m1_480000_278400 0 2.292204e-07
I11859 n1_m1_480000_283200 0 2.372630e-07
I11860 n1_m1_480000_288000 0 3.701341e-07
I11861 n1_m1_480000_292800 0 3.307528e-07
I11862 n1_m1_480000_297600 0 5.595717e-07
I11863 n1_m1_480000_302400 0 3.298565e-07
I11864 n1_m1_480000_307200 0 3.074526e-07
I11865 n1_m1_480000_312000 0 3.947047e-07
I11866 n1_m1_480000_316800 0 2.602634e-07
I11867 n1_m1_480000_321600 0 3.651550e-07
I11868 n1_m1_480000_326400 0 2.599438e-07
I11869 n1_m1_480000_331200 0 3.080219e-07
I11870 n1_m1_480000_336000 0 8.754927e-07
I11871 n1_m1_480000_340800 0 8.706022e-07
I11872 n1_m1_480000_345600 0 4.400015e-07
I11873 n1_m1_480000_350400 0 4.496753e-07
I11874 n1_m1_480000_355200 0 3.831630e-07
I11875 n1_m1_480000_360000 0 3.704466e-07
I11876 n1_m1_480000_364800 0 2.302070e-07
I11877 n1_m1_480000_369600 0 3.232757e-07
I11878 n1_m1_480000_374400 0 2.218409e-07
I11879 n1_m1_480000_379200 0 2.341234e-07
I11880 n1_m1_480000_384000 0 3.322779e-07
I11881 n1_m1_480000_388800 0 2.198491e-07
I11882 n1_m1_480000_393600 0 3.297737e-07
I11883 n1_m1_480000_398400 0 2.250654e-07
I11884 n1_m1_480000_403200 0 2.298806e-07
I11885 n1_m1_480000_408000 0 3.747983e-07
I11886 n1_m1_480000_412800 0 2.887728e-07
I11887 n1_m1_480000_417600 0 5.029592e-07
I11888 n1_m1_480000_422400 0 2.572529e-07
I11889 n1_m1_480000_427200 0 2.264293e-07
I11890 n1_m1_480000_432000 0 3.268455e-07
I11891 n1_m1_480000_436800 0 2.098560e-07
I11892 n1_m1_480000_441600 0 3.136216e-07
I11893 n1_m1_480000_446400 0 2.089916e-07
I11894 n1_m1_480000_451200 0 2.143191e-07
I11895 n1_m1_480000_456000 0 3.237429e-07
I11896 n1_m1_480000_460800 0 2.207583e-07
I11897 n1_m1_480000_465600 0 3.440539e-07
I11898 n1_m1_480000_470400 0 2.223678e-07
I11899 n1_m1_480000_475200 0 2.129869e-07
I11900 n1_m1_480000_480000 0 3.192179e-07
I11901 n1_m1_480000_484800 0 2.175982e-07
I11902 n1_m1_480000_489600 0 3.154152e-07
I11903 n1_m1_480000_494400 0 2.098560e-07
I11904 n1_m1_480000_499200 0 2.098560e-07
I11905 n1_m1_480000_504000 0 3.147839e-07
I11906 n1_m1_480000_508800 0 2.098560e-07
I11907 n1_m1_480000_513600 0 3.147839e-07
I11908 n1_m1_480000_518400 0 2.098560e-07
I11909 n1_m1_480000_523200 0 2.099050e-07
I11910 n1_m1_480000_528000 0 3.183745e-07
I11911 n1_m1_480000_532800 0 2.179699e-07
I11912 n1_m1_480000_537600 0 3.183642e-07
I11913 n1_m1_480000_542400 0 2.197187e-07
I11914 n1_m1_480000_547200 0 2.379269e-07
I11915 n1_m1_480000_552000 0 3.703568e-07
I11916 n1_m1_480000_556800 0 2.345028e-07
I11917 n1_m1_480000_561600 0 1.164645e-07
I11918 n1_m1_484800_0 0 2.069116e-07
I11919 n1_m1_484800_4800 0 2.921471e-07
I11920 n1_m1_484800_9600 0 6.393524e-07
I11921 n1_m1_484800_14400 0 2.953015e-07
I11922 n1_m1_484800_19200 0 1.744891e-07
I11923 n1_m1_484800_24000 0 2.212000e-07
I11924 n1_m1_484800_28800 0 1.426283e-07
I11925 n1_m1_484800_33600 0 2.139342e-07
I11926 n1_m1_484800_38400 0 1.399040e-07
I11927 n1_m1_484800_43200 0 1.399040e-07
I11928 n1_m1_484800_48000 0 2.098560e-07
I11929 n1_m1_484800_52800 0 1.399743e-07
I11930 n1_m1_484800_57600 0 2.165054e-07
I11931 n1_m1_484800_62400 0 1.464607e-07
I11932 n1_m1_484800_67200 0 1.467160e-07
I11933 n1_m1_484800_72000 0 2.240241e-07
I11934 n1_m1_484800_76800 0 1.544966e-07
I11935 n1_m1_484800_81600 0 2.267354e-07
I11936 n1_m1_484800_86400 0 1.437064e-07
I11937 n1_m1_484800_91200 0 1.406084e-07
I11938 n1_m1_484800_96000 0 2.099369e-07
I11939 n1_m1_484800_100800 0 1.447761e-07
I11940 n1_m1_484800_105600 0 2.187318e-07
I11941 n1_m1_484800_110400 0 1.483884e-07
I11942 n1_m1_484800_115200 0 1.554627e-07
I11943 n1_m1_484800_120000 0 2.729272e-07
I11944 n1_m1_484800_124800 0 1.689188e-07
I11945 n1_m1_484800_129600 0 2.885106e-07
I11946 n1_m1_484800_134400 0 3.193512e-07
I11947 n1_m1_484800_139200 0 4.857400e-07
I11948 n1_m1_484800_144000 0 9.119758e-07
I11949 n1_m1_484800_148800 0 5.800441e-07
I11950 n1_m1_484800_153600 0 4.066662e-07
I11951 n1_m1_484800_158400 0 1.636987e-07
I11952 n1_m1_484800_163200 0 1.503102e-07
I11953 n1_m1_484800_168000 0 2.283396e-07
I11954 n1_m1_484800_172800 0 1.429532e-07
I11955 n1_m1_484800_177600 0 2.192951e-07
I11956 n1_m1_484800_182400 0 1.464416e-07
I11957 n1_m1_484800_187200 0 1.443593e-07
I11958 n1_m1_484800_192000 0 2.098560e-07
I11959 n1_m1_484800_196800 0 1.399040e-07
I11960 n1_m1_484800_201600 0 2.104902e-07
I11961 n1_m1_484800_206400 0 1.450677e-07
I11962 n1_m1_484800_211200 0 1.416950e-07
I11963 n1_m1_484800_216000 0 2.168244e-07
I11964 n1_m1_484800_220800 0 2.004208e-07
I11965 n1_m1_484800_225600 0 5.601699e-07
I11966 n1_m1_484800_230400 0 1.982047e-07
I11967 n1_m1_484800_235200 0 2.042483e-07
I11968 n1_m1_484800_240000 0 2.809256e-07
I11969 n1_m1_484800_244800 0 1.585180e-07
I11970 n1_m1_484800_249600 0 2.328439e-07
I11971 n1_m1_484800_254400 0 1.437891e-07
I11972 n1_m1_484800_259200 0 1.402980e-07
I11973 n1_m1_484800_264000 0 2.099964e-07
I11974 n1_m1_484800_268800 0 1.407693e-07
I11975 n1_m1_484800_273600 0 2.189630e-07
I11976 n1_m1_484800_278400 0 1.480912e-07
I11977 n1_m1_484800_283200 0 1.574095e-07
I11978 n1_m1_484800_288000 0 2.609273e-07
I11979 n1_m1_484800_292800 0 3.079473e-07
I11980 n1_m1_484800_297600 0 5.344952e-07
I11981 n1_m1_484800_302400 0 2.284170e-07
I11982 n1_m1_484800_307200 0 1.953988e-07
I11983 n1_m1_484800_312000 0 2.735166e-07
I11984 n1_m1_484800_316800 0 1.795630e-07
I11985 n1_m1_484800_321600 0 2.423443e-07
I11986 n1_m1_484800_326400 0 1.965601e-07
I11987 n1_m1_484800_331200 0 2.713567e-07
I11988 n1_m1_484800_336000 0 7.079881e-07
I11989 n1_m1_484800_340800 0 7.166381e-07
I11990 n1_m1_484800_345600 0 3.852983e-07
I11991 n1_m1_484800_350400 0 2.868880e-07
I11992 n1_m1_484800_355200 0 2.386058e-07
I11993 n1_m1_484800_360000 0 2.341154e-07
I11994 n1_m1_484800_364800 0 1.506756e-07
I11995 n1_m1_484800_369600 0 2.209287e-07
I11996 n1_m1_484800_374400 0 1.489905e-07
I11997 n1_m1_484800_379200 0 1.568556e-07
I11998 n1_m1_484800_384000 0 2.222166e-07
I11999 n1_m1_484800_388800 0 1.479589e-07
I12000 n1_m1_484800_393600 0 2.219384e-07
I12001 n1_m1_484800_398400 0 1.502972e-07
I12002 n1_m1_484800_403200 0 1.518353e-07
I12003 n1_m1_484800_408000 0 2.445347e-07
I12004 n1_m1_484800_412800 0 2.117708e-07
I12005 n1_m1_484800_417600 0 4.438708e-07
I12006 n1_m1_484800_422400 0 1.846688e-07
I12007 n1_m1_484800_427200 0 1.561427e-07
I12008 n1_m1_484800_432000 0 2.193543e-07
I12009 n1_m1_484800_436800 0 1.412969e-07
I12010 n1_m1_484800_441600 0 2.078622e-07
I12011 n1_m1_484800_446400 0 1.375147e-07
I12012 n1_m1_484800_451200 0 1.428794e-07
I12013 n1_m1_484800_456000 0 2.166894e-07
I12014 n1_m1_484800_460800 0 1.485231e-07
I12015 n1_m1_484800_465600 0 2.308161e-07
I12016 n1_m1_484800_470400 0 1.479446e-07
I12017 n1_m1_484800_475200 0 1.412703e-07
I12018 n1_m1_484800_480000 0 2.131360e-07
I12019 n1_m1_484800_484800 0 1.450747e-07
I12020 n1_m1_484800_489600 0 2.102768e-07
I12021 n1_m1_484800_494400 0 1.399040e-07
I12022 n1_m1_484800_499200 0 1.399040e-07
I12023 n1_m1_484800_504000 0 2.098560e-07
I12024 n1_m1_484800_508800 0 1.399040e-07
I12025 n1_m1_484800_513600 0 2.098560e-07
I12026 n1_m1_484800_518400 0 1.399040e-07
I12027 n1_m1_484800_523200 0 1.399040e-07
I12028 n1_m1_484800_528000 0 2.113200e-07
I12029 n1_m1_484800_532800 0 1.461946e-07
I12030 n1_m1_484800_537600 0 2.203560e-07
I12031 n1_m1_484800_542400 0 1.531689e-07
I12032 n1_m1_484800_547200 0 1.648739e-07
I12033 n1_m1_484800_552000 0 2.515988e-07
I12034 n1_m1_484800_556800 0 1.565390e-07
I12035 n1_m1_484800_561600 0 7.771053e-08
I12036 n1_m1_489600_0 0 3.761724e-07
I12037 n1_m1_489600_4800 0 4.770542e-07
I12038 n1_m1_489600_9600 0 6.860880e-07
I12039 n1_m1_489600_14400 0 2.800750e-07
I12040 n1_m1_489600_19200 0 2.404078e-07
I12041 n1_m1_489600_24000 0 3.394889e-07
I12042 n1_m1_489600_28800 0 2.163766e-07
I12043 n1_m1_489600_33600 0 3.183757e-07
I12044 n1_m1_489600_38400 0 2.084101e-07
I12045 n1_m1_489600_43200 0 2.098560e-07
I12046 n1_m1_489600_48000 0 3.147839e-07
I12047 n1_m1_489600_52800 0 2.098616e-07
I12048 n1_m1_489600_57600 0 3.171752e-07
I12049 n1_m1_489600_62400 0 2.196897e-07
I12050 n1_m1_489600_67200 0 2.233455e-07
I12051 n1_m1_489600_72000 0 3.417509e-07
I12052 n1_m1_489600_76800 0 2.357042e-07
I12053 n1_m1_489600_81600 0 3.435411e-07
I12054 n1_m1_489600_86400 0 2.196207e-07
I12055 n1_m1_489600_91200 0 2.150850e-07
I12056 n1_m1_489600_96000 0 3.181435e-07
I12057 n1_m1_489600_100800 0 2.181610e-07
I12058 n1_m1_489600_105600 0 3.286205e-07
I12059 n1_m1_489600_110400 0 2.253230e-07
I12060 n1_m1_489600_115200 0 2.355059e-07
I12061 n1_m1_489600_120000 0 4.418360e-07
I12062 n1_m1_489600_124800 0 2.745538e-07
I12063 n1_m1_489600_129600 0 4.599919e-07
I12064 n1_m1_489600_134400 0 5.968079e-07
I12065 n1_m1_489600_139200 0 1.137404e-06
I12066 n1_m1_489600_144000 0 2.333371e-06
I12067 n1_m1_489600_148800 0 1.166999e-06
I12068 n1_m1_489600_153600 0 6.778246e-07
I12069 n1_m1_489600_158400 0 2.406519e-07
I12070 n1_m1_489600_163200 0 2.213870e-07
I12071 n1_m1_489600_168000 0 3.428416e-07
I12072 n1_m1_489600_172800 0 2.173584e-07
I12073 n1_m1_489600_177600 0 3.293877e-07
I12074 n1_m1_489600_182400 0 2.198491e-07
I12075 n1_m1_489600_187200 0 2.178480e-07
I12076 n1_m1_489600_192000 0 3.203495e-07
I12077 n1_m1_489600_196800 0 2.135663e-07
I12078 n1_m1_489600_201600 0 3.243312e-07
I12079 n1_m1_489600_206400 0 2.188869e-07
I12080 n1_m1_489600_211200 0 2.122255e-07
I12081 n1_m1_489600_216000 0 3.458431e-07
I12082 n1_m1_489600_220800 0 3.292169e-07
I12083 n1_m1_489600_225600 0 9.762501e-07
I12084 n1_m1_489600_230400 0 3.314136e-07
I12085 n1_m1_489600_235200 0 3.202801e-07
I12086 n1_m1_489600_240000 0 3.742969e-07
I12087 n1_m1_489600_244800 0 2.305968e-07
I12088 n1_m1_489600_249600 0 3.411293e-07
I12089 n1_m1_489600_254400 0 2.199603e-07
I12090 n1_m1_489600_259200 0 2.152248e-07
I12091 n1_m1_489600_264000 0 3.239576e-07
I12092 n1_m1_489600_268800 0 2.146975e-07
I12093 n1_m1_489600_273600 0 3.301022e-07
I12094 n1_m1_489600_278400 0 2.216538e-07
I12095 n1_m1_489600_283200 0 2.391274e-07
I12096 n1_m1_489600_288000 0 4.467778e-07
I12097 n1_m1_489600_292800 0 3.953862e-07
I12098 n1_m1_489600_297600 0 6.939982e-07
I12099 n1_m1_489600_302400 0 4.792252e-07
I12100 n1_m1_489600_307200 0 4.088170e-07
I12101 n1_m1_489600_312000 0 4.253785e-07
I12102 n1_m1_489600_316800 0 3.041439e-07
I12103 n1_m1_489600_321600 0 3.831840e-07
I12104 n1_m1_489600_326400 0 2.736423e-07
I12105 n1_m1_489600_331200 0 3.300996e-07
I12106 n1_m1_489600_336000 0 7.446652e-07
I12107 n1_m1_489600_340800 0 7.183067e-07
I12108 n1_m1_489600_345600 0 5.454553e-07
I12109 n1_m1_489600_350400 0 3.774926e-07
I12110 n1_m1_489600_355200 0 3.170708e-07
I12111 n1_m1_489600_360000 0 3.567958e-07
I12112 n1_m1_489600_364800 0 2.213790e-07
I12113 n1_m1_489600_369600 0 3.251563e-07
I12114 n1_m1_489600_374400 0 2.197839e-07
I12115 n1_m1_489600_379200 0 2.331080e-07
I12116 n1_m1_489600_384000 0 3.414481e-07
I12117 n1_m1_489600_388800 0 2.257110e-07
I12118 n1_m1_489600_393600 0 3.359818e-07
I12119 n1_m1_489600_398400 0 2.209567e-07
I12120 n1_m1_489600_403200 0 2.221779e-07
I12121 n1_m1_489600_408000 0 3.695862e-07
I12122 n1_m1_489600_412800 0 3.455139e-07
I12123 n1_m1_489600_417600 0 7.063516e-07
I12124 n1_m1_489600_422400 0 2.801508e-07
I12125 n1_m1_489600_427200 0 2.373024e-07
I12126 n1_m1_489600_432000 0 3.310063e-07
I12127 n1_m1_489600_436800 0 2.157179e-07
I12128 n1_m1_489600_441600 0 3.219703e-07
I12129 n1_m1_489600_446400 0 2.133709e-07
I12130 n1_m1_489600_451200 0 2.163723e-07
I12131 n1_m1_489600_456000 0 3.377950e-07
I12132 n1_m1_489600_460800 0 2.351087e-07
I12133 n1_m1_489600_465600 0 3.564687e-07
I12134 n1_m1_489600_470400 0 2.342854e-07
I12135 n1_m1_489600_475200 0 2.173829e-07
I12136 n1_m1_489600_480000 0 3.253329e-07
I12137 n1_m1_489600_484800 0 2.205479e-07
I12138 n1_m1_489600_489600 0 3.156496e-07
I12139 n1_m1_489600_494400 0 2.098560e-07
I12140 n1_m1_489600_499200 0 2.098560e-07
I12141 n1_m1_489600_504000 0 3.147839e-07
I12142 n1_m1_489600_508800 0 2.098560e-07
I12143 n1_m1_489600_513600 0 3.147839e-07
I12144 n1_m1_489600_518400 0 2.098560e-07
I12145 n1_m1_489600_523200 0 2.098560e-07
I12146 n1_m1_489600_528000 0 3.177953e-07
I12147 n1_m1_489600_532800 0 2.221899e-07
I12148 n1_m1_489600_537600 0 3.311863e-07
I12149 n1_m1_489600_542400 0 2.285168e-07
I12150 n1_m1_489600_547200 0 2.461408e-07
I12151 n1_m1_489600_552000 0 3.881707e-07
I12152 n1_m1_489600_556800 0 2.372241e-07
I12153 n1_m1_489600_561600 0 1.167393e-07
I12154 n1_m1_494400_0 0 1.837718e-07
I12155 n1_m1_494400_4800 0 2.534664e-07
I12156 n1_m1_494400_9600 0 4.023108e-07
I12157 n1_m1_494400_14400 0 1.762771e-07
I12158 n1_m1_494400_19200 0 1.596189e-07
I12159 n1_m1_494400_24000 0 2.192424e-07
I12160 n1_m1_494400_28800 0 1.422627e-07
I12161 n1_m1_494400_33600 0 2.129684e-07
I12162 n1_m1_494400_38400 0 1.385228e-07
I12163 n1_m1_494400_43200 0 1.415294e-07
I12164 n1_m1_494400_48000 0 2.143522e-07
I12165 n1_m1_494400_52800 0 1.405724e-07
I12166 n1_m1_494400_57600 0 2.111659e-07
I12167 n1_m1_494400_62400 0 1.466015e-07
I12168 n1_m1_494400_67200 0 1.493032e-07
I12169 n1_m1_494400_72000 0 2.216875e-07
I12170 n1_m1_494400_76800 0 1.501105e-07
I12171 n1_m1_494400_81600 0 2.229268e-07
I12172 n1_m1_494400_86400 0 1.465661e-07
I12173 n1_m1_494400_91200 0 1.435432e-07
I12174 n1_m1_494400_96000 0 2.156171e-07
I12175 n1_m1_494400_100800 0 1.465661e-07
I12176 n1_m1_494400_105600 0 2.268825e-07
I12177 n1_m1_494400_110400 0 1.508599e-07
I12178 n1_m1_494400_115200 0 1.558439e-07
I12179 n1_m1_494400_120000 0 2.485781e-07
I12180 n1_m1_494400_124800 0 1.778779e-07
I12181 n1_m1_494400_129600 0 2.557536e-07
I12182 n1_m1_494400_134400 0 4.291665e-07
I12183 n1_m1_494400_139200 0 7.981646e-07
I12184 n1_m1_494400_144000 0 1.534225e-06
I12185 n1_m1_494400_148800 0 7.115490e-07
I12186 n1_m1_494400_153600 0 4.081135e-07
I12187 n1_m1_494400_158400 0 1.610638e-07
I12188 n1_m1_494400_163200 0 1.437807e-07
I12189 n1_m1_494400_168000 0 2.144909e-07
I12190 n1_m1_494400_172800 0 1.460631e-07
I12191 n1_m1_494400_177600 0 2.198092e-07
I12192 n1_m1_494400_182400 0 1.465661e-07
I12193 n1_m1_494400_187200 0 1.465661e-07
I12194 n1_m1_494400_192000 0 2.198491e-07
I12195 n1_m1_494400_196800 0 1.484245e-07
I12196 n1_m1_494400_201600 0 2.277578e-07
I12197 n1_m1_494400_206400 0 1.499734e-07
I12198 n1_m1_494400_211200 0 1.445611e-07
I12199 n1_m1_494400_216000 0 2.293425e-07
I12200 n1_m1_494400_220800 0 1.846309e-07
I12201 n1_m1_494400_225600 0 3.906468e-07
I12202 n1_m1_494400_230400 0 1.922294e-07
I12203 n1_m1_494400_235200 0 1.653314e-07
I12204 n1_m1_494400_240000 0 2.511549e-07
I12205 n1_m1_494400_244800 0 1.517581e-07
I12206 n1_m1_494400_249600 0 2.204708e-07
I12207 n1_m1_494400_254400 0 1.458187e-07
I12208 n1_m1_494400_259200 0 1.465661e-07
I12209 n1_m1_494400_264000 0 2.232958e-07
I12210 n1_m1_494400_268800 0 1.469792e-07
I12211 n1_m1_494400_273600 0 2.233817e-07
I12212 n1_m1_494400_278400 0 1.552647e-07
I12213 n1_m1_494400_283200 0 1.553767e-07
I12214 n1_m1_494400_288000 0 2.510659e-07
I12215 n1_m1_494400_292800 0 2.778622e-07
I12216 n1_m1_494400_297600 0 4.825187e-07
I12217 n1_m1_494400_302400 0 2.716873e-07
I12218 n1_m1_494400_307200 0 2.065859e-07
I12219 n1_m1_494400_312000 0 2.594354e-07
I12220 n1_m1_494400_316800 0 1.825946e-07
I12221 n1_m1_494400_321600 0 2.537648e-07
I12222 n1_m1_494400_326400 0 1.691807e-07
I12223 n1_m1_494400_331200 0 1.754696e-07
I12224 n1_m1_494400_336000 0 2.596676e-07
I12225 n1_m1_494400_340800 0 2.017706e-07
I12226 n1_m1_494400_345600 0 3.652147e-07
I12227 n1_m1_494400_350400 0 1.998131e-07
I12228 n1_m1_494400_355200 0 1.728825e-07
I12229 n1_m1_494400_360000 0 2.438377e-07
I12230 n1_m1_494400_364800 0 1.487295e-07
I12231 n1_m1_494400_369600 0 2.120925e-07
I12232 n1_m1_494400_374400 0 1.441731e-07
I12233 n1_m1_494400_379200 0 1.503922e-07
I12234 n1_m1_494400_384000 0 2.313249e-07
I12235 n1_m1_494400_388800 0 1.486686e-07
I12236 n1_m1_494400_393600 0 2.173800e-07
I12237 n1_m1_494400_398400 0 1.451597e-07
I12238 n1_m1_494400_403200 0 1.499920e-07
I12239 n1_m1_494400_408000 0 2.432886e-07
I12240 n1_m1_494400_412800 0 1.776335e-07
I12241 n1_m1_494400_417600 0 2.919921e-07
I12242 n1_m1_494400_422400 0 1.675585e-07
I12243 n1_m1_494400_427200 0 1.541824e-07
I12244 n1_m1_494400_432000 0 2.186578e-07
I12245 n1_m1_494400_436800 0 1.399040e-07
I12246 n1_m1_494400_441600 0 2.140168e-07
I12247 n1_m1_494400_446400 0 1.465661e-07
I12248 n1_m1_494400_451200 0 1.479585e-07
I12249 n1_m1_494400_456000 0 2.306134e-07
I12250 n1_m1_494400_460800 0 1.695837e-07
I12251 n1_m1_494400_465600 0 2.414024e-07
I12252 n1_m1_494400_470400 0 1.582419e-07
I12253 n1_m1_494400_475200 0 1.482632e-07
I12254 n1_m1_494400_480000 0 2.157946e-07
I12255 n1_m1_494400_484800 0 1.526011e-07
I12256 n1_m1_494400_489600 0 2.108946e-07
I12257 n1_m1_494400_494400 0 1.399040e-07
I12258 n1_m1_494400_499200 0 1.399040e-07
I12259 n1_m1_494400_504000 0 2.098560e-07
I12260 n1_m1_494400_508800 0 1.399040e-07
I12261 n1_m1_494400_513600 0 2.098560e-07
I12262 n1_m1_494400_518400 0 1.399040e-07
I12263 n1_m1_494400_523200 0 1.399040e-07
I12264 n1_m1_494400_528000 0 2.120989e-07
I12265 n1_m1_494400_532800 0 1.489535e-07
I12266 n1_m1_494400_537600 0 2.184585e-07
I12267 n1_m1_494400_542400 0 1.444407e-07
I12268 n1_m1_494400_547200 0 1.559677e-07
I12269 n1_m1_494400_552000 0 2.605412e-07
I12270 n1_m1_494400_556800 0 1.562379e-07
I12271 n1_m1_494400_561600 0 7.648606e-08
I12272 n1_m1_499200_0 0 1.604468e-07
I12273 n1_m1_499200_4800 0 1.897071e-07
I12274 n1_m1_499200_9600 0 2.834707e-07
I12275 n1_m1_499200_14400 0 1.581237e-07
I12276 n1_m1_499200_19200 0 1.520575e-07
I12277 n1_m1_499200_24000 0 2.139910e-07
I12278 n1_m1_499200_28800 0 1.399040e-07
I12279 n1_m1_499200_33600 0 2.098560e-07
I12280 n1_m1_499200_38400 0 1.414450e-07
I12281 n1_m1_499200_43200 0 1.445858e-07
I12282 n1_m1_499200_48000 0 2.194638e-07
I12283 n1_m1_499200_52800 0 1.413324e-07
I12284 n1_m1_499200_57600 0 2.106694e-07
I12285 n1_m1_499200_62400 0 1.441124e-07
I12286 n1_m1_499200_67200 0 1.459910e-07
I12287 n1_m1_499200_72000 0 2.164773e-07
I12288 n1_m1_499200_76800 0 1.447105e-07
I12289 n1_m1_499200_81600 0 2.197840e-07
I12290 n1_m1_499200_86400 0 1.451958e-07
I12291 n1_m1_499200_91200 0 1.421639e-07
I12292 n1_m1_499200_96000 0 2.134943e-07
I12293 n1_m1_499200_100800 0 1.458877e-07
I12294 n1_m1_499200_105600 0 2.253973e-07
I12295 n1_m1_499200_110400 0 1.556900e-07
I12296 n1_m1_499200_115200 0 1.588806e-07
I12297 n1_m1_499200_120000 0 2.370795e-07
I12298 n1_m1_499200_124800 0 1.670833e-07
I12299 n1_m1_499200_129600 0 2.462877e-07
I12300 n1_m1_499200_134400 0 3.757841e-07
I12301 n1_m1_499200_139200 0 6.842412e-07
I12302 n1_m1_499200_144000 0 1.395008e-06
I12303 n1_m1_499200_148800 0 6.944057e-07
I12304 n1_m1_499200_153600 0 4.206508e-07
I12305 n1_m1_499200_158400 0 1.666237e-07
I12306 n1_m1_499200_163200 0 1.467193e-07
I12307 n1_m1_499200_168000 0 2.171678e-07
I12308 n1_m1_499200_172800 0 1.496374e-07
I12309 n1_m1_499200_177600 0 2.202356e-07
I12310 n1_m1_499200_182400 0 1.465661e-07
I12311 n1_m1_499200_187200 0 1.465661e-07
I12312 n1_m1_499200_192000 0 2.198491e-07
I12313 n1_m1_499200_196800 0 1.505372e-07
I12314 n1_m1_499200_201600 0 2.296019e-07
I12315 n1_m1_499200_206400 0 1.509404e-07
I12316 n1_m1_499200_211200 0 1.475083e-07
I12317 n1_m1_499200_216000 0 2.260585e-07
I12318 n1_m1_499200_220800 0 1.654782e-07
I12319 n1_m1_499200_225600 0 2.981585e-07
I12320 n1_m1_499200_230400 0 1.638970e-07
I12321 n1_m1_499200_235200 0 1.557176e-07
I12322 n1_m1_499200_240000 0 2.389226e-07
I12323 n1_m1_499200_244800 0 1.488962e-07
I12324 n1_m1_499200_249600 0 2.212110e-07
I12325 n1_m1_499200_254400 0 1.440838e-07
I12326 n1_m1_499200_259200 0 1.458517e-07
I12327 n1_m1_499200_264000 0 2.170007e-07
I12328 n1_m1_499200_268800 0 1.443219e-07
I12329 n1_m1_499200_273600 0 2.242553e-07
I12330 n1_m1_499200_278400 0 1.596418e-07
I12331 n1_m1_499200_283200 0 1.589978e-07
I12332 n1_m1_499200_288000 0 2.361915e-07
I12333 n1_m1_499200_292800 0 2.236479e-07
I12334 n1_m1_499200_297600 0 4.379005e-07
I12335 n1_m1_499200_302400 0 3.432113e-07
I12336 n1_m1_499200_307200 0 2.422370e-07
I12337 n1_m1_499200_312000 0 2.668193e-07
I12338 n1_m1_499200_316800 0 2.152941e-07
I12339 n1_m1_499200_321600 0 2.592109e-07
I12340 n1_m1_499200_326400 0 1.583660e-07
I12341 n1_m1_499200_331200 0 1.605602e-07
I12342 n1_m1_499200_336000 0 2.396764e-07
I12343 n1_m1_499200_340800 0 1.699009e-07
I12344 n1_m1_499200_345600 0 2.664306e-07
I12345 n1_m1_499200_350400 0 1.725821e-07
I12346 n1_m1_499200_355200 0 1.668131e-07
I12347 n1_m1_499200_360000 0 2.384752e-07
I12348 n1_m1_499200_364800 0 1.483745e-07
I12349 n1_m1_499200_369600 0 2.155316e-07
I12350 n1_m1_499200_374400 0 1.463784e-07
I12351 n1_m1_499200_379200 0 1.471366e-07
I12352 n1_m1_499200_384000 0 2.265458e-07
I12353 n1_m1_499200_388800 0 1.518810e-07
I12354 n1_m1_499200_393600 0 2.218776e-07
I12355 n1_m1_499200_398400 0 1.465661e-07
I12356 n1_m1_499200_403200 0 1.499920e-07
I12357 n1_m1_499200_408000 0 2.343933e-07
I12358 n1_m1_499200_412800 0 1.678909e-07
I12359 n1_m1_499200_417600 0 2.661404e-07
I12360 n1_m1_499200_422400 0 1.657554e-07
I12361 n1_m1_499200_427200 0 1.539196e-07
I12362 n1_m1_499200_432000 0 2.161710e-07
I12363 n1_m1_499200_436800 0 1.399040e-07
I12364 n1_m1_499200_441600 0 2.140168e-07
I12365 n1_m1_499200_446400 0 1.465661e-07
I12366 n1_m1_499200_451200 0 1.484138e-07
I12367 n1_m1_499200_456000 0 2.352029e-07
I12368 n1_m1_499200_460800 0 2.789096e-07
I12369 n1_m1_499200_465600 0 3.322808e-07
I12370 n1_m1_499200_470400 0 1.554472e-07
I12371 n1_m1_499200_475200 0 1.492316e-07
I12372 n1_m1_499200_480000 0 2.250111e-07
I12373 n1_m1_499200_484800 0 1.549518e-07
I12374 n1_m1_499200_489600 0 2.088967e-07
I12375 n1_m1_499200_494400 0 1.399040e-07
I12376 n1_m1_499200_499200 0 1.399040e-07
I12377 n1_m1_499200_504000 0 2.098560e-07
I12378 n1_m1_499200_508800 0 1.399040e-07
I12379 n1_m1_499200_513600 0 2.098560e-07
I12380 n1_m1_499200_518400 0 1.399040e-07
I12381 n1_m1_499200_523200 0 1.399961e-07
I12382 n1_m1_499200_528000 0 2.133822e-07
I12383 n1_m1_499200_532800 0 1.443990e-07
I12384 n1_m1_499200_537600 0 2.196042e-07
I12385 n1_m1_499200_542400 0 1.485878e-07
I12386 n1_m1_499200_547200 0 1.575552e-07
I12387 n1_m1_499200_552000 0 2.514669e-07
I12388 n1_m1_499200_556800 0 1.552304e-07
I12389 n1_m1_499200_561600 0 7.657867e-08
I12390 n1_m1_504000_0 0 2.503926e-07
I12391 n1_m1_504000_4800 0 2.757064e-07
I12392 n1_m1_504000_9600 0 3.872017e-07
I12393 n1_m1_504000_14400 0 2.271000e-07
I12394 n1_m1_504000_19200 0 2.287140e-07
I12395 n1_m1_504000_24000 0 3.339513e-07
I12396 n1_m1_504000_28800 0 2.133086e-07
I12397 n1_m1_504000_33600 0 3.147839e-07
I12398 n1_m1_504000_38400 0 2.159550e-07
I12399 n1_m1_504000_43200 0 2.198491e-07
I12400 n1_m1_504000_48000 0 3.291958e-07
I12401 n1_m1_504000_52800 0 2.119986e-07
I12402 n1_m1_504000_57600 0 3.147839e-07
I12403 n1_m1_504000_62400 0 2.105891e-07
I12404 n1_m1_504000_67200 0 2.135772e-07
I12405 n1_m1_504000_72000 0 3.174093e-07
I12406 n1_m1_504000_76800 0 2.163079e-07
I12407 n1_m1_504000_81600 0 3.263808e-07
I12408 n1_m1_504000_86400 0 2.120596e-07
I12409 n1_m1_504000_91200 0 2.098560e-07
I12410 n1_m1_504000_96000 0 3.150240e-07
I12411 n1_m1_504000_100800 0 2.171641e-07
I12412 n1_m1_504000_105600 0 3.330277e-07
I12413 n1_m1_504000_110400 0 2.376483e-07
I12414 n1_m1_504000_115200 0 2.383595e-07
I12415 n1_m1_504000_120000 0 3.394645e-07
I12416 n1_m1_504000_124800 0 2.406334e-07
I12417 n1_m1_504000_129600 0 3.584503e-07
I12418 n1_m1_504000_134400 0 4.050729e-07
I12419 n1_m1_504000_139200 0 7.751180e-07
I12420 n1_m1_504000_144000 0 1.974087e-06
I12421 n1_m1_504000_148800 0 1.092675e-06
I12422 n1_m1_504000_153600 0 7.019101e-07
I12423 n1_m1_504000_158400 0 2.650826e-07
I12424 n1_m1_504000_163200 0 2.269528e-07
I12425 n1_m1_504000_168000 0 3.182249e-07
I12426 n1_m1_504000_172800 0 2.153642e-07
I12427 n1_m1_504000_177600 0 3.292903e-07
I12428 n1_m1_504000_182400 0 2.198491e-07
I12429 n1_m1_504000_187200 0 2.198491e-07
I12430 n1_m1_504000_192000 0 3.297737e-07
I12431 n1_m1_504000_196800 0 2.227215e-07
I12432 n1_m1_504000_201600 0 3.365431e-07
I12433 n1_m1_504000_206400 0 2.207022e-07
I12434 n1_m1_504000_211200 0 2.198813e-07
I12435 n1_m1_504000_216000 0 3.368740e-07
I12436 n1_m1_504000_220800 0 2.359907e-07
I12437 n1_m1_504000_225600 0 3.981694e-07
I12438 n1_m1_504000_230400 0 2.448142e-07
I12439 n1_m1_504000_235200 0 2.325450e-07
I12440 n1_m1_504000_240000 0 3.568369e-07
I12441 n1_m1_504000_244800 0 2.228580e-07
I12442 n1_m1_504000_249600 0 3.308476e-07
I12443 n1_m1_504000_254400 0 2.152867e-07
I12444 n1_m1_504000_259200 0 2.259067e-07
I12445 n1_m1_504000_264000 0 3.390551e-07
I12446 n1_m1_504000_268800 0 2.207682e-07
I12447 n1_m1_504000_273600 0 3.370502e-07
I12448 n1_m1_504000_278400 0 2.315769e-07
I12449 n1_m1_504000_283200 0 2.123019e-07
I12450 n1_m1_504000_288000 0 3.290831e-07
I12451 n1_m1_504000_292800 0 3.416458e-07
I12452 n1_m1_504000_297600 0 8.058684e-07
I12453 n1_m1_504000_302400 0 7.073074e-07
I12454 n1_m1_504000_307200 0 4.436287e-07
I12455 n1_m1_504000_312000 0 4.101400e-07
I12456 n1_m1_504000_316800 0 4.323674e-07
I12457 n1_m1_504000_321600 0 4.217654e-07
I12458 n1_m1_504000_326400 0 2.363664e-07
I12459 n1_m1_504000_331200 0 2.399010e-07
I12460 n1_m1_504000_336000 0 3.626102e-07
I12461 n1_m1_504000_340800 0 2.489395e-07
I12462 n1_m1_504000_345600 0 3.662707e-07
I12463 n1_m1_504000_350400 0 2.378935e-07
I12464 n1_m1_504000_355200 0 2.366760e-07
I12465 n1_m1_504000_360000 0 3.463269e-07
I12466 n1_m1_504000_364800 0 2.216895e-07
I12467 n1_m1_504000_369600 0 3.297737e-07
I12468 n1_m1_504000_374400 0 2.198491e-07
I12469 n1_m1_504000_379200 0 2.198491e-07
I12470 n1_m1_504000_384000 0 3.339167e-07
I12471 n1_m1_504000_388800 0 2.298422e-07
I12472 n1_m1_504000_393600 0 3.378020e-07
I12473 n1_m1_504000_398400 0 2.198491e-07
I12474 n1_m1_504000_403200 0 2.249879e-07
I12475 n1_m1_504000_408000 0 3.458480e-07
I12476 n1_m1_504000_412800 0 2.455699e-07
I12477 n1_m1_504000_417600 0 3.838348e-07
I12478 n1_m1_504000_422400 0 2.436544e-07
I12479 n1_m1_504000_427200 0 2.301322e-07
I12480 n1_m1_504000_432000 0 3.232408e-07
I12481 n1_m1_504000_436800 0 2.111910e-07
I12482 n1_m1_504000_441600 0 3.254032e-07
I12483 n1_m1_504000_446400 0 2.198491e-07
I12484 n1_m1_504000_451200 0 2.198491e-07
I12485 n1_m1_504000_456000 0 3.501204e-07
I12486 n1_m1_504000_460800 0 6.466151e-07
I12487 n1_m1_504000_465600 0 6.546341e-07
I12488 n1_m1_504000_470400 0 2.350681e-07
I12489 n1_m1_504000_475200 0 2.369627e-07
I12490 n1_m1_504000_480000 0 3.569339e-07
I12491 n1_m1_504000_484800 0 2.245682e-07
I12492 n1_m1_504000_489600 0 3.117840e-07
I12493 n1_m1_504000_494400 0 2.098560e-07
I12494 n1_m1_504000_499200 0 2.098560e-07
I12495 n1_m1_504000_504000 0 3.147839e-07
I12496 n1_m1_504000_508800 0 2.098560e-07
I12497 n1_m1_504000_513600 0 3.147839e-07
I12498 n1_m1_504000_518400 0 2.098560e-07
I12499 n1_m1_504000_523200 0 2.100317e-07
I12500 n1_m1_504000_528000 0 3.197785e-07
I12501 n1_m1_504000_532800 0 2.118604e-07
I12502 n1_m1_504000_537600 0 3.389324e-07
I12503 n1_m1_504000_542400 0 2.464767e-07
I12504 n1_m1_504000_547200 0 2.536366e-07
I12505 n1_m1_504000_552000 0 3.644749e-07
I12506 n1_m1_504000_556800 0 2.318229e-07
I12507 n1_m1_504000_561600 0 1.155771e-07
I12508 n1_m1_508800_0 0 8.765272e-08
I12509 n1_m1_508800_4800 0 9.813356e-08
I12510 n1_m1_508800_9600 0 1.266249e-07
I12511 n1_m1_508800_14400 0 7.151379e-08
I12512 n1_m1_508800_19200 0 7.338083e-08
I12513 n1_m1_508800_24000 0 1.090977e-07
I12514 n1_m1_508800_28800 0 7.020906e-08
I12515 n1_m1_508800_33600 0 1.049280e-07
I12516 n1_m1_508800_38400 0 7.198499e-08
I12517 n1_m1_508800_43200 0 7.328303e-08
I12518 n1_m1_508800_48000 0 1.097319e-07
I12519 n1_m1_508800_52800 0 7.066621e-08
I12520 n1_m1_508800_57600 0 1.049280e-07
I12521 n1_m1_508800_62400 0 6.995199e-08
I12522 n1_m1_508800_67200 0 7.026911e-08
I12523 n1_m1_508800_72000 0 1.089982e-07
I12524 n1_m1_508800_76800 0 7.328303e-08
I12525 n1_m1_508800_81600 0 1.096812e-07
I12526 n1_m1_508800_86400 0 7.129908e-08
I12527 n1_m1_508800_91200 0 6.995199e-08
I12528 n1_m1_508800_96000 0 1.074847e-07
I12529 n1_m1_508800_100800 0 7.317952e-08
I12530 n1_m1_508800_105600 0 1.105296e-07
I12531 n1_m1_508800_110400 0 7.659267e-08
I12532 n1_m1_508800_115200 0 7.672492e-08
I12533 n1_m1_508800_120000 0 1.134143e-07
I12534 n1_m1_508800_124800 0 8.345389e-08
I12535 n1_m1_508800_129600 0 1.218361e-07
I12536 n1_m1_508800_134400 0 9.708596e-08
I12537 n1_m1_508800_139200 0 1.511479e-07
I12538 n1_m1_508800_144000 0 4.470665e-07
I12539 n1_m1_508800_148800 0 2.867032e-07
I12540 n1_m1_508800_153600 0 1.970967e-07
I12541 n1_m1_508800_158400 0 8.149062e-08
I12542 n1_m1_508800_163200 0 7.238802e-08
I12543 n1_m1_508800_168000 0 1.087407e-07
I12544 n1_m1_508800_172800 0 7.296667e-08
I12545 n1_m1_508800_177600 0 1.098886e-07
I12546 n1_m1_508800_182400 0 7.328303e-08
I12547 n1_m1_508800_187200 0 7.328303e-08
I12548 n1_m1_508800_192000 0 1.099246e-07
I12549 n1_m1_508800_196800 0 7.328303e-08
I12550 n1_m1_508800_201600 0 1.099246e-07
I12551 n1_m1_508800_206400 0 7.328303e-08
I12552 n1_m1_508800_211200 0 7.330378e-08
I12553 n1_m1_508800_216000 0 1.150240e-07
I12554 n1_m1_508800_220800 0 9.084135e-08
I12555 n1_m1_508800_225600 0 1.955814e-07
I12556 n1_m1_508800_230400 0 1.056608e-07
I12557 n1_m1_508800_235200 0 8.721954e-08
I12558 n1_m1_508800_240000 0 1.284705e-07
I12559 n1_m1_508800_244800 0 7.643242e-08
I12560 n1_m1_508800_249600 0 1.119724e-07
I12561 n1_m1_508800_254400 0 7.577010e-08
I12562 n1_m1_508800_259200 0 8.311845e-08
I12563 n1_m1_508800_264000 0 1.277778e-07
I12564 n1_m1_508800_268800 0 7.992097e-08
I12565 n1_m1_508800_273600 0 1.151580e-07
I12566 n1_m1_508800_278400 0 7.738177e-08
I12567 n1_m1_508800_283200 0 7.853119e-08
I12568 n1_m1_508800_288000 0 1.154712e-07
I12569 n1_m1_508800_292800 0 8.179452e-08
I12570 n1_m1_508800_297600 0 1.438312e-07
I12571 n1_m1_508800_302400 0 1.717565e-07
I12572 n1_m1_508800_307200 0 1.589349e-07
I12573 n1_m1_508800_312000 0 2.198933e-07
I12574 n1_m1_508800_316800 0 1.587776e-07
I12575 n1_m1_508800_321600 0 1.455614e-07
I12576 n1_m1_508800_326400 0 8.720261e-08
I12577 n1_m1_508800_331200 0 9.176171e-08
I12578 n1_m1_508800_336000 0 1.381703e-07
I12579 n1_m1_508800_340800 0 9.110663e-08
I12580 n1_m1_508800_345600 0 1.263546e-07
I12581 n1_m1_508800_350400 0 7.560769e-08
I12582 n1_m1_508800_355200 0 7.366830e-08
I12583 n1_m1_508800_360000 0 1.104685e-07
I12584 n1_m1_508800_364800 0 7.335399e-08
I12585 n1_m1_508800_369600 0 1.099246e-07
I12586 n1_m1_508800_374400 0 7.328303e-08
I12587 n1_m1_508800_379200 0 7.328303e-08
I12588 n1_m1_508800_384000 0 1.113056e-07
I12589 n1_m1_508800_388800 0 7.661408e-08
I12590 n1_m1_508800_393600 0 1.126007e-07
I12591 n1_m1_508800_398400 0 7.505994e-08
I12592 n1_m1_508800_403200 0 7.642693e-08
I12593 n1_m1_508800_408000 0 1.180083e-07
I12594 n1_m1_508800_412800 0 8.477358e-08
I12595 n1_m1_508800_417600 0 1.279415e-07
I12596 n1_m1_508800_422400 0 7.726520e-08
I12597 n1_m1_508800_427200 0 7.373350e-08
I12598 n1_m1_508800_432000 0 1.059323e-07
I12599 n1_m1_508800_436800 0 7.081142e-08
I12600 n1_m1_508800_441600 0 1.098268e-07
I12601 n1_m1_508800_446400 0 7.328303e-08
I12602 n1_m1_508800_451200 0 7.328303e-08
I12603 n1_m1_508800_456000 0 1.124158e-07
I12604 n1_m1_508800_460800 0 1.501421e-07
I12605 n1_m1_508800_465600 0 1.543738e-07
I12606 n1_m1_508800_470400 0 7.355586e-08
I12607 n1_m1_508800_475200 0 8.493310e-08
I12608 n1_m1_508800_480000 0 1.100938e-07
I12609 n1_m1_508800_484800 0 7.150288e-08
I12610 n1_m1_508800_489600 0 1.101363e-07
I12611 n1_m1_508800_494400 0 6.995199e-08
I12612 n1_m1_508800_499200 0 6.995199e-08
I12613 n1_m1_508800_504000 0 1.049280e-07
I12614 n1_m1_508800_508800 0 6.995199e-08
I12615 n1_m1_508800_513600 0 1.049280e-07
I12616 n1_m1_508800_518400 0 7.019048e-08
I12617 n1_m1_508800_523200 0 7.222685e-08
I12618 n1_m1_508800_528000 0 1.062934e-07
I12619 n1_m1_508800_532800 0 7.384326e-08
I12620 n1_m1_508800_537600 0 1.261145e-07
I12621 n1_m1_508800_542400 0 9.795754e-08
I12622 n1_m1_508800_547200 0 9.689506e-08
I12623 n1_m1_508800_552000 0 1.228608e-07
I12624 n1_m1_508800_556800 0 7.487911e-08
I12625 n1_m1_508800_561600 0 3.723513e-08
I12626 n1_m1_513600_0 0 2.792908e-07
I12627 n1_m1_513600_4800 0 3.351326e-07
I12628 n1_m1_513600_9600 0 4.072952e-07
I12629 n1_m1_513600_14400 0 2.214759e-07
I12630 n1_m1_513600_19200 0 2.262896e-07
I12631 n1_m1_513600_24000 0 3.370202e-07
I12632 n1_m1_513600_28800 0 2.151580e-07
I12633 n1_m1_513600_33600 0 3.161089e-07
I12634 n1_m1_513600_38400 0 2.154449e-07
I12635 n1_m1_513600_43200 0 2.194491e-07
I12636 n1_m1_513600_48000 0 3.291958e-07
I12637 n1_m1_513600_52800 0 2.119986e-07
I12638 n1_m1_513600_57600 0 3.147839e-07
I12639 n1_m1_513600_62400 0 2.109380e-07
I12640 n1_m1_513600_67200 0 2.165143e-07
I12641 n1_m1_513600_72000 0 3.307115e-07
I12642 n1_m1_513600_76800 0 2.231847e-07
I12643 n1_m1_513600_81600 0 3.370413e-07
I12644 n1_m1_513600_86400 0 2.186680e-07
I12645 n1_m1_513600_91200 0 2.165893e-07
I12646 n1_m1_513600_96000 0 3.274129e-07
I12647 n1_m1_513600_100800 0 2.198491e-07
I12648 n1_m1_513600_105600 0 3.302426e-07
I12649 n1_m1_513600_110400 0 2.226122e-07
I12650 n1_m1_513600_115200 0 2.238077e-07
I12651 n1_m1_513600_120000 0 3.408239e-07
I12652 n1_m1_513600_124800 0 2.536564e-07
I12653 n1_m1_513600_129600 0 3.589557e-07
I12654 n1_m1_513600_134400 0 3.771708e-07
I12655 n1_m1_513600_139200 0 5.616979e-07
I12656 n1_m1_513600_144000 0 1.377983e-06
I12657 n1_m1_513600_148800 0 9.162676e-07
I12658 n1_m1_513600_153600 0 6.124053e-07
I12659 n1_m1_513600_158400 0 2.420746e-07
I12660 n1_m1_513600_163200 0 2.158504e-07
I12661 n1_m1_513600_168000 0 3.263529e-07
I12662 n1_m1_513600_172800 0 2.191628e-07
I12663 n1_m1_513600_177600 0 3.296956e-07
I12664 n1_m1_513600_182400 0 2.198491e-07
I12665 n1_m1_513600_187200 0 2.198491e-07
I12666 n1_m1_513600_192000 0 3.297737e-07
I12667 n1_m1_513600_196800 0 2.198491e-07
I12668 n1_m1_513600_201600 0 3.297737e-07
I12669 n1_m1_513600_206400 0 2.198491e-07
I12670 n1_m1_513600_211200 0 2.199556e-07
I12671 n1_m1_513600_216000 0 3.540149e-07
I12672 n1_m1_513600_220800 0 2.974375e-07
I12673 n1_m1_513600_225600 0 7.519475e-07
I12674 n1_m1_513600_230400 0 4.043625e-07
I12675 n1_m1_513600_235200 0 2.795905e-07
I12676 n1_m1_513600_240000 0 4.041273e-07
I12677 n1_m1_513600_244800 0 2.294482e-07
I12678 n1_m1_513600_249600 0 3.363736e-07
I12679 n1_m1_513600_254400 0 2.330609e-07
I12680 n1_m1_513600_259200 0 2.519172e-07
I12681 n1_m1_513600_264000 0 3.842437e-07
I12682 n1_m1_513600_268800 0 2.402132e-07
I12683 n1_m1_513600_273600 0 3.462380e-07
I12684 n1_m1_513600_278400 0 2.303989e-07
I12685 n1_m1_513600_283200 0 2.345934e-07
I12686 n1_m1_513600_288000 0 3.535003e-07
I12687 n1_m1_513600_292800 0 2.345010e-07
I12688 n1_m1_513600_297600 0 3.752206e-07
I12689 n1_m1_513600_302400 0 4.074892e-07
I12690 n1_m1_513600_307200 0 3.923836e-07
I12691 n1_m1_513600_312000 0 5.998150e-07
I12692 n1_m1_513600_316800 0 3.715728e-07
I12693 n1_m1_513600_321600 0 3.952030e-07
I12694 n1_m1_513600_326400 0 2.590163e-07
I12695 n1_m1_513600_331200 0 2.820136e-07
I12696 n1_m1_513600_336000 0 4.133205e-07
I12697 n1_m1_513600_340800 0 2.693841e-07
I12698 n1_m1_513600_345600 0 3.796241e-07
I12699 n1_m1_513600_350400 0 2.264282e-07
I12700 n1_m1_513600_355200 0 2.198491e-07
I12701 n1_m1_513600_360000 0 3.297737e-07
I12702 n1_m1_513600_364800 0 2.198491e-07
I12703 n1_m1_513600_369600 0 3.297737e-07
I12704 n1_m1_513600_374400 0 2.200015e-07
I12705 n1_m1_513600_379200 0 2.206097e-07
I12706 n1_m1_513600_384000 0 3.348238e-07
I12707 n1_m1_513600_388800 0 2.298422e-07
I12708 n1_m1_513600_393600 0 3.421745e-07
I12709 n1_m1_513600_398400 0 2.278635e-07
I12710 n1_m1_513600_403200 0 2.290065e-07
I12711 n1_m1_513600_408000 0 3.534548e-07
I12712 n1_m1_513600_412800 0 2.491287e-07
I12713 n1_m1_513600_417600 0 3.797337e-07
I12714 n1_m1_513600_422400 0 2.299536e-07
I12715 n1_m1_513600_427200 0 2.199413e-07
I12716 n1_m1_513600_432000 0 3.164643e-07
I12717 n1_m1_513600_436800 0 2.124343e-07
I12718 n1_m1_513600_441600 0 3.294803e-07
I12719 n1_m1_513600_446400 0 2.198491e-07
I12720 n1_m1_513600_451200 0 2.198491e-07
I12721 n1_m1_513600_456000 0 3.258549e-07
I12722 n1_m1_513600_460800 0 2.899358e-07
I12723 n1_m1_513600_465600 0 3.616074e-07
I12724 n1_m1_513600_470400 0 2.224223e-07
I12725 n1_m1_513600_475200 0 2.499228e-07
I12726 n1_m1_513600_480000 0 3.223455e-07
I12727 n1_m1_513600_484800 0 2.116217e-07
I12728 n1_m1_513600_489600 0 3.422838e-07
I12729 n1_m1_513600_494400 0 2.098560e-07
I12730 n1_m1_513600_499200 0 2.098560e-07
I12731 n1_m1_513600_504000 0 3.147839e-07
I12732 n1_m1_513600_508800 0 2.098560e-07
I12733 n1_m1_513600_513600 0 3.148888e-07
I12734 n1_m1_513600_518400 0 2.107346e-07
I12735 n1_m1_513600_523200 0 2.122708e-07
I12736 n1_m1_513600_528000 0 3.206623e-07
I12737 n1_m1_513600_532800 0 2.329398e-07
I12738 n1_m1_513600_537600 0 3.922511e-07
I12739 n1_m1_513600_542400 0 2.821533e-07
I12740 n1_m1_513600_547200 0 2.769731e-07
I12741 n1_m1_513600_552000 0 3.693576e-07
I12742 n1_m1_513600_556800 0 2.243001e-07
I12743 n1_m1_513600_561600 0 1.113986e-07
I12744 n1_m1_518400_0 0 1.815493e-07
I12745 n1_m1_518400_4800 0 2.211222e-07
I12746 n1_m1_518400_9600 0 2.806440e-07
I12747 n1_m1_518400_14400 0 1.528465e-07
I12748 n1_m1_518400_19200 0 1.532856e-07
I12749 n1_m1_518400_24000 0 2.310984e-07
I12750 n1_m1_518400_28800 0 1.475926e-07
I12751 n1_m1_518400_33600 0 2.184401e-07
I12752 n1_m1_518400_38400 0 1.405009e-07
I12753 n1_m1_518400_43200 0 1.435642e-07
I12754 n1_m1_518400_48000 0 2.186860e-07
I12755 n1_m1_518400_52800 0 1.412168e-07
I12756 n1_m1_518400_57600 0 2.099620e-07
I12757 n1_m1_518400_62400 0 1.414161e-07
I12758 n1_m1_518400_67200 0 1.469172e-07
I12759 n1_m1_518400_72000 0 2.302615e-07
I12760 n1_m1_518400_76800 0 1.587330e-07
I12761 n1_m1_518400_81600 0 2.349440e-07
I12762 n1_m1_518400_86400 0 1.494120e-07
I12763 n1_m1_518400_91200 0 1.439870e-07
I12764 n1_m1_518400_96000 0 2.157719e-07
I12765 n1_m1_518400_100800 0 1.460267e-07
I12766 n1_m1_518400_105600 0 2.191279e-07
I12767 n1_m1_518400_110400 0 1.479160e-07
I12768 n1_m1_518400_115200 0 1.558015e-07
I12769 n1_m1_518400_120000 0 2.268275e-07
I12770 n1_m1_518400_124800 0 1.580503e-07
I12771 n1_m1_518400_129600 0 2.263045e-07
I12772 n1_m1_518400_134400 0 4.036959e-07
I12773 n1_m1_518400_139200 0 6.142709e-07
I12774 n1_m1_518400_144000 0 1.171415e-06
I12775 n1_m1_518400_148800 0 7.872882e-07
I12776 n1_m1_518400_153600 0 4.942276e-07
I12777 n1_m1_518400_158400 0 1.641660e-07
I12778 n1_m1_518400_163200 0 1.437166e-07
I12779 n1_m1_518400_168000 0 2.117729e-07
I12780 n1_m1_518400_172800 0 1.423413e-07
I12781 n1_m1_518400_177600 0 2.193685e-07
I12782 n1_m1_518400_182400 0 1.465661e-07
I12783 n1_m1_518400_187200 0 1.465661e-07
I12784 n1_m1_518400_192000 0 2.198491e-07
I12785 n1_m1_518400_196800 0 1.465661e-07
I12786 n1_m1_518400_201600 0 2.198491e-07
I12787 n1_m1_518400_206400 0 1.465661e-07
I12788 n1_m1_518400_211200 0 1.466457e-07
I12789 n1_m1_518400_216000 0 2.375590e-07
I12790 n1_m1_518400_220800 0 2.006856e-07
I12791 n1_m1_518400_225600 0 5.184795e-07
I12792 n1_m1_518400_230400 0 2.789086e-07
I12793 n1_m1_518400_235200 0 1.823420e-07
I12794 n1_m1_518400_240000 0 2.567696e-07
I12795 n1_m1_518400_244800 0 1.502936e-07
I12796 n1_m1_518400_249600 0 2.240191e-07
I12797 n1_m1_518400_254400 0 1.522896e-07
I12798 n1_m1_518400_259200 0 1.587586e-07
I12799 n1_m1_518400_264000 0 2.405702e-07
I12800 n1_m1_518400_268800 0 1.544484e-07
I12801 n1_m1_518400_273600 0 2.295803e-07
I12802 n1_m1_518400_278400 0 1.522201e-07
I12803 n1_m1_518400_283200 0 1.497800e-07
I12804 n1_m1_518400_288000 0 2.308692e-07
I12805 n1_m1_518400_292800 0 1.604244e-07
I12806 n1_m1_518400_297600 0 2.486769e-07
I12807 n1_m1_518400_302400 0 2.282504e-07
I12808 n1_m1_518400_307200 0 2.051572e-07
I12809 n1_m1_518400_312000 0 2.690552e-07
I12810 n1_m1_518400_316800 0 1.826080e-07
I12811 n1_m1_518400_321600 0 2.446143e-07
I12812 n1_m1_518400_326400 0 1.651498e-07
I12813 n1_m1_518400_331200 0 1.775192e-07
I12814 n1_m1_518400_336000 0 2.509001e-07
I12815 n1_m1_518400_340800 0 1.645200e-07
I12816 n1_m1_518400_345600 0 2.450758e-07
I12817 n1_m1_518400_350400 0 1.507746e-07
I12818 n1_m1_518400_355200 0 1.465661e-07
I12819 n1_m1_518400_360000 0 2.198491e-07
I12820 n1_m1_518400_364800 0 1.465661e-07
I12821 n1_m1_518400_369600 0 2.199715e-07
I12822 n1_m1_518400_374400 0 1.480193e-07
I12823 n1_m1_518400_379200 0 1.518623e-07
I12824 n1_m1_518400_384000 0 2.292937e-07
I12825 n1_m1_518400_388800 0 1.532282e-07
I12826 n1_m1_518400_393600 0 2.258826e-07
I12827 n1_m1_518400_398400 0 1.475440e-07
I12828 n1_m1_518400_403200 0 1.475440e-07
I12829 n1_m1_518400_408000 0 2.273135e-07
I12830 n1_m1_518400_412800 0 1.584645e-07
I12831 n1_m1_518400_417600 0 2.383077e-07
I12832 n1_m1_518400_422400 0 1.484458e-07
I12833 n1_m1_518400_427200 0 1.459935e-07
I12834 n1_m1_518400_432000 0 2.109762e-07
I12835 n1_m1_518400_436800 0 1.416228e-07
I12836 n1_m1_518400_441600 0 2.199904e-07
I12837 n1_m1_518400_446400 0 1.468166e-07
I12838 n1_m1_518400_451200 0 1.465661e-07
I12839 n1_m1_518400_456000 0 2.147833e-07
I12840 n1_m1_518400_460800 0 1.470022e-07
I12841 n1_m1_518400_465600 0 2.154084e-07
I12842 n1_m1_518400_470400 0 1.515969e-07
I12843 n1_m1_518400_475200 0 1.532558e-07
I12844 n1_m1_518400_480000 0 2.073101e-07
I12845 n1_m1_518400_484800 0 1.421856e-07
I12846 n1_m1_518400_489600 0 2.178653e-07
I12847 n1_m1_518400_494400 0 1.399040e-07
I12848 n1_m1_518400_499200 0 1.399040e-07
I12849 n1_m1_518400_504000 0 2.098560e-07
I12850 n1_m1_518400_508800 0 1.399040e-07
I12851 n1_m1_518400_513600 0 2.105690e-07
I12852 n1_m1_518400_518400 0 1.442935e-07
I12853 n1_m1_518400_523200 0 1.411986e-07
I12854 n1_m1_518400_528000 0 2.225412e-07
I12855 n1_m1_518400_532800 0 1.708168e-07
I12856 n1_m1_518400_537600 0 2.616742e-07
I12857 n1_m1_518400_542400 0 1.658084e-07
I12858 n1_m1_518400_547200 0 1.640523e-07
I12859 n1_m1_518400_552000 0 2.449982e-07
I12860 n1_m1_518400_556800 0 1.516408e-07
I12861 n1_m1_518400_561600 0 7.496361e-08
I12862 n1_m1_523200_0 0 1.549694e-07
I12863 n1_m1_523200_4800 0 1.778345e-07
I12864 n1_m1_523200_9600 0 2.571094e-07
I12865 n1_m1_523200_14400 0 1.449944e-07
I12866 n1_m1_523200_19200 0 1.475767e-07
I12867 n1_m1_523200_24000 0 2.202611e-07
I12868 n1_m1_523200_28800 0 1.434763e-07
I12869 n1_m1_523200_33600 0 2.159546e-07
I12870 n1_m1_523200_38400 0 1.400523e-07
I12871 n1_m1_523200_43200 0 1.408114e-07
I12872 n1_m1_523200_48000 0 2.120442e-07
I12873 n1_m1_523200_52800 0 1.402293e-07
I12874 n1_m1_523200_57600 0 2.108675e-07
I12875 n1_m1_523200_62400 0 1.456732e-07
I12876 n1_m1_523200_67200 0 1.516017e-07
I12877 n1_m1_523200_72000 0 2.384973e-07
I12878 n1_m1_523200_76800 0 1.648564e-07
I12879 n1_m1_523200_81600 0 2.433380e-07
I12880 n1_m1_523200_86400 0 1.518334e-07
I12881 n1_m1_523200_91200 0 1.434105e-07
I12882 n1_m1_523200_96000 0 2.109696e-07
I12883 n1_m1_523200_100800 0 1.415337e-07
I12884 n1_m1_523200_105600 0 2.128580e-07
I12885 n1_m1_523200_110400 0 1.482920e-07
I12886 n1_m1_523200_115200 0 1.608526e-07
I12887 n1_m1_523200_120000 0 2.291925e-07
I12888 n1_m1_523200_124800 0 1.477538e-07
I12889 n1_m1_523200_129600 0 2.225168e-07
I12890 n1_m1_523200_134400 0 5.141420e-07
I12891 n1_m1_523200_139200 0 7.532889e-07
I12892 n1_m1_523200_144000 0 1.199067e-06
I12893 n1_m1_523200_148800 0 8.227146e-07
I12894 n1_m1_523200_153600 0 5.037891e-07
I12895 n1_m1_523200_158400 0 1.633026e-07
I12896 n1_m1_523200_163200 0 1.438618e-07
I12897 n1_m1_523200_168000 0 2.164098e-07
I12898 n1_m1_523200_172800 0 1.456381e-07
I12899 n1_m1_523200_177600 0 2.202729e-07
I12900 n1_m1_523200_182400 0 1.463231e-07
I12901 n1_m1_523200_187200 0 1.466327e-07
I12902 n1_m1_523200_192000 0 2.211094e-07
I12903 n1_m1_523200_196800 0 1.468138e-07
I12904 n1_m1_523200_201600 0 2.195309e-07
I12905 n1_m1_523200_206400 0 1.466984e-07
I12906 n1_m1_523200_211200 0 1.464786e-07
I12907 n1_m1_523200_216000 0 2.303260e-07
I12908 n1_m1_523200_220800 0 1.853118e-07
I12909 n1_m1_523200_225600 0 4.450317e-07
I12910 n1_m1_523200_230400 0 2.421872e-07
I12911 n1_m1_523200_235200 0 1.746866e-07
I12912 n1_m1_523200_240000 0 2.418358e-07
I12913 n1_m1_523200_244800 0 1.471610e-07
I12914 n1_m1_523200_249600 0 2.230245e-07
I12915 n1_m1_523200_254400 0 1.473543e-07
I12916 n1_m1_523200_259200 0 1.486855e-07
I12917 n1_m1_523200_264000 0 2.284766e-07
I12918 n1_m1_523200_268800 0 1.485885e-07
I12919 n1_m1_523200_273600 0 2.254773e-07
I12920 n1_m1_523200_278400 0 1.563824e-07
I12921 n1_m1_523200_283200 0 1.531229e-07
I12922 n1_m1_523200_288000 0 2.310281e-07
I12923 n1_m1_523200_292800 0 1.521042e-07
I12924 n1_m1_523200_297600 0 2.344370e-07
I12925 n1_m1_523200_302400 0 1.875692e-07
I12926 n1_m1_523200_307200 0 1.786950e-07
I12927 n1_m1_523200_312000 0 2.455638e-07
I12928 n1_m1_523200_316800 0 1.743821e-07
I12929 n1_m1_523200_321600 0 2.386290e-07
I12930 n1_m1_523200_326400 0 1.617198e-07
I12931 n1_m1_523200_331200 0 1.659633e-07
I12932 n1_m1_523200_336000 0 2.347987e-07
I12933 n1_m1_523200_340800 0 1.574172e-07
I12934 n1_m1_523200_345600 0 2.362363e-07
I12935 n1_m1_523200_350400 0 1.490986e-07
I12936 n1_m1_523200_355200 0 1.464247e-07
I12937 n1_m1_523200_360000 0 2.194846e-07
I12938 n1_m1_523200_364800 0 1.463337e-07
I12939 n1_m1_523200_369600 0 2.209605e-07
I12940 n1_m1_523200_374400 0 1.517541e-07
I12941 n1_m1_523200_379200 0 1.538348e-07
I12942 n1_m1_523200_384000 0 2.351679e-07
I12943 n1_m1_523200_388800 0 1.534768e-07
I12944 n1_m1_523200_393600 0 2.250061e-07
I12945 n1_m1_523200_398400 0 1.467127e-07
I12946 n1_m1_523200_403200 0 1.469340e-07
I12947 n1_m1_523200_408000 0 2.213635e-07
I12948 n1_m1_523200_412800 0 1.486493e-07
I12949 n1_m1_523200_417600 0 2.230609e-07
I12950 n1_m1_523200_422400 0 1.465802e-07
I12951 n1_m1_523200_427200 0 1.458678e-07
I12952 n1_m1_523200_432000 0 2.113842e-07
I12953 n1_m1_523200_436800 0 1.420462e-07
I12954 n1_m1_523200_441600 0 2.230866e-07
I12955 n1_m1_523200_446400 0 1.489554e-07
I12956 n1_m1_523200_451200 0 1.464575e-07
I12957 n1_m1_523200_456000 0 2.184227e-07
I12958 n1_m1_523200_460800 0 1.461476e-07
I12959 n1_m1_523200_465600 0 2.157017e-07
I12960 n1_m1_523200_470400 0 1.545139e-07
I12961 n1_m1_523200_475200 0 1.443294e-07
I12962 n1_m1_523200_480000 0 2.081434e-07
I12963 n1_m1_523200_484800 0 1.520203e-07
I12964 n1_m1_523200_489600 0 2.123013e-07
I12965 n1_m1_523200_494400 0 1.401470e-07
I12966 n1_m1_523200_499200 0 1.401470e-07
I12967 n1_m1_523200_504000 0 2.102205e-07
I12968 n1_m1_523200_508800 0 1.399874e-07
I12969 n1_m1_523200_513600 0 2.106612e-07
I12970 n1_m1_523200_518400 0 1.448611e-07
I12971 n1_m1_523200_523200 0 1.413748e-07
I12972 n1_m1_523200_528000 0 2.250514e-07
I12973 n1_m1_523200_532800 0 1.752786e-07
I12974 n1_m1_523200_537600 0 2.493571e-07
I12975 n1_m1_523200_542400 0 1.498789e-07
I12976 n1_m1_523200_547200 0 1.528669e-07
I12977 n1_m1_523200_552000 0 2.406861e-07
I12978 n1_m1_523200_556800 0 1.517997e-07
I12979 n1_m1_523200_561600 0 7.497523e-08
I12980 n1_m1_528000_0 0 2.429423e-07
I12981 n1_m1_528000_4800 0 2.412086e-07
I12982 n1_m1_528000_9600 0 3.407219e-07
I12983 n1_m1_528000_14400 0 2.174638e-07
I12984 n1_m1_528000_19200 0 2.184520e-07
I12985 n1_m1_528000_24000 0 3.288973e-07
I12986 n1_m1_528000_28800 0 2.164678e-07
I12987 n1_m1_528000_33600 0 3.172318e-07
I12988 n1_m1_528000_38400 0 2.149638e-07
I12989 n1_m1_528000_43200 0 2.182251e-07
I12990 n1_m1_528000_48000 0 3.255733e-07
I12991 n1_m1_528000_52800 0 2.113365e-07
I12992 n1_m1_528000_57600 0 3.151033e-07
I12993 n1_m1_528000_62400 0 2.126548e-07
I12994 n1_m1_528000_67200 0 2.191596e-07
I12995 n1_m1_528000_72000 0 3.352026e-07
I12996 n1_m1_528000_76800 0 2.323812e-07
I12997 n1_m1_528000_81600 0 3.512688e-07
I12998 n1_m1_528000_86400 0 2.192807e-07
I12999 n1_m1_528000_91200 0 2.107431e-07
I13000 n1_m1_528000_96000 0 3.151157e-07
I13001 n1_m1_528000_100800 0 2.199556e-07
I13002 n1_m1_528000_105600 0 3.227128e-07
I13003 n1_m1_528000_110400 0 2.257950e-07
I13004 n1_m1_528000_115200 0 2.245097e-07
I13005 n1_m1_528000_120000 0 3.277769e-07
I13006 n1_m1_528000_124800 0 2.273551e-07
I13007 n1_m1_528000_129600 0 3.453481e-07
I13008 n1_m1_528000_134400 0 4.005483e-07
I13009 n1_m1_528000_139200 0 5.998630e-07
I13010 n1_m1_528000_144000 0 1.869588e-06
I13011 n1_m1_528000_148800 0 1.481650e-06
I13012 n1_m1_528000_153600 0 8.621914e-07
I13013 n1_m1_528000_158400 0 2.438889e-07
I13014 n1_m1_528000_163200 0 2.155488e-07
I13015 n1_m1_528000_168000 0 3.196853e-07
I13016 n1_m1_528000_172800 0 2.265357e-07
I13017 n1_m1_528000_177600 0 3.463366e-07
I13018 n1_m1_528000_182400 0 2.144080e-07
I13019 n1_m1_528000_187200 0 2.222727e-07
I13020 n1_m1_528000_192000 0 3.633871e-07
I13021 n1_m1_528000_196800 0 2.271707e-07
I13022 n1_m1_528000_201600 0 3.226479e-07
I13023 n1_m1_528000_206400 0 2.227375e-07
I13024 n1_m1_528000_211200 0 2.156801e-07
I13025 n1_m1_528000_216000 0 3.259815e-07
I13026 n1_m1_528000_220800 0 2.632412e-07
I13027 n1_m1_528000_225600 0 5.251698e-07
I13028 n1_m1_528000_230400 0 2.956612e-07
I13029 n1_m1_528000_235200 0 2.534288e-07
I13030 n1_m1_528000_240000 0 3.445639e-07
I13031 n1_m1_528000_244800 0 2.079233e-07
I13032 n1_m1_528000_249600 0 3.142600e-07
I13033 n1_m1_528000_254400 0 2.116215e-07
I13034 n1_m1_528000_259200 0 2.174813e-07
I13035 n1_m1_528000_264000 0 3.313529e-07
I13036 n1_m1_528000_268800 0 2.200384e-07
I13037 n1_m1_528000_273600 0 3.309469e-07
I13038 n1_m1_528000_278400 0 2.230536e-07
I13039 n1_m1_528000_283200 0 2.215545e-07
I13040 n1_m1_528000_288000 0 3.321554e-07
I13041 n1_m1_528000_292800 0 2.258990e-07
I13042 n1_m1_528000_297600 0 3.408443e-07
I13043 n1_m1_528000_302400 0 2.656576e-07
I13044 n1_m1_528000_307200 0 2.534379e-07
I13045 n1_m1_528000_312000 0 3.590431e-07
I13046 n1_m1_528000_316800 0 2.437865e-07
I13047 n1_m1_528000_321600 0 3.660445e-07
I13048 n1_m1_528000_326400 0 2.387547e-07
I13049 n1_m1_528000_331200 0 2.354783e-07
I13050 n1_m1_528000_336000 0 3.602791e-07
I13051 n1_m1_528000_340800 0 2.424640e-07
I13052 n1_m1_528000_345600 0 3.452399e-07
I13053 n1_m1_528000_350400 0 2.228298e-07
I13054 n1_m1_528000_355200 0 2.179075e-07
I13055 n1_m1_528000_360000 0 3.216120e-07
I13056 n1_m1_528000_364800 0 2.147090e-07
I13057 n1_m1_528000_369600 0 3.307531e-07
I13058 n1_m1_528000_374400 0 2.243898e-07
I13059 n1_m1_528000_379200 0 2.317304e-07
I13060 n1_m1_528000_384000 0 3.595828e-07
I13061 n1_m1_528000_388800 0 2.368732e-07
I13062 n1_m1_528000_393600 0 3.376664e-07
I13063 n1_m1_528000_398400 0 2.257570e-07
I13064 n1_m1_528000_403200 0 2.303051e-07
I13065 n1_m1_528000_408000 0 3.387701e-07
I13066 n1_m1_528000_412800 0 2.170969e-07
I13067 n1_m1_528000_417600 0 3.278240e-07
I13068 n1_m1_528000_422400 0 2.169953e-07
I13069 n1_m1_528000_427200 0 2.203188e-07
I13070 n1_m1_528000_432000 0 3.302528e-07
I13071 n1_m1_528000_436800 0 2.255492e-07
I13072 n1_m1_528000_441600 0 3.367853e-07
I13073 n1_m1_528000_446400 0 2.213874e-07
I13074 n1_m1_528000_451200 0 2.188830e-07
I13075 n1_m1_528000_456000 0 3.201825e-07
I13076 n1_m1_528000_460800 0 2.164807e-07
I13077 n1_m1_528000_465600 0 3.360108e-07
I13078 n1_m1_528000_470400 0 2.271396e-07
I13079 n1_m1_528000_475200 0 2.129143e-07
I13080 n1_m1_528000_480000 0 3.144906e-07
I13081 n1_m1_528000_484800 0 2.150317e-07
I13082 n1_m1_528000_489600 0 3.258285e-07
I13083 n1_m1_528000_494400 0 2.182251e-07
I13084 n1_m1_528000_499200 0 2.176702e-07
I13085 n1_m1_528000_504000 0 3.251416e-07
I13086 n1_m1_528000_508800 0 2.122273e-07
I13087 n1_m1_528000_513600 0 3.149877e-07
I13088 n1_m1_528000_518400 0 2.111101e-07
I13089 n1_m1_528000_523200 0 2.104777e-07
I13090 n1_m1_528000_528000 0 3.291220e-07
I13091 n1_m1_528000_532800 0 2.325140e-07
I13092 n1_m1_528000_537600 0 3.371663e-07
I13093 n1_m1_528000_542400 0 2.198491e-07
I13094 n1_m1_528000_547200 0 2.251608e-07
I13095 n1_m1_528000_552000 0 3.506343e-07
I13096 n1_m1_528000_556800 0 2.190932e-07
I13097 n1_m1_528000_561600 0 1.082613e-07
I13098 n1_m1_532800_0 0 1.647650e-07
I13099 n1_m1_532800_4800 0 1.566480e-07
I13100 n1_m1_532800_9600 0 2.190023e-07
I13101 n1_m1_532800_14400 0 1.404688e-07
I13102 n1_m1_532800_19200 0 1.411466e-07
I13103 n1_m1_532800_24000 0 2.190236e-07
I13104 n1_m1_532800_28800 0 1.464497e-07
I13105 n1_m1_532800_33600 0 2.156857e-07
I13106 n1_m1_532800_38400 0 1.451376e-07
I13107 n1_m1_532800_43200 0 1.477337e-07
I13108 n1_m1_532800_48000 0 2.156272e-07
I13109 n1_m1_532800_52800 0 1.402293e-07
I13110 n1_m1_532800_57600 0 2.098560e-07
I13111 n1_m1_532800_62400 0 1.401348e-07
I13112 n1_m1_532800_67200 0 1.411134e-07
I13113 n1_m1_532800_72000 0 2.106965e-07
I13114 n1_m1_532800_76800 0 1.423697e-07
I13115 n1_m1_532800_81600 0 2.165181e-07
I13116 n1_m1_532800_86400 0 1.402238e-07
I13117 n1_m1_532800_91200 0 1.399040e-07
I13118 n1_m1_532800_96000 0 2.099008e-07
I13119 n1_m1_532800_100800 0 1.412694e-07
I13120 n1_m1_532800_105600 0 2.138368e-07
I13121 n1_m1_532800_110400 0 1.511096e-07
I13122 n1_m1_532800_115200 0 1.475656e-07
I13123 n1_m1_532800_120000 0 2.217372e-07
I13124 n1_m1_532800_124800 0 1.526816e-07
I13125 n1_m1_532800_129600 0 2.239187e-07
I13126 n1_m1_532800_134400 0 1.730058e-07
I13127 n1_m1_532800_139200 0 2.123215e-07
I13128 n1_m1_532800_144000 0 1.038561e-06
I13129 n1_m1_532800_148800 0 9.145272e-07
I13130 n1_m1_532800_153600 0 5.591333e-07
I13131 n1_m1_532800_158400 0 1.661611e-07
I13132 n1_m1_532800_163200 0 1.468928e-07
I13133 n1_m1_532800_168000 0 2.185696e-07
I13134 n1_m1_532800_172800 0 1.602643e-07
I13135 n1_m1_532800_177600 0 2.260037e-07
I13136 n1_m1_532800_182400 0 1.541722e-07
I13137 n1_m1_532800_187200 0 1.509166e-07
I13138 n1_m1_532800_192000 0 2.139455e-07
I13139 n1_m1_532800_196800 0 1.486073e-07
I13140 n1_m1_532800_201600 0 2.288339e-07
I13141 n1_m1_532800_206400 0 1.441670e-07
I13142 n1_m1_532800_211200 0 1.460940e-07
I13143 n1_m1_532800_216000 0 2.159856e-07
I13144 n1_m1_532800_220800 0 1.625396e-07
I13145 n1_m1_532800_225600 0 2.688864e-07
I13146 n1_m1_532800_230400 0 1.635757e-07
I13147 n1_m1_532800_235200 0 1.583718e-07
I13148 n1_m1_532800_240000 0 2.278911e-07
I13149 n1_m1_532800_244800 0 1.414374e-07
I13150 n1_m1_532800_249600 0 2.114114e-07
I13151 n1_m1_532800_254400 0 1.411645e-07
I13152 n1_m1_532800_259200 0 1.450116e-07
I13153 n1_m1_532800_264000 0 2.209845e-07
I13154 n1_m1_532800_268800 0 1.468320e-07
I13155 n1_m1_532800_273600 0 2.214125e-07
I13156 n1_m1_532800_278400 0 1.494522e-07
I13157 n1_m1_532800_283200 0 1.525365e-07
I13158 n1_m1_532800_288000 0 2.294885e-07
I13159 n1_m1_532800_292800 0 1.553584e-07
I13160 n1_m1_532800_297600 0 2.271035e-07
I13161 n1_m1_532800_302400 0 1.723022e-07
I13162 n1_m1_532800_307200 0 1.617514e-07
I13163 n1_m1_532800_312000 0 2.306230e-07
I13164 n1_m1_532800_316800 0 1.588778e-07
I13165 n1_m1_532800_321600 0 2.390080e-07
I13166 n1_m1_532800_326400 0 1.603101e-07
I13167 n1_m1_532800_331200 0 1.616241e-07
I13168 n1_m1_532800_336000 0 2.407116e-07
I13169 n1_m1_532800_340800 0 1.573708e-07
I13170 n1_m1_532800_345600 0 2.334238e-07
I13171 n1_m1_532800_350400 0 1.574828e-07
I13172 n1_m1_532800_355200 0 1.548263e-07
I13173 n1_m1_532800_360000 0 2.287931e-07
I13174 n1_m1_532800_364800 0 1.525440e-07
I13175 n1_m1_532800_369600 0 2.295023e-07
I13176 n1_m1_532800_374400 0 1.549952e-07
I13177 n1_m1_532800_379200 0 1.590951e-07
I13178 n1_m1_532800_384000 0 2.366356e-07
I13179 n1_m1_532800_388800 0 1.562095e-07
I13180 n1_m1_532800_393600 0 2.448766e-07
I13181 n1_m1_532800_398400 0 1.529013e-07
I13182 n1_m1_532800_403200 0 1.482965e-07
I13183 n1_m1_532800_408000 0 2.318255e-07
I13184 n1_m1_532800_412800 0 1.584280e-07
I13185 n1_m1_532800_417600 0 2.240112e-07
I13186 n1_m1_532800_422400 0 1.540122e-07
I13187 n1_m1_532800_427200 0 1.516239e-07
I13188 n1_m1_532800_432000 0 2.212407e-07
I13189 n1_m1_532800_436800 0 1.483847e-07
I13190 n1_m1_532800_441600 0 2.228946e-07
I13191 n1_m1_532800_446400 0 1.504892e-07
I13192 n1_m1_532800_451200 0 1.550200e-07
I13193 n1_m1_532800_456000 0 2.232563e-07
I13194 n1_m1_532800_460800 0 1.416469e-07
I13195 n1_m1_532800_465600 0 2.183695e-07
I13196 n1_m1_532800_470400 0 1.462450e-07
I13197 n1_m1_532800_475200 0 1.419919e-07
I13198 n1_m1_532800_480000 0 2.116074e-07
I13199 n1_m1_532800_484800 0 1.409006e-07
I13200 n1_m1_532800_489600 0 2.139478e-07
I13201 n1_m1_532800_494400 0 1.465661e-07
I13202 n1_m1_532800_499200 0 1.446162e-07
I13203 n1_m1_532800_504000 0 2.121320e-07
I13204 n1_m1_532800_508800 0 1.411917e-07
I13205 n1_m1_532800_513600 0 2.116074e-07
I13206 n1_m1_532800_518400 0 1.410716e-07
I13207 n1_m1_532800_523200 0 1.410844e-07
I13208 n1_m1_532800_528000 0 2.132541e-07
I13209 n1_m1_532800_532800 0 1.465661e-07
I13210 n1_m1_532800_537600 0 2.198830e-07
I13211 n1_m1_532800_542400 0 1.460986e-07
I13212 n1_m1_532800_547200 0 1.463434e-07
I13213 n1_m1_532800_552000 0 2.216129e-07
I13214 n1_m1_532800_556800 0 1.427860e-07
I13215 n1_m1_532800_561600 0 7.090644e-08
I13216 n1_m1_537600_0 0 1.701798e-07
I13217 n1_m1_537600_4800 0 1.616617e-07
I13218 n1_m1_537600_9600 0 2.211471e-07
I13219 n1_m1_537600_14400 0 1.401766e-07
I13220 n1_m1_537600_19200 0 1.403852e-07
I13221 n1_m1_537600_24000 0 2.145143e-07
I13222 n1_m1_537600_28800 0 1.433061e-07
I13223 n1_m1_537600_33600 0 2.172649e-07
I13224 n1_m1_537600_38400 0 1.486425e-07
I13225 n1_m1_537600_43200 0 1.499682e-07
I13226 n1_m1_537600_48000 0 2.185440e-07
I13227 n1_m1_537600_52800 0 1.406334e-07
I13228 n1_m1_537600_57600 0 2.098560e-07
I13229 n1_m1_537600_62400 0 1.404216e-07
I13230 n1_m1_537600_67200 0 1.425313e-07
I13231 n1_m1_537600_72000 0 2.115702e-07
I13232 n1_m1_537600_76800 0 1.440659e-07
I13233 n1_m1_537600_81600 0 2.176123e-07
I13234 n1_m1_537600_86400 0 1.431639e-07
I13235 n1_m1_537600_91200 0 1.431639e-07
I13236 n1_m1_537600_96000 0 2.148276e-07
I13237 n1_m1_537600_100800 0 1.456520e-07
I13238 n1_m1_537600_105600 0 2.172098e-07
I13239 n1_m1_537600_110400 0 1.484509e-07
I13240 n1_m1_537600_115200 0 1.445723e-07
I13241 n1_m1_537600_120000 0 2.220855e-07
I13242 n1_m1_537600_124800 0 1.543381e-07
I13243 n1_m1_537600_129600 0 2.204490e-07
I13244 n1_m1_537600_134400 0 1.623915e-07
I13245 n1_m1_537600_139200 0 1.773042e-07
I13246 n1_m1_537600_144000 0 6.504535e-07
I13247 n1_m1_537600_148800 0 5.037635e-07
I13248 n1_m1_537600_153600 0 3.617660e-07
I13249 n1_m1_537600_158400 0 1.719172e-07
I13250 n1_m1_537600_163200 0 1.647727e-07
I13251 n1_m1_537600_168000 0 2.356125e-07
I13252 n1_m1_537600_172800 0 1.528891e-07
I13253 n1_m1_537600_177600 0 2.268297e-07
I13254 n1_m1_537600_182400 0 1.547567e-07
I13255 n1_m1_537600_187200 0 1.576750e-07
I13256 n1_m1_537600_192000 0 2.371725e-07
I13257 n1_m1_537600_196800 0 1.525442e-07
I13258 n1_m1_537600_201600 0 2.283517e-07
I13259 n1_m1_537600_206400 0 1.529782e-07
I13260 n1_m1_537600_211200 0 1.506165e-07
I13261 n1_m1_537600_216000 0 2.199859e-07
I13262 n1_m1_537600_220800 0 1.604386e-07
I13263 n1_m1_537600_225600 0 2.495559e-07
I13264 n1_m1_537600_230400 0 1.520719e-07
I13265 n1_m1_537600_235200 0 1.514974e-07
I13266 n1_m1_537600_240000 0 2.365256e-07
I13267 n1_m1_537600_244800 0 1.527818e-07
I13268 n1_m1_537600_249600 0 2.198491e-07
I13269 n1_m1_537600_254400 0 1.466212e-07
I13270 n1_m1_537600_259200 0 1.489037e-07
I13271 n1_m1_537600_264000 0 2.280473e-07
I13272 n1_m1_537600_268800 0 1.506009e-07
I13273 n1_m1_537600_273600 0 2.304719e-07
I13274 n1_m1_537600_278400 0 1.574143e-07
I13275 n1_m1_537600_283200 0 1.591154e-07
I13276 n1_m1_537600_288000 0 2.459480e-07
I13277 n1_m1_537600_292800 0 1.672636e-07
I13278 n1_m1_537600_297600 0 2.323512e-07
I13279 n1_m1_537600_302400 0 1.655795e-07
I13280 n1_m1_537600_307200 0 1.568817e-07
I13281 n1_m1_537600_312000 0 2.295563e-07
I13282 n1_m1_537600_316800 0 1.608904e-07
I13283 n1_m1_537600_321600 0 2.337314e-07
I13284 n1_m1_537600_326400 0 1.641033e-07
I13285 n1_m1_537600_331200 0 1.769183e-07
I13286 n1_m1_537600_336000 0 2.477189e-07
I13287 n1_m1_537600_340800 0 1.558480e-07
I13288 n1_m1_537600_345600 0 2.634764e-07
I13289 n1_m1_537600_350400 0 1.629860e-07
I13290 n1_m1_537600_355200 0 1.518650e-07
I13291 n1_m1_537600_360000 0 2.266055e-07
I13292 n1_m1_537600_364800 0 1.499682e-07
I13293 n1_m1_537600_369600 0 2.272034e-07
I13294 n1_m1_537600_374400 0 1.600346e-07
I13295 n1_m1_537600_379200 0 1.633068e-07
I13296 n1_m1_537600_384000 0 2.519982e-07
I13297 n1_m1_537600_388800 0 1.667528e-07
I13298 n1_m1_537600_393600 0 2.253156e-07
I13299 n1_m1_537600_398400 0 1.563980e-07
I13300 n1_m1_537600_403200 0 1.680411e-07
I13301 n1_m1_537600_408000 0 2.500101e-07
I13302 n1_m1_537600_412800 0 1.530416e-07
I13303 n1_m1_537600_417600 0 2.233937e-07
I13304 n1_m1_537600_422400 0 1.441856e-07
I13305 n1_m1_537600_427200 0 1.461453e-07
I13306 n1_m1_537600_432000 0 2.210296e-07
I13307 n1_m1_537600_436800 0 1.516871e-07
I13308 n1_m1_537600_441600 0 2.326251e-07
I13309 n1_m1_537600_446400 0 1.549741e-07
I13310 n1_m1_537600_451200 0 1.579440e-07
I13311 n1_m1_537600_456000 0 2.366231e-07
I13312 n1_m1_537600_460800 0 1.493026e-07
I13313 n1_m1_537600_465600 0 2.161483e-07
I13314 n1_m1_537600_470400 0 1.436803e-07
I13315 n1_m1_537600_475200 0 1.460527e-07
I13316 n1_m1_537600_480000 0 2.198491e-07
I13317 n1_m1_537600_484800 0 1.451732e-07
I13318 n1_m1_537600_489600 0 2.139872e-07
I13319 n1_m1_537600_494400 0 1.465661e-07
I13320 n1_m1_537600_499200 0 1.465661e-07
I13321 n1_m1_537600_504000 0 2.198491e-07
I13322 n1_m1_537600_508800 0 1.465661e-07
I13323 n1_m1_537600_513600 0 2.194402e-07
I13324 n1_m1_537600_518400 0 1.437847e-07
I13325 n1_m1_537600_523200 0 1.433061e-07
I13326 n1_m1_537600_528000 0 2.163920e-07
I13327 n1_m1_537600_532800 0 1.489124e-07
I13328 n1_m1_537600_537600 0 2.185701e-07
I13329 n1_m1_537600_542400 0 1.419441e-07
I13330 n1_m1_537600_547200 0 1.430379e-07
I13331 n1_m1_537600_552000 0 2.226190e-07
I13332 n1_m1_537600_556800 0 1.407223e-07
I13333 n1_m1_537600_561600 0 6.967262e-08
I13334 n1_m1_542400_0 0 1.633931e-07
I13335 n1_m1_542400_4800 0 1.584777e-07
I13336 n1_m1_542400_9600 0 2.288791e-07
I13337 n1_m1_542400_14400 0 1.455725e-07
I13338 n1_m1_542400_19200 0 1.452384e-07
I13339 n1_m1_542400_24000 0 2.167328e-07
I13340 n1_m1_542400_28800 0 1.416837e-07
I13341 n1_m1_542400_33600 0 2.145680e-07
I13342 n1_m1_542400_38400 0 1.465661e-07
I13343 n1_m1_542400_43200 0 1.451755e-07
I13344 n1_m1_542400_48000 0 2.121235e-07
I13345 n1_m1_542400_52800 0 1.399040e-07
I13346 n1_m1_542400_57600 0 2.098560e-07
I13347 n1_m1_542400_62400 0 1.399040e-07
I13348 n1_m1_542400_67200 0 1.401911e-07
I13349 n1_m1_542400_72000 0 2.148323e-07
I13350 n1_m1_542400_76800 0 1.465661e-07
I13351 n1_m1_542400_81600 0 2.198491e-07
I13352 n1_m1_542400_86400 0 1.480136e-07
I13353 n1_m1_542400_91200 0 1.492333e-07
I13354 n1_m1_542400_96000 0 2.237858e-07
I13355 n1_m1_542400_100800 0 1.472827e-07
I13356 n1_m1_542400_105600 0 2.159360e-07
I13357 n1_m1_542400_110400 0 1.456562e-07
I13358 n1_m1_542400_115200 0 1.434811e-07
I13359 n1_m1_542400_120000 0 2.209651e-07
I13360 n1_m1_542400_124800 0 1.522780e-07
I13361 n1_m1_542400_129600 0 2.255925e-07
I13362 n1_m1_542400_134400 0 1.677259e-07
I13363 n1_m1_542400_139200 0 1.826386e-07
I13364 n1_m1_542400_144000 0 5.321895e-07
I13365 n1_m1_542400_148800 0 3.409838e-07
I13366 n1_m1_542400_153600 0 2.862635e-07
I13367 n1_m1_542400_158400 0 1.715069e-07
I13368 n1_m1_542400_163200 0 1.677498e-07
I13369 n1_m1_542400_168000 0 2.457714e-07
I13370 n1_m1_542400_172800 0 1.558036e-07
I13371 n1_m1_542400_177600 0 2.341633e-07
I13372 n1_m1_542400_182400 0 1.540741e-07
I13373 n1_m1_542400_187200 0 1.648730e-07
I13374 n1_m1_542400_192000 0 2.672543e-07
I13375 n1_m1_542400_196800 0 1.626404e-07
I13376 n1_m1_542400_201600 0 2.304338e-07
I13377 n1_m1_542400_206400 0 1.624605e-07
I13378 n1_m1_542400_211200 0 1.589883e-07
I13379 n1_m1_542400_216000 0 2.361989e-07
I13380 n1_m1_542400_220800 0 1.770959e-07
I13381 n1_m1_542400_225600 0 2.899318e-07
I13382 n1_m1_542400_230400 0 1.603233e-07
I13383 n1_m1_542400_235200 0 1.602340e-07
I13384 n1_m1_542400_240000 0 2.500843e-07
I13385 n1_m1_542400_244800 0 1.586574e-07
I13386 n1_m1_542400_249600 0 2.265195e-07
I13387 n1_m1_542400_254400 0 1.540728e-07
I13388 n1_m1_542400_259200 0 1.574324e-07
I13389 n1_m1_542400_264000 0 2.382591e-07
I13390 n1_m1_542400_268800 0 1.612156e-07
I13391 n1_m1_542400_273600 0 2.487858e-07
I13392 n1_m1_542400_278400 0 1.732263e-07
I13393 n1_m1_542400_283200 0 1.726781e-07
I13394 n1_m1_542400_288000 0 2.875364e-07
I13395 n1_m1_542400_292800 0 2.014668e-07
I13396 n1_m1_542400_297600 0 2.480720e-07
I13397 n1_m1_542400_302400 0 1.710688e-07
I13398 n1_m1_542400_307200 0 1.624358e-07
I13399 n1_m1_542400_312000 0 2.379706e-07
I13400 n1_m1_542400_316800 0 1.667923e-07
I13401 n1_m1_542400_321600 0 2.418762e-07
I13402 n1_m1_542400_326400 0 1.766751e-07
I13403 n1_m1_542400_331200 0 2.100628e-07
I13404 n1_m1_542400_336000 0 2.695463e-07
I13405 n1_m1_542400_340800 0 1.611824e-07
I13406 n1_m1_542400_345600 0 3.105960e-07
I13407 n1_m1_542400_350400 0 1.875414e-07
I13408 n1_m1_542400_355200 0 1.622265e-07
I13409 n1_m1_542400_360000 0 2.361127e-07
I13410 n1_m1_542400_364800 0 1.502157e-07
I13411 n1_m1_542400_369600 0 2.274779e-07
I13412 n1_m1_542400_374400 0 1.676600e-07
I13413 n1_m1_542400_379200 0 1.822848e-07
I13414 n1_m1_542400_384000 0 2.766218e-07
I13415 n1_m1_542400_388800 0 1.626767e-07
I13416 n1_m1_542400_393600 0 2.352828e-07
I13417 n1_m1_542400_398400 0 2.132308e-07
I13418 n1_m1_542400_403200 0 2.143218e-07
I13419 n1_m1_542400_408000 0 2.410729e-07
I13420 n1_m1_542400_412800 0 1.437159e-07
I13421 n1_m1_542400_417600 0 2.464944e-07
I13422 n1_m1_542400_422400 0 1.644691e-07
I13423 n1_m1_542400_427200 0 1.571139e-07
I13424 n1_m1_542400_432000 0 2.225685e-07
I13425 n1_m1_542400_436800 0 1.502640e-07
I13426 n1_m1_542400_441600 0 2.313908e-07
I13427 n1_m1_542400_446400 0 1.651776e-07
I13428 n1_m1_542400_451200 0 1.964526e-07
I13429 n1_m1_542400_456000 0 2.838218e-07
I13430 n1_m1_542400_460800 0 1.529081e-07
I13431 n1_m1_542400_465600 0 2.158621e-07
I13432 n1_m1_542400_470400 0 1.409699e-07
I13433 n1_m1_542400_475200 0 1.457044e-07
I13434 n1_m1_542400_480000 0 2.225661e-07
I13435 n1_m1_542400_484800 0 1.457807e-07
I13436 n1_m1_542400_489600 0 2.148486e-07
I13437 n1_m1_542400_494400 0 1.438989e-07
I13438 n1_m1_542400_499200 0 1.438989e-07
I13439 n1_m1_542400_504000 0 2.158483e-07
I13440 n1_m1_542400_508800 0 1.438989e-07
I13441 n1_m1_542400_513600 0 2.153472e-07
I13442 n1_m1_542400_518400 0 1.404904e-07
I13443 n1_m1_542400_523200 0 1.399040e-07
I13444 n1_m1_542400_528000 0 2.127840e-07
I13445 n1_m1_542400_532800 0 1.518286e-07
I13446 n1_m1_542400_537600 0 2.196723e-07
I13447 n1_m1_542400_542400 0 1.399040e-07
I13448 n1_m1_542400_547200 0 1.419785e-07
I13449 n1_m1_542400_552000 0 2.198313e-07
I13450 n1_m1_542400_556800 0 1.387185e-07
I13451 n1_m1_542400_561600 0 6.843464e-08
I13452 n1_m1_547200_0 0 1.506812e-07
I13453 n1_m1_547200_4800 0 1.495517e-07
I13454 n1_m1_547200_9600 0 2.267471e-07
I13455 n1_m1_547200_14400 0 1.539129e-07
I13456 n1_m1_547200_19200 0 1.570191e-07
I13457 n1_m1_547200_24000 0 2.332563e-07
I13458 n1_m1_547200_28800 0 1.484983e-07
I13459 n1_m1_547200_33600 0 2.237261e-07
I13460 n1_m1_547200_38400 0 1.548641e-07
I13461 n1_m1_547200_43200 0 1.513908e-07
I13462 n1_m1_547200_48000 0 2.201288e-07
I13463 n1_m1_547200_52800 0 1.428681e-07
I13464 n1_m1_547200_57600 0 2.137835e-07
I13465 n1_m1_547200_62400 0 1.461293e-07
I13466 n1_m1_547200_67200 0 1.486700e-07
I13467 n1_m1_547200_72000 0 2.304650e-07
I13468 n1_m1_547200_76800 0 1.522396e-07
I13469 n1_m1_547200_81600 0 2.274365e-07
I13470 n1_m1_547200_86400 0 1.564051e-07
I13471 n1_m1_547200_91200 0 1.594517e-07
I13472 n1_m1_547200_96000 0 2.390174e-07
I13473 n1_m1_547200_100800 0 1.545795e-07
I13474 n1_m1_547200_105600 0 2.291843e-07
I13475 n1_m1_547200_110400 0 1.522986e-07
I13476 n1_m1_547200_115200 0 1.494323e-07
I13477 n1_m1_547200_120000 0 2.287581e-07
I13478 n1_m1_547200_124800 0 1.613626e-07
I13479 n1_m1_547200_129600 0 2.448769e-07
I13480 n1_m1_547200_134400 0 1.947516e-07
I13481 n1_m1_547200_139200 0 2.206163e-07
I13482 n1_m1_547200_144000 0 5.901674e-07
I13483 n1_m1_547200_148800 0 4.204498e-07
I13484 n1_m1_547200_153600 0 4.005621e-07
I13485 n1_m1_547200_158400 0 1.854859e-07
I13486 n1_m1_547200_163200 0 1.686585e-07
I13487 n1_m1_547200_168000 0 3.128647e-07
I13488 n1_m1_547200_172800 0 2.397164e-07
I13489 n1_m1_547200_177600 0 3.022280e-07
I13490 n1_m1_547200_182400 0 2.404628e-07
I13491 n1_m1_547200_187200 0 2.438748e-07
I13492 n1_m1_547200_192000 0 3.392881e-07
I13493 n1_m1_547200_196800 0 2.474281e-07
I13494 n1_m1_547200_201600 0 3.580288e-07
I13495 n1_m1_547200_206400 0 1.896496e-07
I13496 n1_m1_547200_211200 0 2.160028e-07
I13497 n1_m1_547200_216000 0 3.296107e-07
I13498 n1_m1_547200_220800 0 2.763641e-07
I13499 n1_m1_547200_225600 0 4.616296e-07
I13500 n1_m1_547200_230400 0 2.121966e-07
I13501 n1_m1_547200_235200 0 1.842993e-07
I13502 n1_m1_547200_240000 0 2.750485e-07
I13503 n1_m1_547200_244800 0 1.788607e-07
I13504 n1_m1_547200_249600 0 2.890389e-07
I13505 n1_m1_547200_254400 0 2.094041e-07
I13506 n1_m1_547200_259200 0 2.092161e-07
I13507 n1_m1_547200_264000 0 3.093891e-07
I13508 n1_m1_547200_268800 0 2.185557e-07
I13509 n1_m1_547200_273600 0 3.747012e-07
I13510 n1_m1_547200_278400 0 2.797537e-07
I13511 n1_m1_547200_283200 0 2.891834e-07
I13512 n1_m1_547200_288000 0 4.705197e-07
I13513 n1_m1_547200_292800 0 3.261244e-07
I13514 n1_m1_547200_297600 0 3.589852e-07
I13515 n1_m1_547200_302400 0 2.477135e-07
I13516 n1_m1_547200_307200 0 2.026596e-07
I13517 n1_m1_547200_312000 0 2.649176e-07
I13518 n1_m1_547200_316800 0 1.939352e-07
I13519 n1_m1_547200_321600 0 2.956337e-07
I13520 n1_m1_547200_326400 0 2.436744e-07
I13521 n1_m1_547200_331200 0 3.071584e-07
I13522 n1_m1_547200_336000 0 3.847635e-07
I13523 n1_m1_547200_340800 0 2.082147e-07
I13524 n1_m1_547200_345600 0 4.087708e-07
I13525 n1_m1_547200_350400 0 2.706599e-07
I13526 n1_m1_547200_355200 0 2.445255e-07
I13527 n1_m1_547200_360000 0 3.234107e-07
I13528 n1_m1_547200_364800 0 1.676362e-07
I13529 n1_m1_547200_369600 0 2.470062e-07
I13530 n1_m1_547200_374400 0 2.007391e-07
I13531 n1_m1_547200_379200 0 2.362983e-07
I13532 n1_m1_547200_384000 0 3.390008e-07
I13533 n1_m1_547200_388800 0 1.853157e-07
I13534 n1_m1_547200_393600 0 3.045161e-07
I13535 n1_m1_547200_398400 0 2.624356e-07
I13536 n1_m1_547200_403200 0 2.546728e-07
I13537 n1_m1_547200_408000 0 3.303398e-07
I13538 n1_m1_547200_412800 0 1.901230e-07
I13539 n1_m1_547200_417600 0 2.674038e-07
I13540 n1_m1_547200_422400 0 1.843846e-07
I13541 n1_m1_547200_427200 0 1.750402e-07
I13542 n1_m1_547200_432000 0 2.435679e-07
I13543 n1_m1_547200_436800 0 1.667456e-07
I13544 n1_m1_547200_441600 0 2.600709e-07
I13545 n1_m1_547200_446400 0 1.908460e-07
I13546 n1_m1_547200_451200 0 2.383791e-07
I13547 n1_m1_547200_456000 0 3.321635e-07
I13548 n1_m1_547200_460800 0 1.652010e-07
I13549 n1_m1_547200_465600 0 2.313102e-07
I13550 n1_m1_547200_470400 0 1.474067e-07
I13551 n1_m1_547200_475200 0 1.504609e-07
I13552 n1_m1_547200_480000 0 2.340182e-07
I13553 n1_m1_547200_484800 0 1.549110e-07
I13554 n1_m1_547200_489600 0 2.262750e-07
I13555 n1_m1_547200_494400 0 1.440530e-07
I13556 n1_m1_547200_499200 0 1.440530e-07
I13557 n1_m1_547200_504000 0 2.160794e-07
I13558 n1_m1_547200_508800 0 1.440530e-07
I13559 n1_m1_547200_513600 0 2.158192e-07
I13560 n1_m1_547200_518400 0 1.422830e-07
I13561 n1_m1_547200_523200 0 1.421298e-07
I13562 n1_m1_547200_528000 0 2.211078e-07
I13563 n1_m1_547200_532800 0 1.587522e-07
I13564 n1_m1_547200_537600 0 2.326576e-07
I13565 n1_m1_547200_542400 0 1.452969e-07
I13566 n1_m1_547200_547200 0 1.461275e-07
I13567 n1_m1_547200_552000 0 2.260548e-07
I13568 n1_m1_547200_556800 0 1.440894e-07
I13569 n1_m1_547200_561600 0 7.126400e-08
I13570 n1_m1_552000_0 0 2.301157e-07
I13571 n1_m1_552000_4800 0 2.215862e-07
I13572 n1_m1_552000_9600 0 3.308606e-07
I13573 n1_m1_552000_14400 0 2.279674e-07
I13574 n1_m1_552000_19200 0 2.407059e-07
I13575 n1_m1_552000_24000 0 3.711985e-07
I13576 n1_m1_552000_28800 0 2.424940e-07
I13577 n1_m1_552000_33600 0 3.794386e-07
I13578 n1_m1_552000_38400 0 2.687835e-07
I13579 n1_m1_552000_43200 0 2.635735e-07
I13580 n1_m1_552000_48000 0 3.737810e-07
I13581 n1_m1_552000_52800 0 2.321736e-07
I13582 n1_m1_552000_57600 0 3.463311e-07
I13583 n1_m1_552000_62400 0 2.446489e-07
I13584 n1_m1_552000_67200 0 2.541515e-07
I13585 n1_m1_552000_72000 0 3.912235e-07
I13586 n1_m1_552000_76800 0 2.528444e-07
I13587 n1_m1_552000_81600 0 3.768382e-07
I13588 n1_m1_552000_86400 0 2.597150e-07
I13589 n1_m1_552000_91200 0 2.642848e-07
I13590 n1_m1_552000_96000 0 3.922814e-07
I13591 n1_m1_552000_100800 0 2.524602e-07
I13592 n1_m1_552000_105600 0 3.753981e-07
I13593 n1_m1_552000_110400 0 2.519711e-07
I13594 n1_m1_552000_115200 0 2.419696e-07
I13595 n1_m1_552000_120000 0 3.914931e-07
I13596 n1_m1_552000_124800 0 3.097140e-07
I13597 n1_m1_552000_129600 0 4.129553e-07
I13598 n1_m1_552000_134400 0 3.334267e-07
I13599 n1_m1_552000_139200 0 4.017006e-07
I13600 n1_m1_552000_144000 0 9.837104e-07
I13601 n1_m1_552000_148800 0 8.075575e-07
I13602 n1_m1_552000_153600 0 9.089718e-07
I13603 n1_m1_552000_158400 0 3.193991e-07
I13604 n1_m1_552000_163200 0 2.549356e-07
I13605 n1_m1_552000_168000 0 6.508979e-07
I13606 n1_m1_552000_172800 0 5.979205e-07
I13607 n1_m1_552000_177600 0 7.047242e-07
I13608 n1_m1_552000_182400 0 6.042882e-07
I13609 n1_m1_552000_187200 0 5.276166e-07
I13610 n1_m1_552000_192000 0 6.301137e-07
I13611 n1_m1_552000_196800 0 6.272129e-07
I13612 n1_m1_552000_201600 0 9.574471e-07
I13613 n1_m1_552000_206400 0 3.506501e-07
I13614 n1_m1_552000_211200 0 4.410420e-07
I13615 n1_m1_552000_216000 0 6.767423e-07
I13616 n1_m1_552000_220800 0 6.224934e-07
I13617 n1_m1_552000_225600 0 1.035105e-06
I13618 n1_m1_552000_230400 0 4.850183e-07
I13619 n1_m1_552000_235200 0 3.691349e-07
I13620 n1_m1_552000_240000 0 4.843511e-07
I13621 n1_m1_552000_244800 0 3.386253e-07
I13622 n1_m1_552000_249600 0 6.423237e-07
I13623 n1_m1_552000_254400 0 4.819331e-07
I13624 n1_m1_552000_259200 0 4.678465e-07
I13625 n1_m1_552000_264000 0 6.341895e-07
I13626 n1_m1_552000_268800 0 4.474035e-07
I13627 n1_m1_552000_273600 0 8.541732e-07
I13628 n1_m1_552000_278400 0 6.842426e-07
I13629 n1_m1_552000_283200 0 7.227000e-07
I13630 n1_m1_552000_288000 0 1.063930e-06
I13631 n1_m1_552000_292800 0 7.076349e-07
I13632 n1_m1_552000_297600 0 8.263024e-07
I13633 n1_m1_552000_302400 0 6.112111e-07
I13634 n1_m1_552000_307200 0 4.315377e-07
I13635 n1_m1_552000_312000 0 4.527654e-07
I13636 n1_m1_552000_316800 0 3.296009e-07
I13637 n1_m1_552000_321600 0 5.714561e-07
I13638 n1_m1_552000_326400 0 5.148758e-07
I13639 n1_m1_552000_331200 0 6.176203e-07
I13640 n1_m1_552000_336000 0 8.603911e-07
I13641 n1_m1_552000_340800 0 4.606803e-07
I13642 n1_m1_552000_345600 0 6.888462e-07
I13643 n1_m1_552000_350400 0 5.112560e-07
I13644 n1_m1_552000_355200 0 5.565425e-07
I13645 n1_m1_552000_360000 0 7.055141e-07
I13646 n1_m1_552000_364800 0 2.910056e-07
I13647 n1_m1_552000_369600 0 4.071723e-07
I13648 n1_m1_552000_374400 0 3.485756e-07
I13649 n1_m1_552000_379200 0 4.057957e-07
I13650 n1_m1_552000_384000 0 6.092926e-07
I13651 n1_m1_552000_388800 0 4.787846e-07
I13652 n1_m1_552000_393600 0 6.146593e-07
I13653 n1_m1_552000_398400 0 2.923294e-07
I13654 n1_m1_552000_403200 0 3.554723e-07
I13655 n1_m1_552000_408000 0 9.378901e-07
I13656 n1_m1_552000_412800 0 5.336885e-07
I13657 n1_m1_552000_417600 0 4.152444e-07
I13658 n1_m1_552000_422400 0 2.426562e-07
I13659 n1_m1_552000_427200 0 2.573735e-07
I13660 n1_m1_552000_432000 0 4.564329e-07
I13661 n1_m1_552000_436800 0 3.896878e-07
I13662 n1_m1_552000_441600 0 5.678481e-07
I13663 n1_m1_552000_446400 0 3.190210e-07
I13664 n1_m1_552000_451200 0 2.941959e-07
I13665 n1_m1_552000_456000 0 4.416122e-07
I13666 n1_m1_552000_460800 0 2.810180e-07
I13667 n1_m1_552000_465600 0 3.915379e-07
I13668 n1_m1_552000_470400 0 2.454216e-07
I13669 n1_m1_552000_475200 0 2.412106e-07
I13670 n1_m1_552000_480000 0 3.754530e-07
I13671 n1_m1_552000_484800 0 2.614531e-07
I13672 n1_m1_552000_489600 0 3.834123e-07
I13673 n1_m1_552000_494400 0 2.343232e-07
I13674 n1_m1_552000_499200 0 2.360349e-07
I13675 n1_m1_552000_504000 0 3.617673e-07
I13676 n1_m1_552000_508800 0 2.403907e-07
I13677 n1_m1_552000_513600 0 3.570081e-07
I13678 n1_m1_552000_518400 0 2.299630e-07
I13679 n1_m1_552000_523200 0 2.257747e-07
I13680 n1_m1_552000_528000 0 3.603026e-07
I13681 n1_m1_552000_532800 0 2.595108e-07
I13682 n1_m1_552000_537600 0 3.862094e-07
I13683 n1_m1_552000_542400 0 2.384966e-07
I13684 n1_m1_552000_547200 0 2.329184e-07
I13685 n1_m1_552000_552000 0 3.627349e-07
I13686 n1_m1_552000_556800 0 2.384202e-07
I13687 n1_m1_552000_561600 0 1.185154e-07
I13688 n1_m1_556800_0 0 1.852729e-07
I13689 n1_m1_556800_4800 0 1.720627e-07
I13690 n1_m1_556800_9600 0 2.330571e-07
I13691 n1_m1_556800_14400 0 1.474034e-07
I13692 n1_m1_556800_19200 0 1.503979e-07
I13693 n1_m1_556800_24000 0 2.384825e-07
I13694 n1_m1_556800_28800 0 1.626286e-07
I13695 n1_m1_556800_33600 0 2.525286e-07
I13696 n1_m1_556800_38400 0 1.723726e-07
I13697 n1_m1_556800_43200 0 1.673703e-07
I13698 n1_m1_556800_48000 0 2.371222e-07
I13699 n1_m1_556800_52800 0 1.495474e-07
I13700 n1_m1_556800_57600 0 2.227169e-07
I13701 n1_m1_556800_62400 0 1.522607e-07
I13702 n1_m1_556800_67200 0 1.613113e-07
I13703 n1_m1_556800_72000 0 2.539422e-07
I13704 n1_m1_556800_76800 0 1.643266e-07
I13705 n1_m1_556800_81600 0 2.422660e-07
I13706 n1_m1_556800_86400 0 1.650587e-07
I13707 n1_m1_556800_91200 0 1.681053e-07
I13708 n1_m1_556800_96000 0 2.462367e-07
I13709 n1_m1_556800_100800 0 1.565711e-07
I13710 n1_m1_556800_105600 0 2.332563e-07
I13711 n1_m1_556800_110400 0 1.603901e-07
I13712 n1_m1_556800_115200 0 1.599080e-07
I13713 n1_m1_556800_120000 0 2.646216e-07
I13714 n1_m1_556800_124800 0 2.063379e-07
I13715 n1_m1_556800_129600 0 2.650208e-07
I13716 n1_m1_556800_134400 0 1.783764e-07
I13717 n1_m1_556800_139200 0 1.978950e-07
I13718 n1_m1_556800_144000 0 3.941319e-07
I13719 n1_m1_556800_148800 0 2.880679e-07
I13720 n1_m1_556800_153600 0 3.798362e-07
I13721 n1_m1_556800_158400 0 1.845531e-07
I13722 n1_m1_556800_163200 0 1.618930e-07
I13723 n1_m1_556800_168000 0 3.215588e-07
I13724 n1_m1_556800_172800 0 2.659178e-07
I13725 n1_m1_556800_177600 0 4.035322e-07
I13726 n1_m1_556800_182400 0 2.629155e-07
I13727 n1_m1_556800_187200 0 2.232300e-07
I13728 n1_m1_556800_192000 0 3.061533e-07
I13729 n1_m1_556800_196800 0 2.830318e-07
I13730 n1_m1_556800_201600 0 4.323460e-07
I13731 n1_m1_556800_206400 0 1.990767e-07
I13732 n1_m1_556800_211200 0 2.086432e-07
I13733 n1_m1_556800_216000 0 3.050604e-07
I13734 n1_m1_556800_220800 0 2.627077e-07
I13735 n1_m1_556800_225600 0 4.628517e-07
I13736 n1_m1_556800_230400 0 2.606920e-07
I13737 n1_m1_556800_235200 0 2.231941e-07
I13738 n1_m1_556800_240000 0 2.938243e-07
I13739 n1_m1_556800_244800 0 1.985478e-07
I13740 n1_m1_556800_249600 0 3.444667e-07
I13741 n1_m1_556800_254400 0 2.451502e-07
I13742 n1_m1_556800_259200 0 2.357032e-07
I13743 n1_m1_556800_264000 0 3.102766e-07
I13744 n1_m1_556800_268800 0 2.075924e-07
I13745 n1_m1_556800_273600 0 3.747654e-07
I13746 n1_m1_556800_278400 0 2.892689e-07
I13747 n1_m1_556800_283200 0 2.924645e-07
I13748 n1_m1_556800_288000 0 4.277335e-07
I13749 n1_m1_556800_292800 0 2.865987e-07
I13750 n1_m1_556800_297600 0 3.805005e-07
I13751 n1_m1_556800_302400 0 3.139925e-07
I13752 n1_m1_556800_307200 0 2.424835e-07
I13753 n1_m1_556800_312000 0 2.719850e-07
I13754 n1_m1_556800_316800 0 1.738446e-07
I13755 n1_m1_556800_321600 0 3.011258e-07
I13756 n1_m1_556800_326400 0 2.413082e-07
I13757 n1_m1_556800_331200 0 2.670089e-07
I13758 n1_m1_556800_336000 0 4.029941e-07
I13759 n1_m1_556800_340800 0 2.434051e-07
I13760 n1_m1_556800_345600 0 3.108437e-07
I13761 n1_m1_556800_350400 0 2.182207e-07
I13762 n1_m1_556800_355200 0 2.512186e-07
I13763 n1_m1_556800_360000 0 3.518288e-07
I13764 n1_m1_556800_364800 0 1.761079e-07
I13765 n1_m1_556800_369600 0 2.529369e-07
I13766 n1_m1_556800_374400 0 1.884260e-07
I13767 n1_m1_556800_379200 0 1.952644e-07
I13768 n1_m1_556800_384000 0 3.099106e-07
I13769 n1_m1_556800_388800 0 2.798954e-07
I13770 n1_m1_556800_393600 0 3.323651e-07
I13771 n1_m1_556800_398400 0 1.678208e-07
I13772 n1_m1_556800_403200 0 1.874436e-07
I13773 n1_m1_556800_408000 0 4.466307e-07
I13774 n1_m1_556800_412800 0 2.826234e-07
I13775 n1_m1_556800_417600 0 2.719837e-07
I13776 n1_m1_556800_422400 0 1.558487e-07
I13777 n1_m1_556800_427200 0 1.606382e-07
I13778 n1_m1_556800_432000 0 2.780235e-07
I13779 n1_m1_556800_436800 0 2.325000e-07
I13780 n1_m1_556800_441600 0 3.273208e-07
I13781 n1_m1_556800_446400 0 1.801856e-07
I13782 n1_m1_556800_451200 0 1.685971e-07
I13783 n1_m1_556800_456000 0 2.645131e-07
I13784 n1_m1_556800_460800 0 1.770331e-07
I13785 n1_m1_556800_465600 0 2.524661e-07
I13786 n1_m1_556800_470400 0 1.559723e-07
I13787 n1_m1_556800_475200 0 1.526664e-07
I13788 n1_m1_556800_480000 0 2.323836e-07
I13789 n1_m1_556800_484800 0 1.602540e-07
I13790 n1_m1_556800_489600 0 2.449528e-07
I13791 n1_m1_556800_494400 0 1.538789e-07
I13792 n1_m1_556800_499200 0 1.570043e-07
I13793 n1_m1_556800_504000 0 2.432316e-07
I13794 n1_m1_556800_508800 0 1.609927e-07
I13795 n1_m1_556800_513600 0 2.372215e-07
I13796 n1_m1_556800_518400 0 1.524813e-07
I13797 n1_m1_556800_523200 0 1.467549e-07
I13798 n1_m1_556800_528000 0 2.244389e-07
I13799 n1_m1_556800_532800 0 1.619114e-07
I13800 n1_m1_556800_537600 0 2.430720e-07
I13801 n1_m1_556800_542400 0 1.470938e-07
I13802 n1_m1_556800_547200 0 1.423096e-07
I13803 n1_m1_556800_552000 0 2.208020e-07
I13804 n1_m1_556800_556800 0 1.469336e-07
I13805 n1_m1_556800_561600 0 7.300446e-08
I13806 n1_m1_561600_0 0 9.519975e-08
I13807 n1_m1_561600_4800 0 8.800403e-08
I13808 n1_m1_561600_9600 0 1.179081e-07
I13809 n1_m1_561600_14400 0 7.365439e-08
I13810 n1_m1_561600_19200 0 7.471111e-08
I13811 n1_m1_561600_24000 0 1.181097e-07
I13812 n1_m1_561600_28800 0 8.085198e-08
I13813 n1_m1_561600_33600 0 1.249168e-07
I13814 n1_m1_561600_38400 0 8.451719e-08
I13815 n1_m1_561600_43200 0 8.183588e-08
I13816 n1_m1_561600_48000 0 1.162182e-07
I13817 n1_m1_561600_52800 0 7.338676e-08
I13818 n1_m1_561600_57600 0 1.091871e-07
I13819 n1_m1_561600_62400 0 7.438639e-08
I13820 n1_m1_561600_67200 0 7.926295e-08
I13821 n1_m1_561600_72000 0 1.255081e-07
I13822 n1_m1_561600_76800 0 8.111612e-08
I13823 n1_m1_561600_81600 0 1.190645e-07
I13824 n1_m1_561600_86400 0 8.114241e-08
I13825 n1_m1_561600_91200 0 8.266568e-08
I13826 n1_m1_561600_96000 0 1.210379e-07
I13827 n1_m1_561600_100800 0 7.689858e-08
I13828 n1_m1_561600_105600 0 1.145477e-07
I13829 n1_m1_561600_110400 0 7.886281e-08
I13830 n1_m1_561600_115200 0 7.899235e-08
I13831 n1_m1_561600_120000 0 1.303336e-07
I13832 n1_m1_561600_124800 0 9.929687e-08
I13833 n1_m1_561600_129600 0 1.304979e-07
I13834 n1_m1_561600_134400 0 8.606718e-08
I13835 n1_m1_561600_139200 0 9.339971e-08
I13836 n1_m1_561600_144000 0 1.752758e-07
I13837 n1_m1_561600_148800 0 1.235284e-07
I13838 n1_m1_561600_153600 0 1.674904e-07
I13839 n1_m1_561600_158400 0 8.904734e-08
I13840 n1_m1_561600_163200 0 7.999596e-08
I13841 n1_m1_561600_168000 0 1.478856e-07
I13842 n1_m1_561600_172800 0 1.175268e-07
I13843 n1_m1_561600_177600 0 1.875301e-07
I13844 n1_m1_561600_182400 0 1.153968e-07
I13845 n1_m1_561600_187200 0 1.012795e-07
I13846 n1_m1_561600_192000 0 1.451103e-07
I13847 n1_m1_561600_196800 0 1.241001e-07
I13848 n1_m1_561600_201600 0 1.875999e-07
I13849 n1_m1_561600_206400 0 9.505792e-08
I13850 n1_m1_561600_211200 0 9.658192e-08
I13851 n1_m1_561600_216000 0 1.408127e-07
I13852 n1_m1_561600_220800 0 1.171072e-07
I13853 n1_m1_561600_225600 0 2.069918e-07
I13854 n1_m1_561600_230400 0 1.200541e-07
I13855 n1_m1_561600_235200 0 1.051263e-07
I13856 n1_m1_561600_240000 0 1.415067e-07
I13857 n1_m1_561600_244800 0 9.446649e-08
I13858 n1_m1_561600_249600 0 1.589994e-07
I13859 n1_m1_561600_254400 0 1.115359e-07
I13860 n1_m1_561600_259200 0 1.076198e-07
I13861 n1_m1_561600_264000 0 1.440822e-07
I13862 n1_m1_561600_268800 0 9.599276e-08
I13863 n1_m1_561600_273600 0 1.684269e-07
I13864 n1_m1_561600_278400 0 1.269842e-07
I13865 n1_m1_561600_283200 0 1.270178e-07
I13866 n1_m1_561600_288000 0 1.868299e-07
I13867 n1_m1_561600_292800 0 1.253694e-07
I13868 n1_m1_561600_297600 0 1.711978e-07
I13869 n1_m1_561600_302400 0 1.434895e-07
I13870 n1_m1_561600_307200 0 1.142782e-07
I13871 n1_m1_561600_312000 0 1.326090e-07
I13872 n1_m1_561600_316800 0 8.482255e-08
I13873 n1_m1_561600_321600 0 1.423436e-07
I13874 n1_m1_561600_326400 0 1.102565e-07
I13875 n1_m1_561600_331200 0 1.191801e-07
I13876 n1_m1_561600_336000 0 1.821604e-07
I13877 n1_m1_561600_340800 0 1.123419e-07
I13878 n1_m1_561600_345600 0 1.458021e-07
I13879 n1_m1_561600_350400 0 1.007714e-07
I13880 n1_m1_561600_355200 0 1.137486e-07
I13881 n1_m1_561600_360000 0 1.623411e-07
I13882 n1_m1_561600_364800 0 8.593733e-08
I13883 n1_m1_561600_369600 0 1.247669e-07
I13884 n1_m1_561600_374400 0 9.154273e-08
I13885 n1_m1_561600_379200 0 9.359926e-08
I13886 n1_m1_561600_384000 0 1.452919e-07
I13887 n1_m1_561600_388800 0 1.241862e-07
I13888 n1_m1_561600_393600 0 1.565257e-07
I13889 n1_m1_561600_398400 0 8.391038e-08
I13890 n1_m1_561600_403200 0 8.849154e-08
I13891 n1_m1_561600_408000 0 1.888572e-07
I13892 n1_m1_561600_412800 0 1.225949e-07
I13893 n1_m1_561600_417600 0 1.335042e-07
I13894 n1_m1_561600_422400 0 7.878480e-08
I13895 n1_m1_561600_427200 0 8.019282e-08
I13896 n1_m1_561600_432000 0 1.325644e-07
I13897 n1_m1_561600_436800 0 1.039912e-07
I13898 n1_m1_561600_441600 0 1.488901e-07
I13899 n1_m1_561600_446400 0 8.726873e-08
I13900 n1_m1_561600_451200 0 8.445569e-08
I13901 n1_m1_561600_456000 0 1.304998e-07
I13902 n1_m1_561600_460800 0 8.674706e-08
I13903 n1_m1_561600_465600 0 1.241526e-07
I13904 n1_m1_561600_470400 0 7.665225e-08
I13905 n1_m1_561600_475200 0 7.530328e-08
I13906 n1_m1_561600_480000 0 1.140756e-07
I13907 n1_m1_561600_484800 0 7.828637e-08
I13908 n1_m1_561600_489600 0 1.202175e-07
I13909 n1_m1_561600_494400 0 7.623119e-08
I13910 n1_m1_561600_499200 0 7.786463e-08
I13911 n1_m1_561600_504000 0 1.202289e-07
I13912 n1_m1_561600_508800 0 7.957172e-08
I13913 n1_m1_561600_513600 0 1.172238e-07
I13914 n1_m1_561600_518400 0 7.531604e-08
I13915 n1_m1_561600_523200 0 7.243594e-08
I13916 n1_m1_561600_528000 0 1.102517e-07
I13917 n1_m1_561600_532800 0 7.956876e-08
I13918 n1_m1_561600_537600 0 1.192294e-07
I13919 n1_m1_561600_542400 0 7.188272e-08
I13920 n1_m1_561600_547200 0 6.962388e-08
I13921 n1_m1_561600_552000 0 1.076283e-07
I13922 n1_m1_561600_556800 0 7.161751e-08
I13923 n1_m1_561600_561600 0 3.557760e-08
I13924 n1_m1_4000_0 0 8.588865e-08
I13925 n1_m1_4000_4800 0 8.683342e-08
I13926 n1_m1_4000_9600 0 1.212513e-07
I13927 n1_m1_4000_14400 0 7.448624e-08
I13928 n1_m1_4000_19200 0 7.437787e-08
I13929 n1_m1_4000_24000 0 1.120616e-07
I13930 n1_m1_4000_28800 0 7.217466e-08
I13931 n1_m1_4000_33600 0 1.034230e-07
I13932 n1_m1_4000_38400 0 6.912281e-08
I13933 n1_m1_4000_43200 0 6.995199e-08
I13934 n1_m1_4000_48000 0 1.069119e-07
I13935 n1_m1_4000_52800 0 7.210822e-08
I13936 n1_m1_4000_57600 0 1.109309e-07
I13937 n1_m1_4000_62400 0 7.531988e-08
I13938 n1_m1_4000_67200 0 7.596854e-08
I13939 n1_m1_4000_72000 0 1.236713e-07
I13940 n1_m1_4000_76800 0 8.828733e-08
I13941 n1_m1_4000_81600 0 1.177649e-07
I13942 n1_m1_4000_86400 0 7.975838e-08
I13943 n1_m1_4000_91200 0 8.558583e-08
I13944 n1_m1_4000_96000 0 1.290834e-07
I13945 n1_m1_4000_100800 0 9.350741e-08
I13946 n1_m1_4000_105600 0 1.469135e-07
I13947 n1_m1_4000_110400 0 1.453176e-07
I13948 n1_m1_4000_115200 0 1.483425e-07
I13949 n1_m1_4000_120000 0 1.645014e-07
I13950 n1_m1_4000_124800 0 1.128883e-07
I13951 n1_m1_4000_129600 0 1.830919e-07
I13952 n1_m1_4000_134400 0 1.525914e-07
I13953 n1_m1_4000_139200 0 1.654567e-07
I13954 n1_m1_4000_144000 0 2.283239e-07
I13955 n1_m1_4000_148800 0 1.576111e-07
I13956 n1_m1_4000_153600 0 2.161452e-07
I13957 n1_m1_4000_158400 0 1.377877e-07
I13958 n1_m1_4000_163200 0 1.645420e-07
I13959 n1_m1_4000_168000 0 2.630408e-07
I13960 n1_m1_4000_172800 0 1.504988e-07
I13961 n1_m1_4000_177600 0 1.572700e-07
I13962 n1_m1_4000_182400 0 9.810250e-08
I13963 n1_m1_4000_187200 0 1.095800e-07
I13964 n1_m1_4000_192000 0 1.935264e-07
I13965 n1_m1_4000_196800 0 1.118151e-07
I13966 n1_m1_4000_201600 0 1.500894e-07
I13967 n1_m1_4000_206400 0 1.064945e-07
I13968 n1_m1_4000_211200 0 9.746062e-08
I13969 n1_m1_4000_216000 0 2.813686e-07
I13970 n1_m1_4000_220800 0 1.151921e-07
I13971 n1_m1_4000_225600 0 1.919448e-07
I13972 n1_m1_4000_230400 0 1.390195e-07
I13973 n1_m1_4000_235200 0 1.287268e-07
I13974 n1_m1_4000_240000 0 2.335767e-07
I13975 n1_m1_4000_244800 0 1.825286e-07
I13976 n1_m1_4000_249600 0 2.680021e-07
I13977 n1_m1_4000_254400 0 1.384014e-07
I13978 n1_m1_4000_259200 0 1.154153e-07
I13979 n1_m1_4000_264000 0 2.063295e-07
I13980 n1_m1_4000_268800 0 1.768455e-07
I13981 n1_m1_4000_273600 0 2.344423e-07
I13982 n1_m1_4000_278400 0 1.189636e-07
I13983 n1_m1_4000_283200 0 1.323288e-07
I13984 n1_m1_4000_288000 0 2.039769e-07
I13985 n1_m1_4000_292800 0 1.414885e-07
I13986 n1_m1_4000_297600 0 2.183787e-07
I13987 n1_m1_4000_302400 0 1.465015e-07
I13988 n1_m1_4000_307200 0 1.434228e-07
I13989 n1_m1_4000_312000 0 2.036603e-07
I13990 n1_m1_4000_316800 0 1.036480e-07
I13991 n1_m1_4000_321600 0 2.199628e-07
I13992 n1_m1_4000_326400 0 9.642148e-08
I13993 n1_m1_4000_331200 0 1.271992e-07
I13994 n1_m1_4000_336000 0 1.992564e-07
I13995 n1_m1_4000_340800 0 1.257930e-07
I13996 n1_m1_4000_345600 0 2.502380e-07
I13997 n1_m1_4000_350400 0 1.986834e-07
I13998 n1_m1_4000_355200 0 1.995849e-07
I13999 n1_m1_4000_360000 0 2.415653e-07
I14000 n1_m1_4000_364800 0 1.471299e-07
I14001 n1_m1_4000_369600 0 2.827294e-07
I14002 n1_m1_4000_374400 0 2.073890e-07
I14003 n1_m1_4000_379200 0 1.396100e-07
I14004 n1_m1_4000_384000 0 1.317875e-07
I14005 n1_m1_4000_388800 0 8.581187e-08
I14006 n1_m1_4000_393600 0 1.283629e-07
I14007 n1_m1_4000_398400 0 8.154604e-08
I14008 n1_m1_4000_403200 0 8.244738e-08
I14009 n1_m1_4000_408000 0 1.299928e-07
I14010 n1_m1_4000_412800 0 8.493053e-08
I14011 n1_m1_4000_417600 0 1.284606e-07
I14012 n1_m1_4000_422400 0 8.696820e-08
I14013 n1_m1_4000_427200 0 8.849885e-08
I14014 n1_m1_4000_432000 0 1.263373e-07
I14015 n1_m1_4000_436800 0 8.124540e-08
I14016 n1_m1_4000_441600 0 1.249966e-07
I14017 n1_m1_4000_446400 0 8.306300e-08
I14018 n1_m1_4000_451200 0 7.561234e-08
I14019 n1_m1_4000_456000 0 1.112098e-07
I14020 n1_m1_4000_460800 0 7.548771e-08
I14021 n1_m1_4000_465600 0 1.131607e-07
I14022 n1_m1_4000_470400 0 7.642257e-08
I14023 n1_m1_4000_475200 0 8.158197e-08
I14024 n1_m1_4000_480000 0 1.277592e-07
I14025 n1_m1_4000_484800 0 8.102877e-08
I14026 n1_m1_4000_489600 0 1.129084e-07
I14027 n1_m1_4000_494400 0 7.810178e-08
I14028 n1_m1_4000_499200 0 7.874192e-08
I14029 n1_m1_4000_504000 0 1.190474e-07
I14030 n1_m1_4000_508800 0 7.994513e-08
I14031 n1_m1_4000_513600 0 1.159436e-07
I14032 n1_m1_4000_518400 0 7.377202e-08
I14033 n1_m1_4000_523200 0 7.332692e-08
I14034 n1_m1_4000_528000 0 1.121681e-07
I14035 n1_m1_4000_532800 0 7.801538e-08
I14036 n1_m1_4000_537600 0 1.164514e-07
I14037 n1_m1_4000_542400 0 7.280132e-08
I14038 n1_m1_4000_547200 0 7.207983e-08
I14039 n1_m1_4000_552000 0 1.073040e-07
I14040 n1_m1_4000_556800 0 6.837016e-08
I14041 n1_m1_4000_561600 0 3.388976e-08
I14042 n1_m1_32000_0 0 7.337757e-08
I14043 n1_m1_32000_4800 0 7.318643e-08
I14044 n1_m1_32000_9600 0 1.056898e-07
I14045 n1_m1_32000_14400 0 6.996191e-08
I14046 n1_m1_32000_19200 0 7.046439e-08
I14047 n1_m1_32000_24000 0 1.095184e-07
I14048 n1_m1_32000_28800 0 7.222801e-08
I14049 n1_m1_32000_33600 0 1.049703e-07
I14050 n1_m1_32000_38400 0 6.995199e-08
I14051 n1_m1_32000_43200 0 6.995199e-08
I14052 n1_m1_32000_48000 0 1.049280e-07
I14053 n1_m1_32000_52800 0 6.999573e-08
I14054 n1_m1_32000_57600 0 1.089044e-07
I14055 n1_m1_32000_62400 0 7.327900e-08
I14056 n1_m1_32000_67200 0 7.328303e-08
I14057 n1_m1_32000_72000 0 1.123402e-07
I14058 n1_m1_32000_76800 0 7.833888e-08
I14059 n1_m1_32000_81600 0 1.081650e-07
I14060 n1_m1_32000_86400 0 7.000533e-08
I14061 n1_m1_32000_91200 0 7.151675e-08
I14062 n1_m1_32000_96000 0 1.100385e-07
I14063 n1_m1_32000_100800 0 7.571909e-08
I14064 n1_m1_32000_105600 0 1.176503e-07
I14065 n1_m1_32000_110400 0 9.086838e-08
I14066 n1_m1_32000_115200 0 8.951148e-08
I14067 n1_m1_32000_120000 0 1.227123e-07
I14068 n1_m1_32000_124800 0 8.235908e-08
I14069 n1_m1_32000_129600 0 1.143298e-07
I14070 n1_m1_32000_134400 0 7.150919e-08
I14071 n1_m1_32000_139200 0 7.578147e-08
I14072 n1_m1_32000_144000 0 1.146382e-07
I14073 n1_m1_32000_148800 0 7.337178e-08
I14074 n1_m1_32000_153600 0 1.135430e-07
I14075 n1_m1_32000_158400 0 7.656838e-08
I14076 n1_m1_32000_163200 0 7.656074e-08
I14077 n1_m1_32000_168000 0 1.155850e-07
I14078 n1_m1_32000_172800 0 7.913311e-08
I14079 n1_m1_32000_177600 0 1.200868e-07
I14080 n1_m1_32000_182400 0 8.380765e-08
I14081 n1_m1_32000_187200 0 8.197972e-08
I14082 n1_m1_32000_192000 0 1.254669e-07
I14083 n1_m1_32000_196800 0 9.174097e-08
I14084 n1_m1_32000_201600 0 1.418150e-07
I14085 n1_m1_32000_206400 0 9.379119e-08
I14086 n1_m1_32000_211200 0 1.057770e-07
I14087 n1_m1_32000_216000 0 1.442584e-07
I14088 n1_m1_32000_220800 0 1.244753e-07
I14089 n1_m1_32000_225600 0 2.110788e-07
I14090 n1_m1_32000_230400 0 1.748531e-07
I14091 n1_m1_32000_235200 0 1.986413e-07
I14092 n1_m1_32000_240000 0 1.749834e-07
I14093 n1_m1_32000_244800 0 8.825785e-08
I14094 n1_m1_32000_249600 0 1.221452e-07
I14095 n1_m1_32000_254400 0 7.409415e-08
I14096 n1_m1_32000_259200 0 7.568676e-08
I14097 n1_m1_32000_264000 0 1.244229e-07
I14098 n1_m1_32000_268800 0 7.770677e-08
I14099 n1_m1_32000_273600 0 1.183929e-07
I14100 n1_m1_32000_278400 0 8.551604e-08
I14101 n1_m1_32000_283200 0 8.189396e-08
I14102 n1_m1_32000_288000 0 1.135564e-07
I14103 n1_m1_32000_292800 0 7.482234e-08
I14104 n1_m1_32000_297600 0 1.177004e-07
I14105 n1_m1_32000_302400 0 7.987783e-08
I14106 n1_m1_32000_307200 0 7.772838e-08
I14107 n1_m1_32000_312000 0 1.149172e-07
I14108 n1_m1_32000_316800 0 7.749464e-08
I14109 n1_m1_32000_321600 0 1.296411e-07
I14110 n1_m1_32000_326400 0 9.177912e-08
I14111 n1_m1_32000_331200 0 8.737024e-08
I14112 n1_m1_32000_336000 0 1.253032e-07
I14113 n1_m1_32000_340800 0 8.060304e-08
I14114 n1_m1_32000_345600 0 1.202429e-07
I14115 n1_m1_32000_350400 0 7.882468e-08
I14116 n1_m1_32000_355200 0 7.486214e-08
I14117 n1_m1_32000_360000 0 1.111460e-07
I14118 n1_m1_32000_364800 0 8.134686e-08
I14119 n1_m1_32000_369600 0 1.224991e-07
I14120 n1_m1_32000_374400 0 7.312409e-08
I14121 n1_m1_32000_379200 0 7.071802e-08
I14122 n1_m1_32000_384000 0 1.176812e-07
I14123 n1_m1_32000_388800 0 8.446300e-08
I14124 n1_m1_32000_393600 0 1.024662e-07
I14125 n1_m1_32000_398400 0 8.197559e-08
I14126 n1_m1_32000_403200 0 8.134765e-08
I14127 n1_m1_32000_408000 0 1.109713e-07
I14128 n1_m1_32000_412800 0 7.905283e-08
I14129 n1_m1_32000_417600 0 1.087949e-07
I14130 n1_m1_32000_422400 0 7.501265e-08
I14131 n1_m1_32000_427200 0 8.341435e-08
I14132 n1_m1_32000_432000 0 1.132849e-07
I14133 n1_m1_32000_436800 0 7.574088e-08
I14134 n1_m1_32000_441600 0 1.058830e-07
I14135 n1_m1_32000_446400 0 7.544797e-08
I14136 n1_m1_32000_451200 0 7.724921e-08
I14137 n1_m1_32000_456000 0 1.050989e-07
I14138 n1_m1_32000_460800 0 7.236433e-08
I14139 n1_m1_32000_465600 0 1.131235e-07
I14140 n1_m1_32000_470400 0 7.365338e-08
I14141 n1_m1_32000_475200 0 7.327929e-08
I14142 n1_m1_32000_480000 0 1.098553e-07
I14143 n1_m1_32000_484800 0 7.322969e-08
I14144 n1_m1_32000_489600 0 1.098445e-07
I14145 n1_m1_32000_494400 0 7.322969e-08
I14146 n1_m1_32000_499200 0 7.198743e-08
I14147 n1_m1_32000_504000 0 1.049280e-07
I14148 n1_m1_32000_508800 0 6.995199e-08
I14149 n1_m1_32000_513600 0 1.049280e-07
I14150 n1_m1_32000_518400 0 6.995199e-08
I14151 n1_m1_32000_523200 0 6.995199e-08
I14152 n1_m1_32000_528000 0 1.056600e-07
I14153 n1_m1_32000_532800 0 7.369201e-08
I14154 n1_m1_32000_537600 0 1.129681e-07
I14155 n1_m1_32000_542400 0 7.461664e-08
I14156 n1_m1_32000_547200 0 7.765133e-08
I14157 n1_m1_32000_552000 0 1.198726e-07
I14158 n1_m1_32000_556800 0 7.789849e-08
I14159 n1_m1_32000_561600 0 3.871438e-08
I14160 n1_m1_60000_0 0 7.374337e-08
I14161 n1_m1_60000_4800 0 7.503446e-08
I14162 n1_m1_60000_9600 0 1.147566e-07
I14163 n1_m1_60000_14400 0 7.338194e-08
I14164 n1_m1_60000_19200 0 7.030083e-08
I14165 n1_m1_60000_24000 0 1.049280e-07
I14166 n1_m1_60000_28800 0 6.995199e-08
I14167 n1_m1_60000_33600 0 1.049280e-07
I14168 n1_m1_60000_38400 0 6.995199e-08
I14169 n1_m1_60000_43200 0 6.995199e-08
I14170 n1_m1_60000_48000 0 1.049280e-07
I14171 n1_m1_60000_52800 0 6.995199e-08
I14172 n1_m1_60000_57600 0 1.055829e-07
I14173 n1_m1_60000_62400 0 7.303113e-08
I14174 n1_m1_60000_67200 0 7.314202e-08
I14175 n1_m1_60000_72000 0 1.093548e-07
I14176 n1_m1_60000_76800 0 7.442104e-08
I14177 n1_m1_60000_81600 0 1.075964e-07
I14178 n1_m1_60000_86400 0 7.487743e-08
I14179 n1_m1_60000_91200 0 7.581821e-08
I14180 n1_m1_60000_96000 0 1.109883e-07
I14181 n1_m1_60000_100800 0 8.765264e-08
I14182 n1_m1_60000_105600 0 1.252815e-07
I14183 n1_m1_60000_110400 0 8.041723e-08
I14184 n1_m1_60000_115200 0 7.884959e-08
I14185 n1_m1_60000_120000 0 1.156689e-07
I14186 n1_m1_60000_124800 0 7.490499e-08
I14187 n1_m1_60000_129600 0 1.100450e-07
I14188 n1_m1_60000_134400 0 7.232281e-08
I14189 n1_m1_60000_139200 0 7.410889e-08
I14190 n1_m1_60000_144000 0 1.189842e-07
I14191 n1_m1_60000_148800 0 7.994513e-08
I14192 n1_m1_60000_153600 0 1.178195e-07
I14193 n1_m1_60000_158400 0 7.387885e-08
I14194 n1_m1_60000_163200 0 7.164130e-08
I14195 n1_m1_60000_168000 0 1.073442e-07
I14196 n1_m1_60000_172800 0 7.318414e-08
I14197 n1_m1_60000_177600 0 1.099246e-07
I14198 n1_m1_60000_182400 0 7.328303e-08
I14199 n1_m1_60000_187200 0 7.392678e-08
I14200 n1_m1_60000_192000 0 1.152412e-07
I14201 n1_m1_60000_196800 0 8.019685e-08
I14202 n1_m1_60000_201600 0 1.238611e-07
I14203 n1_m1_60000_206400 0 8.247603e-08
I14204 n1_m1_60000_211200 0 7.804846e-08
I14205 n1_m1_60000_216000 0 1.296463e-07
I14206 n1_m1_60000_220800 0 9.314190e-08
I14207 n1_m1_60000_225600 0 2.304319e-07
I14208 n1_m1_60000_230400 0 1.039025e-07
I14209 n1_m1_60000_235200 0 8.279015e-08
I14210 n1_m1_60000_240000 0 1.128461e-07
I14211 n1_m1_60000_244800 0 7.390069e-08
I14212 n1_m1_60000_249600 0 1.099246e-07
I14213 n1_m1_60000_254400 0 7.326089e-08
I14214 n1_m1_60000_259200 0 7.234373e-08
I14215 n1_m1_60000_264000 0 1.081637e-07
I14216 n1_m1_60000_268800 0 7.327604e-08
I14217 n1_m1_60000_273600 0 1.124085e-07
I14218 n1_m1_60000_278400 0 7.661408e-08
I14219 n1_m1_60000_283200 0 7.661408e-08
I14220 n1_m1_60000_288000 0 1.142009e-07
I14221 n1_m1_60000_292800 0 7.437273e-08
I14222 n1_m1_60000_297600 0 1.099246e-07
I14223 n1_m1_60000_302400 0 7.328303e-08
I14224 n1_m1_60000_307200 0 7.413377e-08
I14225 n1_m1_60000_312000 0 1.138732e-07
I14226 n1_m1_60000_316800 0 7.544608e-08
I14227 n1_m1_60000_321600 0 1.149619e-07
I14228 n1_m1_60000_326400 0 1.140208e-07
I14229 n1_m1_60000_331200 0 1.964962e-07
I14230 n1_m1_60000_336000 0 2.156667e-07
I14231 n1_m1_60000_340800 0 1.865553e-07
I14232 n1_m1_60000_345600 0 4.188384e-07
I14233 n1_m1_60000_350400 0 3.089297e-07
I14234 n1_m1_60000_355200 0 2.970134e-07
I14235 n1_m1_60000_360000 0 3.323006e-07
I14236 n1_m1_60000_364800 0 1.180986e-07
I14237 n1_m1_60000_369600 0 1.289962e-07
I14238 n1_m1_60000_374400 0 7.789682e-08
I14239 n1_m1_60000_379200 0 7.404269e-08
I14240 n1_m1_60000_384000 0 1.140658e-07
I14241 n1_m1_60000_388800 0 8.053629e-08
I14242 n1_m1_60000_393600 0 1.221477e-07
I14243 n1_m1_60000_398400 0 8.194257e-08
I14244 n1_m1_60000_403200 0 9.474789e-08
I14245 n1_m1_60000_408000 0 4.281282e-07
I14246 n1_m1_60000_412800 0 3.897878e-07
I14247 n1_m1_60000_417600 0 8.814423e-07
I14248 n1_m1_60000_422400 0 4.124721e-07
I14249 n1_m1_60000_427200 0 2.359859e-07
I14250 n1_m1_60000_432000 0 3.845173e-07
I14251 n1_m1_60000_436800 0 1.146247e-07
I14252 n1_m1_60000_441600 0 1.701249e-07
I14253 n1_m1_60000_446400 0 8.243076e-08
I14254 n1_m1_60000_451200 0 7.922026e-08
I14255 n1_m1_60000_456000 0 1.105911e-07
I14256 n1_m1_60000_460800 0 7.459293e-08
I14257 n1_m1_60000_465600 0 1.118894e-07
I14258 n1_m1_60000_470400 0 7.444260e-08
I14259 n1_m1_60000_475200 0 7.334725e-08
I14260 n1_m1_60000_480000 0 1.069351e-07
I14261 n1_m1_60000_484800 0 6.997646e-08
I14262 n1_m1_60000_489600 0 1.049280e-07
I14263 n1_m1_60000_494400 0 6.995199e-08
I14264 n1_m1_60000_499200 0 6.995199e-08
I14265 n1_m1_60000_504000 0 1.049280e-07
I14266 n1_m1_60000_508800 0 6.995199e-08
I14267 n1_m1_60000_513600 0 1.049280e-07
I14268 n1_m1_60000_518400 0 6.995199e-08
I14269 n1_m1_60000_523200 0 7.007349e-08
I14270 n1_m1_60000_528000 0 1.092688e-07
I14271 n1_m1_60000_532800 0 7.360271e-08
I14272 n1_m1_60000_537600 0 1.078077e-07
I14273 n1_m1_60000_542400 0 7.335958e-08
I14274 n1_m1_60000_547200 0 7.898385e-08
I14275 n1_m1_60000_552000 0 1.253950e-07
I14276 n1_m1_60000_556800 0 7.828858e-08
I14277 n1_m1_60000_561600 0 3.864043e-08
I14278 n1_m1_88000_0 0 7.813143e-08
I14279 n1_m1_88000_4800 0 8.207297e-08
I14280 n1_m1_88000_9600 0 1.233614e-07
I14281 n1_m1_88000_14400 0 7.627327e-08
I14282 n1_m1_88000_19200 0 7.357050e-08
I14283 n1_m1_88000_24000 0 1.099246e-07
I14284 n1_m1_88000_28800 0 7.217466e-08
I14285 n1_m1_88000_33600 0 1.049280e-07
I14286 n1_m1_88000_38400 0 6.995199e-08
I14287 n1_m1_88000_43200 0 6.995199e-08
I14288 n1_m1_88000_48000 0 1.049722e-07
I14289 n1_m1_88000_52800 0 7.058690e-08
I14290 n1_m1_88000_57600 0 1.091802e-07
I14291 n1_m1_88000_62400 0 7.328303e-08
I14292 n1_m1_88000_67200 0 7.380625e-08
I14293 n1_m1_88000_72000 0 1.226609e-07
I14294 n1_m1_88000_76800 0 9.307485e-08
I14295 n1_m1_88000_81600 0 1.250654e-07
I14296 n1_m1_88000_86400 0 7.994513e-08
I14297 n1_m1_88000_91200 0 7.878064e-08
I14298 n1_m1_88000_96000 0 1.148624e-07
I14299 n1_m1_88000_100800 0 7.940386e-08
I14300 n1_m1_88000_105600 0 1.254121e-07
I14301 n1_m1_88000_110400 0 8.709778e-08
I14302 n1_m1_88000_115200 0 8.801874e-08
I14303 n1_m1_88000_120000 0 1.319856e-07
I14304 n1_m1_88000_124800 0 8.667510e-08
I14305 n1_m1_88000_129600 0 1.243808e-07
I14306 n1_m1_88000_134400 0 8.034648e-08
I14307 n1_m1_88000_139200 0 8.251750e-08
I14308 n1_m1_88000_144000 0 1.252673e-07
I14309 n1_m1_88000_148800 0 7.628809e-08
I14310 n1_m1_88000_153600 0 1.102497e-07
I14311 n1_m1_88000_158400 0 7.328303e-08
I14312 n1_m1_88000_163200 0 7.328303e-08
I14313 n1_m1_88000_168000 0 1.099246e-07
I14314 n1_m1_88000_172800 0 7.328303e-08
I14315 n1_m1_88000_177600 0 1.099246e-07
I14316 n1_m1_88000_182400 0 7.328303e-08
I14317 n1_m1_88000_187200 0 7.328303e-08
I14318 n1_m1_88000_192000 0 1.104490e-07
I14319 n1_m1_88000_196800 0 7.557746e-08
I14320 n1_m1_88000_201600 0 1.185202e-07
I14321 n1_m1_88000_206400 0 8.188827e-08
I14322 n1_m1_88000_211200 0 7.992798e-08
I14323 n1_m1_88000_216000 0 1.316100e-07
I14324 n1_m1_88000_220800 0 1.486404e-07
I14325 n1_m1_88000_225600 0 3.267560e-07
I14326 n1_m1_88000_230400 0 1.723822e-07
I14327 n1_m1_88000_235200 0 1.233554e-07
I14328 n1_m1_88000_240000 0 1.382619e-07
I14329 n1_m1_88000_244800 0 8.503653e-08
I14330 n1_m1_88000_249600 0 1.265768e-07
I14331 n1_m1_88000_254400 0 8.064749e-08
I14332 n1_m1_88000_259200 0 7.994513e-08
I14333 n1_m1_88000_264000 0 1.228129e-07
I14334 n1_m1_88000_268800 0 8.185572e-08
I14335 n1_m1_88000_273600 0 1.146676e-07
I14336 n1_m1_88000_278400 0 7.418989e-08
I14337 n1_m1_88000_283200 0 7.653999e-08
I14338 n1_m1_88000_288000 0 1.149211e-07
I14339 n1_m1_88000_292800 0 7.543132e-08
I14340 n1_m1_88000_297600 0 1.104048e-07
I14341 n1_m1_88000_302400 0 7.328303e-08
I14342 n1_m1_88000_307200 0 7.328303e-08
I14343 n1_m1_88000_312000 0 1.101109e-07
I14344 n1_m1_88000_316800 0 7.640410e-08
I14345 n1_m1_88000_321600 0 1.417350e-07
I14346 n1_m1_88000_326400 0 1.218673e-07
I14347 n1_m1_88000_331200 0 1.966231e-07
I14348 n1_m1_88000_336000 0 2.052680e-07
I14349 n1_m1_88000_340800 0 1.661347e-07
I14350 n1_m1_88000_345600 0 2.185693e-07
I14351 n1_m1_88000_350400 0 1.481346e-07
I14352 n1_m1_88000_355200 0 1.672451e-07
I14353 n1_m1_88000_360000 0 2.031495e-07
I14354 n1_m1_88000_364800 0 9.192361e-08
I14355 n1_m1_88000_369600 0 1.153123e-07
I14356 n1_m1_88000_374400 0 7.280903e-08
I14357 n1_m1_88000_379200 0 7.321433e-08
I14358 n1_m1_88000_384000 0 1.117356e-07
I14359 n1_m1_88000_388800 0 7.898497e-08
I14360 n1_m1_88000_393600 0 1.167243e-07
I14361 n1_m1_88000_398400 0 7.374424e-08
I14362 n1_m1_88000_403200 0 7.536739e-08
I14363 n1_m1_88000_408000 0 1.791358e-07
I14364 n1_m1_88000_412800 0 1.158999e-07
I14365 n1_m1_88000_417600 0 3.240769e-07
I14366 n1_m1_88000_422400 0 1.222971e-07
I14367 n1_m1_88000_427200 0 9.938360e-08
I14368 n1_m1_88000_432000 0 1.736175e-07
I14369 n1_m1_88000_436800 0 1.239685e-07
I14370 n1_m1_88000_441600 0 1.373706e-07
I14371 n1_m1_88000_446400 0 9.207743e-08
I14372 n1_m1_88000_451200 0 8.846470e-08
I14373 n1_m1_88000_456000 0 1.236992e-07
I14374 n1_m1_88000_460800 0 8.009923e-08
I14375 n1_m1_88000_465600 0 1.153268e-07
I14376 n1_m1_88000_470400 0 7.327711e-08
I14377 n1_m1_88000_475200 0 7.047654e-08
I14378 n1_m1_88000_480000 0 1.058585e-07
I14379 n1_m1_88000_484800 0 7.375738e-08
I14380 n1_m1_88000_489600 0 1.117569e-07
I14381 n1_m1_88000_494400 0 7.287625e-08
I14382 n1_m1_88000_499200 0 7.299325e-08
I14383 n1_m1_88000_504000 0 1.093715e-07
I14384 n1_m1_88000_508800 0 7.109592e-08
I14385 n1_m1_88000_513600 0 1.049280e-07
I14386 n1_m1_88000_518400 0 7.022167e-08
I14387 n1_m1_88000_523200 0 7.264587e-08
I14388 n1_m1_88000_528000 0 1.093606e-07
I14389 n1_m1_88000_532800 0 7.026748e-08
I14390 n1_m1_88000_537600 0 1.115552e-07
I14391 n1_m1_88000_542400 0 9.264030e-08
I14392 n1_m1_88000_547200 0 9.748142e-08
I14393 n1_m1_88000_552000 0 1.477317e-07
I14394 n1_m1_88000_556800 0 8.472253e-08
I14395 n1_m1_88000_561600 0 3.999663e-08
I14396 n1_m1_116000_0 0 1.693723e-07
I14397 n1_m1_116000_4800 0 1.938855e-07
I14398 n1_m1_116000_9600 0 2.919132e-07
I14399 n1_m1_116000_14400 0 1.674878e-07
I14400 n1_m1_116000_19200 0 1.567920e-07
I14401 n1_m1_116000_24000 0 2.184551e-07
I14402 n1_m1_116000_28800 0 1.421207e-07
I14403 n1_m1_116000_33600 0 2.198491e-07
I14404 n1_m1_116000_38400 0 1.465661e-07
I14405 n1_m1_116000_43200 0 1.443968e-07
I14406 n1_m1_116000_48000 0 2.112757e-07
I14407 n1_m1_116000_52800 0 1.399040e-07
I14408 n1_m1_116000_57600 0 2.098560e-07
I14409 n1_m1_116000_62400 0 1.399040e-07
I14410 n1_m1_116000_67200 0 1.401732e-07
I14411 n1_m1_116000_72000 0 2.155552e-07
I14412 n1_m1_116000_76800 0 1.477410e-07
I14413 n1_m1_116000_81600 0 2.214829e-07
I14414 n1_m1_116000_86400 0 1.537440e-07
I14415 n1_m1_116000_91200 0 1.518649e-07
I14416 n1_m1_116000_96000 0 2.380188e-07
I14417 n1_m1_116000_100800 0 1.827544e-07
I14418 n1_m1_116000_105600 0 2.503860e-07
I14419 n1_m1_116000_110400 0 1.526996e-07
I14420 n1_m1_116000_115200 0 1.571628e-07
I14421 n1_m1_116000_120000 0 2.451616e-07
I14422 n1_m1_116000_124800 0 1.513443e-07
I14423 n1_m1_116000_129600 0 2.350603e-07
I14424 n1_m1_116000_134400 0 1.545558e-07
I14425 n1_m1_116000_139200 0 1.459964e-07
I14426 n1_m1_116000_144000 0 2.353987e-07
I14427 n1_m1_116000_148800 0 1.684727e-07
I14428 n1_m1_116000_153600 0 2.475136e-07
I14429 n1_m1_116000_158400 0 1.540751e-07
I14430 n1_m1_116000_163200 0 1.463685e-07
I14431 n1_m1_116000_168000 0 2.156875e-07
I14432 n1_m1_116000_172800 0 1.482940e-07
I14433 n1_m1_116000_177600 0 2.180171e-07
I14434 n1_m1_116000_182400 0 1.424052e-07
I14435 n1_m1_116000_187200 0 1.416086e-07
I14436 n1_m1_116000_192000 0 2.144258e-07
I14437 n1_m1_116000_196800 0 1.465661e-07
I14438 n1_m1_116000_201600 0 2.265586e-07
I14439 n1_m1_116000_206400 0 1.531867e-07
I14440 n1_m1_116000_211200 0 1.527211e-07
I14441 n1_m1_116000_216000 0 2.682046e-07
I14442 n1_m1_116000_220800 0 2.694404e-07
I14443 n1_m1_116000_225600 0 5.703160e-07
I14444 n1_m1_116000_230400 0 2.730498e-07
I14445 n1_m1_116000_235200 0 1.742436e-07
I14446 n1_m1_116000_240000 0 2.431169e-07
I14447 n1_m1_116000_244800 0 1.547453e-07
I14448 n1_m1_116000_249600 0 2.287333e-07
I14449 n1_m1_116000_254400 0 1.543604e-07
I14450 n1_m1_116000_259200 0 1.548878e-07
I14451 n1_m1_116000_264000 0 2.316838e-07
I14452 n1_m1_116000_268800 0 1.512119e-07
I14453 n1_m1_116000_273600 0 2.260904e-07
I14454 n1_m1_116000_278400 0 1.502751e-07
I14455 n1_m1_116000_283200 0 1.499594e-07
I14456 n1_m1_116000_288000 0 2.259016e-07
I14457 n1_m1_116000_292800 0 1.465661e-07
I14458 n1_m1_116000_297600 0 2.198491e-07
I14459 n1_m1_116000_302400 0 1.465661e-07
I14460 n1_m1_116000_307200 0 1.422393e-07
I14461 n1_m1_116000_312000 0 2.180380e-07
I14462 n1_m1_116000_316800 0 1.671129e-07
I14463 n1_m1_116000_321600 0 4.275063e-07
I14464 n1_m1_116000_326400 0 2.747434e-07
I14465 n1_m1_116000_331200 0 3.284066e-07
I14466 n1_m1_116000_336000 0 2.914595e-07
I14467 n1_m1_116000_340800 0 1.879858e-07
I14468 n1_m1_116000_345600 0 2.719979e-07
I14469 n1_m1_116000_350400 0 1.768418e-07
I14470 n1_m1_116000_355200 0 2.313586e-07
I14471 n1_m1_116000_360000 0 3.120573e-07
I14472 n1_m1_116000_364800 0 1.525193e-07
I14473 n1_m1_116000_369600 0 2.151304e-07
I14474 n1_m1_116000_374400 0 1.443368e-07
I14475 n1_m1_116000_379200 0 1.441225e-07
I14476 n1_m1_116000_384000 0 2.249382e-07
I14477 n1_m1_116000_388800 0 1.622611e-07
I14478 n1_m1_116000_393600 0 2.978746e-07
I14479 n1_m1_116000_398400 0 7.997509e-07
I14480 n1_m1_116000_403200 0 1.042463e-06
I14481 n1_m1_116000_408000 0 1.726414e-06
I14482 n1_m1_116000_412800 0 1.086279e-06
I14483 n1_m1_116000_417600 0 1.518141e-06
I14484 n1_m1_116000_422400 0 8.022609e-07
I14485 n1_m1_116000_427200 0 4.381951e-07
I14486 n1_m1_116000_432000 0 7.661747e-07
I14487 n1_m1_116000_436800 0 1.703419e-07
I14488 n1_m1_116000_441600 0 2.355418e-07
I14489 n1_m1_116000_446400 0 1.510235e-07
I14490 n1_m1_116000_451200 0 1.563424e-07
I14491 n1_m1_116000_456000 0 2.394692e-07
I14492 n1_m1_116000_460800 0 1.507269e-07
I14493 n1_m1_116000_465600 0 2.189257e-07
I14494 n1_m1_116000_470400 0 1.455189e-07
I14495 n1_m1_116000_475200 0 1.409531e-07
I14496 n1_m1_116000_480000 0 2.098560e-07
I14497 n1_m1_116000_484800 0 1.399040e-07
I14498 n1_m1_116000_489600 0 2.098560e-07
I14499 n1_m1_116000_494400 0 1.399040e-07
I14500 n1_m1_116000_499200 0 1.399040e-07
I14501 n1_m1_116000_504000 0 2.098560e-07
I14502 n1_m1_116000_508800 0 1.399040e-07
I14503 n1_m1_116000_513600 0 2.098560e-07
I14504 n1_m1_116000_518400 0 1.399040e-07
I14505 n1_m1_116000_523200 0 1.399952e-07
I14506 n1_m1_116000_528000 0 2.124485e-07
I14507 n1_m1_116000_532800 0 1.400353e-07
I14508 n1_m1_116000_537600 0 2.151519e-07
I14509 n1_m1_116000_542400 0 1.597299e-07
I14510 n1_m1_116000_547200 0 1.820292e-07
I14511 n1_m1_116000_552000 0 2.875336e-07
I14512 n1_m1_116000_556800 0 1.681053e-07
I14513 n1_m1_116000_561600 0 8.266568e-08
I14514 n1_m1_172000_0 0 1.025393e-07
I14515 n1_m1_172000_4800 0 1.428722e-07
I14516 n1_m1_172000_9600 0 1.952598e-07
I14517 n1_m1_172000_14400 0 8.791814e-08
I14518 n1_m1_172000_19200 0 8.279458e-08
I14519 n1_m1_172000_24000 0 1.184596e-07
I14520 n1_m1_172000_28800 0 7.728799e-08
I14521 n1_m1_172000_33600 0 1.215263e-07
I14522 n1_m1_172000_38400 0 7.501712e-08
I14523 n1_m1_172000_43200 0 6.995199e-08
I14524 n1_m1_172000_48000 0 1.107544e-07
I14525 n1_m1_172000_52800 0 7.138043e-08
I14526 n1_m1_172000_57600 0 1.055829e-07
I14527 n1_m1_172000_62400 0 7.257396e-08
I14528 n1_m1_172000_67200 0 7.167959e-08
I14529 n1_m1_172000_72000 0 1.150189e-07
I14530 n1_m1_172000_76800 0 7.228383e-08
I14531 n1_m1_172000_81600 0 1.154526e-07
I14532 n1_m1_172000_86400 0 7.365052e-08
I14533 n1_m1_172000_91200 0 7.756940e-08
I14534 n1_m1_172000_96000 0 1.316847e-07
I14535 n1_m1_172000_100800 0 8.536780e-08
I14536 n1_m1_172000_105600 0 1.235963e-07
I14537 n1_m1_172000_110400 0 8.991946e-08
I14538 n1_m1_172000_115200 0 9.818978e-08
I14539 n1_m1_172000_120000 0 1.519657e-07
I14540 n1_m1_172000_124800 0 7.792093e-08
I14541 n1_m1_172000_129600 0 1.120985e-07
I14542 n1_m1_172000_134400 0 7.961059e-08
I14543 n1_m1_172000_139200 0 9.472273e-08
I14544 n1_m1_172000_144000 0 1.556232e-07
I14545 n1_m1_172000_148800 0 1.001065e-07
I14546 n1_m1_172000_153600 0 1.235777e-07
I14547 n1_m1_172000_158400 0 7.853807e-08
I14548 n1_m1_172000_163200 0 7.228920e-08
I14549 n1_m1_172000_168000 0 1.153212e-07
I14550 n1_m1_172000_172800 0 7.097836e-08
I14551 n1_m1_172000_177600 0 1.076630e-07
I14552 n1_m1_172000_182400 0 7.130930e-08
I14553 n1_m1_172000_187200 0 7.434399e-08
I14554 n1_m1_172000_192000 0 1.126362e-07
I14555 n1_m1_172000_196800 0 7.129745e-08
I14556 n1_m1_172000_201600 0 1.052761e-07
I14557 n1_m1_172000_206400 0 7.392551e-08
I14558 n1_m1_172000_211200 0 8.974310e-08
I14559 n1_m1_172000_216000 0 4.471242e-07
I14560 n1_m1_172000_220800 0 5.729527e-07
I14561 n1_m1_172000_225600 0 1.013502e-06
I14562 n1_m1_172000_230400 0 6.347532e-07
I14563 n1_m1_172000_235200 0 4.640655e-07
I14564 n1_m1_172000_240000 0 2.142209e-07
I14565 n1_m1_172000_244800 0 8.134588e-08
I14566 n1_m1_172000_249600 0 1.107990e-07
I14567 n1_m1_172000_254400 0 7.391708e-08
I14568 n1_m1_172000_259200 0 7.608989e-08
I14569 n1_m1_172000_264000 0 1.107659e-07
I14570 n1_m1_172000_268800 0 7.067441e-08
I14571 n1_m1_172000_273600 0 1.123258e-07
I14572 n1_m1_172000_278400 0 8.075074e-08
I14573 n1_m1_172000_283200 0 7.543834e-08
I14574 n1_m1_172000_288000 0 1.076712e-07
I14575 n1_m1_172000_292800 0 7.207390e-08
I14576 n1_m1_172000_297600 0 1.113913e-07
I14577 n1_m1_172000_302400 0 8.137814e-08
I14578 n1_m1_172000_307200 0 7.667170e-08
I14579 n1_m1_172000_312000 0 2.011247e-07
I14580 n1_m1_172000_316800 0 2.867155e-07
I14581 n1_m1_172000_321600 0 8.421764e-07
I14582 n1_m1_172000_326400 0 5.634651e-07
I14583 n1_m1_172000_331200 0 4.131228e-07
I14584 n1_m1_172000_336000 0 3.422350e-07
I14585 n1_m1_172000_340800 0 1.049163e-07
I14586 n1_m1_172000_345600 0 1.204717e-07
I14587 n1_m1_172000_350400 0 7.126719e-08
I14588 n1_m1_172000_355200 0 6.833981e-08
I14589 n1_m1_172000_360000 0 1.036687e-07
I14590 n1_m1_172000_364800 0 7.241783e-08
I14591 n1_m1_172000_369600 0 1.098497e-07
I14592 n1_m1_172000_374400 0 7.395002e-08
I14593 n1_m1_172000_379200 0 7.702586e-08
I14594 n1_m1_172000_384000 0 1.204896e-07
I14595 n1_m1_172000_388800 0 8.642456e-08
I14596 n1_m1_172000_393600 0 2.008431e-07
I14597 n1_m1_172000_398400 0 2.212636e-07
I14598 n1_m1_172000_403200 0 1.650892e-07
I14599 n1_m1_172000_408000 0 1.927876e-07
I14600 n1_m1_172000_412800 0 2.186832e-07
I14601 n1_m1_172000_417600 0 4.166941e-07
I14602 n1_m1_172000_422400 0 3.815233e-07
I14603 n1_m1_172000_427200 0 2.376020e-07
I14604 n1_m1_172000_432000 0 1.581086e-07
I14605 n1_m1_172000_436800 0 8.530325e-08
I14606 n1_m1_172000_441600 0 1.204476e-07
I14607 n1_m1_172000_446400 0 7.506710e-08
I14608 n1_m1_172000_451200 0 8.107721e-08
I14609 n1_m1_172000_456000 0 1.240608e-07
I14610 n1_m1_172000_460800 0 7.512045e-08
I14611 n1_m1_172000_465600 0 1.061950e-07
I14612 n1_m1_172000_470400 0 7.024115e-08
I14613 n1_m1_172000_475200 0 7.025507e-08
I14614 n1_m1_172000_480000 0 1.050849e-07
I14615 n1_m1_172000_484800 0 7.090017e-08
I14616 n1_m1_172000_489600 0 1.078795e-07
I14617 n1_m1_172000_494400 0 6.995199e-08
I14618 n1_m1_172000_499200 0 6.995199e-08
I14619 n1_m1_172000_504000 0 1.075152e-07
I14620 n1_m1_172000_508800 0 7.109592e-08
I14621 n1_m1_172000_513600 0 1.049280e-07
I14622 n1_m1_172000_518400 0 6.995199e-08
I14623 n1_m1_172000_523200 0 7.007349e-08
I14624 n1_m1_172000_528000 0 1.091125e-07
I14625 n1_m1_172000_532800 0 7.269921e-08
I14626 n1_m1_172000_537600 0 1.070405e-07
I14627 n1_m1_172000_542400 0 7.894344e-08
I14628 n1_m1_172000_547200 0 9.761022e-08
I14629 n1_m1_172000_552000 0 1.630121e-07
I14630 n1_m1_172000_556800 0 8.770967e-08
I14631 n1_m1_172000_561600 0 4.316136e-08
I14632 n1_m1_200000_0 0 9.392980e-08
I14633 n1_m1_200000_4800 0 1.102199e-07
I14634 n1_m1_200000_9600 0 1.593621e-07
I14635 n1_m1_200000_14400 0 8.499415e-08
I14636 n1_m1_200000_19200 0 7.873218e-08
I14637 n1_m1_200000_24000 0 1.092694e-07
I14638 n1_m1_200000_28800 0 7.185910e-08
I14639 n1_m1_200000_33600 0 1.118274e-07
I14640 n1_m1_200000_38400 0 7.905286e-08
I14641 n1_m1_200000_43200 0 1.008418e-07
I14642 n1_m1_200000_48000 0 2.237216e-07
I14643 n1_m1_200000_52800 0 2.446934e-07
I14644 n1_m1_200000_57600 0 6.178377e-07
I14645 n1_m1_200000_62400 0 5.300008e-07
I14646 n1_m1_200000_67200 0 5.611905e-07
I14647 n1_m1_200000_72000 0 9.454396e-07
I14648 n1_m1_200000_76800 0 6.321469e-07
I14649 n1_m1_200000_81600 0 7.903486e-07
I14650 n1_m1_200000_86400 0 5.599738e-07
I14651 n1_m1_200000_91200 0 5.474966e-07
I14652 n1_m1_200000_96000 0 4.478723e-07
I14653 n1_m1_200000_100800 0 1.023784e-07
I14654 n1_m1_200000_105600 0 1.977421e-07
I14655 n1_m1_200000_110400 0 1.053962e-07
I14656 n1_m1_200000_115200 0 1.032313e-07
I14657 n1_m1_200000_120000 0 1.887093e-07
I14658 n1_m1_200000_124800 0 2.153334e-07
I14659 n1_m1_200000_129600 0 5.971790e-07
I14660 n1_m1_200000_134400 0 4.448280e-07
I14661 n1_m1_200000_139200 0 6.078239e-07
I14662 n1_m1_200000_144000 0 7.350146e-07
I14663 n1_m1_200000_148800 0 2.968107e-07
I14664 n1_m1_200000_153600 0 2.168092e-07
I14665 n1_m1_200000_158400 0 8.361702e-08
I14666 n1_m1_200000_163200 0 7.431937e-08
I14667 n1_m1_200000_168000 0 1.141453e-07
I14668 n1_m1_200000_172800 0 7.550533e-08
I14669 n1_m1_200000_177600 0 1.147838e-07
I14670 n1_m1_200000_182400 0 7.525677e-08
I14671 n1_m1_200000_187200 0 7.251847e-08
I14672 n1_m1_200000_192000 0 1.079704e-07
I14673 n1_m1_200000_196800 0 7.725421e-08
I14674 n1_m1_200000_201600 0 1.235896e-07
I14675 n1_m1_200000_206400 0 8.635532e-08
I14676 n1_m1_200000_211200 0 9.218031e-08
I14677 n1_m1_200000_216000 0 2.544754e-07
I14678 n1_m1_200000_220800 0 3.910726e-07
I14679 n1_m1_200000_225600 0 9.009489e-07
I14680 n1_m1_200000_230400 0 4.684834e-07
I14681 n1_m1_200000_235200 0 2.347107e-07
I14682 n1_m1_200000_240000 0 1.434444e-07
I14683 n1_m1_200000_244800 0 8.088736e-08
I14684 n1_m1_200000_249600 0 1.150685e-07
I14685 n1_m1_200000_254400 0 7.846784e-08
I14686 n1_m1_200000_259200 0 7.729322e-08
I14687 n1_m1_200000_264000 0 1.134976e-07
I14688 n1_m1_200000_268800 0 7.356281e-08
I14689 n1_m1_200000_273600 0 1.099246e-07
I14690 n1_m1_200000_278400 0 7.459006e-08
I14691 n1_m1_200000_283200 0 7.767513e-08
I14692 n1_m1_200000_288000 0 1.131877e-07
I14693 n1_m1_200000_292800 0 7.371189e-08
I14694 n1_m1_200000_297600 0 1.154144e-07
I14695 n1_m1_200000_302400 0 7.655481e-08
I14696 n1_m1_200000_307200 0 8.121906e-08
I14697 n1_m1_200000_312000 0 2.250398e-07
I14698 n1_m1_200000_316800 0 2.200331e-07
I14699 n1_m1_200000_321600 0 5.926789e-07
I14700 n1_m1_200000_326400 0 3.355138e-07
I14701 n1_m1_200000_331200 0 1.582124e-07
I14702 n1_m1_200000_336000 0 1.473335e-07
I14703 n1_m1_200000_340800 0 7.569073e-08
I14704 n1_m1_200000_345600 0 1.103911e-07
I14705 n1_m1_200000_350400 0 7.232688e-08
I14706 n1_m1_200000_355200 0 7.561032e-08
I14707 n1_m1_200000_360000 0 1.113204e-07
I14708 n1_m1_200000_364800 0 7.056545e-08
I14709 n1_m1_200000_369600 0 1.051391e-07
I14710 n1_m1_200000_374400 0 7.144786e-08
I14711 n1_m1_200000_379200 0 7.470465e-08
I14712 n1_m1_200000_384000 0 1.231286e-07
I14713 n1_m1_200000_388800 0 8.503279e-08
I14714 n1_m1_200000_393600 0 1.426014e-07
I14715 n1_m1_200000_398400 0 9.626397e-08
I14716 n1_m1_200000_403200 0 8.405856e-08
I14717 n1_m1_200000_408000 0 2.507728e-07
I14718 n1_m1_200000_412800 0 2.743549e-07
I14719 n1_m1_200000_417600 0 5.547161e-07
I14720 n1_m1_200000_422400 0 1.867429e-07
I14721 n1_m1_200000_427200 0 1.043477e-07
I14722 n1_m1_200000_432000 0 1.725186e-07
I14723 n1_m1_200000_436800 0 8.079571e-08
I14724 n1_m1_200000_441600 0 1.170931e-07
I14725 n1_m1_200000_446400 0 8.096949e-08
I14726 n1_m1_200000_451200 0 8.284279e-08
I14727 n1_m1_200000_456000 0 1.146075e-07
I14728 n1_m1_200000_460800 0 7.530477e-08
I14729 n1_m1_200000_465600 0 1.194805e-07
I14730 n1_m1_200000_470400 0 8.318419e-08
I14731 n1_m1_200000_475200 0 8.264922e-08
I14732 n1_m1_200000_480000 0 1.195214e-07
I14733 n1_m1_200000_484800 0 7.849259e-08
I14734 n1_m1_200000_489600 0 1.153393e-07
I14735 n1_m1_200000_494400 0 7.377812e-08
I14736 n1_m1_200000_499200 0 7.328303e-08
I14737 n1_m1_200000_504000 0 1.099246e-07
I14738 n1_m1_200000_508800 0 7.389402e-08
I14739 n1_m1_200000_513600 0 1.112037e-07
I14740 n1_m1_200000_518400 0 7.322529e-08
I14741 n1_m1_200000_523200 0 7.142928e-08
I14742 n1_m1_200000_528000 0 1.086074e-07
I14743 n1_m1_200000_532800 0 7.012684e-08
I14744 n1_m1_200000_537600 0 1.107286e-07
I14745 n1_m1_200000_542400 0 1.042023e-07
I14746 n1_m1_200000_547200 0 1.580799e-07
I14747 n1_m1_200000_552000 0 2.480388e-07
I14748 n1_m1_200000_556800 0 9.778894e-08
I14749 n1_m1_200000_561600 0 4.628716e-08
I14750 n1_m1_228000_0 0 1.309134e-07
I14751 n1_m1_228000_4800 0 2.402360e-07
I14752 n1_m1_228000_9600 0 6.406925e-07
I14753 n1_m1_228000_14400 0 4.137813e-07
I14754 n1_m1_228000_19200 0 2.757248e-07
I14755 n1_m1_228000_24000 0 1.751046e-07
I14756 n1_m1_228000_28800 0 8.105757e-08
I14757 n1_m1_228000_33600 0 1.220962e-07
I14758 n1_m1_228000_38400 0 8.372194e-08
I14759 n1_m1_228000_43200 0 8.094313e-08
I14760 n1_m1_228000_48000 0 1.172291e-07
I14761 n1_m1_228000_52800 0 7.774275e-08
I14762 n1_m1_228000_57600 0 1.163379e-07
I14763 n1_m1_228000_62400 0 8.321992e-08
I14764 n1_m1_228000_67200 0 9.190141e-08
I14765 n1_m1_228000_72000 0 1.466007e-07
I14766 n1_m1_228000_76800 0 8.763462e-08
I14767 n1_m1_228000_81600 0 1.274020e-07
I14768 n1_m1_228000_86400 0 8.665024e-08
I14769 n1_m1_228000_91200 0 8.864277e-08
I14770 n1_m1_228000_96000 0 1.328124e-07
I14771 n1_m1_228000_100800 0 8.605093e-08
I14772 n1_m1_228000_105600 0 1.421426e-07
I14773 n1_m1_228000_110400 0 7.579187e-08
I14774 n1_m1_228000_115200 0 7.471147e-08
I14775 n1_m1_228000_120000 0 1.149228e-07
I14776 n1_m1_228000_124800 0 9.272792e-08
I14777 n1_m1_228000_129600 0 1.397487e-07
I14778 n1_m1_228000_134400 0 2.782208e-07
I14779 n1_m1_228000_139200 0 4.456266e-07
I14780 n1_m1_228000_144000 0 7.952200e-07
I14781 n1_m1_228000_148800 0 6.044258e-07
I14782 n1_m1_228000_153600 0 5.731049e-07
I14783 n1_m1_228000_158400 0 1.944135e-07
I14784 n1_m1_228000_163200 0 9.825870e-08
I14785 n1_m1_228000_168000 0 1.093464e-07
I14786 n1_m1_228000_172800 0 7.940720e-08
I14787 n1_m1_228000_177600 0 1.183275e-07
I14788 n1_m1_228000_182400 0 8.329820e-08
I14789 n1_m1_228000_187200 0 8.595803e-08
I14790 n1_m1_228000_192000 0 1.210557e-07
I14791 n1_m1_228000_196800 0 1.295463e-07
I14792 n1_m1_228000_201600 0 2.197557e-07
I14793 n1_m1_228000_206400 0 1.526347e-07
I14794 n1_m1_228000_211200 0 1.643282e-07
I14795 n1_m1_228000_216000 0 2.149672e-07
I14796 n1_m1_228000_220800 0 1.760699e-07
I14797 n1_m1_228000_225600 0 2.794368e-07
I14798 n1_m1_228000_230400 0 1.580950e-07
I14799 n1_m1_228000_235200 0 1.448438e-07
I14800 n1_m1_228000_240000 0 3.450930e-07
I14801 n1_m1_228000_244800 0 1.547643e-07
I14802 n1_m1_228000_249600 0 1.664427e-07
I14803 n1_m1_228000_254400 0 8.829646e-08
I14804 n1_m1_228000_259200 0 8.526176e-08
I14805 n1_m1_228000_264000 0 1.140288e-07
I14806 n1_m1_228000_268800 0 7.402393e-08
I14807 n1_m1_228000_273600 0 1.164385e-07
I14808 n1_m1_228000_278400 0 7.478531e-08
I14809 n1_m1_228000_283200 0 7.685980e-08
I14810 n1_m1_228000_288000 0 1.098104e-07
I14811 n1_m1_228000_292800 0 7.723083e-08
I14812 n1_m1_228000_297600 0 1.150445e-07
I14813 n1_m1_228000_302400 0 7.991856e-08
I14814 n1_m1_228000_307200 0 9.210240e-08
I14815 n1_m1_228000_312000 0 3.713477e-07
I14816 n1_m1_228000_316800 0 2.234126e-07
I14817 n1_m1_228000_321600 0 5.262911e-07
I14818 n1_m1_228000_326400 0 3.592969e-07
I14819 n1_m1_228000_331200 0 1.551009e-07
I14820 n1_m1_228000_336000 0 1.453260e-07
I14821 n1_m1_228000_340800 0 7.643096e-08
I14822 n1_m1_228000_345600 0 1.094946e-07
I14823 n1_m1_228000_350400 0 7.180995e-08
I14824 n1_m1_228000_355200 0 7.328303e-08
I14825 n1_m1_228000_360000 0 1.070114e-07
I14826 n1_m1_228000_364800 0 7.379793e-08
I14827 n1_m1_228000_369600 0 1.180815e-07
I14828 n1_m1_228000_374400 0 8.268939e-08
I14829 n1_m1_228000_379200 0 8.572408e-08
I14830 n1_m1_228000_384000 0 1.283196e-07
I14831 n1_m1_228000_388800 0 7.921751e-08
I14832 n1_m1_228000_393600 0 1.247112e-07
I14833 n1_m1_228000_398400 0 8.511014e-08
I14834 n1_m1_228000_403200 0 9.246763e-08
I14835 n1_m1_228000_408000 0 5.416310e-07
I14836 n1_m1_228000_412800 0 4.646865e-07
I14837 n1_m1_228000_417600 0 8.659103e-07
I14838 n1_m1_228000_422400 0 3.515528e-07
I14839 n1_m1_228000_427200 0 1.435539e-07
I14840 n1_m1_228000_432000 0 1.405108e-07
I14841 n1_m1_228000_436800 0 7.195536e-08
I14842 n1_m1_228000_441600 0 1.121942e-07
I14843 n1_m1_228000_446400 0 7.547015e-08
I14844 n1_m1_228000_451200 0 7.300563e-08
I14845 n1_m1_228000_456000 0 1.068038e-07
I14846 n1_m1_228000_460800 0 7.213910e-08
I14847 n1_m1_228000_465600 0 1.057258e-07
I14848 n1_m1_228000_470400 0 6.995199e-08
I14849 n1_m1_228000_475200 0 6.995199e-08
I14850 n1_m1_228000_480000 0 1.058585e-07
I14851 n1_m1_228000_484800 0 7.298163e-08
I14852 n1_m1_228000_489600 0 1.089180e-07
I14853 n1_m1_228000_494400 0 7.328303e-08
I14854 n1_m1_228000_499200 0 7.245411e-08
I14855 n1_m1_228000_504000 0 1.057554e-07
I14856 n1_m1_228000_508800 0 6.995199e-08
I14857 n1_m1_228000_513600 0 1.053458e-07
I14858 n1_m1_228000_518400 0 7.279405e-08
I14859 n1_m1_228000_523200 0 7.328303e-08
I14860 n1_m1_228000_528000 0 1.096732e-07
I14861 n1_m1_228000_532800 0 7.239964e-08
I14862 n1_m1_228000_537600 0 1.130735e-07
I14863 n1_m1_228000_542400 0 8.844508e-08
I14864 n1_m1_228000_547200 0 1.188407e-07
I14865 n1_m1_228000_552000 0 1.967645e-07
I14866 n1_m1_228000_556800 0 8.844651e-08
I14867 n1_m1_228000_561600 0 4.298109e-08
I14868 n1_m1_256000_0 0 1.369934e-07
I14869 n1_m1_256000_4800 0 2.157562e-07
I14870 n1_m1_256000_9600 0 3.119594e-07
I14871 n1_m1_256000_14400 0 9.622666e-08
I14872 n1_m1_256000_19200 0 7.964485e-08
I14873 n1_m1_256000_24000 0 1.154834e-07
I14874 n1_m1_256000_28800 0 7.047759e-08
I14875 n1_m1_256000_33600 0 1.099971e-07
I14876 n1_m1_256000_38400 0 7.661408e-08
I14877 n1_m1_256000_43200 0 7.481872e-08
I14878 n1_m1_256000_48000 0 1.097621e-07
I14879 n1_m1_256000_52800 0 7.325889e-08
I14880 n1_m1_256000_57600 0 1.112344e-07
I14881 n1_m1_256000_62400 0 7.996523e-08
I14882 n1_m1_256000_67200 0 8.224588e-08
I14883 n1_m1_256000_72000 0 1.137171e-07
I14884 n1_m1_256000_76800 0 6.921132e-08
I14885 n1_m1_256000_81600 0 1.044894e-07
I14886 n1_m1_256000_86400 0 7.520342e-08
I14887 n1_m1_256000_91200 0 7.516418e-08
I14888 n1_m1_256000_96000 0 1.070440e-07
I14889 n1_m1_256000_100800 0 6.995199e-08
I14890 n1_m1_256000_105600 0 1.028601e-07
I14891 n1_m1_256000_110400 0 7.517867e-08
I14892 n1_m1_256000_115200 0 7.484445e-08
I14893 n1_m1_256000_120000 0 1.248002e-07
I14894 n1_m1_256000_124800 0 1.146354e-07
I14895 n1_m1_256000_129600 0 2.439583e-07
I14896 n1_m1_256000_134400 0 9.624324e-08
I14897 n1_m1_256000_139200 0 1.729253e-07
I14898 n1_m1_256000_144000 0 6.343672e-07
I14899 n1_m1_256000_148800 0 5.766137e-07
I14900 n1_m1_256000_153600 0 6.280739e-07
I14901 n1_m1_256000_158400 0 3.454371e-07
I14902 n1_m1_256000_163200 0 1.454337e-07
I14903 n1_m1_256000_168000 0 1.801032e-07
I14904 n1_m1_256000_172800 0 1.074210e-07
I14905 n1_m1_256000_177600 0 3.392171e-07
I14906 n1_m1_256000_182400 0 2.643686e-07
I14907 n1_m1_256000_187200 0 9.577309e-08
I14908 n1_m1_256000_192000 0 2.627305e-07
I14909 n1_m1_256000_196800 0 3.270494e-07
I14910 n1_m1_256000_201600 0 4.729501e-07
I14911 n1_m1_256000_206400 0 3.079046e-07
I14912 n1_m1_256000_211200 0 3.107990e-07
I14913 n1_m1_256000_216000 0 4.592142e-07
I14914 n1_m1_256000_220800 0 2.884078e-07
I14915 n1_m1_256000_225600 0 2.952200e-07
I14916 n1_m1_256000_230400 0 3.418419e-07
I14917 n1_m1_256000_235200 0 4.266323e-07
I14918 n1_m1_256000_240000 0 2.469088e-07
I14919 n1_m1_256000_244800 0 1.083216e-07
I14920 n1_m1_256000_249600 0 2.272205e-07
I14921 n1_m1_256000_254400 0 1.580335e-07
I14922 n1_m1_256000_259200 0 1.237792e-07
I14923 n1_m1_256000_264000 0 1.452618e-07
I14924 n1_m1_256000_268800 0 8.675420e-08
I14925 n1_m1_256000_273600 0 1.213390e-07
I14926 n1_m1_256000_278400 0 8.175883e-08
I14927 n1_m1_256000_283200 0 8.645904e-08
I14928 n1_m1_256000_288000 0 1.246641e-07
I14929 n1_m1_256000_292800 0 8.574812e-08
I14930 n1_m1_256000_297600 0 1.402492e-07
I14931 n1_m1_256000_302400 0 1.354972e-07
I14932 n1_m1_256000_307200 0 1.614319e-07
I14933 n1_m1_256000_312000 0 3.133984e-07
I14934 n1_m1_256000_316800 0 2.315246e-07
I14935 n1_m1_256000_321600 0 4.155899e-07
I14936 n1_m1_256000_326400 0 2.504387e-07
I14937 n1_m1_256000_331200 0 2.456013e-07
I14938 n1_m1_256000_336000 0 2.615543e-07
I14939 n1_m1_256000_340800 0 9.362273e-08
I14940 n1_m1_256000_345600 0 1.303701e-07
I14941 n1_m1_256000_350400 0 8.361490e-08
I14942 n1_m1_256000_355200 0 7.854972e-08
I14943 n1_m1_256000_360000 0 1.183950e-07
I14944 n1_m1_256000_364800 0 8.554972e-08
I14945 n1_m1_256000_369600 0 1.218096e-07
I14946 n1_m1_256000_374400 0 8.463665e-08
I14947 n1_m1_256000_379200 0 8.395944e-08
I14948 n1_m1_256000_384000 0 1.402971e-07
I14949 n1_m1_256000_388800 0 1.133173e-07
I14950 n1_m1_256000_393600 0 1.162484e-07
I14951 n1_m1_256000_398400 0 8.889221e-08
I14952 n1_m1_256000_403200 0 9.358626e-08
I14953 n1_m1_256000_408000 0 4.215053e-07
I14954 n1_m1_256000_412800 0 2.988258e-07
I14955 n1_m1_256000_417600 0 2.582892e-07
I14956 n1_m1_256000_422400 0 1.036536e-07
I14957 n1_m1_256000_427200 0 8.233927e-08
I14958 n1_m1_256000_432000 0 1.155795e-07
I14959 n1_m1_256000_436800 0 7.520401e-08
I14960 n1_m1_256000_441600 0 1.054647e-07
I14961 n1_m1_256000_446400 0 7.362472e-08
I14962 n1_m1_256000_451200 0 7.363866e-08
I14963 n1_m1_256000_456000 0 1.054789e-07
I14964 n1_m1_256000_460800 0 7.953142e-08
I14965 n1_m1_256000_465600 0 1.202442e-07
I14966 n1_m1_256000_470400 0 7.685673e-08
I14967 n1_m1_256000_475200 0 7.475292e-08
I14968 n1_m1_256000_480000 0 1.241959e-07
I14969 n1_m1_256000_484800 0 8.685719e-08
I14970 n1_m1_256000_489600 0 1.282752e-07
I14971 n1_m1_256000_494400 0 8.327618e-08
I14972 n1_m1_256000_499200 0 8.201370e-08
I14973 n1_m1_256000_504000 0 1.173305e-07
I14974 n1_m1_256000_508800 0 7.442697e-08
I14975 n1_m1_256000_513600 0 1.098043e-07
I14976 n1_m1_256000_518400 0 7.317954e-08
I14977 n1_m1_256000_523200 0 7.337478e-08
I14978 n1_m1_256000_528000 0 1.124117e-07
I14979 n1_m1_256000_532800 0 7.030960e-08
I14980 n1_m1_256000_537600 0 1.132358e-07
I14981 n1_m1_256000_542400 0 1.467771e-07
I14982 n1_m1_256000_547200 0 2.511809e-07
I14983 n1_m1_256000_552000 0 3.297387e-07
I14984 n1_m1_256000_556800 0 1.078549e-07
I14985 n1_m1_256000_561600 0 4.975877e-08
I14986 n1_m1_284000_0 0 2.503089e-07
I14987 n1_m1_284000_4800 0 4.516277e-07
I14988 n1_m1_284000_9600 0 1.179871e-06
I14989 n1_m1_284000_14400 0 5.825734e-07
I14990 n1_m1_284000_19200 0 2.200975e-07
I14991 n1_m1_284000_24000 0 2.437229e-07
I14992 n1_m1_284000_28800 0 1.593407e-07
I14993 n1_m1_284000_33600 0 2.296367e-07
I14994 n1_m1_284000_38400 0 1.515686e-07
I14995 n1_m1_284000_43200 0 1.524458e-07
I14996 n1_m1_284000_48000 0 2.491795e-07
I14997 n1_m1_284000_52800 0 1.643777e-07
I14998 n1_m1_284000_57600 0 2.667350e-07
I14999 n1_m1_284000_62400 0 2.071472e-07
I15000 n1_m1_284000_67200 0 1.844147e-07
I15001 n1_m1_284000_72000 0 2.780730e-07
I15002 n1_m1_284000_76800 0 1.842821e-07
I15003 n1_m1_284000_81600 0 2.615322e-07
I15004 n1_m1_284000_86400 0 1.689588e-07
I15005 n1_m1_284000_91200 0 1.769354e-07
I15006 n1_m1_284000_96000 0 3.004134e-07
I15007 n1_m1_284000_100800 0 2.043783e-07
I15008 n1_m1_284000_105600 0 2.932296e-07
I15009 n1_m1_284000_110400 0 1.718716e-07
I15010 n1_m1_284000_115200 0 2.228529e-07
I15011 n1_m1_284000_120000 0 8.210363e-07
I15012 n1_m1_284000_124800 0 5.125020e-07
I15013 n1_m1_284000_129600 0 8.631259e-07
I15014 n1_m1_284000_134400 0 5.666504e-07
I15015 n1_m1_284000_139200 0 9.364384e-07
I15016 n1_m1_284000_144000 0 1.845719e-06
I15017 n1_m1_284000_148800 0 1.320998e-06
I15018 n1_m1_284000_153600 0 1.974211e-06
I15019 n1_m1_284000_158400 0 1.317234e-06
I15020 n1_m1_284000_163200 0 1.057450e-06
I15021 n1_m1_284000_168000 0 1.638999e-06
I15022 n1_m1_284000_172800 0 9.472626e-07
I15023 n1_m1_284000_177600 0 1.278546e-06
I15024 n1_m1_284000_182400 0 9.947484e-07
I15025 n1_m1_284000_187200 0 9.816710e-07
I15026 n1_m1_284000_192000 0 1.274816e-06
I15027 n1_m1_284000_196800 0 7.443526e-07
I15028 n1_m1_284000_201600 0 1.390414e-06
I15029 n1_m1_284000_206400 0 1.246554e-06
I15030 n1_m1_284000_211200 0 1.157647e-06
I15031 n1_m1_284000_216000 0 1.681045e-06
I15032 n1_m1_284000_220800 0 9.524587e-07
I15033 n1_m1_284000_225600 0 1.478217e-06
I15034 n1_m1_284000_230400 0 1.217601e-06
I15035 n1_m1_284000_235200 0 1.270626e-06
I15036 n1_m1_284000_240000 0 1.513136e-06
I15037 n1_m1_284000_244800 0 8.823738e-07
I15038 n1_m1_284000_249600 0 1.499865e-06
I15039 n1_m1_284000_254400 0 1.128488e-06
I15040 n1_m1_284000_259200 0 1.272342e-06
I15041 n1_m1_284000_264000 0 1.804650e-06
I15042 n1_m1_284000_268800 0 9.633963e-07
I15043 n1_m1_284000_273600 0 1.562270e-06
I15044 n1_m1_284000_278400 0 1.166268e-06
I15045 n1_m1_284000_283200 0 1.123609e-06
I15046 n1_m1_284000_288000 0 1.603264e-06
I15047 n1_m1_284000_292800 0 7.888289e-07
I15048 n1_m1_284000_297600 0 1.301651e-06
I15049 n1_m1_284000_302400 0 9.854166e-07
I15050 n1_m1_284000_307200 0 1.062023e-06
I15051 n1_m1_284000_312000 0 1.858864e-06
I15052 n1_m1_284000_316800 0 1.183474e-06
I15053 n1_m1_284000_321600 0 1.729084e-06
I15054 n1_m1_284000_326400 0 9.995484e-07
I15055 n1_m1_284000_331200 0 1.068057e-06
I15056 n1_m1_284000_336000 0 1.443871e-06
I15057 n1_m1_284000_340800 0 8.836404e-07
I15058 n1_m1_284000_345600 0 1.264206e-06
I15059 n1_m1_284000_350400 0 6.183334e-07
I15060 n1_m1_284000_355200 0 5.281616e-07
I15061 n1_m1_284000_360000 0 6.193176e-07
I15062 n1_m1_284000_364800 0 3.283954e-07
I15063 n1_m1_284000_369600 0 7.928034e-07
I15064 n1_m1_284000_374400 0 6.199231e-07
I15065 n1_m1_284000_379200 0 5.372803e-07
I15066 n1_m1_284000_384000 0 6.259072e-07
I15067 n1_m1_284000_388800 0 2.307172e-07
I15068 n1_m1_284000_393600 0 3.372032e-07
I15069 n1_m1_284000_398400 0 1.940027e-07
I15070 n1_m1_284000_403200 0 1.907700e-07
I15071 n1_m1_284000_408000 0 4.570029e-07
I15072 n1_m1_284000_412800 0 2.652541e-07
I15073 n1_m1_284000_417600 0 2.675672e-07
I15074 n1_m1_284000_422400 0 1.669997e-07
I15075 n1_m1_284000_427200 0 1.584472e-07
I15076 n1_m1_284000_432000 0 2.241486e-07
I15077 n1_m1_284000_436800 0 1.465661e-07
I15078 n1_m1_284000_441600 0 2.225070e-07
I15079 n1_m1_284000_446400 0 1.485425e-07
I15080 n1_m1_284000_451200 0 1.465661e-07
I15081 n1_m1_284000_456000 0 2.220115e-07
I15082 n1_m1_284000_460800 0 1.524579e-07
I15083 n1_m1_284000_465600 0 2.935474e-07
I15084 n1_m1_284000_470400 0 2.347219e-07
I15085 n1_m1_284000_475200 0 1.814118e-07
I15086 n1_m1_284000_480000 0 2.425026e-07
I15087 n1_m1_284000_484800 0 1.580483e-07
I15088 n1_m1_284000_489600 0 2.252135e-07
I15089 n1_m1_284000_494400 0 1.488302e-07
I15090 n1_m1_284000_499200 0 1.465661e-07
I15091 n1_m1_284000_504000 0 2.179801e-07
I15092 n1_m1_284000_508800 0 1.413654e-07
I15093 n1_m1_284000_513600 0 2.106917e-07
I15094 n1_m1_284000_518400 0 1.455881e-07
I15095 n1_m1_284000_523200 0 1.463434e-07
I15096 n1_m1_284000_528000 0 2.115287e-07
I15097 n1_m1_284000_532800 0 1.403125e-07
I15098 n1_m1_284000_537600 0 3.617255e-07
I15099 n1_m1_284000_542400 0 5.154426e-07
I15100 n1_m1_284000_547200 0 5.700853e-07
I15101 n1_m1_284000_552000 0 4.968216e-07
I15102 n1_m1_284000_556800 0 2.010317e-07
I15103 n1_m1_284000_561600 0 9.478873e-08
I15104 n1_m1_340000_0 0 1.307062e-07
I15105 n1_m1_340000_4800 0 2.371722e-07
I15106 n1_m1_340000_9600 0 4.965028e-07
I15107 n1_m1_340000_14400 0 2.104503e-07
I15108 n1_m1_340000_19200 0 9.433141e-08
I15109 n1_m1_340000_24000 0 1.113918e-07
I15110 n1_m1_340000_28800 0 7.383426e-08
I15111 n1_m1_340000_33600 0 1.127175e-07
I15112 n1_m1_340000_38400 0 7.458108e-08
I15113 n1_m1_340000_43200 0 7.154639e-08
I15114 n1_m1_340000_48000 0 1.080019e-07
I15115 n1_m1_340000_52800 0 7.289445e-08
I15116 n1_m1_340000_57600 0 1.132365e-07
I15117 n1_m1_340000_62400 0 7.657240e-08
I15118 n1_m1_340000_67200 0 7.649540e-08
I15119 n1_m1_340000_72000 0 1.140345e-07
I15120 n1_m1_340000_76800 0 7.716531e-08
I15121 n1_m1_340000_81600 0 1.132956e-07
I15122 n1_m1_340000_86400 0 8.470225e-08
I15123 n1_m1_340000_91200 0 1.725604e-07
I15124 n1_m1_340000_96000 0 5.039062e-07
I15125 n1_m1_340000_100800 0 5.081311e-07
I15126 n1_m1_340000_105600 0 6.321735e-07
I15127 n1_m1_340000_110400 0 4.364991e-07
I15128 n1_m1_340000_115200 0 2.794894e-07
I15129 n1_m1_340000_120000 0 5.909938e-07
I15130 n1_m1_340000_124800 0 4.933610e-07
I15131 n1_m1_340000_129600 0 7.909385e-07
I15132 n1_m1_340000_134400 0 4.709799e-07
I15133 n1_m1_340000_139200 0 4.618226e-07
I15134 n1_m1_340000_144000 0 9.148798e-07
I15135 n1_m1_340000_148800 0 4.948557e-07
I15136 n1_m1_340000_153600 0 4.621129e-07
I15137 n1_m1_340000_158400 0 4.909450e-07
I15138 n1_m1_340000_163200 0 4.056448e-07
I15139 n1_m1_340000_168000 0 4.981384e-07
I15140 n1_m1_340000_172800 0 2.645239e-07
I15141 n1_m1_340000_177600 0 2.837011e-07
I15142 n1_m1_340000_182400 0 2.065086e-07
I15143 n1_m1_340000_187200 0 2.648763e-07
I15144 n1_m1_340000_192000 0 2.474699e-07
I15145 n1_m1_340000_196800 0 2.649882e-07
I15146 n1_m1_340000_201600 0 5.709174e-07
I15147 n1_m1_340000_206400 0 4.672389e-07
I15148 n1_m1_340000_211200 0 2.806943e-07
I15149 n1_m1_340000_216000 0 4.189640e-07
I15150 n1_m1_340000_220800 0 2.250684e-07
I15151 n1_m1_340000_225600 0 3.650512e-07
I15152 n1_m1_340000_230400 0 3.808570e-07
I15153 n1_m1_340000_235200 0 4.505070e-07
I15154 n1_m1_340000_240000 0 6.953383e-07
I15155 n1_m1_340000_244800 0 3.160215e-07
I15156 n1_m1_340000_249600 0 5.944195e-07
I15157 n1_m1_340000_254400 0 3.837719e-07
I15158 n1_m1_340000_259200 0 2.276277e-07
I15159 n1_m1_340000_264000 0 2.988269e-07
I15160 n1_m1_340000_268800 0 1.946433e-07
I15161 n1_m1_340000_273600 0 2.328135e-07
I15162 n1_m1_340000_278400 0 1.909774e-07
I15163 n1_m1_340000_283200 0 2.310062e-07
I15164 n1_m1_340000_288000 0 3.438292e-07
I15165 n1_m1_340000_292800 0 3.109341e-07
I15166 n1_m1_340000_297600 0 5.162566e-07
I15167 n1_m1_340000_302400 0 4.247611e-07
I15168 n1_m1_340000_307200 0 4.193599e-07
I15169 n1_m1_340000_312000 0 5.150556e-07
I15170 n1_m1_340000_316800 0 3.159623e-07
I15171 n1_m1_340000_321600 0 4.208301e-07
I15172 n1_m1_340000_326400 0 3.085658e-07
I15173 n1_m1_340000_331200 0 4.688854e-07
I15174 n1_m1_340000_336000 0 4.321911e-07
I15175 n1_m1_340000_340800 0 2.797546e-07
I15176 n1_m1_340000_345600 0 3.935591e-07
I15177 n1_m1_340000_350400 0 2.848077e-07
I15178 n1_m1_340000_355200 0 2.882264e-07
I15179 n1_m1_340000_360000 0 4.396623e-07
I15180 n1_m1_340000_364800 0 1.518971e-07
I15181 n1_m1_340000_369600 0 1.374053e-07
I15182 n1_m1_340000_374400 0 7.964190e-08
I15183 n1_m1_340000_379200 0 8.561216e-08
I15184 n1_m1_340000_384000 0 1.204140e-07
I15185 n1_m1_340000_388800 0 8.284014e-08
I15186 n1_m1_340000_393600 0 1.452566e-07
I15187 n1_m1_340000_398400 0 1.030449e-07
I15188 n1_m1_340000_403200 0 1.127403e-07
I15189 n1_m1_340000_408000 0 2.187073e-07
I15190 n1_m1_340000_412800 0 1.346090e-07
I15191 n1_m1_340000_417600 0 1.401730e-07
I15192 n1_m1_340000_422400 0 7.682854e-08
I15193 n1_m1_340000_427200 0 7.292256e-08
I15194 n1_m1_340000_432000 0 1.053954e-07
I15195 n1_m1_340000_436800 0 6.995199e-08
I15196 n1_m1_340000_441600 0 1.052723e-07
I15197 n1_m1_340000_446400 0 7.020798e-08
I15198 n1_m1_340000_451200 0 6.995199e-08
I15199 n1_m1_340000_456000 0 1.106417e-07
I15200 n1_m1_340000_460800 0 7.661408e-08
I15201 n1_m1_340000_465600 0 1.111396e-07
I15202 n1_m1_340000_470400 0 7.328303e-08
I15203 n1_m1_340000_475200 0 7.328303e-08
I15204 n1_m1_340000_480000 0 1.099246e-07
I15205 n1_m1_340000_484800 0 7.328303e-08
I15206 n1_m1_340000_489600 0 1.099246e-07
I15207 n1_m1_340000_494400 0 7.328303e-08
I15208 n1_m1_340000_499200 0 7.202056e-08
I15209 n1_m1_340000_504000 0 1.049280e-07
I15210 n1_m1_340000_508800 0 6.995199e-08
I15211 n1_m1_340000_513600 0 1.084843e-07
I15212 n1_m1_340000_518400 0 7.328303e-08
I15213 n1_m1_340000_523200 0 7.316153e-08
I15214 n1_m1_340000_528000 0 1.073251e-07
I15215 n1_m1_340000_532800 0 7.610624e-08
I15216 n1_m1_340000_537600 0 1.151909e-07
I15217 n1_m1_340000_542400 0 1.172973e-07
I15218 n1_m1_340000_547200 0 1.755142e-07
I15219 n1_m1_340000_552000 0 2.183936e-07
I15220 n1_m1_340000_556800 0 8.437728e-08
I15221 n1_m1_340000_561600 0 4.153342e-08
I15222 n1_m1_368000_0 0 1.425309e-07
I15223 n1_m1_368000_4800 0 2.455046e-07
I15224 n1_m1_368000_9600 0 5.002830e-07
I15225 n1_m1_368000_14400 0 2.145652e-07
I15226 n1_m1_368000_19200 0 1.148535e-07
I15227 n1_m1_368000_24000 0 1.314246e-07
I15228 n1_m1_368000_28800 0 7.795344e-08
I15229 n1_m1_368000_33600 0 1.153584e-07
I15230 n1_m1_368000_38400 0 8.206199e-08
I15231 n1_m1_368000_43200 0 7.893759e-08
I15232 n1_m1_368000_48000 0 1.120079e-07
I15233 n1_m1_368000_52800 0 7.598497e-08
I15234 n1_m1_368000_57600 0 1.254452e-07
I15235 n1_m1_368000_62400 0 9.924630e-08
I15236 n1_m1_368000_67200 0 1.125155e-07
I15237 n1_m1_368000_72000 0 2.161103e-07
I15238 n1_m1_368000_76800 0 2.558194e-07
I15239 n1_m1_368000_81600 0 2.192615e-07
I15240 n1_m1_368000_86400 0 2.157100e-07
I15241 n1_m1_368000_91200 0 4.190495e-07
I15242 n1_m1_368000_96000 0 6.243635e-07
I15243 n1_m1_368000_100800 0 4.646088e-07
I15244 n1_m1_368000_105600 0 8.062977e-07
I15245 n1_m1_368000_110400 0 5.917393e-07
I15246 n1_m1_368000_115200 0 5.186467e-07
I15247 n1_m1_368000_120000 0 9.224655e-07
I15248 n1_m1_368000_124800 0 4.910215e-07
I15249 n1_m1_368000_129600 0 6.061086e-07
I15250 n1_m1_368000_134400 0 4.216966e-07
I15251 n1_m1_368000_139200 0 3.031883e-07
I15252 n1_m1_368000_144000 0 7.968720e-07
I15253 n1_m1_368000_148800 0 4.762933e-07
I15254 n1_m1_368000_153600 0 4.173716e-07
I15255 n1_m1_368000_158400 0 3.715870e-07
I15256 n1_m1_368000_163200 0 2.709983e-07
I15257 n1_m1_368000_168000 0 6.269902e-07
I15258 n1_m1_368000_172800 0 5.677079e-07
I15259 n1_m1_368000_177600 0 4.337723e-07
I15260 n1_m1_368000_182400 0 2.170210e-07
I15261 n1_m1_368000_187200 0 1.983058e-07
I15262 n1_m1_368000_192000 0 1.586631e-07
I15263 n1_m1_368000_196800 0 2.125779e-07
I15264 n1_m1_368000_201600 0 3.228678e-07
I15265 n1_m1_368000_206400 0 4.268255e-07
I15266 n1_m1_368000_211200 0 3.783199e-07
I15267 n1_m1_368000_216000 0 6.831820e-07
I15268 n1_m1_368000_220800 0 4.630035e-07
I15269 n1_m1_368000_225600 0 9.512168e-07
I15270 n1_m1_368000_230400 0 5.905879e-07
I15271 n1_m1_368000_235200 0 5.144288e-07
I15272 n1_m1_368000_240000 0 8.179782e-07
I15273 n1_m1_368000_244800 0 4.014344e-07
I15274 n1_m1_368000_249600 0 7.092680e-07
I15275 n1_m1_368000_254400 0 4.307921e-07
I15276 n1_m1_368000_259200 0 3.067907e-07
I15277 n1_m1_368000_264000 0 3.573412e-07
I15278 n1_m1_368000_268800 0 1.401983e-07
I15279 n1_m1_368000_273600 0 2.564312e-07
I15280 n1_m1_368000_278400 0 1.987541e-07
I15281 n1_m1_368000_283200 0 1.789467e-07
I15282 n1_m1_368000_288000 0 3.032054e-07
I15283 n1_m1_368000_292800 0 1.947463e-07
I15284 n1_m1_368000_297600 0 4.119378e-07
I15285 n1_m1_368000_302400 0 5.154957e-07
I15286 n1_m1_368000_307200 0 4.538761e-07
I15287 n1_m1_368000_312000 0 5.405030e-07
I15288 n1_m1_368000_316800 0 3.671360e-07
I15289 n1_m1_368000_321600 0 4.662140e-07
I15290 n1_m1_368000_326400 0 4.694789e-07
I15291 n1_m1_368000_331200 0 6.282310e-07
I15292 n1_m1_368000_336000 0 7.545917e-07
I15293 n1_m1_368000_340800 0 3.630287e-07
I15294 n1_m1_368000_345600 0 3.076513e-07
I15295 n1_m1_368000_350400 0 1.921053e-07
I15296 n1_m1_368000_355200 0 1.527586e-07
I15297 n1_m1_368000_360000 0 2.464011e-07
I15298 n1_m1_368000_364800 0 1.013554e-07
I15299 n1_m1_368000_369600 0 1.117978e-07
I15300 n1_m1_368000_374400 0 7.621762e-08
I15301 n1_m1_368000_379200 0 7.926526e-08
I15302 n1_m1_368000_384000 0 1.109637e-07
I15303 n1_m1_368000_388800 0 7.429065e-08
I15304 n1_m1_368000_393600 0 1.190140e-07
I15305 n1_m1_368000_398400 0 1.029972e-07
I15306 n1_m1_368000_403200 0 1.116512e-07
I15307 n1_m1_368000_408000 0 5.838738e-07
I15308 n1_m1_368000_412800 0 3.164817e-07
I15309 n1_m1_368000_417600 0 2.496992e-07
I15310 n1_m1_368000_422400 0 9.501381e-08
I15311 n1_m1_368000_427200 0 8.101905e-08
I15312 n1_m1_368000_432000 0 1.319169e-07
I15313 n1_m1_368000_436800 0 8.573411e-08
I15314 n1_m1_368000_441600 0 1.238921e-07
I15315 n1_m1_368000_446400 0 8.275459e-08
I15316 n1_m1_368000_451200 0 8.114834e-08
I15317 n1_m1_368000_456000 0 1.219058e-07
I15318 n1_m1_368000_460800 0 8.104828e-08
I15319 n1_m1_368000_465600 0 1.241745e-07
I15320 n1_m1_368000_470400 0 8.434283e-08
I15321 n1_m1_368000_475200 0 8.417376e-08
I15322 n1_m1_368000_480000 0 1.191152e-07
I15323 n1_m1_368000_484800 0 7.457852e-08
I15324 n1_m1_368000_489600 0 1.081656e-07
I15325 n1_m1_368000_494400 0 6.995199e-08
I15326 n1_m1_368000_499200 0 6.995199e-08
I15327 n1_m1_368000_504000 0 1.049280e-07
I15328 n1_m1_368000_508800 0 6.995199e-08
I15329 n1_m1_368000_513600 0 1.049280e-07
I15330 n1_m1_368000_518400 0 6.995199e-08
I15331 n1_m1_368000_523200 0 7.007349e-08
I15332 n1_m1_368000_528000 0 1.113085e-07
I15333 n1_m1_368000_532800 0 8.100016e-08
I15334 n1_m1_368000_537600 0 1.108936e-07
I15335 n1_m1_368000_542400 0 7.934121e-08
I15336 n1_m1_368000_547200 0 8.737775e-08
I15337 n1_m1_368000_552000 0 1.286675e-07
I15338 n1_m1_368000_556800 0 8.072158e-08
I15339 n1_m1_368000_561600 0 3.966732e-08
I15340 n1_m1_396000_0 0 1.100370e-07
I15341 n1_m1_396000_4800 0 1.749203e-07
I15342 n1_m1_396000_9600 0 3.543890e-07
I15343 n1_m1_396000_14400 0 1.178167e-07
I15344 n1_m1_396000_19200 0 1.118968e-07
I15345 n1_m1_396000_24000 0 1.273698e-07
I15346 n1_m1_396000_28800 0 7.653079e-08
I15347 n1_m1_396000_33600 0 1.098515e-07
I15348 n1_m1_396000_38400 0 7.661408e-08
I15349 n1_m1_396000_43200 0 7.487743e-08
I15350 n1_m1_396000_48000 0 1.068342e-07
I15351 n1_m1_396000_52800 0 7.016152e-08
I15352 n1_m1_396000_57600 0 1.052756e-07
I15353 n1_m1_396000_62400 0 7.051951e-08
I15354 n1_m1_396000_67200 0 7.278776e-08
I15355 n1_m1_396000_72000 0 1.119411e-07
I15356 n1_m1_396000_76800 0 8.395780e-08
I15357 n1_m1_396000_81600 0 1.132433e-07
I15358 n1_m1_396000_86400 0 7.731006e-08
I15359 n1_m1_396000_91200 0 1.604009e-07
I15360 n1_m1_396000_96000 0 2.693046e-07
I15361 n1_m1_396000_100800 0 1.852535e-07
I15362 n1_m1_396000_105600 0 5.010235e-07
I15363 n1_m1_396000_110400 0 5.907117e-07
I15364 n1_m1_396000_115200 0 4.780578e-07
I15365 n1_m1_396000_120000 0 9.188386e-07
I15366 n1_m1_396000_124800 0 5.339696e-07
I15367 n1_m1_396000_129600 0 4.918651e-07
I15368 n1_m1_396000_134400 0 3.548210e-07
I15369 n1_m1_396000_139200 0 2.689785e-07
I15370 n1_m1_396000_144000 0 6.663261e-07
I15371 n1_m1_396000_148800 0 4.872523e-07
I15372 n1_m1_396000_153600 0 3.780046e-07
I15373 n1_m1_396000_158400 0 4.012100e-07
I15374 n1_m1_396000_163200 0 5.553684e-07
I15375 n1_m1_396000_168000 0 7.329808e-07
I15376 n1_m1_396000_172800 0 6.455215e-07
I15377 n1_m1_396000_177600 0 8.319212e-07
I15378 n1_m1_396000_182400 0 4.219508e-07
I15379 n1_m1_396000_187200 0 3.436176e-07
I15380 n1_m1_396000_192000 0 5.354045e-07
I15381 n1_m1_396000_196800 0 3.326450e-07
I15382 n1_m1_396000_201600 0 2.570471e-07
I15383 n1_m1_396000_206400 0 1.719333e-07
I15384 n1_m1_396000_211200 0 1.454490e-07
I15385 n1_m1_396000_216000 0 6.726462e-07
I15386 n1_m1_396000_220800 0 3.856263e-07
I15387 n1_m1_396000_225600 0 9.739103e-07
I15388 n1_m1_396000_230400 0 6.137158e-07
I15389 n1_m1_396000_235200 0 5.484825e-07
I15390 n1_m1_396000_240000 0 1.030252e-06
I15391 n1_m1_396000_244800 0 6.677919e-07
I15392 n1_m1_396000_249600 0 1.034225e-06
I15393 n1_m1_396000_254400 0 6.257013e-07
I15394 n1_m1_396000_259200 0 2.364334e-07
I15395 n1_m1_396000_264000 0 4.576242e-07
I15396 n1_m1_396000_268800 0 3.996547e-07
I15397 n1_m1_396000_273600 0 3.132531e-07
I15398 n1_m1_396000_278400 0 3.709671e-07
I15399 n1_m1_396000_283200 0 2.857120e-07
I15400 n1_m1_396000_288000 0 4.482453e-07
I15401 n1_m1_396000_292800 0 3.594350e-07
I15402 n1_m1_396000_297600 0 5.777992e-07
I15403 n1_m1_396000_302400 0 5.865885e-07
I15404 n1_m1_396000_307200 0 4.730669e-07
I15405 n1_m1_396000_312000 0 3.993218e-07
I15406 n1_m1_396000_316800 0 2.930990e-07
I15407 n1_m1_396000_321600 0 3.983628e-07
I15408 n1_m1_396000_326400 0 4.577424e-07
I15409 n1_m1_396000_331200 0 6.179307e-07
I15410 n1_m1_396000_336000 0 8.763654e-07
I15411 n1_m1_396000_340800 0 5.530497e-07
I15412 n1_m1_396000_345600 0 5.550707e-07
I15413 n1_m1_396000_350400 0 3.140285e-07
I15414 n1_m1_396000_355200 0 2.859305e-07
I15415 n1_m1_396000_360000 0 3.342776e-07
I15416 n1_m1_396000_364800 0 1.063740e-07
I15417 n1_m1_396000_369600 0 1.199561e-07
I15418 n1_m1_396000_374400 0 8.782101e-08
I15419 n1_m1_396000_379200 0 7.678401e-08
I15420 n1_m1_396000_384000 0 1.211730e-07
I15421 n1_m1_396000_388800 0 7.967841e-08
I15422 n1_m1_396000_393600 0 1.197034e-07
I15423 n1_m1_396000_398400 0 8.766054e-08
I15424 n1_m1_396000_403200 0 8.828284e-08
I15425 n1_m1_396000_408000 0 2.053138e-07
I15426 n1_m1_396000_412800 0 1.133660e-07
I15427 n1_m1_396000_417600 0 2.037309e-07
I15428 n1_m1_396000_422400 0 1.481864e-07
I15429 n1_m1_396000_427200 0 9.431587e-08
I15430 n1_m1_396000_432000 0 1.167894e-07
I15431 n1_m1_396000_436800 0 7.634836e-08
I15432 n1_m1_396000_441600 0 1.081320e-07
I15433 n1_m1_396000_446400 0 7.350114e-08
I15434 n1_m1_396000_451200 0 7.384843e-08
I15435 n1_m1_396000_456000 0 1.082988e-07
I15436 n1_m1_396000_460800 0 7.328303e-08
I15437 n1_m1_396000_465600 0 1.137061e-07
I15438 n1_m1_396000_470400 0 7.623178e-08
I15439 n1_m1_396000_475200 0 7.380759e-08
I15440 n1_m1_396000_480000 0 1.099246e-07
I15441 n1_m1_396000_484800 0 7.328303e-08
I15442 n1_m1_396000_489600 0 1.080694e-07
I15443 n1_m1_396000_494400 0 6.995199e-08
I15444 n1_m1_396000_499200 0 6.995199e-08
I15445 n1_m1_396000_504000 0 1.049280e-07
I15446 n1_m1_396000_508800 0 6.995199e-08
I15447 n1_m1_396000_513600 0 1.049280e-07
I15448 n1_m1_396000_518400 0 6.995199e-08
I15449 n1_m1_396000_523200 0 6.995199e-08
I15450 n1_m1_396000_528000 0 1.056600e-07
I15451 n1_m1_396000_532800 0 7.257111e-08
I15452 n1_m1_396000_537600 0 1.072552e-07
I15453 n1_m1_396000_542400 0 7.632375e-08
I15454 n1_m1_396000_547200 0 8.263612e-08
I15455 n1_m1_396000_552000 0 1.305501e-07
I15456 n1_m1_396000_556800 0 8.072158e-08
I15457 n1_m1_396000_561600 0 3.966732e-08
I15458 n1_m1_424000_0 0 1.023616e-07
I15459 n1_m1_424000_4800 0 1.523710e-07
I15460 n1_m1_424000_9600 0 2.696473e-07
I15461 n1_m1_424000_14400 0 1.216107e-07
I15462 n1_m1_424000_19200 0 9.115248e-08
I15463 n1_m1_424000_24000 0 1.182582e-07
I15464 n1_m1_424000_28800 0 7.385124e-08
I15465 n1_m1_424000_33600 0 1.104957e-07
I15466 n1_m1_424000_38400 0 6.995199e-08
I15467 n1_m1_424000_43200 0 6.995199e-08
I15468 n1_m1_424000_48000 0 1.049280e-07
I15469 n1_m1_424000_52800 0 6.999644e-08
I15470 n1_m1_424000_57600 0 1.089584e-07
I15471 n1_m1_424000_62400 0 7.328303e-08
I15472 n1_m1_424000_67200 0 7.378710e-08
I15473 n1_m1_424000_72000 0 1.173570e-07
I15474 n1_m1_424000_76800 0 7.979266e-08
I15475 n1_m1_424000_81600 0 1.165405e-07
I15476 n1_m1_424000_86400 0 8.519282e-08
I15477 n1_m1_424000_91200 0 8.673628e-08
I15478 n1_m1_424000_96000 0 1.284524e-07
I15479 n1_m1_424000_100800 0 1.155453e-07
I15480 n1_m1_424000_105600 0 3.681602e-07
I15481 n1_m1_424000_110400 0 4.058202e-07
I15482 n1_m1_424000_115200 0 4.122934e-07
I15483 n1_m1_424000_120000 0 7.919219e-07
I15484 n1_m1_424000_124800 0 5.151850e-07
I15485 n1_m1_424000_129600 0 7.809375e-07
I15486 n1_m1_424000_134400 0 5.505691e-07
I15487 n1_m1_424000_139200 0 5.155400e-07
I15488 n1_m1_424000_144000 0 5.842302e-07
I15489 n1_m1_424000_148800 0 2.367581e-07
I15490 n1_m1_424000_153600 0 1.813852e-07
I15491 n1_m1_424000_158400 0 8.525839e-08
I15492 n1_m1_424000_163200 0 8.164228e-08
I15493 n1_m1_424000_168000 0 1.189870e-07
I15494 n1_m1_424000_172800 0 7.979264e-08
I15495 n1_m1_424000_177600 0 1.250192e-07
I15496 n1_m1_424000_182400 0 8.363773e-08
I15497 n1_m1_424000_187200 0 8.363773e-08
I15498 n1_m1_424000_192000 0 1.254566e-07
I15499 n1_m1_424000_196800 0 8.363773e-08
I15500 n1_m1_424000_201600 0 1.255508e-07
I15501 n1_m1_424000_206400 0 8.568978e-08
I15502 n1_m1_424000_211200 0 1.046656e-07
I15503 n1_m1_424000_216000 0 3.883405e-07
I15504 n1_m1_424000_220800 0 4.284358e-07
I15505 n1_m1_424000_225600 0 9.018549e-07
I15506 n1_m1_424000_230400 0 6.201909e-07
I15507 n1_m1_424000_235200 0 6.652884e-07
I15508 n1_m1_424000_240000 0 9.624148e-07
I15509 n1_m1_424000_244800 0 5.968168e-07
I15510 n1_m1_424000_249600 0 7.749181e-07
I15511 n1_m1_424000_254400 0 3.577696e-07
I15512 n1_m1_424000_259200 0 1.914264e-07
I15513 n1_m1_424000_264000 0 1.502581e-07
I15514 n1_m1_424000_268800 0 9.091408e-08
I15515 n1_m1_424000_273600 0 1.986975e-07
I15516 n1_m1_424000_278400 0 2.216304e-07
I15517 n1_m1_424000_283200 0 3.094286e-07
I15518 n1_m1_424000_288000 0 8.539464e-07
I15519 n1_m1_424000_292800 0 5.892784e-07
I15520 n1_m1_424000_297600 0 9.626285e-07
I15521 n1_m1_424000_302400 0 6.303397e-07
I15522 n1_m1_424000_307200 0 6.389454e-07
I15523 n1_m1_424000_312000 0 9.432143e-07
I15524 n1_m1_424000_316800 0 5.973384e-07
I15525 n1_m1_424000_321600 0 7.781408e-07
I15526 n1_m1_424000_326400 0 5.959601e-07
I15527 n1_m1_424000_331200 0 5.950509e-07
I15528 n1_m1_424000_336000 0 8.932035e-07
I15529 n1_m1_424000_340800 0 6.194714e-07
I15530 n1_m1_424000_345600 0 7.512766e-07
I15531 n1_m1_424000_350400 0 5.452083e-07
I15532 n1_m1_424000_355200 0 4.952214e-07
I15533 n1_m1_424000_360000 0 4.530119e-07
I15534 n1_m1_424000_364800 0 1.840575e-07
I15535 n1_m1_424000_369600 0 1.776772e-07
I15536 n1_m1_424000_374400 0 1.106631e-07
I15537 n1_m1_424000_379200 0 1.450070e-07
I15538 n1_m1_424000_384000 0 2.387357e-07
I15539 n1_m1_424000_388800 0 1.786515e-07
I15540 n1_m1_424000_393600 0 2.992915e-07
I15541 n1_m1_424000_398400 0 2.222099e-07
I15542 n1_m1_424000_403200 0 3.349240e-07
I15543 n1_m1_424000_408000 0 7.723508e-07
I15544 n1_m1_424000_412800 0 5.091233e-07
I15545 n1_m1_424000_417600 0 7.668429e-07
I15546 n1_m1_424000_422400 0 3.903204e-07
I15547 n1_m1_424000_427200 0 2.083922e-07
I15548 n1_m1_424000_432000 0 2.469662e-07
I15549 n1_m1_424000_436800 0 8.623433e-08
I15550 n1_m1_424000_441600 0 1.262633e-07
I15551 n1_m1_424000_446400 0 8.209075e-08
I15552 n1_m1_424000_451200 0 8.259210e-08
I15553 n1_m1_424000_456000 0 1.181610e-07
I15554 n1_m1_424000_460800 0 8.482978e-08
I15555 n1_m1_424000_465600 0 1.190593e-07
I15556 n1_m1_424000_470400 0 7.650048e-08
I15557 n1_m1_424000_475200 0 7.561557e-08
I15558 n1_m1_424000_480000 0 1.138431e-07
I15559 n1_m1_424000_484800 0 8.260120e-08
I15560 n1_m1_424000_489600 0 1.079775e-07
I15561 n1_m1_424000_494400 0 7.104761e-08
I15562 n1_m1_424000_499200 0 7.355568e-08
I15563 n1_m1_424000_504000 0 1.134364e-07
I15564 n1_m1_424000_508800 0 7.408705e-08
I15565 n1_m1_424000_513600 0 1.096309e-07
I15566 n1_m1_424000_518400 0 7.120536e-08
I15567 n1_m1_424000_523200 0 7.026283e-08
I15568 n1_m1_424000_528000 0 1.096270e-07
I15569 n1_m1_424000_532800 0 7.509102e-08
I15570 n1_m1_424000_537600 0 1.101516e-07
I15571 n1_m1_424000_542400 0 7.555396e-08
I15572 n1_m1_424000_547200 0 8.133802e-08
I15573 n1_m1_424000_552000 0 1.298904e-07
I15574 n1_m1_424000_556800 0 8.210048e-08
I15575 n1_m1_424000_561600 0 4.051924e-08
I15576 n1_m1_452000_0 0 1.844622e-07
I15577 n1_m1_452000_4800 0 2.278365e-07
I15578 n1_m1_452000_9600 0 3.123566e-07
I15579 n1_m1_452000_14400 0 1.700601e-07
I15580 n1_m1_452000_19200 0 1.585230e-07
I15581 n1_m1_452000_24000 0 2.289798e-07
I15582 n1_m1_452000_28800 0 1.451927e-07
I15583 n1_m1_452000_33600 0 2.142772e-07
I15584 n1_m1_452000_38400 0 1.399040e-07
I15585 n1_m1_452000_43200 0 1.399040e-07
I15586 n1_m1_452000_48000 0 2.098560e-07
I15587 n1_m1_452000_52800 0 1.399929e-07
I15588 n1_m1_452000_57600 0 2.179169e-07
I15589 n1_m1_452000_62400 0 1.465661e-07
I15590 n1_m1_452000_67200 0 1.479539e-07
I15591 n1_m1_452000_72000 0 2.478626e-07
I15592 n1_m1_452000_76800 0 1.865348e-07
I15593 n1_m1_452000_81600 0 2.580544e-07
I15594 n1_m1_452000_86400 0 1.753332e-07
I15595 n1_m1_452000_91200 0 2.057072e-07
I15596 n1_m1_452000_96000 0 3.140054e-07
I15597 n1_m1_452000_100800 0 2.244253e-07
I15598 n1_m1_452000_105600 0 3.445855e-07
I15599 n1_m1_452000_110400 0 1.815834e-07
I15600 n1_m1_452000_115200 0 1.875813e-07
I15601 n1_m1_452000_120000 0 3.349860e-07
I15602 n1_m1_452000_124800 0 2.300433e-07
I15603 n1_m1_452000_129600 0 4.618560e-07
I15604 n1_m1_452000_134400 0 2.512552e-07
I15605 n1_m1_452000_139200 0 3.490258e-07
I15606 n1_m1_452000_144000 0 5.357146e-07
I15607 n1_m1_452000_148800 0 2.805433e-07
I15608 n1_m1_452000_153600 0 2.952299e-07
I15609 n1_m1_452000_158400 0 1.598460e-07
I15610 n1_m1_452000_163200 0 1.486131e-07
I15611 n1_m1_452000_168000 0 2.262463e-07
I15612 n1_m1_452000_172800 0 1.507908e-07
I15613 n1_m1_452000_177600 0 2.203297e-07
I15614 n1_m1_452000_182400 0 1.465661e-07
I15615 n1_m1_452000_187200 0 1.465661e-07
I15616 n1_m1_452000_192000 0 2.233781e-07
I15617 n1_m1_452000_196800 0 1.517108e-07
I15618 n1_m1_452000_201600 0 2.343709e-07
I15619 n1_m1_452000_206400 0 1.621292e-07
I15620 n1_m1_452000_211200 0 1.575586e-07
I15621 n1_m1_452000_216000 0 2.732903e-07
I15622 n1_m1_452000_220800 0 2.756484e-07
I15623 n1_m1_452000_225600 0 8.342796e-07
I15624 n1_m1_452000_230400 0 2.809458e-07
I15625 n1_m1_452000_235200 0 2.938213e-07
I15626 n1_m1_452000_240000 0 3.869609e-07
I15627 n1_m1_452000_244800 0 2.370455e-07
I15628 n1_m1_452000_249600 0 2.815766e-07
I15629 n1_m1_452000_254400 0 1.709548e-07
I15630 n1_m1_452000_259200 0 1.577376e-07
I15631 n1_m1_452000_264000 0 2.312689e-07
I15632 n1_m1_452000_268800 0 1.687059e-07
I15633 n1_m1_452000_273600 0 2.255162e-07
I15634 n1_m1_452000_278400 0 1.560712e-07
I15635 n1_m1_452000_283200 0 1.701247e-07
I15636 n1_m1_452000_288000 0 2.901443e-07
I15637 n1_m1_452000_292800 0 4.008997e-07
I15638 n1_m1_452000_297600 0 9.243846e-07
I15639 n1_m1_452000_302400 0 6.336991e-07
I15640 n1_m1_452000_307200 0 6.712968e-07
I15641 n1_m1_452000_312000 0 1.095340e-06
I15642 n1_m1_452000_316800 0 3.344118e-07
I15643 n1_m1_452000_321600 0 3.724525e-07
I15644 n1_m1_452000_326400 0 1.836132e-07
I15645 n1_m1_452000_331200 0 2.161044e-07
I15646 n1_m1_452000_336000 0 5.466620e-07
I15647 n1_m1_452000_340800 0 4.819013e-07
I15648 n1_m1_452000_345600 0 7.127628e-07
I15649 n1_m1_452000_350400 0 7.637438e-07
I15650 n1_m1_452000_355200 0 6.239847e-07
I15651 n1_m1_452000_360000 0 3.772819e-07
I15652 n1_m1_452000_364800 0 1.563818e-07
I15653 n1_m1_452000_369600 0 2.223059e-07
I15654 n1_m1_452000_374400 0 1.485120e-07
I15655 n1_m1_452000_379200 0 1.518379e-07
I15656 n1_m1_452000_384000 0 2.177183e-07
I15657 n1_m1_452000_388800 0 1.517108e-07
I15658 n1_m1_452000_393600 0 2.232267e-07
I15659 n1_m1_452000_398400 0 1.526033e-07
I15660 n1_m1_452000_403200 0 1.572882e-07
I15661 n1_m1_452000_408000 0 2.548221e-07
I15662 n1_m1_452000_412800 0 1.794418e-07
I15663 n1_m1_452000_417600 0 7.368826e-07
I15664 n1_m1_452000_422400 0 2.584718e-07
I15665 n1_m1_452000_427200 0 1.669892e-07
I15666 n1_m1_452000_432000 0 2.527863e-07
I15667 n1_m1_452000_436800 0 1.465661e-07
I15668 n1_m1_452000_441600 0 2.166359e-07
I15669 n1_m1_452000_446400 0 1.459196e-07
I15670 n1_m1_452000_451200 0 1.503045e-07
I15671 n1_m1_452000_456000 0 2.352232e-07
I15672 n1_m1_452000_460800 0 2.263344e-07
I15673 n1_m1_452000_465600 0 3.511585e-07
I15674 n1_m1_452000_470400 0 2.290279e-07
I15675 n1_m1_452000_475200 0 1.809461e-07
I15676 n1_m1_452000_480000 0 2.321256e-07
I15677 n1_m1_452000_484800 0 1.617734e-07
I15678 n1_m1_452000_489600 0 2.204764e-07
I15679 n1_m1_452000_494400 0 1.461334e-07
I15680 n1_m1_452000_499200 0 1.457223e-07
I15681 n1_m1_452000_504000 0 2.272497e-07
I15682 n1_m1_452000_508800 0 1.659719e-07
I15683 n1_m1_452000_513600 0 2.525546e-07
I15684 n1_m1_452000_518400 0 1.486868e-07
I15685 n1_m1_452000_523200 0 1.365122e-07
I15686 n1_m1_452000_528000 0 2.164013e-07
I15687 n1_m1_452000_532800 0 1.460693e-07
I15688 n1_m1_452000_537600 0 2.117680e-07
I15689 n1_m1_452000_542400 0 1.436113e-07
I15690 n1_m1_452000_547200 0 1.526651e-07
I15691 n1_m1_452000_552000 0 2.379151e-07
I15692 n1_m1_452000_556800 0 1.499281e-07
I15693 n1_m1_452000_561600 0 7.439643e-08
I15694 n1_m1_508000_0 0 8.696154e-08
I15695 n1_m1_508000_4800 0 9.586159e-08
I15696 n1_m1_508000_9600 0 1.278763e-07
I15697 n1_m1_508000_14400 0 7.303113e-08
I15698 n1_m1_508000_19200 0 7.489818e-08
I15699 n1_m1_508000_24000 0 1.113737e-07
I15700 n1_m1_508000_28800 0 7.122152e-08
I15701 n1_m1_508000_33600 0 1.049280e-07
I15702 n1_m1_508000_38400 0 7.198499e-08
I15703 n1_m1_508000_43200 0 7.328303e-08
I15704 n1_m1_508000_48000 0 1.097319e-07
I15705 n1_m1_508000_52800 0 7.066621e-08
I15706 n1_m1_508000_57600 0 1.049280e-07
I15707 n1_m1_508000_62400 0 6.995199e-08
I15708 n1_m1_508000_67200 0 7.010576e-08
I15709 n1_m1_508000_72000 0 1.075092e-07
I15710 n1_m1_508000_76800 0 7.328303e-08
I15711 n1_m1_508000_81600 0 1.087227e-07
I15712 n1_m1_508000_86400 0 7.060521e-08
I15713 n1_m1_508000_91200 0 6.995199e-08
I15714 n1_m1_508000_96000 0 1.062090e-07
I15715 n1_m1_508000_100800 0 7.277184e-08
I15716 n1_m1_508000_105600 0 1.107767e-07
I15717 n1_m1_508000_110400 0 7.794397e-08
I15718 n1_m1_508000_115200 0 7.813022e-08
I15719 n1_m1_508000_120000 0 1.132807e-07
I15720 n1_m1_508000_124800 0 8.195949e-08
I15721 n1_m1_508000_129600 0 1.204159e-07
I15722 n1_m1_508000_134400 0 1.035738e-07
I15723 n1_m1_508000_139200 0 1.829663e-07
I15724 n1_m1_508000_144000 0 5.357178e-07
I15725 n1_m1_508000_148800 0 3.252281e-07
I15726 n1_m1_508000_153600 0 2.183584e-07
I15727 n1_m1_508000_158400 0 8.526643e-08
I15728 n1_m1_508000_163200 0 7.406871e-08
I15729 n1_m1_508000_168000 0 1.071829e-07
I15730 n1_m1_508000_172800 0 7.172066e-08
I15731 n1_m1_508000_177600 0 1.097468e-07
I15732 n1_m1_508000_182400 0 7.328303e-08
I15733 n1_m1_508000_187200 0 7.328303e-08
I15734 n1_m1_508000_192000 0 1.099246e-07
I15735 n1_m1_508000_196800 0 7.328303e-08
I15736 n1_m1_508000_201600 0 1.099246e-07
I15737 n1_m1_508000_206400 0 7.328303e-08
I15738 n1_m1_508000_211200 0 7.330378e-08
I15739 n1_m1_508000_216000 0 1.144490e-07
I15740 n1_m1_508000_220800 0 8.475712e-08
I15741 n1_m1_508000_225600 0 1.643395e-07
I15742 n1_m1_508000_230400 0 9.409710e-08
I15743 n1_m1_508000_235200 0 8.304819e-08
I15744 n1_m1_508000_240000 0 1.248054e-07
I15745 n1_m1_508000_244800 0 7.571694e-08
I15746 n1_m1_508000_249600 0 1.118793e-07
I15747 n1_m1_508000_254400 0 7.454704e-08
I15748 n1_m1_508000_259200 0 8.051305e-08
I15749 n1_m1_508000_264000 0 1.234620e-07
I15750 n1_m1_508000_268800 0 7.822678e-08
I15751 n1_m1_508000_273600 0 1.139781e-07
I15752 n1_m1_508000_278400 0 7.683369e-08
I15753 n1_m1_508000_283200 0 7.325423e-08
I15754 n1_m1_508000_288000 0 1.123852e-07
I15755 n1_m1_508000_292800 0 9.717857e-08
I15756 n1_m1_508000_297600 0 2.067565e-07
I15757 n1_m1_508000_302400 0 2.102274e-07
I15758 n1_m1_508000_307200 0 1.563862e-07
I15759 n1_m1_508000_312000 0 1.792976e-07
I15760 n1_m1_508000_316800 0 1.584455e-07
I15761 n1_m1_508000_321600 0 1.458530e-07
I15762 n1_m1_508000_326400 0 8.387498e-08
I15763 n1_m1_508000_331200 0 8.729472e-08
I15764 n1_m1_508000_336000 0 1.313422e-07
I15765 n1_m1_508000_340800 0 8.774795e-08
I15766 n1_m1_508000_345600 0 1.240785e-07
I15767 n1_m1_508000_350400 0 7.612607e-08
I15768 n1_m1_508000_355200 0 7.518564e-08
I15769 n1_m1_508000_360000 0 1.126109e-07
I15770 n1_m1_508000_364800 0 7.363343e-08
I15771 n1_m1_508000_369600 0 1.099246e-07
I15772 n1_m1_508000_374400 0 7.328303e-08
I15773 n1_m1_508000_379200 0 7.328303e-08
I15774 n1_m1_508000_384000 0 1.113056e-07
I15775 n1_m1_508000_388800 0 7.661408e-08
I15776 n1_m1_508000_393600 0 1.126007e-07
I15777 n1_m1_508000_398400 0 7.414467e-08
I15778 n1_m1_508000_403200 0 7.568986e-08
I15779 n1_m1_508000_408000 0 1.166044e-07
I15780 n1_m1_508000_412800 0 8.327109e-08
I15781 n1_m1_508000_417600 0 1.277835e-07
I15782 n1_m1_508000_422400 0 7.866240e-08
I15783 n1_m1_508000_427200 0 7.525084e-08
I15784 n1_m1_508000_432000 0 1.076819e-07
I15785 n1_m1_508000_436800 0 7.081142e-08
I15786 n1_m1_508000_441600 0 1.098268e-07
I15787 n1_m1_508000_446400 0 7.328303e-08
I15788 n1_m1_508000_451200 0 7.328303e-08
I15789 n1_m1_508000_456000 0 1.147107e-07
I15790 n1_m1_508000_460800 0 1.868230e-07
I15791 n1_m1_508000_465600 0 1.847275e-07
I15792 n1_m1_508000_470400 0 7.575088e-08
I15793 n1_m1_508000_475200 0 8.314847e-08
I15794 n1_m1_508000_480000 0 1.145418e-07
I15795 n1_m1_508000_484800 0 7.212520e-08
I15796 n1_m1_508000_489600 0 1.075619e-07
I15797 n1_m1_508000_494400 0 6.995199e-08
I15798 n1_m1_508000_499200 0 6.995199e-08
I15799 n1_m1_508000_504000 0 1.049280e-07
I15800 n1_m1_508000_508800 0 6.995199e-08
I15801 n1_m1_508000_513600 0 1.049280e-07
I15802 n1_m1_508000_518400 0 7.006764e-08
I15803 n1_m1_508000_523200 0 7.105509e-08
I15804 n1_m1_508000_528000 0 1.055901e-07
I15805 n1_m1_508000_532800 0 7.213963e-08
I15806 n1_m1_508000_537600 0 1.209671e-07
I15807 n1_m1_508000_542400 0 9.279803e-08
I15808 n1_m1_508000_547200 0 9.224313e-08
I15809 n1_m1_508000_552000 0 1.216013e-07
I15810 n1_m1_508000_556800 0 7.577278e-08
I15811 n1_m1_508000_561600 0 3.778726e-08
I15812 n1_m1_536000_0 0 8.444382e-08
I15813 n1_m1_536000_4800 0 8.009200e-08
I15814 n1_m1_536000_9600 0 1.077050e-07
I15815 n1_m1_536000_14400 0 6.997900e-08
I15816 n1_m1_536000_19200 0 7.042319e-08
I15817 n1_m1_536000_24000 0 1.094889e-07
I15818 n1_m1_536000_28800 0 7.328303e-08
I15819 n1_m1_536000_33600 0 1.094676e-07
I15820 n1_m1_536000_38400 0 7.466998e-08
I15821 n1_m1_536000_43200 0 7.596802e-08
I15822 n1_m1_536000_48000 0 1.106910e-07
I15823 n1_m1_536000_52800 0 7.052768e-08
I15824 n1_m1_536000_57600 0 1.049280e-07
I15825 n1_m1_536000_62400 0 7.036047e-08
I15826 n1_m1_536000_67200 0 7.202545e-08
I15827 n1_m1_536000_72000 0 1.053699e-07
I15828 n1_m1_536000_76800 0 7.083513e-08
I15829 n1_m1_536000_81600 0 1.077345e-07
I15830 n1_m1_536000_86400 0 6.995199e-08
I15831 n1_m1_536000_91200 0 6.995199e-08
I15832 n1_m1_536000_96000 0 1.049925e-07
I15833 n1_m1_536000_100800 0 7.191557e-08
I15834 n1_m1_536000_105600 0 1.096030e-07
I15835 n1_m1_536000_110400 0 7.578471e-08
I15836 n1_m1_536000_115200 0 7.379573e-08
I15837 n1_m1_536000_120000 0 1.116480e-07
I15838 n1_m1_536000_124800 0 7.792887e-08
I15839 n1_m1_536000_129600 0 1.106476e-07
I15840 n1_m1_536000_134400 0 8.214875e-08
I15841 n1_m1_536000_139200 0 9.193985e-08
I15842 n1_m1_536000_144000 0 4.127509e-07
I15843 n1_m1_536000_148800 0 3.587449e-07
I15844 n1_m1_536000_153600 0 2.335641e-07
I15845 n1_m1_536000_158400 0 8.572980e-08
I15846 n1_m1_536000_163200 0 7.927137e-08
I15847 n1_m1_536000_168000 0 1.147950e-07
I15848 n1_m1_536000_172800 0 7.902647e-08
I15849 n1_m1_536000_177600 0 1.135939e-07
I15850 n1_m1_536000_182400 0 8.039313e-08
I15851 n1_m1_536000_187200 0 7.900697e-08
I15852 n1_m1_536000_192000 0 1.089555e-07
I15853 n1_m1_536000_196800 0 7.500767e-08
I15854 n1_m1_536000_201600 0 1.169910e-07
I15855 n1_m1_536000_206400 0 7.398540e-08
I15856 n1_m1_536000_211200 0 7.519263e-08
I15857 n1_m1_536000_216000 0 1.086522e-07
I15858 n1_m1_536000_220800 0 8.027180e-08
I15859 n1_m1_536000_225600 0 1.265517e-07
I15860 n1_m1_536000_230400 0 7.677411e-08
I15861 n1_m1_536000_235200 0 7.524879e-08
I15862 n1_m1_536000_240000 0 1.146051e-07
I15863 n1_m1_536000_244800 0 7.390303e-08
I15864 n1_m1_536000_249600 0 1.089555e-07
I15865 n1_m1_536000_254400 0 7.264790e-08
I15866 n1_m1_536000_259200 0 7.310025e-08
I15867 n1_m1_536000_264000 0 1.125355e-07
I15868 n1_m1_536000_268800 0 7.389456e-08
I15869 n1_m1_536000_273600 0 1.135197e-07
I15870 n1_m1_536000_278400 0 7.687488e-08
I15871 n1_m1_536000_283200 0 7.854040e-08
I15872 n1_m1_536000_288000 0 1.193135e-07
I15873 n1_m1_536000_292800 0 8.100747e-08
I15874 n1_m1_536000_297600 0 1.148088e-07
I15875 n1_m1_536000_302400 0 8.447043e-08
I15876 n1_m1_536000_307200 0 7.859967e-08
I15877 n1_m1_536000_312000 0 1.141471e-07
I15878 n1_m1_536000_316800 0 7.923646e-08
I15879 n1_m1_536000_321600 0 1.172016e-07
I15880 n1_m1_536000_326400 0 8.107502e-08
I15881 n1_m1_536000_331200 0 8.455309e-08
I15882 n1_m1_536000_336000 0 1.216257e-07
I15883 n1_m1_536000_340800 0 7.806193e-08
I15884 n1_m1_536000_345600 0 1.232341e-07
I15885 n1_m1_536000_350400 0 7.969902e-08
I15886 n1_m1_536000_355200 0 7.688423e-08
I15887 n1_m1_536000_360000 0 1.149211e-07
I15888 n1_m1_536000_364800 0 7.661408e-08
I15889 n1_m1_536000_369600 0 1.155303e-07
I15890 n1_m1_536000_374400 0 7.929507e-08
I15891 n1_m1_536000_379200 0 7.988708e-08
I15892 n1_m1_536000_384000 0 1.216083e-07
I15893 n1_m1_536000_388800 0 8.290552e-08
I15894 n1_m1_536000_393600 0 1.171459e-07
I15895 n1_m1_536000_398400 0 7.405210e-08
I15896 n1_m1_536000_403200 0 7.604447e-08
I15897 n1_m1_536000_408000 0 1.256282e-07
I15898 n1_m1_536000_412800 0 8.146859e-08
I15899 n1_m1_536000_417600 0 1.089240e-07
I15900 n1_m1_536000_422400 0 7.209079e-08
I15901 n1_m1_536000_427200 0 7.360970e-08
I15902 n1_m1_536000_432000 0 1.109648e-07
I15903 n1_m1_536000_436800 0 7.666077e-08
I15904 n1_m1_536000_441600 0 1.162238e-07
I15905 n1_m1_536000_446400 0 7.631404e-08
I15906 n1_m1_536000_451200 0 7.690262e-08
I15907 n1_m1_536000_456000 0 1.141730e-07
I15908 n1_m1_536000_460800 0 7.337750e-08
I15909 n1_m1_536000_465600 0 1.096889e-07
I15910 n1_m1_536000_470400 0 7.320889e-08
I15911 n1_m1_536000_475200 0 7.273871e-08
I15912 n1_m1_536000_480000 0 1.089555e-07
I15913 n1_m1_536000_484800 0 7.207561e-08
I15914 n1_m1_536000_489600 0 1.069528e-07
I15915 n1_m1_536000_494400 0 7.328303e-08
I15916 n1_m1_536000_499200 0 7.303818e-08
I15917 n1_m1_536000_504000 0 1.089555e-07
I15918 n1_m1_536000_508800 0 7.263698e-08
I15919 n1_m1_536000_513600 0 1.089555e-07
I15920 n1_m1_536000_518400 0 7.263698e-08
I15921 n1_m1_536000_523200 0 7.263698e-08
I15922 n1_m1_536000_528000 0 1.090974e-07
I15923 n1_m1_536000_532800 0 7.324912e-08
I15924 n1_m1_536000_537600 0 1.099246e-07
I15925 n1_m1_536000_542400 0 7.220808e-08
I15926 n1_m1_536000_547200 0 7.227019e-08
I15927 n1_m1_536000_552000 0 1.121175e-07
I15928 n1_m1_536000_556800 0 7.132115e-08
I15929 n1_m1_536000_561600 0 3.542942e-08
.op
.end
