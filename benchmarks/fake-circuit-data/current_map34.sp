R0 n1_m1_0_0 n1_m1_4000_0 4.463529
R1 n1_m1_4800_0 n1_m1_4000_0 0.892706
R2 n1_m1_4800_0 n1_m1_9600_0 5.356235
R3 n1_m1_9600_0 n1_m1_14400_0 5.356235
R4 n1_m1_14400_0 n1_m1_19200_0 5.356235
R5 n1_m1_19200_0 n1_m1_24000_0 5.356235
R6 n1_m1_24000_0 n1_m1_28800_0 5.356235
R7 n1_m1_28800_0 n1_m1_32000_0 3.570824
R8 n1_m1_33600_0 n1_m1_32000_0 1.785412
R9 n1_m1_33600_0 n1_m1_38400_0 5.356235
R10 n1_m1_38400_0 n1_m1_43200_0 5.356235
R11 n1_m1_43200_0 n1_m1_48000_0 5.356235
R12 n1_m1_48000_0 n1_m1_52800_0 5.356235
R13 n1_m1_52800_0 n1_m1_57600_0 5.356235
R14 n1_m1_57600_0 n1_m1_60000_0 2.678118
R15 n1_m1_62400_0 n1_m1_60000_0 2.678118
R16 n1_m1_62400_0 n1_m1_67200_0 5.356235
R17 n1_m1_67200_0 n1_m1_72000_0 5.356235
R18 n1_m1_72000_0 n1_m1_76800_0 5.356235
R19 n1_m1_76800_0 n1_m1_81600_0 5.356235
R20 n1_m1_81600_0 n1_m1_86400_0 5.356235
R21 n1_m1_86400_0 n1_m1_88000_0 1.785412
R22 n1_m1_91200_0 n1_m1_88000_0 3.570824
R23 n1_m1_91200_0 n1_m1_96000_0 5.356235
R24 n1_m1_96000_0 n1_m1_100800_0 5.356235
R25 n1_m1_100800_0 n1_m1_105600_0 5.356235
R26 n1_m1_105600_0 n1_m1_110400_0 5.356235
R27 n1_m1_110400_0 n1_m1_115200_0 5.356235
R28 n1_m1_115200_0 n1_m1_116000_0 0.892706
R29 n1_m1_120000_0 n1_m1_116000_0 4.463529
R30 n1_m1_120000_0 n1_m1_124800_0 5.356235
R31 n1_m1_124800_0 n1_m1_129600_0 5.356235
R32 n1_m1_129600_0 n1_m1_134400_0 5.356235
R33 n1_m1_134400_0 n1_m1_139200_0 5.356235
R34 n1_m1_139200_0 n1_m1_144000_0 5.356235
R35 n1_m1_144000_0 n1_m1_148800_0 5.356235
R36 n1_m1_148800_0 n1_m1_153600_0 5.356235
R37 n1_m1_153600_0 n1_m1_158400_0 5.356235
R38 n1_m1_158400_0 n1_m1_163200_0 5.356235
R39 n1_m1_163200_0 n1_m1_168000_0 5.356235
R40 n1_m1_168000_0 n1_m1_172000_0 4.463529
R41 n1_m1_172800_0 n1_m1_172000_0 0.892706
R42 n1_m1_172800_0 n1_m1_177600_0 5.356235
R43 n1_m1_177600_0 n1_m1_182400_0 5.356235
R44 n1_m1_182400_0 n1_m1_187200_0 5.356235
R45 n1_m1_187200_0 n1_m1_192000_0 5.356235
R46 n1_m1_192000_0 n1_m1_196800_0 5.356235
R47 n1_m1_196800_0 n1_m1_200000_0 3.570824
R48 n1_m1_201600_0 n1_m1_200000_0 1.785412
R49 n1_m1_201600_0 n1_m1_206400_0 5.356235
R50 n1_m1_206400_0 n1_m1_211200_0 5.356235
R51 n1_m1_211200_0 n1_m1_216000_0 5.356235
R52 n1_m1_216000_0 n1_m1_220800_0 5.356235
R53 n1_m1_220800_0 n1_m1_225600_0 5.356235
R54 n1_m1_225600_0 n1_m1_228000_0 2.678118
R55 n1_m1_230400_0 n1_m1_228000_0 2.678118
R56 n1_m1_230400_0 n1_m1_235200_0 5.356235
R57 n1_m1_235200_0 n1_m1_240000_0 5.356235
R58 n1_m1_240000_0 n1_m1_244800_0 5.356235
R59 n1_m1_244800_0 n1_m1_249600_0 5.356235
R60 n1_m1_249600_0 n1_m1_254400_0 5.356235
R61 n1_m1_254400_0 n1_m1_256000_0 1.785412
R62 n1_m1_259200_0 n1_m1_256000_0 3.570824
R63 n1_m1_259200_0 n1_m1_264000_0 5.356235
R64 n1_m1_264000_0 n1_m1_268800_0 5.356235
R65 n1_m1_268800_0 n1_m1_273600_0 5.356235
R66 n1_m1_273600_0 n1_m1_278400_0 5.356235
R67 n1_m1_278400_0 n1_m1_283200_0 5.356235
R68 n1_m1_283200_0 n1_m1_284000_0 0.892706
R69 n1_m1_288000_0 n1_m1_284000_0 4.463529
R70 n1_m1_288000_0 n1_m1_292800_0 5.356235
R71 n1_m1_292800_0 n1_m1_297600_0 5.356235
R72 n1_m1_297600_0 n1_m1_302400_0 5.356235
R73 n1_m1_302400_0 n1_m1_307200_0 5.356235
R74 n1_m1_307200_0 n1_m1_312000_0 5.356235
R75 n1_m1_312000_0 n1_m1_316800_0 5.356235
R76 n1_m1_316800_0 n1_m1_321600_0 5.356235
R77 n1_m1_321600_0 n1_m1_326400_0 5.356235
R78 n1_m1_326400_0 n1_m1_331200_0 5.356235
R79 n1_m1_331200_0 n1_m1_336000_0 5.356235
R80 n1_m1_336000_0 n1_m1_340000_0 4.463529
R81 n1_m1_340800_0 n1_m1_340000_0 0.892706
R82 n1_m1_340800_0 n1_m1_345600_0 5.356235
R83 n1_m1_345600_0 n1_m1_350400_0 5.356235
R84 n1_m1_350400_0 n1_m1_355200_0 5.356235
R85 n1_m1_355200_0 n1_m1_360000_0 5.356235
R86 n1_m1_360000_0 n1_m1_364800_0 5.356235
R87 n1_m1_364800_0 n1_m1_368000_0 3.570824
R88 n1_m1_369600_0 n1_m1_368000_0 1.785412
R89 n1_m1_369600_0 n1_m1_374400_0 5.356235
R90 n1_m1_374400_0 n1_m1_379200_0 5.356235
R91 n1_m1_379200_0 n1_m1_384000_0 5.356235
R92 n1_m1_384000_0 n1_m1_388800_0 5.356235
R93 n1_m1_388800_0 n1_m1_393600_0 5.356235
R94 n1_m1_393600_0 n1_m1_396000_0 2.678118
R95 n1_m1_398400_0 n1_m1_396000_0 2.678118
R96 n1_m1_398400_0 n1_m1_403200_0 5.356235
R97 n1_m1_403200_0 n1_m1_408000_0 5.356235
R98 n1_m1_408000_0 n1_m1_412800_0 5.356235
R99 n1_m1_412800_0 n1_m1_417600_0 5.356235
R100 n1_m1_417600_0 n1_m1_422400_0 5.356235
R101 n1_m1_422400_0 n1_m1_424000_0 1.785412
R102 n1_m1_427200_0 n1_m1_424000_0 3.570824
R103 n1_m1_427200_0 n1_m1_432000_0 5.356235
R104 n1_m1_432000_0 n1_m1_436800_0 5.356235
R105 n1_m1_436800_0 n1_m1_441600_0 5.356235
R106 n1_m1_441600_0 n1_m1_446400_0 5.356235
R107 n1_m1_446400_0 n1_m1_451200_0 5.356235
R108 n1_m1_451200_0 n1_m1_452000_0 0.892706
R109 n1_m1_456000_0 n1_m1_452000_0 4.463529
R110 n1_m1_456000_0 n1_m1_460800_0 5.356235
R111 n1_m1_460800_0 n1_m1_465600_0 5.356235
R112 n1_m1_465600_0 n1_m1_470400_0 5.356235
R113 n1_m1_470400_0 n1_m1_475200_0 5.356235
R114 n1_m1_475200_0 n1_m1_480000_0 5.356235
R115 n1_m1_480000_0 n1_m1_484800_0 5.356235
R116 n1_m1_484800_0 n1_m1_489600_0 5.356235
R117 n1_m1_489600_0 n1_m1_494400_0 5.356235
R118 n1_m1_0_4800 n1_m1_4000_4800 4.463529
R119 n1_m1_4800_4800 n1_m1_4000_4800 0.892706
R120 n1_m1_4800_4800 n1_m1_9600_4800 5.356235
R121 n1_m1_9600_4800 n1_m1_14400_4800 5.356235
R122 n1_m1_14400_4800 n1_m1_19200_4800 5.356235
R123 n1_m1_19200_4800 n1_m1_24000_4800 5.356235
R124 n1_m1_24000_4800 n1_m1_28800_4800 5.356235
R125 n1_m1_28800_4800 n1_m1_32000_4800 3.570824
R126 n1_m1_33600_4800 n1_m1_32000_4800 1.785412
R127 n1_m1_33600_4800 n1_m1_38400_4800 5.356235
R128 n1_m1_38400_4800 n1_m1_43200_4800 5.356235
R129 n1_m1_43200_4800 n1_m1_48000_4800 5.356235
R130 n1_m1_48000_4800 n1_m1_52800_4800 5.356235
R131 n1_m1_52800_4800 n1_m1_57600_4800 5.356235
R132 n1_m1_57600_4800 n1_m1_60000_4800 2.678118
R133 n1_m1_62400_4800 n1_m1_60000_4800 2.678118
R134 n1_m1_62400_4800 n1_m1_67200_4800 5.356235
R135 n1_m1_67200_4800 n1_m1_72000_4800 5.356235
R136 n1_m1_72000_4800 n1_m1_76800_4800 5.356235
R137 n1_m1_76800_4800 n1_m1_81600_4800 5.356235
R138 n1_m1_81600_4800 n1_m1_86400_4800 5.356235
R139 n1_m1_86400_4800 n1_m1_88000_4800 1.785412
R140 n1_m1_91200_4800 n1_m1_88000_4800 3.570824
R141 n1_m1_91200_4800 n1_m1_96000_4800 5.356235
R142 n1_m1_96000_4800 n1_m1_100800_4800 5.356235
R143 n1_m1_100800_4800 n1_m1_105600_4800 5.356235
R144 n1_m1_105600_4800 n1_m1_110400_4800 5.356235
R145 n1_m1_110400_4800 n1_m1_115200_4800 5.356235
R146 n1_m1_115200_4800 n1_m1_116000_4800 0.892706
R147 n1_m1_120000_4800 n1_m1_116000_4800 4.463529
R148 n1_m1_120000_4800 n1_m1_124800_4800 5.356235
R149 n1_m1_124800_4800 n1_m1_129600_4800 5.356235
R150 n1_m1_129600_4800 n1_m1_134400_4800 5.356235
R151 n1_m1_134400_4800 n1_m1_139200_4800 5.356235
R152 n1_m1_139200_4800 n1_m1_144000_4800 5.356235
R153 n1_m1_144000_4800 n1_m1_148800_4800 5.356235
R154 n1_m1_148800_4800 n1_m1_153600_4800 5.356235
R155 n1_m1_153600_4800 n1_m1_158400_4800 5.356235
R156 n1_m1_158400_4800 n1_m1_163200_4800 5.356235
R157 n1_m1_163200_4800 n1_m1_168000_4800 5.356235
R158 n1_m1_168000_4800 n1_m1_172000_4800 4.463529
R159 n1_m1_172800_4800 n1_m1_172000_4800 0.892706
R160 n1_m1_172800_4800 n1_m1_177600_4800 5.356235
R161 n1_m1_177600_4800 n1_m1_182400_4800 5.356235
R162 n1_m1_182400_4800 n1_m1_187200_4800 5.356235
R163 n1_m1_187200_4800 n1_m1_192000_4800 5.356235
R164 n1_m1_192000_4800 n1_m1_196800_4800 5.356235
R165 n1_m1_196800_4800 n1_m1_200000_4800 3.570824
R166 n1_m1_201600_4800 n1_m1_200000_4800 1.785412
R167 n1_m1_201600_4800 n1_m1_206400_4800 5.356235
R168 n1_m1_206400_4800 n1_m1_211200_4800 5.356235
R169 n1_m1_211200_4800 n1_m1_216000_4800 5.356235
R170 n1_m1_216000_4800 n1_m1_220800_4800 5.356235
R171 n1_m1_220800_4800 n1_m1_225600_4800 5.356235
R172 n1_m1_225600_4800 n1_m1_228000_4800 2.678118
R173 n1_m1_230400_4800 n1_m1_228000_4800 2.678118
R174 n1_m1_230400_4800 n1_m1_235200_4800 5.356235
R175 n1_m1_235200_4800 n1_m1_240000_4800 5.356235
R176 n1_m1_240000_4800 n1_m1_244800_4800 5.356235
R177 n1_m1_244800_4800 n1_m1_249600_4800 5.356235
R178 n1_m1_249600_4800 n1_m1_254400_4800 5.356235
R179 n1_m1_254400_4800 n1_m1_256000_4800 1.785412
R180 n1_m1_259200_4800 n1_m1_256000_4800 3.570824
R181 n1_m1_259200_4800 n1_m1_264000_4800 5.356235
R182 n1_m1_264000_4800 n1_m1_268800_4800 5.356235
R183 n1_m1_268800_4800 n1_m1_273600_4800 5.356235
R184 n1_m1_273600_4800 n1_m1_278400_4800 5.356235
R185 n1_m1_278400_4800 n1_m1_283200_4800 5.356235
R186 n1_m1_283200_4800 n1_m1_284000_4800 0.892706
R187 n1_m1_288000_4800 n1_m1_284000_4800 4.463529
R188 n1_m1_288000_4800 n1_m1_292800_4800 5.356235
R189 n1_m1_292800_4800 n1_m1_297600_4800 5.356235
R190 n1_m1_297600_4800 n1_m1_302400_4800 5.356235
R191 n1_m1_302400_4800 n1_m1_307200_4800 5.356235
R192 n1_m1_307200_4800 n1_m1_312000_4800 5.356235
R193 n1_m1_312000_4800 n1_m1_316800_4800 5.356235
R194 n1_m1_316800_4800 n1_m1_321600_4800 5.356235
R195 n1_m1_321600_4800 n1_m1_326400_4800 5.356235
R196 n1_m1_326400_4800 n1_m1_331200_4800 5.356235
R197 n1_m1_331200_4800 n1_m1_336000_4800 5.356235
R198 n1_m1_336000_4800 n1_m1_340000_4800 4.463529
R199 n1_m1_340800_4800 n1_m1_340000_4800 0.892706
R200 n1_m1_340800_4800 n1_m1_345600_4800 5.356235
R201 n1_m1_345600_4800 n1_m1_350400_4800 5.356235
R202 n1_m1_350400_4800 n1_m1_355200_4800 5.356235
R203 n1_m1_355200_4800 n1_m1_360000_4800 5.356235
R204 n1_m1_360000_4800 n1_m1_364800_4800 5.356235
R205 n1_m1_364800_4800 n1_m1_368000_4800 3.570824
R206 n1_m1_369600_4800 n1_m1_368000_4800 1.785412
R207 n1_m1_369600_4800 n1_m1_374400_4800 5.356235
R208 n1_m1_374400_4800 n1_m1_379200_4800 5.356235
R209 n1_m1_379200_4800 n1_m1_384000_4800 5.356235
R210 n1_m1_384000_4800 n1_m1_388800_4800 5.356235
R211 n1_m1_388800_4800 n1_m1_393600_4800 5.356235
R212 n1_m1_393600_4800 n1_m1_396000_4800 2.678118
R213 n1_m1_398400_4800 n1_m1_396000_4800 2.678118
R214 n1_m1_398400_4800 n1_m1_403200_4800 5.356235
R215 n1_m1_403200_4800 n1_m1_408000_4800 5.356235
R216 n1_m1_408000_4800 n1_m1_412800_4800 5.356235
R217 n1_m1_412800_4800 n1_m1_417600_4800 5.356235
R218 n1_m1_417600_4800 n1_m1_422400_4800 5.356235
R219 n1_m1_422400_4800 n1_m1_424000_4800 1.785412
R220 n1_m1_427200_4800 n1_m1_424000_4800 3.570824
R221 n1_m1_427200_4800 n1_m1_432000_4800 5.356235
R222 n1_m1_432000_4800 n1_m1_436800_4800 5.356235
R223 n1_m1_436800_4800 n1_m1_441600_4800 5.356235
R224 n1_m1_441600_4800 n1_m1_446400_4800 5.356235
R225 n1_m1_446400_4800 n1_m1_451200_4800 5.356235
R226 n1_m1_451200_4800 n1_m1_452000_4800 0.892706
R227 n1_m1_456000_4800 n1_m1_452000_4800 4.463529
R228 n1_m1_456000_4800 n1_m1_460800_4800 5.356235
R229 n1_m1_460800_4800 n1_m1_465600_4800 5.356235
R230 n1_m1_465600_4800 n1_m1_470400_4800 5.356235
R231 n1_m1_470400_4800 n1_m1_475200_4800 5.356235
R232 n1_m1_475200_4800 n1_m1_480000_4800 5.356235
R233 n1_m1_480000_4800 n1_m1_484800_4800 5.356235
R234 n1_m1_484800_4800 n1_m1_489600_4800 5.356235
R235 n1_m1_489600_4800 n1_m1_494400_4800 5.356235
R236 n1_m1_0_9600 n1_m1_4000_9600 4.463529
R237 n1_m1_4800_9600 n1_m1_4000_9600 0.892706
R238 n1_m1_4800_9600 n1_m1_9600_9600 5.356235
R239 n1_m1_9600_9600 n1_m1_14400_9600 5.356235
R240 n1_m1_14400_9600 n1_m1_19200_9600 5.356235
R241 n1_m1_19200_9600 n1_m1_24000_9600 5.356235
R242 n1_m1_24000_9600 n1_m1_28800_9600 5.356235
R243 n1_m1_28800_9600 n1_m1_32000_9600 3.570824
R244 n1_m1_33600_9600 n1_m1_32000_9600 1.785412
R245 n1_m1_33600_9600 n1_m1_38400_9600 5.356235
R246 n1_m1_38400_9600 n1_m1_43200_9600 5.356235
R247 n1_m1_43200_9600 n1_m1_48000_9600 5.356235
R248 n1_m1_48000_9600 n1_m1_52800_9600 5.356235
R249 n1_m1_52800_9600 n1_m1_57600_9600 5.356235
R250 n1_m1_57600_9600 n1_m1_60000_9600 2.678118
R251 n1_m1_62400_9600 n1_m1_60000_9600 2.678118
R252 n1_m1_62400_9600 n1_m1_67200_9600 5.356235
R253 n1_m1_67200_9600 n1_m1_72000_9600 5.356235
R254 n1_m1_72000_9600 n1_m1_76800_9600 5.356235
R255 n1_m1_76800_9600 n1_m1_81600_9600 5.356235
R256 n1_m1_81600_9600 n1_m1_86400_9600 5.356235
R257 n1_m1_86400_9600 n1_m1_88000_9600 1.785412
R258 n1_m1_91200_9600 n1_m1_88000_9600 3.570824
R259 n1_m1_91200_9600 n1_m1_96000_9600 5.356235
R260 n1_m1_96000_9600 n1_m1_100800_9600 5.356235
R261 n1_m1_100800_9600 n1_m1_105600_9600 5.356235
R262 n1_m1_105600_9600 n1_m1_110400_9600 5.356235
R263 n1_m1_110400_9600 n1_m1_115200_9600 5.356235
R264 n1_m1_115200_9600 n1_m1_116000_9600 0.892706
R265 n1_m1_120000_9600 n1_m1_116000_9600 4.463529
R266 n1_m1_120000_9600 n1_m1_124800_9600 5.356235
R267 n1_m1_124800_9600 n1_m1_129600_9600 5.356235
R268 n1_m1_129600_9600 n1_m1_134400_9600 5.356235
R269 n1_m1_134400_9600 n1_m1_139200_9600 5.356235
R270 n1_m1_139200_9600 n1_m1_144000_9600 5.356235
R271 n1_m1_144000_9600 n1_m1_148800_9600 5.356235
R272 n1_m1_148800_9600 n1_m1_153600_9600 5.356235
R273 n1_m1_153600_9600 n1_m1_158400_9600 5.356235
R274 n1_m1_158400_9600 n1_m1_163200_9600 5.356235
R275 n1_m1_163200_9600 n1_m1_168000_9600 5.356235
R276 n1_m1_168000_9600 n1_m1_172000_9600 4.463529
R277 n1_m1_172800_9600 n1_m1_172000_9600 0.892706
R278 n1_m1_172800_9600 n1_m1_177600_9600 5.356235
R279 n1_m1_177600_9600 n1_m1_182400_9600 5.356235
R280 n1_m1_182400_9600 n1_m1_187200_9600 5.356235
R281 n1_m1_187200_9600 n1_m1_192000_9600 5.356235
R282 n1_m1_192000_9600 n1_m1_196800_9600 5.356235
R283 n1_m1_196800_9600 n1_m1_200000_9600 3.570824
R284 n1_m1_201600_9600 n1_m1_200000_9600 1.785412
R285 n1_m1_201600_9600 n1_m1_206400_9600 5.356235
R286 n1_m1_206400_9600 n1_m1_211200_9600 5.356235
R287 n1_m1_211200_9600 n1_m1_216000_9600 5.356235
R288 n1_m1_216000_9600 n1_m1_220800_9600 5.356235
R289 n1_m1_220800_9600 n1_m1_225600_9600 5.356235
R290 n1_m1_225600_9600 n1_m1_228000_9600 2.678118
R291 n1_m1_230400_9600 n1_m1_228000_9600 2.678118
R292 n1_m1_230400_9600 n1_m1_235200_9600 5.356235
R293 n1_m1_235200_9600 n1_m1_240000_9600 5.356235
R294 n1_m1_240000_9600 n1_m1_244800_9600 5.356235
R295 n1_m1_244800_9600 n1_m1_249600_9600 5.356235
R296 n1_m1_249600_9600 n1_m1_254400_9600 5.356235
R297 n1_m1_254400_9600 n1_m1_256000_9600 1.785412
R298 n1_m1_259200_9600 n1_m1_256000_9600 3.570824
R299 n1_m1_259200_9600 n1_m1_264000_9600 5.356235
R300 n1_m1_264000_9600 n1_m1_268800_9600 5.356235
R301 n1_m1_268800_9600 n1_m1_273600_9600 5.356235
R302 n1_m1_273600_9600 n1_m1_278400_9600 5.356235
R303 n1_m1_278400_9600 n1_m1_283200_9600 5.356235
R304 n1_m1_283200_9600 n1_m1_284000_9600 0.892706
R305 n1_m1_288000_9600 n1_m1_284000_9600 4.463529
R306 n1_m1_288000_9600 n1_m1_292800_9600 5.356235
R307 n1_m1_292800_9600 n1_m1_297600_9600 5.356235
R308 n1_m1_297600_9600 n1_m1_302400_9600 5.356235
R309 n1_m1_302400_9600 n1_m1_307200_9600 5.356235
R310 n1_m1_307200_9600 n1_m1_312000_9600 5.356235
R311 n1_m1_312000_9600 n1_m1_316800_9600 5.356235
R312 n1_m1_316800_9600 n1_m1_321600_9600 5.356235
R313 n1_m1_321600_9600 n1_m1_326400_9600 5.356235
R314 n1_m1_326400_9600 n1_m1_331200_9600 5.356235
R315 n1_m1_331200_9600 n1_m1_336000_9600 5.356235
R316 n1_m1_336000_9600 n1_m1_340000_9600 4.463529
R317 n1_m1_340800_9600 n1_m1_340000_9600 0.892706
R318 n1_m1_340800_9600 n1_m1_345600_9600 5.356235
R319 n1_m1_345600_9600 n1_m1_350400_9600 5.356235
R320 n1_m1_350400_9600 n1_m1_355200_9600 5.356235
R321 n1_m1_355200_9600 n1_m1_360000_9600 5.356235
R322 n1_m1_360000_9600 n1_m1_364800_9600 5.356235
R323 n1_m1_364800_9600 n1_m1_368000_9600 3.570824
R324 n1_m1_369600_9600 n1_m1_368000_9600 1.785412
R325 n1_m1_369600_9600 n1_m1_374400_9600 5.356235
R326 n1_m1_374400_9600 n1_m1_379200_9600 5.356235
R327 n1_m1_379200_9600 n1_m1_384000_9600 5.356235
R328 n1_m1_384000_9600 n1_m1_388800_9600 5.356235
R329 n1_m1_388800_9600 n1_m1_393600_9600 5.356235
R330 n1_m1_393600_9600 n1_m1_396000_9600 2.678118
R331 n1_m1_398400_9600 n1_m1_396000_9600 2.678118
R332 n1_m1_398400_9600 n1_m1_403200_9600 5.356235
R333 n1_m1_403200_9600 n1_m1_408000_9600 5.356235
R334 n1_m1_408000_9600 n1_m1_412800_9600 5.356235
R335 n1_m1_412800_9600 n1_m1_417600_9600 5.356235
R336 n1_m1_417600_9600 n1_m1_422400_9600 5.356235
R337 n1_m1_422400_9600 n1_m1_424000_9600 1.785412
R338 n1_m1_427200_9600 n1_m1_424000_9600 3.570824
R339 n1_m1_427200_9600 n1_m1_432000_9600 5.356235
R340 n1_m1_432000_9600 n1_m1_436800_9600 5.356235
R341 n1_m1_436800_9600 n1_m1_441600_9600 5.356235
R342 n1_m1_441600_9600 n1_m1_446400_9600 5.356235
R343 n1_m1_446400_9600 n1_m1_451200_9600 5.356235
R344 n1_m1_451200_9600 n1_m1_452000_9600 0.892706
R345 n1_m1_456000_9600 n1_m1_452000_9600 4.463529
R346 n1_m1_456000_9600 n1_m1_460800_9600 5.356235
R347 n1_m1_460800_9600 n1_m1_465600_9600 5.356235
R348 n1_m1_465600_9600 n1_m1_470400_9600 5.356235
R349 n1_m1_470400_9600 n1_m1_475200_9600 5.356235
R350 n1_m1_475200_9600 n1_m1_480000_9600 5.356235
R351 n1_m1_480000_9600 n1_m1_484800_9600 5.356235
R352 n1_m1_484800_9600 n1_m1_489600_9600 5.356235
R353 n1_m1_489600_9600 n1_m1_494400_9600 5.356235
R354 n1_m1_0_14400 n1_m1_4000_14400 4.463529
R355 n1_m1_4800_14400 n1_m1_4000_14400 0.892706
R356 n1_m1_4800_14400 n1_m1_9600_14400 5.356235
R357 n1_m1_9600_14400 n1_m1_14400_14400 5.356235
R358 n1_m1_14400_14400 n1_m1_19200_14400 5.356235
R359 n1_m1_19200_14400 n1_m1_24000_14400 5.356235
R360 n1_m1_24000_14400 n1_m1_28800_14400 5.356235
R361 n1_m1_28800_14400 n1_m1_32000_14400 3.570824
R362 n1_m1_33600_14400 n1_m1_32000_14400 1.785412
R363 n1_m1_33600_14400 n1_m1_38400_14400 5.356235
R364 n1_m1_38400_14400 n1_m1_43200_14400 5.356235
R365 n1_m1_43200_14400 n1_m1_48000_14400 5.356235
R366 n1_m1_48000_14400 n1_m1_52800_14400 5.356235
R367 n1_m1_52800_14400 n1_m1_57600_14400 5.356235
R368 n1_m1_57600_14400 n1_m1_60000_14400 2.678118
R369 n1_m1_62400_14400 n1_m1_60000_14400 2.678118
R370 n1_m1_62400_14400 n1_m1_67200_14400 5.356235
R371 n1_m1_67200_14400 n1_m1_72000_14400 5.356235
R372 n1_m1_72000_14400 n1_m1_76800_14400 5.356235
R373 n1_m1_76800_14400 n1_m1_81600_14400 5.356235
R374 n1_m1_81600_14400 n1_m1_86400_14400 5.356235
R375 n1_m1_86400_14400 n1_m1_88000_14400 1.785412
R376 n1_m1_91200_14400 n1_m1_88000_14400 3.570824
R377 n1_m1_91200_14400 n1_m1_96000_14400 5.356235
R378 n1_m1_96000_14400 n1_m1_100800_14400 5.356235
R379 n1_m1_100800_14400 n1_m1_105600_14400 5.356235
R380 n1_m1_105600_14400 n1_m1_110400_14400 5.356235
R381 n1_m1_110400_14400 n1_m1_115200_14400 5.356235
R382 n1_m1_115200_14400 n1_m1_116000_14400 0.892706
R383 n1_m1_120000_14400 n1_m1_116000_14400 4.463529
R384 n1_m1_120000_14400 n1_m1_124800_14400 5.356235
R385 n1_m1_124800_14400 n1_m1_129600_14400 5.356235
R386 n1_m1_129600_14400 n1_m1_134400_14400 5.356235
R387 n1_m1_134400_14400 n1_m1_139200_14400 5.356235
R388 n1_m1_139200_14400 n1_m1_144000_14400 5.356235
R389 n1_m1_144000_14400 n1_m1_148800_14400 5.356235
R390 n1_m1_148800_14400 n1_m1_153600_14400 5.356235
R391 n1_m1_153600_14400 n1_m1_158400_14400 5.356235
R392 n1_m1_158400_14400 n1_m1_163200_14400 5.356235
R393 n1_m1_163200_14400 n1_m1_168000_14400 5.356235
R394 n1_m1_168000_14400 n1_m1_172000_14400 4.463529
R395 n1_m1_172800_14400 n1_m1_172000_14400 0.892706
R396 n1_m1_172800_14400 n1_m1_177600_14400 5.356235
R397 n1_m1_177600_14400 n1_m1_182400_14400 5.356235
R398 n1_m1_182400_14400 n1_m1_187200_14400 5.356235
R399 n1_m1_187200_14400 n1_m1_192000_14400 5.356235
R400 n1_m1_192000_14400 n1_m1_196800_14400 5.356235
R401 n1_m1_196800_14400 n1_m1_200000_14400 3.570824
R402 n1_m1_201600_14400 n1_m1_200000_14400 1.785412
R403 n1_m1_201600_14400 n1_m1_206400_14400 5.356235
R404 n1_m1_206400_14400 n1_m1_211200_14400 5.356235
R405 n1_m1_211200_14400 n1_m1_216000_14400 5.356235
R406 n1_m1_216000_14400 n1_m1_220800_14400 5.356235
R407 n1_m1_220800_14400 n1_m1_225600_14400 5.356235
R408 n1_m1_225600_14400 n1_m1_228000_14400 2.678118
R409 n1_m1_230400_14400 n1_m1_228000_14400 2.678118
R410 n1_m1_230400_14400 n1_m1_235200_14400 5.356235
R411 n1_m1_235200_14400 n1_m1_240000_14400 5.356235
R412 n1_m1_240000_14400 n1_m1_244800_14400 5.356235
R413 n1_m1_244800_14400 n1_m1_249600_14400 5.356235
R414 n1_m1_249600_14400 n1_m1_254400_14400 5.356235
R415 n1_m1_254400_14400 n1_m1_256000_14400 1.785412
R416 n1_m1_259200_14400 n1_m1_256000_14400 3.570824
R417 n1_m1_259200_14400 n1_m1_264000_14400 5.356235
R418 n1_m1_264000_14400 n1_m1_268800_14400 5.356235
R419 n1_m1_268800_14400 n1_m1_273600_14400 5.356235
R420 n1_m1_273600_14400 n1_m1_278400_14400 5.356235
R421 n1_m1_278400_14400 n1_m1_283200_14400 5.356235
R422 n1_m1_283200_14400 n1_m1_284000_14400 0.892706
R423 n1_m1_288000_14400 n1_m1_284000_14400 4.463529
R424 n1_m1_288000_14400 n1_m1_292800_14400 5.356235
R425 n1_m1_292800_14400 n1_m1_297600_14400 5.356235
R426 n1_m1_297600_14400 n1_m1_302400_14400 5.356235
R427 n1_m1_302400_14400 n1_m1_307200_14400 5.356235
R428 n1_m1_307200_14400 n1_m1_312000_14400 5.356235
R429 n1_m1_312000_14400 n1_m1_316800_14400 5.356235
R430 n1_m1_316800_14400 n1_m1_321600_14400 5.356235
R431 n1_m1_321600_14400 n1_m1_326400_14400 5.356235
R432 n1_m1_326400_14400 n1_m1_331200_14400 5.356235
R433 n1_m1_331200_14400 n1_m1_336000_14400 5.356235
R434 n1_m1_336000_14400 n1_m1_340000_14400 4.463529
R435 n1_m1_340800_14400 n1_m1_340000_14400 0.892706
R436 n1_m1_340800_14400 n1_m1_345600_14400 5.356235
R437 n1_m1_345600_14400 n1_m1_350400_14400 5.356235
R438 n1_m1_350400_14400 n1_m1_355200_14400 5.356235
R439 n1_m1_355200_14400 n1_m1_360000_14400 5.356235
R440 n1_m1_360000_14400 n1_m1_364800_14400 5.356235
R441 n1_m1_364800_14400 n1_m1_368000_14400 3.570824
R442 n1_m1_369600_14400 n1_m1_368000_14400 1.785412
R443 n1_m1_369600_14400 n1_m1_374400_14400 5.356235
R444 n1_m1_374400_14400 n1_m1_379200_14400 5.356235
R445 n1_m1_379200_14400 n1_m1_384000_14400 5.356235
R446 n1_m1_384000_14400 n1_m1_388800_14400 5.356235
R447 n1_m1_388800_14400 n1_m1_393600_14400 5.356235
R448 n1_m1_393600_14400 n1_m1_396000_14400 2.678118
R449 n1_m1_398400_14400 n1_m1_396000_14400 2.678118
R450 n1_m1_398400_14400 n1_m1_403200_14400 5.356235
R451 n1_m1_403200_14400 n1_m1_408000_14400 5.356235
R452 n1_m1_408000_14400 n1_m1_412800_14400 5.356235
R453 n1_m1_412800_14400 n1_m1_417600_14400 5.356235
R454 n1_m1_417600_14400 n1_m1_422400_14400 5.356235
R455 n1_m1_422400_14400 n1_m1_424000_14400 1.785412
R456 n1_m1_427200_14400 n1_m1_424000_14400 3.570824
R457 n1_m1_427200_14400 n1_m1_432000_14400 5.356235
R458 n1_m1_432000_14400 n1_m1_436800_14400 5.356235
R459 n1_m1_436800_14400 n1_m1_441600_14400 5.356235
R460 n1_m1_441600_14400 n1_m1_446400_14400 5.356235
R461 n1_m1_446400_14400 n1_m1_451200_14400 5.356235
R462 n1_m1_451200_14400 n1_m1_452000_14400 0.892706
R463 n1_m1_456000_14400 n1_m1_452000_14400 4.463529
R464 n1_m1_456000_14400 n1_m1_460800_14400 5.356235
R465 n1_m1_460800_14400 n1_m1_465600_14400 5.356235
R466 n1_m1_465600_14400 n1_m1_470400_14400 5.356235
R467 n1_m1_470400_14400 n1_m1_475200_14400 5.356235
R468 n1_m1_475200_14400 n1_m1_480000_14400 5.356235
R469 n1_m1_480000_14400 n1_m1_484800_14400 5.356235
R470 n1_m1_484800_14400 n1_m1_489600_14400 5.356235
R471 n1_m1_489600_14400 n1_m1_494400_14400 5.356235
R472 n1_m1_0_19200 n1_m1_4000_19200 4.463529
R473 n1_m1_4800_19200 n1_m1_4000_19200 0.892706
R474 n1_m1_4800_19200 n1_m1_9600_19200 5.356235
R475 n1_m1_9600_19200 n1_m1_14400_19200 5.356235
R476 n1_m1_14400_19200 n1_m1_19200_19200 5.356235
R477 n1_m1_19200_19200 n1_m1_24000_19200 5.356235
R478 n1_m1_24000_19200 n1_m1_28800_19200 5.356235
R479 n1_m1_28800_19200 n1_m1_32000_19200 3.570824
R480 n1_m1_33600_19200 n1_m1_32000_19200 1.785412
R481 n1_m1_33600_19200 n1_m1_38400_19200 5.356235
R482 n1_m1_38400_19200 n1_m1_43200_19200 5.356235
R483 n1_m1_43200_19200 n1_m1_48000_19200 5.356235
R484 n1_m1_48000_19200 n1_m1_52800_19200 5.356235
R485 n1_m1_52800_19200 n1_m1_57600_19200 5.356235
R486 n1_m1_57600_19200 n1_m1_60000_19200 2.678118
R487 n1_m1_62400_19200 n1_m1_60000_19200 2.678118
R488 n1_m1_62400_19200 n1_m1_67200_19200 5.356235
R489 n1_m1_67200_19200 n1_m1_72000_19200 5.356235
R490 n1_m1_72000_19200 n1_m1_76800_19200 5.356235
R491 n1_m1_76800_19200 n1_m1_81600_19200 5.356235
R492 n1_m1_81600_19200 n1_m1_86400_19200 5.356235
R493 n1_m1_86400_19200 n1_m1_88000_19200 1.785412
R494 n1_m1_91200_19200 n1_m1_88000_19200 3.570824
R495 n1_m1_91200_19200 n1_m1_96000_19200 5.356235
R496 n1_m1_96000_19200 n1_m1_100800_19200 5.356235
R497 n1_m1_100800_19200 n1_m1_105600_19200 5.356235
R498 n1_m1_105600_19200 n1_m1_110400_19200 5.356235
R499 n1_m1_110400_19200 n1_m1_115200_19200 5.356235
R500 n1_m1_115200_19200 n1_m1_116000_19200 0.892706
R501 n1_m1_120000_19200 n1_m1_116000_19200 4.463529
R502 n1_m1_120000_19200 n1_m1_124800_19200 5.356235
R503 n1_m1_124800_19200 n1_m1_129600_19200 5.356235
R504 n1_m1_129600_19200 n1_m1_134400_19200 5.356235
R505 n1_m1_134400_19200 n1_m1_139200_19200 5.356235
R506 n1_m1_139200_19200 n1_m1_144000_19200 5.356235
R507 n1_m1_144000_19200 n1_m1_148800_19200 5.356235
R508 n1_m1_148800_19200 n1_m1_153600_19200 5.356235
R509 n1_m1_153600_19200 n1_m1_158400_19200 5.356235
R510 n1_m1_158400_19200 n1_m1_163200_19200 5.356235
R511 n1_m1_163200_19200 n1_m1_168000_19200 5.356235
R512 n1_m1_168000_19200 n1_m1_172000_19200 4.463529
R513 n1_m1_172800_19200 n1_m1_172000_19200 0.892706
R514 n1_m1_172800_19200 n1_m1_177600_19200 5.356235
R515 n1_m1_177600_19200 n1_m1_182400_19200 5.356235
R516 n1_m1_182400_19200 n1_m1_187200_19200 5.356235
R517 n1_m1_187200_19200 n1_m1_192000_19200 5.356235
R518 n1_m1_192000_19200 n1_m1_196800_19200 5.356235
R519 n1_m1_196800_19200 n1_m1_200000_19200 3.570824
R520 n1_m1_201600_19200 n1_m1_200000_19200 1.785412
R521 n1_m1_201600_19200 n1_m1_206400_19200 5.356235
R522 n1_m1_206400_19200 n1_m1_211200_19200 5.356235
R523 n1_m1_211200_19200 n1_m1_216000_19200 5.356235
R524 n1_m1_216000_19200 n1_m1_220800_19200 5.356235
R525 n1_m1_220800_19200 n1_m1_225600_19200 5.356235
R526 n1_m1_225600_19200 n1_m1_228000_19200 2.678118
R527 n1_m1_230400_19200 n1_m1_228000_19200 2.678118
R528 n1_m1_230400_19200 n1_m1_235200_19200 5.356235
R529 n1_m1_235200_19200 n1_m1_240000_19200 5.356235
R530 n1_m1_240000_19200 n1_m1_244800_19200 5.356235
R531 n1_m1_244800_19200 n1_m1_249600_19200 5.356235
R532 n1_m1_249600_19200 n1_m1_254400_19200 5.356235
R533 n1_m1_254400_19200 n1_m1_256000_19200 1.785412
R534 n1_m1_259200_19200 n1_m1_256000_19200 3.570824
R535 n1_m1_259200_19200 n1_m1_264000_19200 5.356235
R536 n1_m1_264000_19200 n1_m1_268800_19200 5.356235
R537 n1_m1_268800_19200 n1_m1_273600_19200 5.356235
R538 n1_m1_273600_19200 n1_m1_278400_19200 5.356235
R539 n1_m1_278400_19200 n1_m1_283200_19200 5.356235
R540 n1_m1_283200_19200 n1_m1_284000_19200 0.892706
R541 n1_m1_288000_19200 n1_m1_284000_19200 4.463529
R542 n1_m1_288000_19200 n1_m1_292800_19200 5.356235
R543 n1_m1_292800_19200 n1_m1_297600_19200 5.356235
R544 n1_m1_297600_19200 n1_m1_302400_19200 5.356235
R545 n1_m1_302400_19200 n1_m1_307200_19200 5.356235
R546 n1_m1_307200_19200 n1_m1_312000_19200 5.356235
R547 n1_m1_312000_19200 n1_m1_316800_19200 5.356235
R548 n1_m1_316800_19200 n1_m1_321600_19200 5.356235
R549 n1_m1_321600_19200 n1_m1_326400_19200 5.356235
R550 n1_m1_326400_19200 n1_m1_331200_19200 5.356235
R551 n1_m1_331200_19200 n1_m1_336000_19200 5.356235
R552 n1_m1_336000_19200 n1_m1_340000_19200 4.463529
R553 n1_m1_340800_19200 n1_m1_340000_19200 0.892706
R554 n1_m1_340800_19200 n1_m1_345600_19200 5.356235
R555 n1_m1_345600_19200 n1_m1_350400_19200 5.356235
R556 n1_m1_350400_19200 n1_m1_355200_19200 5.356235
R557 n1_m1_355200_19200 n1_m1_360000_19200 5.356235
R558 n1_m1_360000_19200 n1_m1_364800_19200 5.356235
R559 n1_m1_364800_19200 n1_m1_368000_19200 3.570824
R560 n1_m1_369600_19200 n1_m1_368000_19200 1.785412
R561 n1_m1_369600_19200 n1_m1_374400_19200 5.356235
R562 n1_m1_374400_19200 n1_m1_379200_19200 5.356235
R563 n1_m1_379200_19200 n1_m1_384000_19200 5.356235
R564 n1_m1_384000_19200 n1_m1_388800_19200 5.356235
R565 n1_m1_388800_19200 n1_m1_393600_19200 5.356235
R566 n1_m1_393600_19200 n1_m1_396000_19200 2.678118
R567 n1_m1_398400_19200 n1_m1_396000_19200 2.678118
R568 n1_m1_398400_19200 n1_m1_403200_19200 5.356235
R569 n1_m1_403200_19200 n1_m1_408000_19200 5.356235
R570 n1_m1_408000_19200 n1_m1_412800_19200 5.356235
R571 n1_m1_412800_19200 n1_m1_417600_19200 5.356235
R572 n1_m1_417600_19200 n1_m1_422400_19200 5.356235
R573 n1_m1_422400_19200 n1_m1_424000_19200 1.785412
R574 n1_m1_427200_19200 n1_m1_424000_19200 3.570824
R575 n1_m1_427200_19200 n1_m1_432000_19200 5.356235
R576 n1_m1_432000_19200 n1_m1_436800_19200 5.356235
R577 n1_m1_436800_19200 n1_m1_441600_19200 5.356235
R578 n1_m1_441600_19200 n1_m1_446400_19200 5.356235
R579 n1_m1_446400_19200 n1_m1_451200_19200 5.356235
R580 n1_m1_451200_19200 n1_m1_452000_19200 0.892706
R581 n1_m1_456000_19200 n1_m1_452000_19200 4.463529
R582 n1_m1_456000_19200 n1_m1_460800_19200 5.356235
R583 n1_m1_460800_19200 n1_m1_465600_19200 5.356235
R584 n1_m1_465600_19200 n1_m1_470400_19200 5.356235
R585 n1_m1_470400_19200 n1_m1_475200_19200 5.356235
R586 n1_m1_475200_19200 n1_m1_480000_19200 5.356235
R587 n1_m1_480000_19200 n1_m1_484800_19200 5.356235
R588 n1_m1_484800_19200 n1_m1_489600_19200 5.356235
R589 n1_m1_489600_19200 n1_m1_494400_19200 5.356235
R590 n1_m1_0_24000 n1_m1_4000_24000 4.463529
R591 n1_m1_4800_24000 n1_m1_4000_24000 0.892706
R592 n1_m1_4800_24000 n1_m1_9600_24000 5.356235
R593 n1_m1_9600_24000 n1_m1_14400_24000 5.356235
R594 n1_m1_14400_24000 n1_m1_19200_24000 5.356235
R595 n1_m1_19200_24000 n1_m1_24000_24000 5.356235
R596 n1_m1_24000_24000 n1_m1_28800_24000 5.356235
R597 n1_m1_28800_24000 n1_m1_32000_24000 3.570824
R598 n1_m1_33600_24000 n1_m1_32000_24000 1.785412
R599 n1_m1_33600_24000 n1_m1_38400_24000 5.356235
R600 n1_m1_38400_24000 n1_m1_43200_24000 5.356235
R601 n1_m1_43200_24000 n1_m1_48000_24000 5.356235
R602 n1_m1_48000_24000 n1_m1_52800_24000 5.356235
R603 n1_m1_52800_24000 n1_m1_57600_24000 5.356235
R604 n1_m1_57600_24000 n1_m1_60000_24000 2.678118
R605 n1_m1_62400_24000 n1_m1_60000_24000 2.678118
R606 n1_m1_62400_24000 n1_m1_67200_24000 5.356235
R607 n1_m1_67200_24000 n1_m1_72000_24000 5.356235
R608 n1_m1_72000_24000 n1_m1_76800_24000 5.356235
R609 n1_m1_76800_24000 n1_m1_81600_24000 5.356235
R610 n1_m1_81600_24000 n1_m1_86400_24000 5.356235
R611 n1_m1_86400_24000 n1_m1_88000_24000 1.785412
R612 n1_m1_91200_24000 n1_m1_88000_24000 3.570824
R613 n1_m1_91200_24000 n1_m1_96000_24000 5.356235
R614 n1_m1_96000_24000 n1_m1_100800_24000 5.356235
R615 n1_m1_100800_24000 n1_m1_105600_24000 5.356235
R616 n1_m1_105600_24000 n1_m1_110400_24000 5.356235
R617 n1_m1_110400_24000 n1_m1_115200_24000 5.356235
R618 n1_m1_115200_24000 n1_m1_116000_24000 0.892706
R619 n1_m1_120000_24000 n1_m1_116000_24000 4.463529
R620 n1_m1_120000_24000 n1_m1_124800_24000 5.356235
R621 n1_m1_124800_24000 n1_m1_129600_24000 5.356235
R622 n1_m1_129600_24000 n1_m1_134400_24000 5.356235
R623 n1_m1_134400_24000 n1_m1_139200_24000 5.356235
R624 n1_m1_139200_24000 n1_m1_144000_24000 5.356235
R625 n1_m1_144000_24000 n1_m1_148800_24000 5.356235
R626 n1_m1_148800_24000 n1_m1_153600_24000 5.356235
R627 n1_m1_153600_24000 n1_m1_158400_24000 5.356235
R628 n1_m1_158400_24000 n1_m1_163200_24000 5.356235
R629 n1_m1_163200_24000 n1_m1_168000_24000 5.356235
R630 n1_m1_168000_24000 n1_m1_172000_24000 4.463529
R631 n1_m1_172800_24000 n1_m1_172000_24000 0.892706
R632 n1_m1_172800_24000 n1_m1_177600_24000 5.356235
R633 n1_m1_177600_24000 n1_m1_182400_24000 5.356235
R634 n1_m1_182400_24000 n1_m1_187200_24000 5.356235
R635 n1_m1_187200_24000 n1_m1_192000_24000 5.356235
R636 n1_m1_192000_24000 n1_m1_196800_24000 5.356235
R637 n1_m1_196800_24000 n1_m1_200000_24000 3.570824
R638 n1_m1_201600_24000 n1_m1_200000_24000 1.785412
R639 n1_m1_201600_24000 n1_m1_206400_24000 5.356235
R640 n1_m1_206400_24000 n1_m1_211200_24000 5.356235
R641 n1_m1_211200_24000 n1_m1_216000_24000 5.356235
R642 n1_m1_216000_24000 n1_m1_220800_24000 5.356235
R643 n1_m1_220800_24000 n1_m1_225600_24000 5.356235
R644 n1_m1_225600_24000 n1_m1_228000_24000 2.678118
R645 n1_m1_230400_24000 n1_m1_228000_24000 2.678118
R646 n1_m1_230400_24000 n1_m1_235200_24000 5.356235
R647 n1_m1_235200_24000 n1_m1_240000_24000 5.356235
R648 n1_m1_240000_24000 n1_m1_244800_24000 5.356235
R649 n1_m1_244800_24000 n1_m1_249600_24000 5.356235
R650 n1_m1_249600_24000 n1_m1_254400_24000 5.356235
R651 n1_m1_254400_24000 n1_m1_256000_24000 1.785412
R652 n1_m1_259200_24000 n1_m1_256000_24000 3.570824
R653 n1_m1_259200_24000 n1_m1_264000_24000 5.356235
R654 n1_m1_264000_24000 n1_m1_268800_24000 5.356235
R655 n1_m1_268800_24000 n1_m1_273600_24000 5.356235
R656 n1_m1_273600_24000 n1_m1_278400_24000 5.356235
R657 n1_m1_278400_24000 n1_m1_283200_24000 5.356235
R658 n1_m1_283200_24000 n1_m1_284000_24000 0.892706
R659 n1_m1_288000_24000 n1_m1_284000_24000 4.463529
R660 n1_m1_288000_24000 n1_m1_292800_24000 5.356235
R661 n1_m1_292800_24000 n1_m1_297600_24000 5.356235
R662 n1_m1_297600_24000 n1_m1_302400_24000 5.356235
R663 n1_m1_302400_24000 n1_m1_307200_24000 5.356235
R664 n1_m1_307200_24000 n1_m1_312000_24000 5.356235
R665 n1_m1_312000_24000 n1_m1_316800_24000 5.356235
R666 n1_m1_316800_24000 n1_m1_321600_24000 5.356235
R667 n1_m1_321600_24000 n1_m1_326400_24000 5.356235
R668 n1_m1_326400_24000 n1_m1_331200_24000 5.356235
R669 n1_m1_331200_24000 n1_m1_336000_24000 5.356235
R670 n1_m1_336000_24000 n1_m1_340000_24000 4.463529
R671 n1_m1_340800_24000 n1_m1_340000_24000 0.892706
R672 n1_m1_340800_24000 n1_m1_345600_24000 5.356235
R673 n1_m1_345600_24000 n1_m1_350400_24000 5.356235
R674 n1_m1_350400_24000 n1_m1_355200_24000 5.356235
R675 n1_m1_355200_24000 n1_m1_360000_24000 5.356235
R676 n1_m1_360000_24000 n1_m1_364800_24000 5.356235
R677 n1_m1_364800_24000 n1_m1_368000_24000 3.570824
R678 n1_m1_369600_24000 n1_m1_368000_24000 1.785412
R679 n1_m1_369600_24000 n1_m1_374400_24000 5.356235
R680 n1_m1_374400_24000 n1_m1_379200_24000 5.356235
R681 n1_m1_379200_24000 n1_m1_384000_24000 5.356235
R682 n1_m1_384000_24000 n1_m1_388800_24000 5.356235
R683 n1_m1_388800_24000 n1_m1_393600_24000 5.356235
R684 n1_m1_393600_24000 n1_m1_396000_24000 2.678118
R685 n1_m1_398400_24000 n1_m1_396000_24000 2.678118
R686 n1_m1_398400_24000 n1_m1_403200_24000 5.356235
R687 n1_m1_403200_24000 n1_m1_408000_24000 5.356235
R688 n1_m1_408000_24000 n1_m1_412800_24000 5.356235
R689 n1_m1_412800_24000 n1_m1_417600_24000 5.356235
R690 n1_m1_417600_24000 n1_m1_422400_24000 5.356235
R691 n1_m1_422400_24000 n1_m1_424000_24000 1.785412
R692 n1_m1_427200_24000 n1_m1_424000_24000 3.570824
R693 n1_m1_427200_24000 n1_m1_432000_24000 5.356235
R694 n1_m1_432000_24000 n1_m1_436800_24000 5.356235
R695 n1_m1_436800_24000 n1_m1_441600_24000 5.356235
R696 n1_m1_441600_24000 n1_m1_446400_24000 5.356235
R697 n1_m1_446400_24000 n1_m1_451200_24000 5.356235
R698 n1_m1_451200_24000 n1_m1_452000_24000 0.892706
R699 n1_m1_456000_24000 n1_m1_452000_24000 4.463529
R700 n1_m1_456000_24000 n1_m1_460800_24000 5.356235
R701 n1_m1_460800_24000 n1_m1_465600_24000 5.356235
R702 n1_m1_465600_24000 n1_m1_470400_24000 5.356235
R703 n1_m1_470400_24000 n1_m1_475200_24000 5.356235
R704 n1_m1_475200_24000 n1_m1_480000_24000 5.356235
R705 n1_m1_480000_24000 n1_m1_484800_24000 5.356235
R706 n1_m1_484800_24000 n1_m1_489600_24000 5.356235
R707 n1_m1_489600_24000 n1_m1_494400_24000 5.356235
R708 n1_m1_0_28800 n1_m1_4000_28800 4.463529
R709 n1_m1_4800_28800 n1_m1_4000_28800 0.892706
R710 n1_m1_4800_28800 n1_m1_9600_28800 5.356235
R711 n1_m1_9600_28800 n1_m1_14400_28800 5.356235
R712 n1_m1_14400_28800 n1_m1_19200_28800 5.356235
R713 n1_m1_19200_28800 n1_m1_24000_28800 5.356235
R714 n1_m1_24000_28800 n1_m1_28800_28800 5.356235
R715 n1_m1_28800_28800 n1_m1_32000_28800 3.570824
R716 n1_m1_33600_28800 n1_m1_32000_28800 1.785412
R717 n1_m1_33600_28800 n1_m1_38400_28800 5.356235
R718 n1_m1_38400_28800 n1_m1_43200_28800 5.356235
R719 n1_m1_43200_28800 n1_m1_48000_28800 5.356235
R720 n1_m1_48000_28800 n1_m1_52800_28800 5.356235
R721 n1_m1_52800_28800 n1_m1_57600_28800 5.356235
R722 n1_m1_57600_28800 n1_m1_60000_28800 2.678118
R723 n1_m1_62400_28800 n1_m1_60000_28800 2.678118
R724 n1_m1_62400_28800 n1_m1_67200_28800 5.356235
R725 n1_m1_67200_28800 n1_m1_72000_28800 5.356235
R726 n1_m1_72000_28800 n1_m1_76800_28800 5.356235
R727 n1_m1_76800_28800 n1_m1_81600_28800 5.356235
R728 n1_m1_81600_28800 n1_m1_86400_28800 5.356235
R729 n1_m1_86400_28800 n1_m1_88000_28800 1.785412
R730 n1_m1_91200_28800 n1_m1_88000_28800 3.570824
R731 n1_m1_91200_28800 n1_m1_96000_28800 5.356235
R732 n1_m1_96000_28800 n1_m1_100800_28800 5.356235
R733 n1_m1_100800_28800 n1_m1_105600_28800 5.356235
R734 n1_m1_105600_28800 n1_m1_110400_28800 5.356235
R735 n1_m1_110400_28800 n1_m1_115200_28800 5.356235
R736 n1_m1_115200_28800 n1_m1_116000_28800 0.892706
R737 n1_m1_120000_28800 n1_m1_116000_28800 4.463529
R738 n1_m1_120000_28800 n1_m1_124800_28800 5.356235
R739 n1_m1_124800_28800 n1_m1_129600_28800 5.356235
R740 n1_m1_129600_28800 n1_m1_134400_28800 5.356235
R741 n1_m1_134400_28800 n1_m1_139200_28800 5.356235
R742 n1_m1_139200_28800 n1_m1_144000_28800 5.356235
R743 n1_m1_144000_28800 n1_m1_148800_28800 5.356235
R744 n1_m1_148800_28800 n1_m1_153600_28800 5.356235
R745 n1_m1_153600_28800 n1_m1_158400_28800 5.356235
R746 n1_m1_158400_28800 n1_m1_163200_28800 5.356235
R747 n1_m1_163200_28800 n1_m1_168000_28800 5.356235
R748 n1_m1_168000_28800 n1_m1_172000_28800 4.463529
R749 n1_m1_172800_28800 n1_m1_172000_28800 0.892706
R750 n1_m1_172800_28800 n1_m1_177600_28800 5.356235
R751 n1_m1_177600_28800 n1_m1_182400_28800 5.356235
R752 n1_m1_182400_28800 n1_m1_187200_28800 5.356235
R753 n1_m1_187200_28800 n1_m1_192000_28800 5.356235
R754 n1_m1_192000_28800 n1_m1_196800_28800 5.356235
R755 n1_m1_196800_28800 n1_m1_200000_28800 3.570824
R756 n1_m1_201600_28800 n1_m1_200000_28800 1.785412
R757 n1_m1_201600_28800 n1_m1_206400_28800 5.356235
R758 n1_m1_206400_28800 n1_m1_211200_28800 5.356235
R759 n1_m1_211200_28800 n1_m1_216000_28800 5.356235
R760 n1_m1_216000_28800 n1_m1_220800_28800 5.356235
R761 n1_m1_220800_28800 n1_m1_225600_28800 5.356235
R762 n1_m1_225600_28800 n1_m1_228000_28800 2.678118
R763 n1_m1_230400_28800 n1_m1_228000_28800 2.678118
R764 n1_m1_230400_28800 n1_m1_235200_28800 5.356235
R765 n1_m1_235200_28800 n1_m1_240000_28800 5.356235
R766 n1_m1_240000_28800 n1_m1_244800_28800 5.356235
R767 n1_m1_244800_28800 n1_m1_249600_28800 5.356235
R768 n1_m1_249600_28800 n1_m1_254400_28800 5.356235
R769 n1_m1_254400_28800 n1_m1_256000_28800 1.785412
R770 n1_m1_259200_28800 n1_m1_256000_28800 3.570824
R771 n1_m1_259200_28800 n1_m1_264000_28800 5.356235
R772 n1_m1_264000_28800 n1_m1_268800_28800 5.356235
R773 n1_m1_268800_28800 n1_m1_273600_28800 5.356235
R774 n1_m1_273600_28800 n1_m1_278400_28800 5.356235
R775 n1_m1_278400_28800 n1_m1_283200_28800 5.356235
R776 n1_m1_283200_28800 n1_m1_284000_28800 0.892706
R777 n1_m1_288000_28800 n1_m1_284000_28800 4.463529
R778 n1_m1_288000_28800 n1_m1_292800_28800 5.356235
R779 n1_m1_292800_28800 n1_m1_297600_28800 5.356235
R780 n1_m1_297600_28800 n1_m1_302400_28800 5.356235
R781 n1_m1_302400_28800 n1_m1_307200_28800 5.356235
R782 n1_m1_307200_28800 n1_m1_312000_28800 5.356235
R783 n1_m1_312000_28800 n1_m1_316800_28800 5.356235
R784 n1_m1_316800_28800 n1_m1_321600_28800 5.356235
R785 n1_m1_321600_28800 n1_m1_326400_28800 5.356235
R786 n1_m1_326400_28800 n1_m1_331200_28800 5.356235
R787 n1_m1_331200_28800 n1_m1_336000_28800 5.356235
R788 n1_m1_336000_28800 n1_m1_340000_28800 4.463529
R789 n1_m1_340800_28800 n1_m1_340000_28800 0.892706
R790 n1_m1_340800_28800 n1_m1_345600_28800 5.356235
R791 n1_m1_345600_28800 n1_m1_350400_28800 5.356235
R792 n1_m1_350400_28800 n1_m1_355200_28800 5.356235
R793 n1_m1_355200_28800 n1_m1_360000_28800 5.356235
R794 n1_m1_360000_28800 n1_m1_364800_28800 5.356235
R795 n1_m1_364800_28800 n1_m1_368000_28800 3.570824
R796 n1_m1_369600_28800 n1_m1_368000_28800 1.785412
R797 n1_m1_369600_28800 n1_m1_374400_28800 5.356235
R798 n1_m1_374400_28800 n1_m1_379200_28800 5.356235
R799 n1_m1_379200_28800 n1_m1_384000_28800 5.356235
R800 n1_m1_384000_28800 n1_m1_388800_28800 5.356235
R801 n1_m1_388800_28800 n1_m1_393600_28800 5.356235
R802 n1_m1_393600_28800 n1_m1_396000_28800 2.678118
R803 n1_m1_398400_28800 n1_m1_396000_28800 2.678118
R804 n1_m1_398400_28800 n1_m1_403200_28800 5.356235
R805 n1_m1_403200_28800 n1_m1_408000_28800 5.356235
R806 n1_m1_408000_28800 n1_m1_412800_28800 5.356235
R807 n1_m1_412800_28800 n1_m1_417600_28800 5.356235
R808 n1_m1_417600_28800 n1_m1_422400_28800 5.356235
R809 n1_m1_422400_28800 n1_m1_424000_28800 1.785412
R810 n1_m1_427200_28800 n1_m1_424000_28800 3.570824
R811 n1_m1_427200_28800 n1_m1_432000_28800 5.356235
R812 n1_m1_432000_28800 n1_m1_436800_28800 5.356235
R813 n1_m1_436800_28800 n1_m1_441600_28800 5.356235
R814 n1_m1_441600_28800 n1_m1_446400_28800 5.356235
R815 n1_m1_446400_28800 n1_m1_451200_28800 5.356235
R816 n1_m1_451200_28800 n1_m1_452000_28800 0.892706
R817 n1_m1_456000_28800 n1_m1_452000_28800 4.463529
R818 n1_m1_456000_28800 n1_m1_460800_28800 5.356235
R819 n1_m1_460800_28800 n1_m1_465600_28800 5.356235
R820 n1_m1_465600_28800 n1_m1_470400_28800 5.356235
R821 n1_m1_470400_28800 n1_m1_475200_28800 5.356235
R822 n1_m1_475200_28800 n1_m1_480000_28800 5.356235
R823 n1_m1_480000_28800 n1_m1_484800_28800 5.356235
R824 n1_m1_484800_28800 n1_m1_489600_28800 5.356235
R825 n1_m1_489600_28800 n1_m1_494400_28800 5.356235
R826 n1_m1_0_33600 n1_m1_4000_33600 4.463529
R827 n1_m1_4800_33600 n1_m1_4000_33600 0.892706
R828 n1_m1_4800_33600 n1_m1_9600_33600 5.356235
R829 n1_m1_9600_33600 n1_m1_14400_33600 5.356235
R830 n1_m1_14400_33600 n1_m1_19200_33600 5.356235
R831 n1_m1_19200_33600 n1_m1_24000_33600 5.356235
R832 n1_m1_24000_33600 n1_m1_28800_33600 5.356235
R833 n1_m1_28800_33600 n1_m1_32000_33600 3.570824
R834 n1_m1_33600_33600 n1_m1_32000_33600 1.785412
R835 n1_m1_33600_33600 n1_m1_38400_33600 5.356235
R836 n1_m1_38400_33600 n1_m1_43200_33600 5.356235
R837 n1_m1_43200_33600 n1_m1_48000_33600 5.356235
R838 n1_m1_48000_33600 n1_m1_52800_33600 5.356235
R839 n1_m1_52800_33600 n1_m1_57600_33600 5.356235
R840 n1_m1_57600_33600 n1_m1_60000_33600 2.678118
R841 n1_m1_62400_33600 n1_m1_60000_33600 2.678118
R842 n1_m1_62400_33600 n1_m1_67200_33600 5.356235
R843 n1_m1_67200_33600 n1_m1_72000_33600 5.356235
R844 n1_m1_72000_33600 n1_m1_76800_33600 5.356235
R845 n1_m1_76800_33600 n1_m1_81600_33600 5.356235
R846 n1_m1_81600_33600 n1_m1_86400_33600 5.356235
R847 n1_m1_86400_33600 n1_m1_88000_33600 1.785412
R848 n1_m1_91200_33600 n1_m1_88000_33600 3.570824
R849 n1_m1_91200_33600 n1_m1_96000_33600 5.356235
R850 n1_m1_96000_33600 n1_m1_100800_33600 5.356235
R851 n1_m1_100800_33600 n1_m1_105600_33600 5.356235
R852 n1_m1_105600_33600 n1_m1_110400_33600 5.356235
R853 n1_m1_110400_33600 n1_m1_115200_33600 5.356235
R854 n1_m1_115200_33600 n1_m1_116000_33600 0.892706
R855 n1_m1_120000_33600 n1_m1_116000_33600 4.463529
R856 n1_m1_120000_33600 n1_m1_124800_33600 5.356235
R857 n1_m1_124800_33600 n1_m1_129600_33600 5.356235
R858 n1_m1_129600_33600 n1_m1_134400_33600 5.356235
R859 n1_m1_134400_33600 n1_m1_139200_33600 5.356235
R860 n1_m1_139200_33600 n1_m1_144000_33600 5.356235
R861 n1_m1_144000_33600 n1_m1_148800_33600 5.356235
R862 n1_m1_148800_33600 n1_m1_153600_33600 5.356235
R863 n1_m1_153600_33600 n1_m1_158400_33600 5.356235
R864 n1_m1_158400_33600 n1_m1_163200_33600 5.356235
R865 n1_m1_163200_33600 n1_m1_168000_33600 5.356235
R866 n1_m1_168000_33600 n1_m1_172000_33600 4.463529
R867 n1_m1_172800_33600 n1_m1_172000_33600 0.892706
R868 n1_m1_172800_33600 n1_m1_177600_33600 5.356235
R869 n1_m1_177600_33600 n1_m1_182400_33600 5.356235
R870 n1_m1_182400_33600 n1_m1_187200_33600 5.356235
R871 n1_m1_187200_33600 n1_m1_192000_33600 5.356235
R872 n1_m1_192000_33600 n1_m1_196800_33600 5.356235
R873 n1_m1_196800_33600 n1_m1_200000_33600 3.570824
R874 n1_m1_201600_33600 n1_m1_200000_33600 1.785412
R875 n1_m1_201600_33600 n1_m1_206400_33600 5.356235
R876 n1_m1_206400_33600 n1_m1_211200_33600 5.356235
R877 n1_m1_211200_33600 n1_m1_216000_33600 5.356235
R878 n1_m1_216000_33600 n1_m1_220800_33600 5.356235
R879 n1_m1_220800_33600 n1_m1_225600_33600 5.356235
R880 n1_m1_225600_33600 n1_m1_228000_33600 2.678118
R881 n1_m1_230400_33600 n1_m1_228000_33600 2.678118
R882 n1_m1_230400_33600 n1_m1_235200_33600 5.356235
R883 n1_m1_235200_33600 n1_m1_240000_33600 5.356235
R884 n1_m1_240000_33600 n1_m1_244800_33600 5.356235
R885 n1_m1_244800_33600 n1_m1_249600_33600 5.356235
R886 n1_m1_249600_33600 n1_m1_254400_33600 5.356235
R887 n1_m1_254400_33600 n1_m1_256000_33600 1.785412
R888 n1_m1_259200_33600 n1_m1_256000_33600 3.570824
R889 n1_m1_259200_33600 n1_m1_264000_33600 5.356235
R890 n1_m1_264000_33600 n1_m1_268800_33600 5.356235
R891 n1_m1_268800_33600 n1_m1_273600_33600 5.356235
R892 n1_m1_273600_33600 n1_m1_278400_33600 5.356235
R893 n1_m1_278400_33600 n1_m1_283200_33600 5.356235
R894 n1_m1_283200_33600 n1_m1_284000_33600 0.892706
R895 n1_m1_288000_33600 n1_m1_284000_33600 4.463529
R896 n1_m1_288000_33600 n1_m1_292800_33600 5.356235
R897 n1_m1_292800_33600 n1_m1_297600_33600 5.356235
R898 n1_m1_297600_33600 n1_m1_302400_33600 5.356235
R899 n1_m1_302400_33600 n1_m1_307200_33600 5.356235
R900 n1_m1_307200_33600 n1_m1_312000_33600 5.356235
R901 n1_m1_312000_33600 n1_m1_316800_33600 5.356235
R902 n1_m1_316800_33600 n1_m1_321600_33600 5.356235
R903 n1_m1_321600_33600 n1_m1_326400_33600 5.356235
R904 n1_m1_326400_33600 n1_m1_331200_33600 5.356235
R905 n1_m1_331200_33600 n1_m1_336000_33600 5.356235
R906 n1_m1_336000_33600 n1_m1_340000_33600 4.463529
R907 n1_m1_340800_33600 n1_m1_340000_33600 0.892706
R908 n1_m1_340800_33600 n1_m1_345600_33600 5.356235
R909 n1_m1_345600_33600 n1_m1_350400_33600 5.356235
R910 n1_m1_350400_33600 n1_m1_355200_33600 5.356235
R911 n1_m1_355200_33600 n1_m1_360000_33600 5.356235
R912 n1_m1_360000_33600 n1_m1_364800_33600 5.356235
R913 n1_m1_364800_33600 n1_m1_368000_33600 3.570824
R914 n1_m1_369600_33600 n1_m1_368000_33600 1.785412
R915 n1_m1_369600_33600 n1_m1_374400_33600 5.356235
R916 n1_m1_374400_33600 n1_m1_379200_33600 5.356235
R917 n1_m1_379200_33600 n1_m1_384000_33600 5.356235
R918 n1_m1_384000_33600 n1_m1_388800_33600 5.356235
R919 n1_m1_388800_33600 n1_m1_393600_33600 5.356235
R920 n1_m1_393600_33600 n1_m1_396000_33600 2.678118
R921 n1_m1_398400_33600 n1_m1_396000_33600 2.678118
R922 n1_m1_398400_33600 n1_m1_403200_33600 5.356235
R923 n1_m1_403200_33600 n1_m1_408000_33600 5.356235
R924 n1_m1_408000_33600 n1_m1_412800_33600 5.356235
R925 n1_m1_412800_33600 n1_m1_417600_33600 5.356235
R926 n1_m1_417600_33600 n1_m1_422400_33600 5.356235
R927 n1_m1_422400_33600 n1_m1_424000_33600 1.785412
R928 n1_m1_427200_33600 n1_m1_424000_33600 3.570824
R929 n1_m1_427200_33600 n1_m1_432000_33600 5.356235
R930 n1_m1_432000_33600 n1_m1_436800_33600 5.356235
R931 n1_m1_436800_33600 n1_m1_441600_33600 5.356235
R932 n1_m1_441600_33600 n1_m1_446400_33600 5.356235
R933 n1_m1_446400_33600 n1_m1_451200_33600 5.356235
R934 n1_m1_451200_33600 n1_m1_452000_33600 0.892706
R935 n1_m1_456000_33600 n1_m1_452000_33600 4.463529
R936 n1_m1_456000_33600 n1_m1_460800_33600 5.356235
R937 n1_m1_460800_33600 n1_m1_465600_33600 5.356235
R938 n1_m1_465600_33600 n1_m1_470400_33600 5.356235
R939 n1_m1_470400_33600 n1_m1_475200_33600 5.356235
R940 n1_m1_475200_33600 n1_m1_480000_33600 5.356235
R941 n1_m1_480000_33600 n1_m1_484800_33600 5.356235
R942 n1_m1_484800_33600 n1_m1_489600_33600 5.356235
R943 n1_m1_489600_33600 n1_m1_494400_33600 5.356235
R944 n1_m1_0_38400 n1_m1_4000_38400 4.463529
R945 n1_m1_4800_38400 n1_m1_4000_38400 0.892706
R946 n1_m1_4800_38400 n1_m1_9600_38400 5.356235
R947 n1_m1_9600_38400 n1_m1_14400_38400 5.356235
R948 n1_m1_14400_38400 n1_m1_19200_38400 5.356235
R949 n1_m1_19200_38400 n1_m1_24000_38400 5.356235
R950 n1_m1_24000_38400 n1_m1_28800_38400 5.356235
R951 n1_m1_28800_38400 n1_m1_32000_38400 3.570824
R952 n1_m1_33600_38400 n1_m1_32000_38400 1.785412
R953 n1_m1_33600_38400 n1_m1_38400_38400 5.356235
R954 n1_m1_38400_38400 n1_m1_43200_38400 5.356235
R955 n1_m1_43200_38400 n1_m1_48000_38400 5.356235
R956 n1_m1_48000_38400 n1_m1_52800_38400 5.356235
R957 n1_m1_52800_38400 n1_m1_57600_38400 5.356235
R958 n1_m1_57600_38400 n1_m1_60000_38400 2.678118
R959 n1_m1_62400_38400 n1_m1_60000_38400 2.678118
R960 n1_m1_62400_38400 n1_m1_67200_38400 5.356235
R961 n1_m1_67200_38400 n1_m1_72000_38400 5.356235
R962 n1_m1_72000_38400 n1_m1_76800_38400 5.356235
R963 n1_m1_76800_38400 n1_m1_81600_38400 5.356235
R964 n1_m1_81600_38400 n1_m1_86400_38400 5.356235
R965 n1_m1_86400_38400 n1_m1_88000_38400 1.785412
R966 n1_m1_91200_38400 n1_m1_88000_38400 3.570824
R967 n1_m1_91200_38400 n1_m1_96000_38400 5.356235
R968 n1_m1_96000_38400 n1_m1_100800_38400 5.356235
R969 n1_m1_100800_38400 n1_m1_105600_38400 5.356235
R970 n1_m1_105600_38400 n1_m1_110400_38400 5.356235
R971 n1_m1_110400_38400 n1_m1_115200_38400 5.356235
R972 n1_m1_115200_38400 n1_m1_116000_38400 0.892706
R973 n1_m1_120000_38400 n1_m1_116000_38400 4.463529
R974 n1_m1_120000_38400 n1_m1_124800_38400 5.356235
R975 n1_m1_124800_38400 n1_m1_129600_38400 5.356235
R976 n1_m1_129600_38400 n1_m1_134400_38400 5.356235
R977 n1_m1_134400_38400 n1_m1_139200_38400 5.356235
R978 n1_m1_139200_38400 n1_m1_144000_38400 5.356235
R979 n1_m1_144000_38400 n1_m1_148800_38400 5.356235
R980 n1_m1_148800_38400 n1_m1_153600_38400 5.356235
R981 n1_m1_153600_38400 n1_m1_158400_38400 5.356235
R982 n1_m1_158400_38400 n1_m1_163200_38400 5.356235
R983 n1_m1_163200_38400 n1_m1_168000_38400 5.356235
R984 n1_m1_168000_38400 n1_m1_172000_38400 4.463529
R985 n1_m1_172800_38400 n1_m1_172000_38400 0.892706
R986 n1_m1_172800_38400 n1_m1_177600_38400 5.356235
R987 n1_m1_177600_38400 n1_m1_182400_38400 5.356235
R988 n1_m1_182400_38400 n1_m1_187200_38400 5.356235
R989 n1_m1_187200_38400 n1_m1_192000_38400 5.356235
R990 n1_m1_192000_38400 n1_m1_196800_38400 5.356235
R991 n1_m1_196800_38400 n1_m1_200000_38400 3.570824
R992 n1_m1_201600_38400 n1_m1_200000_38400 1.785412
R993 n1_m1_201600_38400 n1_m1_206400_38400 5.356235
R994 n1_m1_206400_38400 n1_m1_211200_38400 5.356235
R995 n1_m1_211200_38400 n1_m1_216000_38400 5.356235
R996 n1_m1_216000_38400 n1_m1_220800_38400 5.356235
R997 n1_m1_220800_38400 n1_m1_225600_38400 5.356235
R998 n1_m1_225600_38400 n1_m1_228000_38400 2.678118
R999 n1_m1_230400_38400 n1_m1_228000_38400 2.678118
R1000 n1_m1_230400_38400 n1_m1_235200_38400 5.356235
R1001 n1_m1_235200_38400 n1_m1_240000_38400 5.356235
R1002 n1_m1_240000_38400 n1_m1_244800_38400 5.356235
R1003 n1_m1_244800_38400 n1_m1_249600_38400 5.356235
R1004 n1_m1_249600_38400 n1_m1_254400_38400 5.356235
R1005 n1_m1_254400_38400 n1_m1_256000_38400 1.785412
R1006 n1_m1_259200_38400 n1_m1_256000_38400 3.570824
R1007 n1_m1_259200_38400 n1_m1_264000_38400 5.356235
R1008 n1_m1_264000_38400 n1_m1_268800_38400 5.356235
R1009 n1_m1_268800_38400 n1_m1_273600_38400 5.356235
R1010 n1_m1_273600_38400 n1_m1_278400_38400 5.356235
R1011 n1_m1_278400_38400 n1_m1_283200_38400 5.356235
R1012 n1_m1_283200_38400 n1_m1_284000_38400 0.892706
R1013 n1_m1_288000_38400 n1_m1_284000_38400 4.463529
R1014 n1_m1_288000_38400 n1_m1_292800_38400 5.356235
R1015 n1_m1_292800_38400 n1_m1_297600_38400 5.356235
R1016 n1_m1_297600_38400 n1_m1_302400_38400 5.356235
R1017 n1_m1_302400_38400 n1_m1_307200_38400 5.356235
R1018 n1_m1_307200_38400 n1_m1_312000_38400 5.356235
R1019 n1_m1_312000_38400 n1_m1_316800_38400 5.356235
R1020 n1_m1_316800_38400 n1_m1_321600_38400 5.356235
R1021 n1_m1_321600_38400 n1_m1_326400_38400 5.356235
R1022 n1_m1_326400_38400 n1_m1_331200_38400 5.356235
R1023 n1_m1_331200_38400 n1_m1_336000_38400 5.356235
R1024 n1_m1_336000_38400 n1_m1_340000_38400 4.463529
R1025 n1_m1_340800_38400 n1_m1_340000_38400 0.892706
R1026 n1_m1_340800_38400 n1_m1_345600_38400 5.356235
R1027 n1_m1_345600_38400 n1_m1_350400_38400 5.356235
R1028 n1_m1_350400_38400 n1_m1_355200_38400 5.356235
R1029 n1_m1_355200_38400 n1_m1_360000_38400 5.356235
R1030 n1_m1_360000_38400 n1_m1_364800_38400 5.356235
R1031 n1_m1_364800_38400 n1_m1_368000_38400 3.570824
R1032 n1_m1_369600_38400 n1_m1_368000_38400 1.785412
R1033 n1_m1_369600_38400 n1_m1_374400_38400 5.356235
R1034 n1_m1_374400_38400 n1_m1_379200_38400 5.356235
R1035 n1_m1_379200_38400 n1_m1_384000_38400 5.356235
R1036 n1_m1_384000_38400 n1_m1_388800_38400 5.356235
R1037 n1_m1_388800_38400 n1_m1_393600_38400 5.356235
R1038 n1_m1_393600_38400 n1_m1_396000_38400 2.678118
R1039 n1_m1_398400_38400 n1_m1_396000_38400 2.678118
R1040 n1_m1_398400_38400 n1_m1_403200_38400 5.356235
R1041 n1_m1_403200_38400 n1_m1_408000_38400 5.356235
R1042 n1_m1_408000_38400 n1_m1_412800_38400 5.356235
R1043 n1_m1_412800_38400 n1_m1_417600_38400 5.356235
R1044 n1_m1_417600_38400 n1_m1_422400_38400 5.356235
R1045 n1_m1_422400_38400 n1_m1_424000_38400 1.785412
R1046 n1_m1_427200_38400 n1_m1_424000_38400 3.570824
R1047 n1_m1_427200_38400 n1_m1_432000_38400 5.356235
R1048 n1_m1_432000_38400 n1_m1_436800_38400 5.356235
R1049 n1_m1_436800_38400 n1_m1_441600_38400 5.356235
R1050 n1_m1_441600_38400 n1_m1_446400_38400 5.356235
R1051 n1_m1_446400_38400 n1_m1_451200_38400 5.356235
R1052 n1_m1_451200_38400 n1_m1_452000_38400 0.892706
R1053 n1_m1_456000_38400 n1_m1_452000_38400 4.463529
R1054 n1_m1_456000_38400 n1_m1_460800_38400 5.356235
R1055 n1_m1_460800_38400 n1_m1_465600_38400 5.356235
R1056 n1_m1_465600_38400 n1_m1_470400_38400 5.356235
R1057 n1_m1_470400_38400 n1_m1_475200_38400 5.356235
R1058 n1_m1_475200_38400 n1_m1_480000_38400 5.356235
R1059 n1_m1_480000_38400 n1_m1_484800_38400 5.356235
R1060 n1_m1_484800_38400 n1_m1_489600_38400 5.356235
R1061 n1_m1_489600_38400 n1_m1_494400_38400 5.356235
R1062 n1_m1_0_43200 n1_m1_4000_43200 4.463529
R1063 n1_m1_4800_43200 n1_m1_4000_43200 0.892706
R1064 n1_m1_4800_43200 n1_m1_9600_43200 5.356235
R1065 n1_m1_9600_43200 n1_m1_14400_43200 5.356235
R1066 n1_m1_14400_43200 n1_m1_19200_43200 5.356235
R1067 n1_m1_19200_43200 n1_m1_24000_43200 5.356235
R1068 n1_m1_24000_43200 n1_m1_28800_43200 5.356235
R1069 n1_m1_28800_43200 n1_m1_32000_43200 3.570824
R1070 n1_m1_33600_43200 n1_m1_32000_43200 1.785412
R1071 n1_m1_33600_43200 n1_m1_38400_43200 5.356235
R1072 n1_m1_38400_43200 n1_m1_43200_43200 5.356235
R1073 n1_m1_43200_43200 n1_m1_48000_43200 5.356235
R1074 n1_m1_48000_43200 n1_m1_52800_43200 5.356235
R1075 n1_m1_52800_43200 n1_m1_57600_43200 5.356235
R1076 n1_m1_57600_43200 n1_m1_60000_43200 2.678118
R1077 n1_m1_62400_43200 n1_m1_60000_43200 2.678118
R1078 n1_m1_62400_43200 n1_m1_67200_43200 5.356235
R1079 n1_m1_67200_43200 n1_m1_72000_43200 5.356235
R1080 n1_m1_72000_43200 n1_m1_76800_43200 5.356235
R1081 n1_m1_76800_43200 n1_m1_81600_43200 5.356235
R1082 n1_m1_81600_43200 n1_m1_86400_43200 5.356235
R1083 n1_m1_86400_43200 n1_m1_88000_43200 1.785412
R1084 n1_m1_91200_43200 n1_m1_88000_43200 3.570824
R1085 n1_m1_91200_43200 n1_m1_96000_43200 5.356235
R1086 n1_m1_96000_43200 n1_m1_100800_43200 5.356235
R1087 n1_m1_100800_43200 n1_m1_105600_43200 5.356235
R1088 n1_m1_105600_43200 n1_m1_110400_43200 5.356235
R1089 n1_m1_110400_43200 n1_m1_115200_43200 5.356235
R1090 n1_m1_115200_43200 n1_m1_116000_43200 0.892706
R1091 n1_m1_120000_43200 n1_m1_116000_43200 4.463529
R1092 n1_m1_120000_43200 n1_m1_124800_43200 5.356235
R1093 n1_m1_124800_43200 n1_m1_129600_43200 5.356235
R1094 n1_m1_129600_43200 n1_m1_134400_43200 5.356235
R1095 n1_m1_134400_43200 n1_m1_139200_43200 5.356235
R1096 n1_m1_139200_43200 n1_m1_144000_43200 5.356235
R1097 n1_m1_144000_43200 n1_m1_148800_43200 5.356235
R1098 n1_m1_148800_43200 n1_m1_153600_43200 5.356235
R1099 n1_m1_153600_43200 n1_m1_158400_43200 5.356235
R1100 n1_m1_158400_43200 n1_m1_163200_43200 5.356235
R1101 n1_m1_163200_43200 n1_m1_168000_43200 5.356235
R1102 n1_m1_168000_43200 n1_m1_172000_43200 4.463529
R1103 n1_m1_172800_43200 n1_m1_172000_43200 0.892706
R1104 n1_m1_172800_43200 n1_m1_177600_43200 5.356235
R1105 n1_m1_177600_43200 n1_m1_182400_43200 5.356235
R1106 n1_m1_182400_43200 n1_m1_187200_43200 5.356235
R1107 n1_m1_187200_43200 n1_m1_192000_43200 5.356235
R1108 n1_m1_192000_43200 n1_m1_196800_43200 5.356235
R1109 n1_m1_196800_43200 n1_m1_200000_43200 3.570824
R1110 n1_m1_201600_43200 n1_m1_200000_43200 1.785412
R1111 n1_m1_201600_43200 n1_m1_206400_43200 5.356235
R1112 n1_m1_206400_43200 n1_m1_211200_43200 5.356235
R1113 n1_m1_211200_43200 n1_m1_216000_43200 5.356235
R1114 n1_m1_216000_43200 n1_m1_220800_43200 5.356235
R1115 n1_m1_220800_43200 n1_m1_225600_43200 5.356235
R1116 n1_m1_225600_43200 n1_m1_228000_43200 2.678118
R1117 n1_m1_230400_43200 n1_m1_228000_43200 2.678118
R1118 n1_m1_230400_43200 n1_m1_235200_43200 5.356235
R1119 n1_m1_235200_43200 n1_m1_240000_43200 5.356235
R1120 n1_m1_240000_43200 n1_m1_244800_43200 5.356235
R1121 n1_m1_244800_43200 n1_m1_249600_43200 5.356235
R1122 n1_m1_249600_43200 n1_m1_254400_43200 5.356235
R1123 n1_m1_254400_43200 n1_m1_256000_43200 1.785412
R1124 n1_m1_259200_43200 n1_m1_256000_43200 3.570824
R1125 n1_m1_259200_43200 n1_m1_264000_43200 5.356235
R1126 n1_m1_264000_43200 n1_m1_268800_43200 5.356235
R1127 n1_m1_268800_43200 n1_m1_273600_43200 5.356235
R1128 n1_m1_273600_43200 n1_m1_278400_43200 5.356235
R1129 n1_m1_278400_43200 n1_m1_283200_43200 5.356235
R1130 n1_m1_283200_43200 n1_m1_284000_43200 0.892706
R1131 n1_m1_288000_43200 n1_m1_284000_43200 4.463529
R1132 n1_m1_288000_43200 n1_m1_292800_43200 5.356235
R1133 n1_m1_292800_43200 n1_m1_297600_43200 5.356235
R1134 n1_m1_297600_43200 n1_m1_302400_43200 5.356235
R1135 n1_m1_302400_43200 n1_m1_307200_43200 5.356235
R1136 n1_m1_307200_43200 n1_m1_312000_43200 5.356235
R1137 n1_m1_312000_43200 n1_m1_316800_43200 5.356235
R1138 n1_m1_316800_43200 n1_m1_321600_43200 5.356235
R1139 n1_m1_321600_43200 n1_m1_326400_43200 5.356235
R1140 n1_m1_326400_43200 n1_m1_331200_43200 5.356235
R1141 n1_m1_331200_43200 n1_m1_336000_43200 5.356235
R1142 n1_m1_336000_43200 n1_m1_340000_43200 4.463529
R1143 n1_m1_340800_43200 n1_m1_340000_43200 0.892706
R1144 n1_m1_340800_43200 n1_m1_345600_43200 5.356235
R1145 n1_m1_345600_43200 n1_m1_350400_43200 5.356235
R1146 n1_m1_350400_43200 n1_m1_355200_43200 5.356235
R1147 n1_m1_355200_43200 n1_m1_360000_43200 5.356235
R1148 n1_m1_360000_43200 n1_m1_364800_43200 5.356235
R1149 n1_m1_364800_43200 n1_m1_368000_43200 3.570824
R1150 n1_m1_369600_43200 n1_m1_368000_43200 1.785412
R1151 n1_m1_369600_43200 n1_m1_374400_43200 5.356235
R1152 n1_m1_374400_43200 n1_m1_379200_43200 5.356235
R1153 n1_m1_379200_43200 n1_m1_384000_43200 5.356235
R1154 n1_m1_384000_43200 n1_m1_388800_43200 5.356235
R1155 n1_m1_388800_43200 n1_m1_393600_43200 5.356235
R1156 n1_m1_393600_43200 n1_m1_396000_43200 2.678118
R1157 n1_m1_398400_43200 n1_m1_396000_43200 2.678118
R1158 n1_m1_398400_43200 n1_m1_403200_43200 5.356235
R1159 n1_m1_403200_43200 n1_m1_408000_43200 5.356235
R1160 n1_m1_408000_43200 n1_m1_412800_43200 5.356235
R1161 n1_m1_412800_43200 n1_m1_417600_43200 5.356235
R1162 n1_m1_417600_43200 n1_m1_422400_43200 5.356235
R1163 n1_m1_422400_43200 n1_m1_424000_43200 1.785412
R1164 n1_m1_427200_43200 n1_m1_424000_43200 3.570824
R1165 n1_m1_427200_43200 n1_m1_432000_43200 5.356235
R1166 n1_m1_432000_43200 n1_m1_436800_43200 5.356235
R1167 n1_m1_436800_43200 n1_m1_441600_43200 5.356235
R1168 n1_m1_441600_43200 n1_m1_446400_43200 5.356235
R1169 n1_m1_446400_43200 n1_m1_451200_43200 5.356235
R1170 n1_m1_451200_43200 n1_m1_452000_43200 0.892706
R1171 n1_m1_456000_43200 n1_m1_452000_43200 4.463529
R1172 n1_m1_456000_43200 n1_m1_460800_43200 5.356235
R1173 n1_m1_460800_43200 n1_m1_465600_43200 5.356235
R1174 n1_m1_465600_43200 n1_m1_470400_43200 5.356235
R1175 n1_m1_470400_43200 n1_m1_475200_43200 5.356235
R1176 n1_m1_475200_43200 n1_m1_480000_43200 5.356235
R1177 n1_m1_480000_43200 n1_m1_484800_43200 5.356235
R1178 n1_m1_484800_43200 n1_m1_489600_43200 5.356235
R1179 n1_m1_489600_43200 n1_m1_494400_43200 5.356235
R1180 n1_m1_0_48000 n1_m1_4000_48000 4.463529
R1181 n1_m1_4800_48000 n1_m1_4000_48000 0.892706
R1182 n1_m1_4800_48000 n1_m1_9600_48000 5.356235
R1183 n1_m1_9600_48000 n1_m1_14400_48000 5.356235
R1184 n1_m1_14400_48000 n1_m1_19200_48000 5.356235
R1185 n1_m1_19200_48000 n1_m1_24000_48000 5.356235
R1186 n1_m1_24000_48000 n1_m1_28800_48000 5.356235
R1187 n1_m1_28800_48000 n1_m1_32000_48000 3.570824
R1188 n1_m1_33600_48000 n1_m1_32000_48000 1.785412
R1189 n1_m1_33600_48000 n1_m1_38400_48000 5.356235
R1190 n1_m1_38400_48000 n1_m1_43200_48000 5.356235
R1191 n1_m1_43200_48000 n1_m1_48000_48000 5.356235
R1192 n1_m1_48000_48000 n1_m1_52800_48000 5.356235
R1193 n1_m1_52800_48000 n1_m1_57600_48000 5.356235
R1194 n1_m1_57600_48000 n1_m1_60000_48000 2.678118
R1195 n1_m1_62400_48000 n1_m1_60000_48000 2.678118
R1196 n1_m1_62400_48000 n1_m1_67200_48000 5.356235
R1197 n1_m1_67200_48000 n1_m1_72000_48000 5.356235
R1198 n1_m1_72000_48000 n1_m1_76800_48000 5.356235
R1199 n1_m1_76800_48000 n1_m1_81600_48000 5.356235
R1200 n1_m1_81600_48000 n1_m1_86400_48000 5.356235
R1201 n1_m1_86400_48000 n1_m1_88000_48000 1.785412
R1202 n1_m1_91200_48000 n1_m1_88000_48000 3.570824
R1203 n1_m1_91200_48000 n1_m1_96000_48000 5.356235
R1204 n1_m1_96000_48000 n1_m1_100800_48000 5.356235
R1205 n1_m1_100800_48000 n1_m1_105600_48000 5.356235
R1206 n1_m1_105600_48000 n1_m1_110400_48000 5.356235
R1207 n1_m1_110400_48000 n1_m1_115200_48000 5.356235
R1208 n1_m1_115200_48000 n1_m1_116000_48000 0.892706
R1209 n1_m1_120000_48000 n1_m1_116000_48000 4.463529
R1210 n1_m1_120000_48000 n1_m1_124800_48000 5.356235
R1211 n1_m1_124800_48000 n1_m1_129600_48000 5.356235
R1212 n1_m1_129600_48000 n1_m1_134400_48000 5.356235
R1213 n1_m1_134400_48000 n1_m1_139200_48000 5.356235
R1214 n1_m1_139200_48000 n1_m1_144000_48000 5.356235
R1215 n1_m1_144000_48000 n1_m1_148800_48000 5.356235
R1216 n1_m1_148800_48000 n1_m1_153600_48000 5.356235
R1217 n1_m1_153600_48000 n1_m1_158400_48000 5.356235
R1218 n1_m1_158400_48000 n1_m1_163200_48000 5.356235
R1219 n1_m1_163200_48000 n1_m1_168000_48000 5.356235
R1220 n1_m1_168000_48000 n1_m1_172000_48000 4.463529
R1221 n1_m1_172800_48000 n1_m1_172000_48000 0.892706
R1222 n1_m1_172800_48000 n1_m1_177600_48000 5.356235
R1223 n1_m1_177600_48000 n1_m1_182400_48000 5.356235
R1224 n1_m1_182400_48000 n1_m1_187200_48000 5.356235
R1225 n1_m1_187200_48000 n1_m1_192000_48000 5.356235
R1226 n1_m1_192000_48000 n1_m1_196800_48000 5.356235
R1227 n1_m1_196800_48000 n1_m1_200000_48000 3.570824
R1228 n1_m1_201600_48000 n1_m1_200000_48000 1.785412
R1229 n1_m1_201600_48000 n1_m1_206400_48000 5.356235
R1230 n1_m1_206400_48000 n1_m1_211200_48000 5.356235
R1231 n1_m1_211200_48000 n1_m1_216000_48000 5.356235
R1232 n1_m1_216000_48000 n1_m1_220800_48000 5.356235
R1233 n1_m1_220800_48000 n1_m1_225600_48000 5.356235
R1234 n1_m1_225600_48000 n1_m1_228000_48000 2.678118
R1235 n1_m1_230400_48000 n1_m1_228000_48000 2.678118
R1236 n1_m1_230400_48000 n1_m1_235200_48000 5.356235
R1237 n1_m1_235200_48000 n1_m1_240000_48000 5.356235
R1238 n1_m1_240000_48000 n1_m1_244800_48000 5.356235
R1239 n1_m1_244800_48000 n1_m1_249600_48000 5.356235
R1240 n1_m1_249600_48000 n1_m1_254400_48000 5.356235
R1241 n1_m1_254400_48000 n1_m1_256000_48000 1.785412
R1242 n1_m1_259200_48000 n1_m1_256000_48000 3.570824
R1243 n1_m1_259200_48000 n1_m1_264000_48000 5.356235
R1244 n1_m1_264000_48000 n1_m1_268800_48000 5.356235
R1245 n1_m1_268800_48000 n1_m1_273600_48000 5.356235
R1246 n1_m1_273600_48000 n1_m1_278400_48000 5.356235
R1247 n1_m1_278400_48000 n1_m1_283200_48000 5.356235
R1248 n1_m1_283200_48000 n1_m1_284000_48000 0.892706
R1249 n1_m1_288000_48000 n1_m1_284000_48000 4.463529
R1250 n1_m1_288000_48000 n1_m1_292800_48000 5.356235
R1251 n1_m1_292800_48000 n1_m1_297600_48000 5.356235
R1252 n1_m1_297600_48000 n1_m1_302400_48000 5.356235
R1253 n1_m1_302400_48000 n1_m1_307200_48000 5.356235
R1254 n1_m1_307200_48000 n1_m1_312000_48000 5.356235
R1255 n1_m1_312000_48000 n1_m1_316800_48000 5.356235
R1256 n1_m1_316800_48000 n1_m1_321600_48000 5.356235
R1257 n1_m1_321600_48000 n1_m1_326400_48000 5.356235
R1258 n1_m1_326400_48000 n1_m1_331200_48000 5.356235
R1259 n1_m1_331200_48000 n1_m1_336000_48000 5.356235
R1260 n1_m1_336000_48000 n1_m1_340000_48000 4.463529
R1261 n1_m1_340800_48000 n1_m1_340000_48000 0.892706
R1262 n1_m1_340800_48000 n1_m1_345600_48000 5.356235
R1263 n1_m1_345600_48000 n1_m1_350400_48000 5.356235
R1264 n1_m1_350400_48000 n1_m1_355200_48000 5.356235
R1265 n1_m1_355200_48000 n1_m1_360000_48000 5.356235
R1266 n1_m1_360000_48000 n1_m1_364800_48000 5.356235
R1267 n1_m1_364800_48000 n1_m1_368000_48000 3.570824
R1268 n1_m1_369600_48000 n1_m1_368000_48000 1.785412
R1269 n1_m1_369600_48000 n1_m1_374400_48000 5.356235
R1270 n1_m1_374400_48000 n1_m1_379200_48000 5.356235
R1271 n1_m1_379200_48000 n1_m1_384000_48000 5.356235
R1272 n1_m1_384000_48000 n1_m1_388800_48000 5.356235
R1273 n1_m1_388800_48000 n1_m1_393600_48000 5.356235
R1274 n1_m1_393600_48000 n1_m1_396000_48000 2.678118
R1275 n1_m1_398400_48000 n1_m1_396000_48000 2.678118
R1276 n1_m1_398400_48000 n1_m1_403200_48000 5.356235
R1277 n1_m1_403200_48000 n1_m1_408000_48000 5.356235
R1278 n1_m1_408000_48000 n1_m1_412800_48000 5.356235
R1279 n1_m1_412800_48000 n1_m1_417600_48000 5.356235
R1280 n1_m1_417600_48000 n1_m1_422400_48000 5.356235
R1281 n1_m1_422400_48000 n1_m1_424000_48000 1.785412
R1282 n1_m1_427200_48000 n1_m1_424000_48000 3.570824
R1283 n1_m1_427200_48000 n1_m1_432000_48000 5.356235
R1284 n1_m1_432000_48000 n1_m1_436800_48000 5.356235
R1285 n1_m1_436800_48000 n1_m1_441600_48000 5.356235
R1286 n1_m1_441600_48000 n1_m1_446400_48000 5.356235
R1287 n1_m1_446400_48000 n1_m1_451200_48000 5.356235
R1288 n1_m1_451200_48000 n1_m1_452000_48000 0.892706
R1289 n1_m1_456000_48000 n1_m1_452000_48000 4.463529
R1290 n1_m1_456000_48000 n1_m1_460800_48000 5.356235
R1291 n1_m1_460800_48000 n1_m1_465600_48000 5.356235
R1292 n1_m1_465600_48000 n1_m1_470400_48000 5.356235
R1293 n1_m1_470400_48000 n1_m1_475200_48000 5.356235
R1294 n1_m1_475200_48000 n1_m1_480000_48000 5.356235
R1295 n1_m1_480000_48000 n1_m1_484800_48000 5.356235
R1296 n1_m1_484800_48000 n1_m1_489600_48000 5.356235
R1297 n1_m1_489600_48000 n1_m1_494400_48000 5.356235
R1298 n1_m1_0_52800 n1_m1_4000_52800 4.463529
R1299 n1_m1_4800_52800 n1_m1_4000_52800 0.892706
R1300 n1_m1_4800_52800 n1_m1_9600_52800 5.356235
R1301 n1_m1_9600_52800 n1_m1_14400_52800 5.356235
R1302 n1_m1_14400_52800 n1_m1_19200_52800 5.356235
R1303 n1_m1_19200_52800 n1_m1_24000_52800 5.356235
R1304 n1_m1_24000_52800 n1_m1_28800_52800 5.356235
R1305 n1_m1_28800_52800 n1_m1_32000_52800 3.570824
R1306 n1_m1_33600_52800 n1_m1_32000_52800 1.785412
R1307 n1_m1_33600_52800 n1_m1_38400_52800 5.356235
R1308 n1_m1_38400_52800 n1_m1_43200_52800 5.356235
R1309 n1_m1_43200_52800 n1_m1_48000_52800 5.356235
R1310 n1_m1_48000_52800 n1_m1_52800_52800 5.356235
R1311 n1_m1_52800_52800 n1_m1_57600_52800 5.356235
R1312 n1_m1_57600_52800 n1_m1_60000_52800 2.678118
R1313 n1_m1_62400_52800 n1_m1_60000_52800 2.678118
R1314 n1_m1_62400_52800 n1_m1_67200_52800 5.356235
R1315 n1_m1_67200_52800 n1_m1_72000_52800 5.356235
R1316 n1_m1_72000_52800 n1_m1_76800_52800 5.356235
R1317 n1_m1_76800_52800 n1_m1_81600_52800 5.356235
R1318 n1_m1_81600_52800 n1_m1_86400_52800 5.356235
R1319 n1_m1_86400_52800 n1_m1_88000_52800 1.785412
R1320 n1_m1_91200_52800 n1_m1_88000_52800 3.570824
R1321 n1_m1_91200_52800 n1_m1_96000_52800 5.356235
R1322 n1_m1_96000_52800 n1_m1_100800_52800 5.356235
R1323 n1_m1_100800_52800 n1_m1_105600_52800 5.356235
R1324 n1_m1_105600_52800 n1_m1_110400_52800 5.356235
R1325 n1_m1_110400_52800 n1_m1_115200_52800 5.356235
R1326 n1_m1_115200_52800 n1_m1_116000_52800 0.892706
R1327 n1_m1_120000_52800 n1_m1_116000_52800 4.463529
R1328 n1_m1_120000_52800 n1_m1_124800_52800 5.356235
R1329 n1_m1_124800_52800 n1_m1_129600_52800 5.356235
R1330 n1_m1_129600_52800 n1_m1_134400_52800 5.356235
R1331 n1_m1_134400_52800 n1_m1_139200_52800 5.356235
R1332 n1_m1_139200_52800 n1_m1_144000_52800 5.356235
R1333 n1_m1_144000_52800 n1_m1_148800_52800 5.356235
R1334 n1_m1_148800_52800 n1_m1_153600_52800 5.356235
R1335 n1_m1_153600_52800 n1_m1_158400_52800 5.356235
R1336 n1_m1_158400_52800 n1_m1_163200_52800 5.356235
R1337 n1_m1_163200_52800 n1_m1_168000_52800 5.356235
R1338 n1_m1_168000_52800 n1_m1_172000_52800 4.463529
R1339 n1_m1_172800_52800 n1_m1_172000_52800 0.892706
R1340 n1_m1_172800_52800 n1_m1_177600_52800 5.356235
R1341 n1_m1_177600_52800 n1_m1_182400_52800 5.356235
R1342 n1_m1_182400_52800 n1_m1_187200_52800 5.356235
R1343 n1_m1_187200_52800 n1_m1_192000_52800 5.356235
R1344 n1_m1_192000_52800 n1_m1_196800_52800 5.356235
R1345 n1_m1_196800_52800 n1_m1_200000_52800 3.570824
R1346 n1_m1_201600_52800 n1_m1_200000_52800 1.785412
R1347 n1_m1_201600_52800 n1_m1_206400_52800 5.356235
R1348 n1_m1_206400_52800 n1_m1_211200_52800 5.356235
R1349 n1_m1_211200_52800 n1_m1_216000_52800 5.356235
R1350 n1_m1_216000_52800 n1_m1_220800_52800 5.356235
R1351 n1_m1_220800_52800 n1_m1_225600_52800 5.356235
R1352 n1_m1_225600_52800 n1_m1_228000_52800 2.678118
R1353 n1_m1_230400_52800 n1_m1_228000_52800 2.678118
R1354 n1_m1_230400_52800 n1_m1_235200_52800 5.356235
R1355 n1_m1_235200_52800 n1_m1_240000_52800 5.356235
R1356 n1_m1_240000_52800 n1_m1_244800_52800 5.356235
R1357 n1_m1_244800_52800 n1_m1_249600_52800 5.356235
R1358 n1_m1_249600_52800 n1_m1_254400_52800 5.356235
R1359 n1_m1_254400_52800 n1_m1_256000_52800 1.785412
R1360 n1_m1_259200_52800 n1_m1_256000_52800 3.570824
R1361 n1_m1_259200_52800 n1_m1_264000_52800 5.356235
R1362 n1_m1_264000_52800 n1_m1_268800_52800 5.356235
R1363 n1_m1_268800_52800 n1_m1_273600_52800 5.356235
R1364 n1_m1_273600_52800 n1_m1_278400_52800 5.356235
R1365 n1_m1_278400_52800 n1_m1_283200_52800 5.356235
R1366 n1_m1_283200_52800 n1_m1_284000_52800 0.892706
R1367 n1_m1_288000_52800 n1_m1_284000_52800 4.463529
R1368 n1_m1_288000_52800 n1_m1_292800_52800 5.356235
R1369 n1_m1_292800_52800 n1_m1_297600_52800 5.356235
R1370 n1_m1_297600_52800 n1_m1_302400_52800 5.356235
R1371 n1_m1_302400_52800 n1_m1_307200_52800 5.356235
R1372 n1_m1_307200_52800 n1_m1_312000_52800 5.356235
R1373 n1_m1_312000_52800 n1_m1_316800_52800 5.356235
R1374 n1_m1_316800_52800 n1_m1_321600_52800 5.356235
R1375 n1_m1_321600_52800 n1_m1_326400_52800 5.356235
R1376 n1_m1_326400_52800 n1_m1_331200_52800 5.356235
R1377 n1_m1_331200_52800 n1_m1_336000_52800 5.356235
R1378 n1_m1_336000_52800 n1_m1_340000_52800 4.463529
R1379 n1_m1_340800_52800 n1_m1_340000_52800 0.892706
R1380 n1_m1_340800_52800 n1_m1_345600_52800 5.356235
R1381 n1_m1_345600_52800 n1_m1_350400_52800 5.356235
R1382 n1_m1_350400_52800 n1_m1_355200_52800 5.356235
R1383 n1_m1_355200_52800 n1_m1_360000_52800 5.356235
R1384 n1_m1_360000_52800 n1_m1_364800_52800 5.356235
R1385 n1_m1_364800_52800 n1_m1_368000_52800 3.570824
R1386 n1_m1_369600_52800 n1_m1_368000_52800 1.785412
R1387 n1_m1_369600_52800 n1_m1_374400_52800 5.356235
R1388 n1_m1_374400_52800 n1_m1_379200_52800 5.356235
R1389 n1_m1_379200_52800 n1_m1_384000_52800 5.356235
R1390 n1_m1_384000_52800 n1_m1_388800_52800 5.356235
R1391 n1_m1_388800_52800 n1_m1_393600_52800 5.356235
R1392 n1_m1_393600_52800 n1_m1_396000_52800 2.678118
R1393 n1_m1_398400_52800 n1_m1_396000_52800 2.678118
R1394 n1_m1_398400_52800 n1_m1_403200_52800 5.356235
R1395 n1_m1_403200_52800 n1_m1_408000_52800 5.356235
R1396 n1_m1_408000_52800 n1_m1_412800_52800 5.356235
R1397 n1_m1_412800_52800 n1_m1_417600_52800 5.356235
R1398 n1_m1_417600_52800 n1_m1_422400_52800 5.356235
R1399 n1_m1_422400_52800 n1_m1_424000_52800 1.785412
R1400 n1_m1_427200_52800 n1_m1_424000_52800 3.570824
R1401 n1_m1_427200_52800 n1_m1_432000_52800 5.356235
R1402 n1_m1_432000_52800 n1_m1_436800_52800 5.356235
R1403 n1_m1_436800_52800 n1_m1_441600_52800 5.356235
R1404 n1_m1_441600_52800 n1_m1_446400_52800 5.356235
R1405 n1_m1_446400_52800 n1_m1_451200_52800 5.356235
R1406 n1_m1_451200_52800 n1_m1_452000_52800 0.892706
R1407 n1_m1_456000_52800 n1_m1_452000_52800 4.463529
R1408 n1_m1_456000_52800 n1_m1_460800_52800 5.356235
R1409 n1_m1_460800_52800 n1_m1_465600_52800 5.356235
R1410 n1_m1_465600_52800 n1_m1_470400_52800 5.356235
R1411 n1_m1_470400_52800 n1_m1_475200_52800 5.356235
R1412 n1_m1_475200_52800 n1_m1_480000_52800 5.356235
R1413 n1_m1_480000_52800 n1_m1_484800_52800 5.356235
R1414 n1_m1_484800_52800 n1_m1_489600_52800 5.356235
R1415 n1_m1_489600_52800 n1_m1_494400_52800 5.356235
R1416 n1_m1_0_57600 n1_m1_4000_57600 4.463529
R1417 n1_m1_4800_57600 n1_m1_4000_57600 0.892706
R1418 n1_m1_4800_57600 n1_m1_9600_57600 5.356235
R1419 n1_m1_9600_57600 n1_m1_14400_57600 5.356235
R1420 n1_m1_14400_57600 n1_m1_19200_57600 5.356235
R1421 n1_m1_19200_57600 n1_m1_24000_57600 5.356235
R1422 n1_m1_24000_57600 n1_m1_28800_57600 5.356235
R1423 n1_m1_28800_57600 n1_m1_32000_57600 3.570824
R1424 n1_m1_33600_57600 n1_m1_32000_57600 1.785412
R1425 n1_m1_33600_57600 n1_m1_38400_57600 5.356235
R1426 n1_m1_38400_57600 n1_m1_43200_57600 5.356235
R1427 n1_m1_43200_57600 n1_m1_48000_57600 5.356235
R1428 n1_m1_48000_57600 n1_m1_52800_57600 5.356235
R1429 n1_m1_52800_57600 n1_m1_57600_57600 5.356235
R1430 n1_m1_57600_57600 n1_m1_60000_57600 2.678118
R1431 n1_m1_62400_57600 n1_m1_60000_57600 2.678118
R1432 n1_m1_62400_57600 n1_m1_67200_57600 5.356235
R1433 n1_m1_67200_57600 n1_m1_72000_57600 5.356235
R1434 n1_m1_72000_57600 n1_m1_76800_57600 5.356235
R1435 n1_m1_76800_57600 n1_m1_81600_57600 5.356235
R1436 n1_m1_81600_57600 n1_m1_86400_57600 5.356235
R1437 n1_m1_86400_57600 n1_m1_88000_57600 1.785412
R1438 n1_m1_91200_57600 n1_m1_88000_57600 3.570824
R1439 n1_m1_91200_57600 n1_m1_96000_57600 5.356235
R1440 n1_m1_96000_57600 n1_m1_100800_57600 5.356235
R1441 n1_m1_100800_57600 n1_m1_105600_57600 5.356235
R1442 n1_m1_105600_57600 n1_m1_110400_57600 5.356235
R1443 n1_m1_110400_57600 n1_m1_115200_57600 5.356235
R1444 n1_m1_115200_57600 n1_m1_116000_57600 0.892706
R1445 n1_m1_120000_57600 n1_m1_116000_57600 4.463529
R1446 n1_m1_120000_57600 n1_m1_124800_57600 5.356235
R1447 n1_m1_124800_57600 n1_m1_129600_57600 5.356235
R1448 n1_m1_129600_57600 n1_m1_134400_57600 5.356235
R1449 n1_m1_134400_57600 n1_m1_139200_57600 5.356235
R1450 n1_m1_139200_57600 n1_m1_144000_57600 5.356235
R1451 n1_m1_144000_57600 n1_m1_148800_57600 5.356235
R1452 n1_m1_148800_57600 n1_m1_153600_57600 5.356235
R1453 n1_m1_153600_57600 n1_m1_158400_57600 5.356235
R1454 n1_m1_158400_57600 n1_m1_163200_57600 5.356235
R1455 n1_m1_163200_57600 n1_m1_168000_57600 5.356235
R1456 n1_m1_168000_57600 n1_m1_172000_57600 4.463529
R1457 n1_m1_172800_57600 n1_m1_172000_57600 0.892706
R1458 n1_m1_172800_57600 n1_m1_177600_57600 5.356235
R1459 n1_m1_177600_57600 n1_m1_182400_57600 5.356235
R1460 n1_m1_182400_57600 n1_m1_187200_57600 5.356235
R1461 n1_m1_187200_57600 n1_m1_192000_57600 5.356235
R1462 n1_m1_192000_57600 n1_m1_196800_57600 5.356235
R1463 n1_m1_196800_57600 n1_m1_200000_57600 3.570824
R1464 n1_m1_201600_57600 n1_m1_200000_57600 1.785412
R1465 n1_m1_201600_57600 n1_m1_206400_57600 5.356235
R1466 n1_m1_206400_57600 n1_m1_211200_57600 5.356235
R1467 n1_m1_211200_57600 n1_m1_216000_57600 5.356235
R1468 n1_m1_216000_57600 n1_m1_220800_57600 5.356235
R1469 n1_m1_220800_57600 n1_m1_225600_57600 5.356235
R1470 n1_m1_225600_57600 n1_m1_228000_57600 2.678118
R1471 n1_m1_230400_57600 n1_m1_228000_57600 2.678118
R1472 n1_m1_230400_57600 n1_m1_235200_57600 5.356235
R1473 n1_m1_235200_57600 n1_m1_240000_57600 5.356235
R1474 n1_m1_240000_57600 n1_m1_244800_57600 5.356235
R1475 n1_m1_244800_57600 n1_m1_249600_57600 5.356235
R1476 n1_m1_249600_57600 n1_m1_254400_57600 5.356235
R1477 n1_m1_254400_57600 n1_m1_256000_57600 1.785412
R1478 n1_m1_259200_57600 n1_m1_256000_57600 3.570824
R1479 n1_m1_259200_57600 n1_m1_264000_57600 5.356235
R1480 n1_m1_264000_57600 n1_m1_268800_57600 5.356235
R1481 n1_m1_268800_57600 n1_m1_273600_57600 5.356235
R1482 n1_m1_273600_57600 n1_m1_278400_57600 5.356235
R1483 n1_m1_278400_57600 n1_m1_283200_57600 5.356235
R1484 n1_m1_283200_57600 n1_m1_284000_57600 0.892706
R1485 n1_m1_288000_57600 n1_m1_284000_57600 4.463529
R1486 n1_m1_288000_57600 n1_m1_292800_57600 5.356235
R1487 n1_m1_292800_57600 n1_m1_297600_57600 5.356235
R1488 n1_m1_297600_57600 n1_m1_302400_57600 5.356235
R1489 n1_m1_302400_57600 n1_m1_307200_57600 5.356235
R1490 n1_m1_307200_57600 n1_m1_312000_57600 5.356235
R1491 n1_m1_312000_57600 n1_m1_316800_57600 5.356235
R1492 n1_m1_316800_57600 n1_m1_321600_57600 5.356235
R1493 n1_m1_321600_57600 n1_m1_326400_57600 5.356235
R1494 n1_m1_326400_57600 n1_m1_331200_57600 5.356235
R1495 n1_m1_331200_57600 n1_m1_336000_57600 5.356235
R1496 n1_m1_336000_57600 n1_m1_340000_57600 4.463529
R1497 n1_m1_340800_57600 n1_m1_340000_57600 0.892706
R1498 n1_m1_340800_57600 n1_m1_345600_57600 5.356235
R1499 n1_m1_345600_57600 n1_m1_350400_57600 5.356235
R1500 n1_m1_350400_57600 n1_m1_355200_57600 5.356235
R1501 n1_m1_355200_57600 n1_m1_360000_57600 5.356235
R1502 n1_m1_360000_57600 n1_m1_364800_57600 5.356235
R1503 n1_m1_364800_57600 n1_m1_368000_57600 3.570824
R1504 n1_m1_369600_57600 n1_m1_368000_57600 1.785412
R1505 n1_m1_369600_57600 n1_m1_374400_57600 5.356235
R1506 n1_m1_374400_57600 n1_m1_379200_57600 5.356235
R1507 n1_m1_379200_57600 n1_m1_384000_57600 5.356235
R1508 n1_m1_384000_57600 n1_m1_388800_57600 5.356235
R1509 n1_m1_388800_57600 n1_m1_393600_57600 5.356235
R1510 n1_m1_393600_57600 n1_m1_396000_57600 2.678118
R1511 n1_m1_398400_57600 n1_m1_396000_57600 2.678118
R1512 n1_m1_398400_57600 n1_m1_403200_57600 5.356235
R1513 n1_m1_403200_57600 n1_m1_408000_57600 5.356235
R1514 n1_m1_408000_57600 n1_m1_412800_57600 5.356235
R1515 n1_m1_412800_57600 n1_m1_417600_57600 5.356235
R1516 n1_m1_417600_57600 n1_m1_422400_57600 5.356235
R1517 n1_m1_422400_57600 n1_m1_424000_57600 1.785412
R1518 n1_m1_427200_57600 n1_m1_424000_57600 3.570824
R1519 n1_m1_427200_57600 n1_m1_432000_57600 5.356235
R1520 n1_m1_432000_57600 n1_m1_436800_57600 5.356235
R1521 n1_m1_436800_57600 n1_m1_441600_57600 5.356235
R1522 n1_m1_441600_57600 n1_m1_446400_57600 5.356235
R1523 n1_m1_446400_57600 n1_m1_451200_57600 5.356235
R1524 n1_m1_451200_57600 n1_m1_452000_57600 0.892706
R1525 n1_m1_456000_57600 n1_m1_452000_57600 4.463529
R1526 n1_m1_456000_57600 n1_m1_460800_57600 5.356235
R1527 n1_m1_460800_57600 n1_m1_465600_57600 5.356235
R1528 n1_m1_465600_57600 n1_m1_470400_57600 5.356235
R1529 n1_m1_470400_57600 n1_m1_475200_57600 5.356235
R1530 n1_m1_475200_57600 n1_m1_480000_57600 5.356235
R1531 n1_m1_480000_57600 n1_m1_484800_57600 5.356235
R1532 n1_m1_484800_57600 n1_m1_489600_57600 5.356235
R1533 n1_m1_489600_57600 n1_m1_494400_57600 5.356235
R1534 n1_m1_0_62400 n1_m1_4000_62400 4.463529
R1535 n1_m1_4800_62400 n1_m1_4000_62400 0.892706
R1536 n1_m1_4800_62400 n1_m1_9600_62400 5.356235
R1537 n1_m1_9600_62400 n1_m1_14400_62400 5.356235
R1538 n1_m1_14400_62400 n1_m1_19200_62400 5.356235
R1539 n1_m1_19200_62400 n1_m1_24000_62400 5.356235
R1540 n1_m1_24000_62400 n1_m1_28800_62400 5.356235
R1541 n1_m1_28800_62400 n1_m1_32000_62400 3.570824
R1542 n1_m1_33600_62400 n1_m1_32000_62400 1.785412
R1543 n1_m1_33600_62400 n1_m1_38400_62400 5.356235
R1544 n1_m1_38400_62400 n1_m1_43200_62400 5.356235
R1545 n1_m1_43200_62400 n1_m1_48000_62400 5.356235
R1546 n1_m1_48000_62400 n1_m1_52800_62400 5.356235
R1547 n1_m1_52800_62400 n1_m1_57600_62400 5.356235
R1548 n1_m1_57600_62400 n1_m1_60000_62400 2.678118
R1549 n1_m1_62400_62400 n1_m1_60000_62400 2.678118
R1550 n1_m1_62400_62400 n1_m1_67200_62400 5.356235
R1551 n1_m1_67200_62400 n1_m1_72000_62400 5.356235
R1552 n1_m1_72000_62400 n1_m1_76800_62400 5.356235
R1553 n1_m1_76800_62400 n1_m1_81600_62400 5.356235
R1554 n1_m1_81600_62400 n1_m1_86400_62400 5.356235
R1555 n1_m1_86400_62400 n1_m1_88000_62400 1.785412
R1556 n1_m1_91200_62400 n1_m1_88000_62400 3.570824
R1557 n1_m1_91200_62400 n1_m1_96000_62400 5.356235
R1558 n1_m1_96000_62400 n1_m1_100800_62400 5.356235
R1559 n1_m1_100800_62400 n1_m1_105600_62400 5.356235
R1560 n1_m1_105600_62400 n1_m1_110400_62400 5.356235
R1561 n1_m1_110400_62400 n1_m1_115200_62400 5.356235
R1562 n1_m1_115200_62400 n1_m1_116000_62400 0.892706
R1563 n1_m1_120000_62400 n1_m1_116000_62400 4.463529
R1564 n1_m1_120000_62400 n1_m1_124800_62400 5.356235
R1565 n1_m1_124800_62400 n1_m1_129600_62400 5.356235
R1566 n1_m1_129600_62400 n1_m1_134400_62400 5.356235
R1567 n1_m1_134400_62400 n1_m1_139200_62400 5.356235
R1568 n1_m1_139200_62400 n1_m1_144000_62400 5.356235
R1569 n1_m1_144000_62400 n1_m1_148800_62400 5.356235
R1570 n1_m1_148800_62400 n1_m1_153600_62400 5.356235
R1571 n1_m1_153600_62400 n1_m1_158400_62400 5.356235
R1572 n1_m1_158400_62400 n1_m1_163200_62400 5.356235
R1573 n1_m1_163200_62400 n1_m1_168000_62400 5.356235
R1574 n1_m1_168000_62400 n1_m1_172000_62400 4.463529
R1575 n1_m1_172800_62400 n1_m1_172000_62400 0.892706
R1576 n1_m1_172800_62400 n1_m1_177600_62400 5.356235
R1577 n1_m1_177600_62400 n1_m1_182400_62400 5.356235
R1578 n1_m1_182400_62400 n1_m1_187200_62400 5.356235
R1579 n1_m1_187200_62400 n1_m1_192000_62400 5.356235
R1580 n1_m1_192000_62400 n1_m1_196800_62400 5.356235
R1581 n1_m1_196800_62400 n1_m1_200000_62400 3.570824
R1582 n1_m1_201600_62400 n1_m1_200000_62400 1.785412
R1583 n1_m1_201600_62400 n1_m1_206400_62400 5.356235
R1584 n1_m1_206400_62400 n1_m1_211200_62400 5.356235
R1585 n1_m1_211200_62400 n1_m1_216000_62400 5.356235
R1586 n1_m1_216000_62400 n1_m1_220800_62400 5.356235
R1587 n1_m1_220800_62400 n1_m1_225600_62400 5.356235
R1588 n1_m1_225600_62400 n1_m1_228000_62400 2.678118
R1589 n1_m1_230400_62400 n1_m1_228000_62400 2.678118
R1590 n1_m1_230400_62400 n1_m1_235200_62400 5.356235
R1591 n1_m1_235200_62400 n1_m1_240000_62400 5.356235
R1592 n1_m1_240000_62400 n1_m1_244800_62400 5.356235
R1593 n1_m1_244800_62400 n1_m1_249600_62400 5.356235
R1594 n1_m1_249600_62400 n1_m1_254400_62400 5.356235
R1595 n1_m1_254400_62400 n1_m1_256000_62400 1.785412
R1596 n1_m1_259200_62400 n1_m1_256000_62400 3.570824
R1597 n1_m1_259200_62400 n1_m1_264000_62400 5.356235
R1598 n1_m1_264000_62400 n1_m1_268800_62400 5.356235
R1599 n1_m1_268800_62400 n1_m1_273600_62400 5.356235
R1600 n1_m1_273600_62400 n1_m1_278400_62400 5.356235
R1601 n1_m1_278400_62400 n1_m1_283200_62400 5.356235
R1602 n1_m1_283200_62400 n1_m1_284000_62400 0.892706
R1603 n1_m1_288000_62400 n1_m1_284000_62400 4.463529
R1604 n1_m1_288000_62400 n1_m1_292800_62400 5.356235
R1605 n1_m1_292800_62400 n1_m1_297600_62400 5.356235
R1606 n1_m1_297600_62400 n1_m1_302400_62400 5.356235
R1607 n1_m1_302400_62400 n1_m1_307200_62400 5.356235
R1608 n1_m1_307200_62400 n1_m1_312000_62400 5.356235
R1609 n1_m1_312000_62400 n1_m1_316800_62400 5.356235
R1610 n1_m1_316800_62400 n1_m1_321600_62400 5.356235
R1611 n1_m1_321600_62400 n1_m1_326400_62400 5.356235
R1612 n1_m1_326400_62400 n1_m1_331200_62400 5.356235
R1613 n1_m1_331200_62400 n1_m1_336000_62400 5.356235
R1614 n1_m1_336000_62400 n1_m1_340000_62400 4.463529
R1615 n1_m1_340800_62400 n1_m1_340000_62400 0.892706
R1616 n1_m1_340800_62400 n1_m1_345600_62400 5.356235
R1617 n1_m1_345600_62400 n1_m1_350400_62400 5.356235
R1618 n1_m1_350400_62400 n1_m1_355200_62400 5.356235
R1619 n1_m1_355200_62400 n1_m1_360000_62400 5.356235
R1620 n1_m1_360000_62400 n1_m1_364800_62400 5.356235
R1621 n1_m1_364800_62400 n1_m1_368000_62400 3.570824
R1622 n1_m1_369600_62400 n1_m1_368000_62400 1.785412
R1623 n1_m1_369600_62400 n1_m1_374400_62400 5.356235
R1624 n1_m1_374400_62400 n1_m1_379200_62400 5.356235
R1625 n1_m1_379200_62400 n1_m1_384000_62400 5.356235
R1626 n1_m1_384000_62400 n1_m1_388800_62400 5.356235
R1627 n1_m1_388800_62400 n1_m1_393600_62400 5.356235
R1628 n1_m1_393600_62400 n1_m1_396000_62400 2.678118
R1629 n1_m1_398400_62400 n1_m1_396000_62400 2.678118
R1630 n1_m1_398400_62400 n1_m1_403200_62400 5.356235
R1631 n1_m1_403200_62400 n1_m1_408000_62400 5.356235
R1632 n1_m1_408000_62400 n1_m1_412800_62400 5.356235
R1633 n1_m1_412800_62400 n1_m1_417600_62400 5.356235
R1634 n1_m1_417600_62400 n1_m1_422400_62400 5.356235
R1635 n1_m1_422400_62400 n1_m1_424000_62400 1.785412
R1636 n1_m1_427200_62400 n1_m1_424000_62400 3.570824
R1637 n1_m1_427200_62400 n1_m1_432000_62400 5.356235
R1638 n1_m1_432000_62400 n1_m1_436800_62400 5.356235
R1639 n1_m1_436800_62400 n1_m1_441600_62400 5.356235
R1640 n1_m1_441600_62400 n1_m1_446400_62400 5.356235
R1641 n1_m1_446400_62400 n1_m1_451200_62400 5.356235
R1642 n1_m1_451200_62400 n1_m1_452000_62400 0.892706
R1643 n1_m1_456000_62400 n1_m1_452000_62400 4.463529
R1644 n1_m1_456000_62400 n1_m1_460800_62400 5.356235
R1645 n1_m1_460800_62400 n1_m1_465600_62400 5.356235
R1646 n1_m1_465600_62400 n1_m1_470400_62400 5.356235
R1647 n1_m1_470400_62400 n1_m1_475200_62400 5.356235
R1648 n1_m1_475200_62400 n1_m1_480000_62400 5.356235
R1649 n1_m1_480000_62400 n1_m1_484800_62400 5.356235
R1650 n1_m1_484800_62400 n1_m1_489600_62400 5.356235
R1651 n1_m1_489600_62400 n1_m1_494400_62400 5.356235
R1652 n1_m1_0_67200 n1_m1_4000_67200 4.463529
R1653 n1_m1_4800_67200 n1_m1_4000_67200 0.892706
R1654 n1_m1_4800_67200 n1_m1_9600_67200 5.356235
R1655 n1_m1_9600_67200 n1_m1_14400_67200 5.356235
R1656 n1_m1_14400_67200 n1_m1_19200_67200 5.356235
R1657 n1_m1_19200_67200 n1_m1_24000_67200 5.356235
R1658 n1_m1_24000_67200 n1_m1_28800_67200 5.356235
R1659 n1_m1_28800_67200 n1_m1_32000_67200 3.570824
R1660 n1_m1_33600_67200 n1_m1_32000_67200 1.785412
R1661 n1_m1_33600_67200 n1_m1_38400_67200 5.356235
R1662 n1_m1_38400_67200 n1_m1_43200_67200 5.356235
R1663 n1_m1_43200_67200 n1_m1_48000_67200 5.356235
R1664 n1_m1_48000_67200 n1_m1_52800_67200 5.356235
R1665 n1_m1_52800_67200 n1_m1_57600_67200 5.356235
R1666 n1_m1_57600_67200 n1_m1_60000_67200 2.678118
R1667 n1_m1_62400_67200 n1_m1_60000_67200 2.678118
R1668 n1_m1_62400_67200 n1_m1_67200_67200 5.356235
R1669 n1_m1_67200_67200 n1_m1_72000_67200 5.356235
R1670 n1_m1_72000_67200 n1_m1_76800_67200 5.356235
R1671 n1_m1_76800_67200 n1_m1_81600_67200 5.356235
R1672 n1_m1_81600_67200 n1_m1_86400_67200 5.356235
R1673 n1_m1_86400_67200 n1_m1_88000_67200 1.785412
R1674 n1_m1_91200_67200 n1_m1_88000_67200 3.570824
R1675 n1_m1_91200_67200 n1_m1_96000_67200 5.356235
R1676 n1_m1_96000_67200 n1_m1_100800_67200 5.356235
R1677 n1_m1_100800_67200 n1_m1_105600_67200 5.356235
R1678 n1_m1_105600_67200 n1_m1_110400_67200 5.356235
R1679 n1_m1_110400_67200 n1_m1_115200_67200 5.356235
R1680 n1_m1_115200_67200 n1_m1_116000_67200 0.892706
R1681 n1_m1_120000_67200 n1_m1_116000_67200 4.463529
R1682 n1_m1_120000_67200 n1_m1_124800_67200 5.356235
R1683 n1_m1_124800_67200 n1_m1_129600_67200 5.356235
R1684 n1_m1_129600_67200 n1_m1_134400_67200 5.356235
R1685 n1_m1_134400_67200 n1_m1_139200_67200 5.356235
R1686 n1_m1_139200_67200 n1_m1_144000_67200 5.356235
R1687 n1_m1_144000_67200 n1_m1_148800_67200 5.356235
R1688 n1_m1_148800_67200 n1_m1_153600_67200 5.356235
R1689 n1_m1_153600_67200 n1_m1_158400_67200 5.356235
R1690 n1_m1_158400_67200 n1_m1_163200_67200 5.356235
R1691 n1_m1_163200_67200 n1_m1_168000_67200 5.356235
R1692 n1_m1_168000_67200 n1_m1_172000_67200 4.463529
R1693 n1_m1_172800_67200 n1_m1_172000_67200 0.892706
R1694 n1_m1_172800_67200 n1_m1_177600_67200 5.356235
R1695 n1_m1_177600_67200 n1_m1_182400_67200 5.356235
R1696 n1_m1_182400_67200 n1_m1_187200_67200 5.356235
R1697 n1_m1_187200_67200 n1_m1_192000_67200 5.356235
R1698 n1_m1_192000_67200 n1_m1_196800_67200 5.356235
R1699 n1_m1_196800_67200 n1_m1_200000_67200 3.570824
R1700 n1_m1_201600_67200 n1_m1_200000_67200 1.785412
R1701 n1_m1_201600_67200 n1_m1_206400_67200 5.356235
R1702 n1_m1_206400_67200 n1_m1_211200_67200 5.356235
R1703 n1_m1_211200_67200 n1_m1_216000_67200 5.356235
R1704 n1_m1_216000_67200 n1_m1_220800_67200 5.356235
R1705 n1_m1_220800_67200 n1_m1_225600_67200 5.356235
R1706 n1_m1_225600_67200 n1_m1_228000_67200 2.678118
R1707 n1_m1_230400_67200 n1_m1_228000_67200 2.678118
R1708 n1_m1_230400_67200 n1_m1_235200_67200 5.356235
R1709 n1_m1_235200_67200 n1_m1_240000_67200 5.356235
R1710 n1_m1_240000_67200 n1_m1_244800_67200 5.356235
R1711 n1_m1_244800_67200 n1_m1_249600_67200 5.356235
R1712 n1_m1_249600_67200 n1_m1_254400_67200 5.356235
R1713 n1_m1_254400_67200 n1_m1_256000_67200 1.785412
R1714 n1_m1_259200_67200 n1_m1_256000_67200 3.570824
R1715 n1_m1_259200_67200 n1_m1_264000_67200 5.356235
R1716 n1_m1_264000_67200 n1_m1_268800_67200 5.356235
R1717 n1_m1_268800_67200 n1_m1_273600_67200 5.356235
R1718 n1_m1_273600_67200 n1_m1_278400_67200 5.356235
R1719 n1_m1_278400_67200 n1_m1_283200_67200 5.356235
R1720 n1_m1_283200_67200 n1_m1_284000_67200 0.892706
R1721 n1_m1_288000_67200 n1_m1_284000_67200 4.463529
R1722 n1_m1_288000_67200 n1_m1_292800_67200 5.356235
R1723 n1_m1_292800_67200 n1_m1_297600_67200 5.356235
R1724 n1_m1_297600_67200 n1_m1_302400_67200 5.356235
R1725 n1_m1_302400_67200 n1_m1_307200_67200 5.356235
R1726 n1_m1_307200_67200 n1_m1_312000_67200 5.356235
R1727 n1_m1_312000_67200 n1_m1_316800_67200 5.356235
R1728 n1_m1_316800_67200 n1_m1_321600_67200 5.356235
R1729 n1_m1_321600_67200 n1_m1_326400_67200 5.356235
R1730 n1_m1_326400_67200 n1_m1_331200_67200 5.356235
R1731 n1_m1_331200_67200 n1_m1_336000_67200 5.356235
R1732 n1_m1_336000_67200 n1_m1_340000_67200 4.463529
R1733 n1_m1_340800_67200 n1_m1_340000_67200 0.892706
R1734 n1_m1_340800_67200 n1_m1_345600_67200 5.356235
R1735 n1_m1_345600_67200 n1_m1_350400_67200 5.356235
R1736 n1_m1_350400_67200 n1_m1_355200_67200 5.356235
R1737 n1_m1_355200_67200 n1_m1_360000_67200 5.356235
R1738 n1_m1_360000_67200 n1_m1_364800_67200 5.356235
R1739 n1_m1_364800_67200 n1_m1_368000_67200 3.570824
R1740 n1_m1_369600_67200 n1_m1_368000_67200 1.785412
R1741 n1_m1_369600_67200 n1_m1_374400_67200 5.356235
R1742 n1_m1_374400_67200 n1_m1_379200_67200 5.356235
R1743 n1_m1_379200_67200 n1_m1_384000_67200 5.356235
R1744 n1_m1_384000_67200 n1_m1_388800_67200 5.356235
R1745 n1_m1_388800_67200 n1_m1_393600_67200 5.356235
R1746 n1_m1_393600_67200 n1_m1_396000_67200 2.678118
R1747 n1_m1_398400_67200 n1_m1_396000_67200 2.678118
R1748 n1_m1_398400_67200 n1_m1_403200_67200 5.356235
R1749 n1_m1_403200_67200 n1_m1_408000_67200 5.356235
R1750 n1_m1_408000_67200 n1_m1_412800_67200 5.356235
R1751 n1_m1_412800_67200 n1_m1_417600_67200 5.356235
R1752 n1_m1_417600_67200 n1_m1_422400_67200 5.356235
R1753 n1_m1_422400_67200 n1_m1_424000_67200 1.785412
R1754 n1_m1_427200_67200 n1_m1_424000_67200 3.570824
R1755 n1_m1_427200_67200 n1_m1_432000_67200 5.356235
R1756 n1_m1_432000_67200 n1_m1_436800_67200 5.356235
R1757 n1_m1_436800_67200 n1_m1_441600_67200 5.356235
R1758 n1_m1_441600_67200 n1_m1_446400_67200 5.356235
R1759 n1_m1_446400_67200 n1_m1_451200_67200 5.356235
R1760 n1_m1_451200_67200 n1_m1_452000_67200 0.892706
R1761 n1_m1_456000_67200 n1_m1_452000_67200 4.463529
R1762 n1_m1_456000_67200 n1_m1_460800_67200 5.356235
R1763 n1_m1_460800_67200 n1_m1_465600_67200 5.356235
R1764 n1_m1_465600_67200 n1_m1_470400_67200 5.356235
R1765 n1_m1_470400_67200 n1_m1_475200_67200 5.356235
R1766 n1_m1_475200_67200 n1_m1_480000_67200 5.356235
R1767 n1_m1_480000_67200 n1_m1_484800_67200 5.356235
R1768 n1_m1_484800_67200 n1_m1_489600_67200 5.356235
R1769 n1_m1_489600_67200 n1_m1_494400_67200 5.356235
R1770 n1_m1_0_72000 n1_m1_4000_72000 4.463529
R1771 n1_m1_4800_72000 n1_m1_4000_72000 0.892706
R1772 n1_m1_4800_72000 n1_m1_9600_72000 5.356235
R1773 n1_m1_9600_72000 n1_m1_14400_72000 5.356235
R1774 n1_m1_14400_72000 n1_m1_19200_72000 5.356235
R1775 n1_m1_19200_72000 n1_m1_24000_72000 5.356235
R1776 n1_m1_24000_72000 n1_m1_28800_72000 5.356235
R1777 n1_m1_28800_72000 n1_m1_32000_72000 3.570824
R1778 n1_m1_33600_72000 n1_m1_32000_72000 1.785412
R1779 n1_m1_33600_72000 n1_m1_38400_72000 5.356235
R1780 n1_m1_38400_72000 n1_m1_43200_72000 5.356235
R1781 n1_m1_43200_72000 n1_m1_48000_72000 5.356235
R1782 n1_m1_48000_72000 n1_m1_52800_72000 5.356235
R1783 n1_m1_52800_72000 n1_m1_57600_72000 5.356235
R1784 n1_m1_57600_72000 n1_m1_60000_72000 2.678118
R1785 n1_m1_62400_72000 n1_m1_60000_72000 2.678118
R1786 n1_m1_62400_72000 n1_m1_67200_72000 5.356235
R1787 n1_m1_67200_72000 n1_m1_72000_72000 5.356235
R1788 n1_m1_72000_72000 n1_m1_76800_72000 5.356235
R1789 n1_m1_76800_72000 n1_m1_81600_72000 5.356235
R1790 n1_m1_81600_72000 n1_m1_86400_72000 5.356235
R1791 n1_m1_86400_72000 n1_m1_88000_72000 1.785412
R1792 n1_m1_91200_72000 n1_m1_88000_72000 3.570824
R1793 n1_m1_91200_72000 n1_m1_96000_72000 5.356235
R1794 n1_m1_96000_72000 n1_m1_100800_72000 5.356235
R1795 n1_m1_100800_72000 n1_m1_105600_72000 5.356235
R1796 n1_m1_105600_72000 n1_m1_110400_72000 5.356235
R1797 n1_m1_110400_72000 n1_m1_115200_72000 5.356235
R1798 n1_m1_115200_72000 n1_m1_116000_72000 0.892706
R1799 n1_m1_120000_72000 n1_m1_116000_72000 4.463529
R1800 n1_m1_120000_72000 n1_m1_124800_72000 5.356235
R1801 n1_m1_124800_72000 n1_m1_129600_72000 5.356235
R1802 n1_m1_129600_72000 n1_m1_134400_72000 5.356235
R1803 n1_m1_134400_72000 n1_m1_139200_72000 5.356235
R1804 n1_m1_139200_72000 n1_m1_144000_72000 5.356235
R1805 n1_m1_144000_72000 n1_m1_148800_72000 5.356235
R1806 n1_m1_148800_72000 n1_m1_153600_72000 5.356235
R1807 n1_m1_153600_72000 n1_m1_158400_72000 5.356235
R1808 n1_m1_158400_72000 n1_m1_163200_72000 5.356235
R1809 n1_m1_163200_72000 n1_m1_168000_72000 5.356235
R1810 n1_m1_168000_72000 n1_m1_172000_72000 4.463529
R1811 n1_m1_172800_72000 n1_m1_172000_72000 0.892706
R1812 n1_m1_172800_72000 n1_m1_177600_72000 5.356235
R1813 n1_m1_177600_72000 n1_m1_182400_72000 5.356235
R1814 n1_m1_182400_72000 n1_m1_187200_72000 5.356235
R1815 n1_m1_187200_72000 n1_m1_192000_72000 5.356235
R1816 n1_m1_192000_72000 n1_m1_196800_72000 5.356235
R1817 n1_m1_196800_72000 n1_m1_200000_72000 3.570824
R1818 n1_m1_201600_72000 n1_m1_200000_72000 1.785412
R1819 n1_m1_201600_72000 n1_m1_206400_72000 5.356235
R1820 n1_m1_206400_72000 n1_m1_211200_72000 5.356235
R1821 n1_m1_211200_72000 n1_m1_216000_72000 5.356235
R1822 n1_m1_216000_72000 n1_m1_220800_72000 5.356235
R1823 n1_m1_220800_72000 n1_m1_225600_72000 5.356235
R1824 n1_m1_225600_72000 n1_m1_228000_72000 2.678118
R1825 n1_m1_230400_72000 n1_m1_228000_72000 2.678118
R1826 n1_m1_230400_72000 n1_m1_235200_72000 5.356235
R1827 n1_m1_235200_72000 n1_m1_240000_72000 5.356235
R1828 n1_m1_240000_72000 n1_m1_244800_72000 5.356235
R1829 n1_m1_244800_72000 n1_m1_249600_72000 5.356235
R1830 n1_m1_249600_72000 n1_m1_254400_72000 5.356235
R1831 n1_m1_254400_72000 n1_m1_256000_72000 1.785412
R1832 n1_m1_259200_72000 n1_m1_256000_72000 3.570824
R1833 n1_m1_259200_72000 n1_m1_264000_72000 5.356235
R1834 n1_m1_264000_72000 n1_m1_268800_72000 5.356235
R1835 n1_m1_268800_72000 n1_m1_273600_72000 5.356235
R1836 n1_m1_273600_72000 n1_m1_278400_72000 5.356235
R1837 n1_m1_278400_72000 n1_m1_283200_72000 5.356235
R1838 n1_m1_283200_72000 n1_m1_284000_72000 0.892706
R1839 n1_m1_288000_72000 n1_m1_284000_72000 4.463529
R1840 n1_m1_288000_72000 n1_m1_292800_72000 5.356235
R1841 n1_m1_292800_72000 n1_m1_297600_72000 5.356235
R1842 n1_m1_297600_72000 n1_m1_302400_72000 5.356235
R1843 n1_m1_302400_72000 n1_m1_307200_72000 5.356235
R1844 n1_m1_307200_72000 n1_m1_312000_72000 5.356235
R1845 n1_m1_312000_72000 n1_m1_316800_72000 5.356235
R1846 n1_m1_316800_72000 n1_m1_321600_72000 5.356235
R1847 n1_m1_321600_72000 n1_m1_326400_72000 5.356235
R1848 n1_m1_326400_72000 n1_m1_331200_72000 5.356235
R1849 n1_m1_331200_72000 n1_m1_336000_72000 5.356235
R1850 n1_m1_336000_72000 n1_m1_340000_72000 4.463529
R1851 n1_m1_340800_72000 n1_m1_340000_72000 0.892706
R1852 n1_m1_340800_72000 n1_m1_345600_72000 5.356235
R1853 n1_m1_345600_72000 n1_m1_350400_72000 5.356235
R1854 n1_m1_350400_72000 n1_m1_355200_72000 5.356235
R1855 n1_m1_355200_72000 n1_m1_360000_72000 5.356235
R1856 n1_m1_360000_72000 n1_m1_364800_72000 5.356235
R1857 n1_m1_364800_72000 n1_m1_368000_72000 3.570824
R1858 n1_m1_369600_72000 n1_m1_368000_72000 1.785412
R1859 n1_m1_369600_72000 n1_m1_374400_72000 5.356235
R1860 n1_m1_374400_72000 n1_m1_379200_72000 5.356235
R1861 n1_m1_379200_72000 n1_m1_384000_72000 5.356235
R1862 n1_m1_384000_72000 n1_m1_388800_72000 5.356235
R1863 n1_m1_388800_72000 n1_m1_393600_72000 5.356235
R1864 n1_m1_393600_72000 n1_m1_396000_72000 2.678118
R1865 n1_m1_398400_72000 n1_m1_396000_72000 2.678118
R1866 n1_m1_398400_72000 n1_m1_403200_72000 5.356235
R1867 n1_m1_403200_72000 n1_m1_408000_72000 5.356235
R1868 n1_m1_408000_72000 n1_m1_412800_72000 5.356235
R1869 n1_m1_412800_72000 n1_m1_417600_72000 5.356235
R1870 n1_m1_417600_72000 n1_m1_422400_72000 5.356235
R1871 n1_m1_422400_72000 n1_m1_424000_72000 1.785412
R1872 n1_m1_427200_72000 n1_m1_424000_72000 3.570824
R1873 n1_m1_427200_72000 n1_m1_432000_72000 5.356235
R1874 n1_m1_432000_72000 n1_m1_436800_72000 5.356235
R1875 n1_m1_436800_72000 n1_m1_441600_72000 5.356235
R1876 n1_m1_441600_72000 n1_m1_446400_72000 5.356235
R1877 n1_m1_446400_72000 n1_m1_451200_72000 5.356235
R1878 n1_m1_451200_72000 n1_m1_452000_72000 0.892706
R1879 n1_m1_456000_72000 n1_m1_452000_72000 4.463529
R1880 n1_m1_456000_72000 n1_m1_460800_72000 5.356235
R1881 n1_m1_460800_72000 n1_m1_465600_72000 5.356235
R1882 n1_m1_465600_72000 n1_m1_470400_72000 5.356235
R1883 n1_m1_470400_72000 n1_m1_475200_72000 5.356235
R1884 n1_m1_475200_72000 n1_m1_480000_72000 5.356235
R1885 n1_m1_480000_72000 n1_m1_484800_72000 5.356235
R1886 n1_m1_484800_72000 n1_m1_489600_72000 5.356235
R1887 n1_m1_489600_72000 n1_m1_494400_72000 5.356235
R1888 n1_m1_0_76800 n1_m1_4000_76800 4.463529
R1889 n1_m1_4800_76800 n1_m1_4000_76800 0.892706
R1890 n1_m1_4800_76800 n1_m1_9600_76800 5.356235
R1891 n1_m1_9600_76800 n1_m1_14400_76800 5.356235
R1892 n1_m1_14400_76800 n1_m1_19200_76800 5.356235
R1893 n1_m1_19200_76800 n1_m1_24000_76800 5.356235
R1894 n1_m1_24000_76800 n1_m1_28800_76800 5.356235
R1895 n1_m1_28800_76800 n1_m1_32000_76800 3.570824
R1896 n1_m1_33600_76800 n1_m1_32000_76800 1.785412
R1897 n1_m1_33600_76800 n1_m1_38400_76800 5.356235
R1898 n1_m1_38400_76800 n1_m1_43200_76800 5.356235
R1899 n1_m1_43200_76800 n1_m1_48000_76800 5.356235
R1900 n1_m1_48000_76800 n1_m1_52800_76800 5.356235
R1901 n1_m1_52800_76800 n1_m1_57600_76800 5.356235
R1902 n1_m1_57600_76800 n1_m1_60000_76800 2.678118
R1903 n1_m1_62400_76800 n1_m1_60000_76800 2.678118
R1904 n1_m1_62400_76800 n1_m1_67200_76800 5.356235
R1905 n1_m1_67200_76800 n1_m1_72000_76800 5.356235
R1906 n1_m1_72000_76800 n1_m1_76800_76800 5.356235
R1907 n1_m1_76800_76800 n1_m1_81600_76800 5.356235
R1908 n1_m1_81600_76800 n1_m1_86400_76800 5.356235
R1909 n1_m1_86400_76800 n1_m1_88000_76800 1.785412
R1910 n1_m1_91200_76800 n1_m1_88000_76800 3.570824
R1911 n1_m1_91200_76800 n1_m1_96000_76800 5.356235
R1912 n1_m1_96000_76800 n1_m1_100800_76800 5.356235
R1913 n1_m1_100800_76800 n1_m1_105600_76800 5.356235
R1914 n1_m1_105600_76800 n1_m1_110400_76800 5.356235
R1915 n1_m1_110400_76800 n1_m1_115200_76800 5.356235
R1916 n1_m1_115200_76800 n1_m1_116000_76800 0.892706
R1917 n1_m1_120000_76800 n1_m1_116000_76800 4.463529
R1918 n1_m1_120000_76800 n1_m1_124800_76800 5.356235
R1919 n1_m1_124800_76800 n1_m1_129600_76800 5.356235
R1920 n1_m1_129600_76800 n1_m1_134400_76800 5.356235
R1921 n1_m1_134400_76800 n1_m1_139200_76800 5.356235
R1922 n1_m1_139200_76800 n1_m1_144000_76800 5.356235
R1923 n1_m1_144000_76800 n1_m1_148800_76800 5.356235
R1924 n1_m1_148800_76800 n1_m1_153600_76800 5.356235
R1925 n1_m1_153600_76800 n1_m1_158400_76800 5.356235
R1926 n1_m1_158400_76800 n1_m1_163200_76800 5.356235
R1927 n1_m1_163200_76800 n1_m1_168000_76800 5.356235
R1928 n1_m1_168000_76800 n1_m1_172000_76800 4.463529
R1929 n1_m1_172800_76800 n1_m1_172000_76800 0.892706
R1930 n1_m1_172800_76800 n1_m1_177600_76800 5.356235
R1931 n1_m1_177600_76800 n1_m1_182400_76800 5.356235
R1932 n1_m1_182400_76800 n1_m1_187200_76800 5.356235
R1933 n1_m1_187200_76800 n1_m1_192000_76800 5.356235
R1934 n1_m1_192000_76800 n1_m1_196800_76800 5.356235
R1935 n1_m1_196800_76800 n1_m1_200000_76800 3.570824
R1936 n1_m1_201600_76800 n1_m1_200000_76800 1.785412
R1937 n1_m1_201600_76800 n1_m1_206400_76800 5.356235
R1938 n1_m1_206400_76800 n1_m1_211200_76800 5.356235
R1939 n1_m1_211200_76800 n1_m1_216000_76800 5.356235
R1940 n1_m1_216000_76800 n1_m1_220800_76800 5.356235
R1941 n1_m1_220800_76800 n1_m1_225600_76800 5.356235
R1942 n1_m1_225600_76800 n1_m1_228000_76800 2.678118
R1943 n1_m1_230400_76800 n1_m1_228000_76800 2.678118
R1944 n1_m1_230400_76800 n1_m1_235200_76800 5.356235
R1945 n1_m1_235200_76800 n1_m1_240000_76800 5.356235
R1946 n1_m1_240000_76800 n1_m1_244800_76800 5.356235
R1947 n1_m1_244800_76800 n1_m1_249600_76800 5.356235
R1948 n1_m1_249600_76800 n1_m1_254400_76800 5.356235
R1949 n1_m1_254400_76800 n1_m1_256000_76800 1.785412
R1950 n1_m1_259200_76800 n1_m1_256000_76800 3.570824
R1951 n1_m1_259200_76800 n1_m1_264000_76800 5.356235
R1952 n1_m1_264000_76800 n1_m1_268800_76800 5.356235
R1953 n1_m1_268800_76800 n1_m1_273600_76800 5.356235
R1954 n1_m1_273600_76800 n1_m1_278400_76800 5.356235
R1955 n1_m1_278400_76800 n1_m1_283200_76800 5.356235
R1956 n1_m1_283200_76800 n1_m1_284000_76800 0.892706
R1957 n1_m1_288000_76800 n1_m1_284000_76800 4.463529
R1958 n1_m1_288000_76800 n1_m1_292800_76800 5.356235
R1959 n1_m1_292800_76800 n1_m1_297600_76800 5.356235
R1960 n1_m1_297600_76800 n1_m1_302400_76800 5.356235
R1961 n1_m1_302400_76800 n1_m1_307200_76800 5.356235
R1962 n1_m1_307200_76800 n1_m1_312000_76800 5.356235
R1963 n1_m1_312000_76800 n1_m1_316800_76800 5.356235
R1964 n1_m1_316800_76800 n1_m1_321600_76800 5.356235
R1965 n1_m1_321600_76800 n1_m1_326400_76800 5.356235
R1966 n1_m1_326400_76800 n1_m1_331200_76800 5.356235
R1967 n1_m1_331200_76800 n1_m1_336000_76800 5.356235
R1968 n1_m1_336000_76800 n1_m1_340000_76800 4.463529
R1969 n1_m1_340800_76800 n1_m1_340000_76800 0.892706
R1970 n1_m1_340800_76800 n1_m1_345600_76800 5.356235
R1971 n1_m1_345600_76800 n1_m1_350400_76800 5.356235
R1972 n1_m1_350400_76800 n1_m1_355200_76800 5.356235
R1973 n1_m1_355200_76800 n1_m1_360000_76800 5.356235
R1974 n1_m1_360000_76800 n1_m1_364800_76800 5.356235
R1975 n1_m1_364800_76800 n1_m1_368000_76800 3.570824
R1976 n1_m1_369600_76800 n1_m1_368000_76800 1.785412
R1977 n1_m1_369600_76800 n1_m1_374400_76800 5.356235
R1978 n1_m1_374400_76800 n1_m1_379200_76800 5.356235
R1979 n1_m1_379200_76800 n1_m1_384000_76800 5.356235
R1980 n1_m1_384000_76800 n1_m1_388800_76800 5.356235
R1981 n1_m1_388800_76800 n1_m1_393600_76800 5.356235
R1982 n1_m1_393600_76800 n1_m1_396000_76800 2.678118
R1983 n1_m1_398400_76800 n1_m1_396000_76800 2.678118
R1984 n1_m1_398400_76800 n1_m1_403200_76800 5.356235
R1985 n1_m1_403200_76800 n1_m1_408000_76800 5.356235
R1986 n1_m1_408000_76800 n1_m1_412800_76800 5.356235
R1987 n1_m1_412800_76800 n1_m1_417600_76800 5.356235
R1988 n1_m1_417600_76800 n1_m1_422400_76800 5.356235
R1989 n1_m1_422400_76800 n1_m1_424000_76800 1.785412
R1990 n1_m1_427200_76800 n1_m1_424000_76800 3.570824
R1991 n1_m1_427200_76800 n1_m1_432000_76800 5.356235
R1992 n1_m1_432000_76800 n1_m1_436800_76800 5.356235
R1993 n1_m1_436800_76800 n1_m1_441600_76800 5.356235
R1994 n1_m1_441600_76800 n1_m1_446400_76800 5.356235
R1995 n1_m1_446400_76800 n1_m1_451200_76800 5.356235
R1996 n1_m1_451200_76800 n1_m1_452000_76800 0.892706
R1997 n1_m1_456000_76800 n1_m1_452000_76800 4.463529
R1998 n1_m1_456000_76800 n1_m1_460800_76800 5.356235
R1999 n1_m1_460800_76800 n1_m1_465600_76800 5.356235
R2000 n1_m1_465600_76800 n1_m1_470400_76800 5.356235
R2001 n1_m1_470400_76800 n1_m1_475200_76800 5.356235
R2002 n1_m1_475200_76800 n1_m1_480000_76800 5.356235
R2003 n1_m1_480000_76800 n1_m1_484800_76800 5.356235
R2004 n1_m1_484800_76800 n1_m1_489600_76800 5.356235
R2005 n1_m1_489600_76800 n1_m1_494400_76800 5.356235
R2006 n1_m1_0_81600 n1_m1_4000_81600 4.463529
R2007 n1_m1_4800_81600 n1_m1_4000_81600 0.892706
R2008 n1_m1_4800_81600 n1_m1_9600_81600 5.356235
R2009 n1_m1_9600_81600 n1_m1_14400_81600 5.356235
R2010 n1_m1_14400_81600 n1_m1_19200_81600 5.356235
R2011 n1_m1_19200_81600 n1_m1_24000_81600 5.356235
R2012 n1_m1_24000_81600 n1_m1_28800_81600 5.356235
R2013 n1_m1_28800_81600 n1_m1_32000_81600 3.570824
R2014 n1_m1_33600_81600 n1_m1_32000_81600 1.785412
R2015 n1_m1_33600_81600 n1_m1_38400_81600 5.356235
R2016 n1_m1_38400_81600 n1_m1_43200_81600 5.356235
R2017 n1_m1_43200_81600 n1_m1_48000_81600 5.356235
R2018 n1_m1_48000_81600 n1_m1_52800_81600 5.356235
R2019 n1_m1_52800_81600 n1_m1_57600_81600 5.356235
R2020 n1_m1_57600_81600 n1_m1_60000_81600 2.678118
R2021 n1_m1_62400_81600 n1_m1_60000_81600 2.678118
R2022 n1_m1_62400_81600 n1_m1_67200_81600 5.356235
R2023 n1_m1_67200_81600 n1_m1_72000_81600 5.356235
R2024 n1_m1_72000_81600 n1_m1_76800_81600 5.356235
R2025 n1_m1_76800_81600 n1_m1_81600_81600 5.356235
R2026 n1_m1_81600_81600 n1_m1_86400_81600 5.356235
R2027 n1_m1_86400_81600 n1_m1_88000_81600 1.785412
R2028 n1_m1_91200_81600 n1_m1_88000_81600 3.570824
R2029 n1_m1_91200_81600 n1_m1_96000_81600 5.356235
R2030 n1_m1_96000_81600 n1_m1_100800_81600 5.356235
R2031 n1_m1_100800_81600 n1_m1_105600_81600 5.356235
R2032 n1_m1_105600_81600 n1_m1_110400_81600 5.356235
R2033 n1_m1_110400_81600 n1_m1_115200_81600 5.356235
R2034 n1_m1_115200_81600 n1_m1_116000_81600 0.892706
R2035 n1_m1_120000_81600 n1_m1_116000_81600 4.463529
R2036 n1_m1_120000_81600 n1_m1_124800_81600 5.356235
R2037 n1_m1_124800_81600 n1_m1_129600_81600 5.356235
R2038 n1_m1_129600_81600 n1_m1_134400_81600 5.356235
R2039 n1_m1_134400_81600 n1_m1_139200_81600 5.356235
R2040 n1_m1_139200_81600 n1_m1_144000_81600 5.356235
R2041 n1_m1_144000_81600 n1_m1_148800_81600 5.356235
R2042 n1_m1_148800_81600 n1_m1_153600_81600 5.356235
R2043 n1_m1_153600_81600 n1_m1_158400_81600 5.356235
R2044 n1_m1_158400_81600 n1_m1_163200_81600 5.356235
R2045 n1_m1_163200_81600 n1_m1_168000_81600 5.356235
R2046 n1_m1_168000_81600 n1_m1_172000_81600 4.463529
R2047 n1_m1_172800_81600 n1_m1_172000_81600 0.892706
R2048 n1_m1_172800_81600 n1_m1_177600_81600 5.356235
R2049 n1_m1_177600_81600 n1_m1_182400_81600 5.356235
R2050 n1_m1_182400_81600 n1_m1_187200_81600 5.356235
R2051 n1_m1_187200_81600 n1_m1_192000_81600 5.356235
R2052 n1_m1_192000_81600 n1_m1_196800_81600 5.356235
R2053 n1_m1_196800_81600 n1_m1_200000_81600 3.570824
R2054 n1_m1_201600_81600 n1_m1_200000_81600 1.785412
R2055 n1_m1_201600_81600 n1_m1_206400_81600 5.356235
R2056 n1_m1_206400_81600 n1_m1_211200_81600 5.356235
R2057 n1_m1_211200_81600 n1_m1_216000_81600 5.356235
R2058 n1_m1_216000_81600 n1_m1_220800_81600 5.356235
R2059 n1_m1_220800_81600 n1_m1_225600_81600 5.356235
R2060 n1_m1_225600_81600 n1_m1_228000_81600 2.678118
R2061 n1_m1_230400_81600 n1_m1_228000_81600 2.678118
R2062 n1_m1_230400_81600 n1_m1_235200_81600 5.356235
R2063 n1_m1_235200_81600 n1_m1_240000_81600 5.356235
R2064 n1_m1_240000_81600 n1_m1_244800_81600 5.356235
R2065 n1_m1_244800_81600 n1_m1_249600_81600 5.356235
R2066 n1_m1_249600_81600 n1_m1_254400_81600 5.356235
R2067 n1_m1_254400_81600 n1_m1_256000_81600 1.785412
R2068 n1_m1_259200_81600 n1_m1_256000_81600 3.570824
R2069 n1_m1_259200_81600 n1_m1_264000_81600 5.356235
R2070 n1_m1_264000_81600 n1_m1_268800_81600 5.356235
R2071 n1_m1_268800_81600 n1_m1_273600_81600 5.356235
R2072 n1_m1_273600_81600 n1_m1_278400_81600 5.356235
R2073 n1_m1_278400_81600 n1_m1_283200_81600 5.356235
R2074 n1_m1_283200_81600 n1_m1_284000_81600 0.892706
R2075 n1_m1_288000_81600 n1_m1_284000_81600 4.463529
R2076 n1_m1_288000_81600 n1_m1_292800_81600 5.356235
R2077 n1_m1_292800_81600 n1_m1_297600_81600 5.356235
R2078 n1_m1_297600_81600 n1_m1_302400_81600 5.356235
R2079 n1_m1_302400_81600 n1_m1_307200_81600 5.356235
R2080 n1_m1_307200_81600 n1_m1_312000_81600 5.356235
R2081 n1_m1_312000_81600 n1_m1_316800_81600 5.356235
R2082 n1_m1_316800_81600 n1_m1_321600_81600 5.356235
R2083 n1_m1_321600_81600 n1_m1_326400_81600 5.356235
R2084 n1_m1_326400_81600 n1_m1_331200_81600 5.356235
R2085 n1_m1_331200_81600 n1_m1_336000_81600 5.356235
R2086 n1_m1_336000_81600 n1_m1_340000_81600 4.463529
R2087 n1_m1_340800_81600 n1_m1_340000_81600 0.892706
R2088 n1_m1_340800_81600 n1_m1_345600_81600 5.356235
R2089 n1_m1_345600_81600 n1_m1_350400_81600 5.356235
R2090 n1_m1_350400_81600 n1_m1_355200_81600 5.356235
R2091 n1_m1_355200_81600 n1_m1_360000_81600 5.356235
R2092 n1_m1_360000_81600 n1_m1_364800_81600 5.356235
R2093 n1_m1_364800_81600 n1_m1_368000_81600 3.570824
R2094 n1_m1_369600_81600 n1_m1_368000_81600 1.785412
R2095 n1_m1_369600_81600 n1_m1_374400_81600 5.356235
R2096 n1_m1_374400_81600 n1_m1_379200_81600 5.356235
R2097 n1_m1_379200_81600 n1_m1_384000_81600 5.356235
R2098 n1_m1_384000_81600 n1_m1_388800_81600 5.356235
R2099 n1_m1_388800_81600 n1_m1_393600_81600 5.356235
R2100 n1_m1_393600_81600 n1_m1_396000_81600 2.678118
R2101 n1_m1_398400_81600 n1_m1_396000_81600 2.678118
R2102 n1_m1_398400_81600 n1_m1_403200_81600 5.356235
R2103 n1_m1_403200_81600 n1_m1_408000_81600 5.356235
R2104 n1_m1_408000_81600 n1_m1_412800_81600 5.356235
R2105 n1_m1_412800_81600 n1_m1_417600_81600 5.356235
R2106 n1_m1_417600_81600 n1_m1_422400_81600 5.356235
R2107 n1_m1_422400_81600 n1_m1_424000_81600 1.785412
R2108 n1_m1_427200_81600 n1_m1_424000_81600 3.570824
R2109 n1_m1_427200_81600 n1_m1_432000_81600 5.356235
R2110 n1_m1_432000_81600 n1_m1_436800_81600 5.356235
R2111 n1_m1_436800_81600 n1_m1_441600_81600 5.356235
R2112 n1_m1_441600_81600 n1_m1_446400_81600 5.356235
R2113 n1_m1_446400_81600 n1_m1_451200_81600 5.356235
R2114 n1_m1_451200_81600 n1_m1_452000_81600 0.892706
R2115 n1_m1_456000_81600 n1_m1_452000_81600 4.463529
R2116 n1_m1_456000_81600 n1_m1_460800_81600 5.356235
R2117 n1_m1_460800_81600 n1_m1_465600_81600 5.356235
R2118 n1_m1_465600_81600 n1_m1_470400_81600 5.356235
R2119 n1_m1_470400_81600 n1_m1_475200_81600 5.356235
R2120 n1_m1_475200_81600 n1_m1_480000_81600 5.356235
R2121 n1_m1_480000_81600 n1_m1_484800_81600 5.356235
R2122 n1_m1_484800_81600 n1_m1_489600_81600 5.356235
R2123 n1_m1_489600_81600 n1_m1_494400_81600 5.356235
R2124 n1_m1_0_86400 n1_m1_4000_86400 4.463529
R2125 n1_m1_4800_86400 n1_m1_4000_86400 0.892706
R2126 n1_m1_4800_86400 n1_m1_9600_86400 5.356235
R2127 n1_m1_9600_86400 n1_m1_14400_86400 5.356235
R2128 n1_m1_14400_86400 n1_m1_19200_86400 5.356235
R2129 n1_m1_19200_86400 n1_m1_24000_86400 5.356235
R2130 n1_m1_24000_86400 n1_m1_28800_86400 5.356235
R2131 n1_m1_28800_86400 n1_m1_32000_86400 3.570824
R2132 n1_m1_33600_86400 n1_m1_32000_86400 1.785412
R2133 n1_m1_33600_86400 n1_m1_38400_86400 5.356235
R2134 n1_m1_38400_86400 n1_m1_43200_86400 5.356235
R2135 n1_m1_43200_86400 n1_m1_48000_86400 5.356235
R2136 n1_m1_48000_86400 n1_m1_52800_86400 5.356235
R2137 n1_m1_52800_86400 n1_m1_57600_86400 5.356235
R2138 n1_m1_57600_86400 n1_m1_60000_86400 2.678118
R2139 n1_m1_62400_86400 n1_m1_60000_86400 2.678118
R2140 n1_m1_62400_86400 n1_m1_67200_86400 5.356235
R2141 n1_m1_67200_86400 n1_m1_72000_86400 5.356235
R2142 n1_m1_72000_86400 n1_m1_76800_86400 5.356235
R2143 n1_m1_76800_86400 n1_m1_81600_86400 5.356235
R2144 n1_m1_81600_86400 n1_m1_86400_86400 5.356235
R2145 n1_m1_86400_86400 n1_m1_88000_86400 1.785412
R2146 n1_m1_91200_86400 n1_m1_88000_86400 3.570824
R2147 n1_m1_91200_86400 n1_m1_96000_86400 5.356235
R2148 n1_m1_96000_86400 n1_m1_100800_86400 5.356235
R2149 n1_m1_100800_86400 n1_m1_105600_86400 5.356235
R2150 n1_m1_105600_86400 n1_m1_110400_86400 5.356235
R2151 n1_m1_110400_86400 n1_m1_115200_86400 5.356235
R2152 n1_m1_115200_86400 n1_m1_116000_86400 0.892706
R2153 n1_m1_120000_86400 n1_m1_116000_86400 4.463529
R2154 n1_m1_120000_86400 n1_m1_124800_86400 5.356235
R2155 n1_m1_124800_86400 n1_m1_129600_86400 5.356235
R2156 n1_m1_129600_86400 n1_m1_134400_86400 5.356235
R2157 n1_m1_134400_86400 n1_m1_139200_86400 5.356235
R2158 n1_m1_139200_86400 n1_m1_144000_86400 5.356235
R2159 n1_m1_144000_86400 n1_m1_148800_86400 5.356235
R2160 n1_m1_148800_86400 n1_m1_153600_86400 5.356235
R2161 n1_m1_153600_86400 n1_m1_158400_86400 5.356235
R2162 n1_m1_158400_86400 n1_m1_163200_86400 5.356235
R2163 n1_m1_163200_86400 n1_m1_168000_86400 5.356235
R2164 n1_m1_168000_86400 n1_m1_172000_86400 4.463529
R2165 n1_m1_172800_86400 n1_m1_172000_86400 0.892706
R2166 n1_m1_172800_86400 n1_m1_177600_86400 5.356235
R2167 n1_m1_177600_86400 n1_m1_182400_86400 5.356235
R2168 n1_m1_182400_86400 n1_m1_187200_86400 5.356235
R2169 n1_m1_187200_86400 n1_m1_192000_86400 5.356235
R2170 n1_m1_192000_86400 n1_m1_196800_86400 5.356235
R2171 n1_m1_196800_86400 n1_m1_200000_86400 3.570824
R2172 n1_m1_201600_86400 n1_m1_200000_86400 1.785412
R2173 n1_m1_201600_86400 n1_m1_206400_86400 5.356235
R2174 n1_m1_206400_86400 n1_m1_211200_86400 5.356235
R2175 n1_m1_211200_86400 n1_m1_216000_86400 5.356235
R2176 n1_m1_216000_86400 n1_m1_220800_86400 5.356235
R2177 n1_m1_220800_86400 n1_m1_225600_86400 5.356235
R2178 n1_m1_225600_86400 n1_m1_228000_86400 2.678118
R2179 n1_m1_230400_86400 n1_m1_228000_86400 2.678118
R2180 n1_m1_230400_86400 n1_m1_235200_86400 5.356235
R2181 n1_m1_235200_86400 n1_m1_240000_86400 5.356235
R2182 n1_m1_240000_86400 n1_m1_244800_86400 5.356235
R2183 n1_m1_244800_86400 n1_m1_249600_86400 5.356235
R2184 n1_m1_249600_86400 n1_m1_254400_86400 5.356235
R2185 n1_m1_254400_86400 n1_m1_256000_86400 1.785412
R2186 n1_m1_259200_86400 n1_m1_256000_86400 3.570824
R2187 n1_m1_259200_86400 n1_m1_264000_86400 5.356235
R2188 n1_m1_264000_86400 n1_m1_268800_86400 5.356235
R2189 n1_m1_268800_86400 n1_m1_273600_86400 5.356235
R2190 n1_m1_273600_86400 n1_m1_278400_86400 5.356235
R2191 n1_m1_278400_86400 n1_m1_283200_86400 5.356235
R2192 n1_m1_283200_86400 n1_m1_284000_86400 0.892706
R2193 n1_m1_288000_86400 n1_m1_284000_86400 4.463529
R2194 n1_m1_288000_86400 n1_m1_292800_86400 5.356235
R2195 n1_m1_292800_86400 n1_m1_297600_86400 5.356235
R2196 n1_m1_297600_86400 n1_m1_302400_86400 5.356235
R2197 n1_m1_302400_86400 n1_m1_307200_86400 5.356235
R2198 n1_m1_307200_86400 n1_m1_312000_86400 5.356235
R2199 n1_m1_312000_86400 n1_m1_316800_86400 5.356235
R2200 n1_m1_316800_86400 n1_m1_321600_86400 5.356235
R2201 n1_m1_321600_86400 n1_m1_326400_86400 5.356235
R2202 n1_m1_326400_86400 n1_m1_331200_86400 5.356235
R2203 n1_m1_331200_86400 n1_m1_336000_86400 5.356235
R2204 n1_m1_336000_86400 n1_m1_340000_86400 4.463529
R2205 n1_m1_340800_86400 n1_m1_340000_86400 0.892706
R2206 n1_m1_340800_86400 n1_m1_345600_86400 5.356235
R2207 n1_m1_345600_86400 n1_m1_350400_86400 5.356235
R2208 n1_m1_350400_86400 n1_m1_355200_86400 5.356235
R2209 n1_m1_355200_86400 n1_m1_360000_86400 5.356235
R2210 n1_m1_360000_86400 n1_m1_364800_86400 5.356235
R2211 n1_m1_364800_86400 n1_m1_368000_86400 3.570824
R2212 n1_m1_369600_86400 n1_m1_368000_86400 1.785412
R2213 n1_m1_369600_86400 n1_m1_374400_86400 5.356235
R2214 n1_m1_374400_86400 n1_m1_379200_86400 5.356235
R2215 n1_m1_379200_86400 n1_m1_384000_86400 5.356235
R2216 n1_m1_384000_86400 n1_m1_388800_86400 5.356235
R2217 n1_m1_388800_86400 n1_m1_393600_86400 5.356235
R2218 n1_m1_393600_86400 n1_m1_396000_86400 2.678118
R2219 n1_m1_398400_86400 n1_m1_396000_86400 2.678118
R2220 n1_m1_398400_86400 n1_m1_403200_86400 5.356235
R2221 n1_m1_403200_86400 n1_m1_408000_86400 5.356235
R2222 n1_m1_408000_86400 n1_m1_412800_86400 5.356235
R2223 n1_m1_412800_86400 n1_m1_417600_86400 5.356235
R2224 n1_m1_417600_86400 n1_m1_422400_86400 5.356235
R2225 n1_m1_422400_86400 n1_m1_424000_86400 1.785412
R2226 n1_m1_427200_86400 n1_m1_424000_86400 3.570824
R2227 n1_m1_427200_86400 n1_m1_432000_86400 5.356235
R2228 n1_m1_432000_86400 n1_m1_436800_86400 5.356235
R2229 n1_m1_436800_86400 n1_m1_441600_86400 5.356235
R2230 n1_m1_441600_86400 n1_m1_446400_86400 5.356235
R2231 n1_m1_446400_86400 n1_m1_451200_86400 5.356235
R2232 n1_m1_451200_86400 n1_m1_452000_86400 0.892706
R2233 n1_m1_456000_86400 n1_m1_452000_86400 4.463529
R2234 n1_m1_456000_86400 n1_m1_460800_86400 5.356235
R2235 n1_m1_460800_86400 n1_m1_465600_86400 5.356235
R2236 n1_m1_465600_86400 n1_m1_470400_86400 5.356235
R2237 n1_m1_470400_86400 n1_m1_475200_86400 5.356235
R2238 n1_m1_475200_86400 n1_m1_480000_86400 5.356235
R2239 n1_m1_480000_86400 n1_m1_484800_86400 5.356235
R2240 n1_m1_484800_86400 n1_m1_489600_86400 5.356235
R2241 n1_m1_489600_86400 n1_m1_494400_86400 5.356235
R2242 n1_m1_0_91200 n1_m1_4000_91200 4.463529
R2243 n1_m1_4800_91200 n1_m1_4000_91200 0.892706
R2244 n1_m1_4800_91200 n1_m1_9600_91200 5.356235
R2245 n1_m1_9600_91200 n1_m1_14400_91200 5.356235
R2246 n1_m1_14400_91200 n1_m1_19200_91200 5.356235
R2247 n1_m1_19200_91200 n1_m1_24000_91200 5.356235
R2248 n1_m1_24000_91200 n1_m1_28800_91200 5.356235
R2249 n1_m1_28800_91200 n1_m1_32000_91200 3.570824
R2250 n1_m1_33600_91200 n1_m1_32000_91200 1.785412
R2251 n1_m1_33600_91200 n1_m1_38400_91200 5.356235
R2252 n1_m1_38400_91200 n1_m1_43200_91200 5.356235
R2253 n1_m1_43200_91200 n1_m1_48000_91200 5.356235
R2254 n1_m1_48000_91200 n1_m1_52800_91200 5.356235
R2255 n1_m1_52800_91200 n1_m1_57600_91200 5.356235
R2256 n1_m1_57600_91200 n1_m1_60000_91200 2.678118
R2257 n1_m1_62400_91200 n1_m1_60000_91200 2.678118
R2258 n1_m1_62400_91200 n1_m1_67200_91200 5.356235
R2259 n1_m1_67200_91200 n1_m1_72000_91200 5.356235
R2260 n1_m1_72000_91200 n1_m1_76800_91200 5.356235
R2261 n1_m1_76800_91200 n1_m1_81600_91200 5.356235
R2262 n1_m1_81600_91200 n1_m1_86400_91200 5.356235
R2263 n1_m1_86400_91200 n1_m1_88000_91200 1.785412
R2264 n1_m1_91200_91200 n1_m1_88000_91200 3.570824
R2265 n1_m1_91200_91200 n1_m1_96000_91200 5.356235
R2266 n1_m1_96000_91200 n1_m1_100800_91200 5.356235
R2267 n1_m1_100800_91200 n1_m1_105600_91200 5.356235
R2268 n1_m1_105600_91200 n1_m1_110400_91200 5.356235
R2269 n1_m1_110400_91200 n1_m1_115200_91200 5.356235
R2270 n1_m1_115200_91200 n1_m1_116000_91200 0.892706
R2271 n1_m1_120000_91200 n1_m1_116000_91200 4.463529
R2272 n1_m1_120000_91200 n1_m1_124800_91200 5.356235
R2273 n1_m1_124800_91200 n1_m1_129600_91200 5.356235
R2274 n1_m1_129600_91200 n1_m1_134400_91200 5.356235
R2275 n1_m1_134400_91200 n1_m1_139200_91200 5.356235
R2276 n1_m1_139200_91200 n1_m1_144000_91200 5.356235
R2277 n1_m1_144000_91200 n1_m1_148800_91200 5.356235
R2278 n1_m1_148800_91200 n1_m1_153600_91200 5.356235
R2279 n1_m1_153600_91200 n1_m1_158400_91200 5.356235
R2280 n1_m1_158400_91200 n1_m1_163200_91200 5.356235
R2281 n1_m1_163200_91200 n1_m1_168000_91200 5.356235
R2282 n1_m1_168000_91200 n1_m1_172000_91200 4.463529
R2283 n1_m1_172800_91200 n1_m1_172000_91200 0.892706
R2284 n1_m1_172800_91200 n1_m1_177600_91200 5.356235
R2285 n1_m1_177600_91200 n1_m1_182400_91200 5.356235
R2286 n1_m1_182400_91200 n1_m1_187200_91200 5.356235
R2287 n1_m1_187200_91200 n1_m1_192000_91200 5.356235
R2288 n1_m1_192000_91200 n1_m1_196800_91200 5.356235
R2289 n1_m1_196800_91200 n1_m1_200000_91200 3.570824
R2290 n1_m1_201600_91200 n1_m1_200000_91200 1.785412
R2291 n1_m1_201600_91200 n1_m1_206400_91200 5.356235
R2292 n1_m1_206400_91200 n1_m1_211200_91200 5.356235
R2293 n1_m1_211200_91200 n1_m1_216000_91200 5.356235
R2294 n1_m1_216000_91200 n1_m1_220800_91200 5.356235
R2295 n1_m1_220800_91200 n1_m1_225600_91200 5.356235
R2296 n1_m1_225600_91200 n1_m1_228000_91200 2.678118
R2297 n1_m1_230400_91200 n1_m1_228000_91200 2.678118
R2298 n1_m1_230400_91200 n1_m1_235200_91200 5.356235
R2299 n1_m1_235200_91200 n1_m1_240000_91200 5.356235
R2300 n1_m1_240000_91200 n1_m1_244800_91200 5.356235
R2301 n1_m1_244800_91200 n1_m1_249600_91200 5.356235
R2302 n1_m1_249600_91200 n1_m1_254400_91200 5.356235
R2303 n1_m1_254400_91200 n1_m1_256000_91200 1.785412
R2304 n1_m1_259200_91200 n1_m1_256000_91200 3.570824
R2305 n1_m1_259200_91200 n1_m1_264000_91200 5.356235
R2306 n1_m1_264000_91200 n1_m1_268800_91200 5.356235
R2307 n1_m1_268800_91200 n1_m1_273600_91200 5.356235
R2308 n1_m1_273600_91200 n1_m1_278400_91200 5.356235
R2309 n1_m1_278400_91200 n1_m1_283200_91200 5.356235
R2310 n1_m1_283200_91200 n1_m1_284000_91200 0.892706
R2311 n1_m1_288000_91200 n1_m1_284000_91200 4.463529
R2312 n1_m1_288000_91200 n1_m1_292800_91200 5.356235
R2313 n1_m1_292800_91200 n1_m1_297600_91200 5.356235
R2314 n1_m1_297600_91200 n1_m1_302400_91200 5.356235
R2315 n1_m1_302400_91200 n1_m1_307200_91200 5.356235
R2316 n1_m1_307200_91200 n1_m1_312000_91200 5.356235
R2317 n1_m1_312000_91200 n1_m1_316800_91200 5.356235
R2318 n1_m1_316800_91200 n1_m1_321600_91200 5.356235
R2319 n1_m1_321600_91200 n1_m1_326400_91200 5.356235
R2320 n1_m1_326400_91200 n1_m1_331200_91200 5.356235
R2321 n1_m1_331200_91200 n1_m1_336000_91200 5.356235
R2322 n1_m1_336000_91200 n1_m1_340000_91200 4.463529
R2323 n1_m1_340800_91200 n1_m1_340000_91200 0.892706
R2324 n1_m1_340800_91200 n1_m1_345600_91200 5.356235
R2325 n1_m1_345600_91200 n1_m1_350400_91200 5.356235
R2326 n1_m1_350400_91200 n1_m1_355200_91200 5.356235
R2327 n1_m1_355200_91200 n1_m1_360000_91200 5.356235
R2328 n1_m1_360000_91200 n1_m1_364800_91200 5.356235
R2329 n1_m1_364800_91200 n1_m1_368000_91200 3.570824
R2330 n1_m1_369600_91200 n1_m1_368000_91200 1.785412
R2331 n1_m1_369600_91200 n1_m1_374400_91200 5.356235
R2332 n1_m1_374400_91200 n1_m1_379200_91200 5.356235
R2333 n1_m1_379200_91200 n1_m1_384000_91200 5.356235
R2334 n1_m1_384000_91200 n1_m1_388800_91200 5.356235
R2335 n1_m1_388800_91200 n1_m1_393600_91200 5.356235
R2336 n1_m1_393600_91200 n1_m1_396000_91200 2.678118
R2337 n1_m1_398400_91200 n1_m1_396000_91200 2.678118
R2338 n1_m1_398400_91200 n1_m1_403200_91200 5.356235
R2339 n1_m1_403200_91200 n1_m1_408000_91200 5.356235
R2340 n1_m1_408000_91200 n1_m1_412800_91200 5.356235
R2341 n1_m1_412800_91200 n1_m1_417600_91200 5.356235
R2342 n1_m1_417600_91200 n1_m1_422400_91200 5.356235
R2343 n1_m1_422400_91200 n1_m1_424000_91200 1.785412
R2344 n1_m1_427200_91200 n1_m1_424000_91200 3.570824
R2345 n1_m1_427200_91200 n1_m1_432000_91200 5.356235
R2346 n1_m1_432000_91200 n1_m1_436800_91200 5.356235
R2347 n1_m1_436800_91200 n1_m1_441600_91200 5.356235
R2348 n1_m1_441600_91200 n1_m1_446400_91200 5.356235
R2349 n1_m1_446400_91200 n1_m1_451200_91200 5.356235
R2350 n1_m1_451200_91200 n1_m1_452000_91200 0.892706
R2351 n1_m1_456000_91200 n1_m1_452000_91200 4.463529
R2352 n1_m1_456000_91200 n1_m1_460800_91200 5.356235
R2353 n1_m1_460800_91200 n1_m1_465600_91200 5.356235
R2354 n1_m1_465600_91200 n1_m1_470400_91200 5.356235
R2355 n1_m1_470400_91200 n1_m1_475200_91200 5.356235
R2356 n1_m1_475200_91200 n1_m1_480000_91200 5.356235
R2357 n1_m1_480000_91200 n1_m1_484800_91200 5.356235
R2358 n1_m1_484800_91200 n1_m1_489600_91200 5.356235
R2359 n1_m1_489600_91200 n1_m1_494400_91200 5.356235
R2360 n1_m1_0_96000 n1_m1_4000_96000 4.463529
R2361 n1_m1_4800_96000 n1_m1_4000_96000 0.892706
R2362 n1_m1_4800_96000 n1_m1_9600_96000 5.356235
R2363 n1_m1_9600_96000 n1_m1_14400_96000 5.356235
R2364 n1_m1_14400_96000 n1_m1_19200_96000 5.356235
R2365 n1_m1_19200_96000 n1_m1_24000_96000 5.356235
R2366 n1_m1_24000_96000 n1_m1_28800_96000 5.356235
R2367 n1_m1_28800_96000 n1_m1_32000_96000 3.570824
R2368 n1_m1_33600_96000 n1_m1_32000_96000 1.785412
R2369 n1_m1_33600_96000 n1_m1_38400_96000 5.356235
R2370 n1_m1_38400_96000 n1_m1_43200_96000 5.356235
R2371 n1_m1_43200_96000 n1_m1_48000_96000 5.356235
R2372 n1_m1_48000_96000 n1_m1_52800_96000 5.356235
R2373 n1_m1_52800_96000 n1_m1_57600_96000 5.356235
R2374 n1_m1_57600_96000 n1_m1_60000_96000 2.678118
R2375 n1_m1_62400_96000 n1_m1_60000_96000 2.678118
R2376 n1_m1_62400_96000 n1_m1_67200_96000 5.356235
R2377 n1_m1_67200_96000 n1_m1_72000_96000 5.356235
R2378 n1_m1_72000_96000 n1_m1_76800_96000 5.356235
R2379 n1_m1_76800_96000 n1_m1_81600_96000 5.356235
R2380 n1_m1_81600_96000 n1_m1_86400_96000 5.356235
R2381 n1_m1_86400_96000 n1_m1_88000_96000 1.785412
R2382 n1_m1_91200_96000 n1_m1_88000_96000 3.570824
R2383 n1_m1_91200_96000 n1_m1_96000_96000 5.356235
R2384 n1_m1_96000_96000 n1_m1_100800_96000 5.356235
R2385 n1_m1_100800_96000 n1_m1_105600_96000 5.356235
R2386 n1_m1_105600_96000 n1_m1_110400_96000 5.356235
R2387 n1_m1_110400_96000 n1_m1_115200_96000 5.356235
R2388 n1_m1_115200_96000 n1_m1_116000_96000 0.892706
R2389 n1_m1_120000_96000 n1_m1_116000_96000 4.463529
R2390 n1_m1_120000_96000 n1_m1_124800_96000 5.356235
R2391 n1_m1_124800_96000 n1_m1_129600_96000 5.356235
R2392 n1_m1_129600_96000 n1_m1_134400_96000 5.356235
R2393 n1_m1_134400_96000 n1_m1_139200_96000 5.356235
R2394 n1_m1_139200_96000 n1_m1_144000_96000 5.356235
R2395 n1_m1_144000_96000 n1_m1_148800_96000 5.356235
R2396 n1_m1_148800_96000 n1_m1_153600_96000 5.356235
R2397 n1_m1_153600_96000 n1_m1_158400_96000 5.356235
R2398 n1_m1_158400_96000 n1_m1_163200_96000 5.356235
R2399 n1_m1_163200_96000 n1_m1_168000_96000 5.356235
R2400 n1_m1_168000_96000 n1_m1_172000_96000 4.463529
R2401 n1_m1_172800_96000 n1_m1_172000_96000 0.892706
R2402 n1_m1_172800_96000 n1_m1_177600_96000 5.356235
R2403 n1_m1_177600_96000 n1_m1_182400_96000 5.356235
R2404 n1_m1_182400_96000 n1_m1_187200_96000 5.356235
R2405 n1_m1_187200_96000 n1_m1_192000_96000 5.356235
R2406 n1_m1_192000_96000 n1_m1_196800_96000 5.356235
R2407 n1_m1_196800_96000 n1_m1_200000_96000 3.570824
R2408 n1_m1_201600_96000 n1_m1_200000_96000 1.785412
R2409 n1_m1_201600_96000 n1_m1_206400_96000 5.356235
R2410 n1_m1_206400_96000 n1_m1_211200_96000 5.356235
R2411 n1_m1_211200_96000 n1_m1_216000_96000 5.356235
R2412 n1_m1_216000_96000 n1_m1_220800_96000 5.356235
R2413 n1_m1_220800_96000 n1_m1_225600_96000 5.356235
R2414 n1_m1_225600_96000 n1_m1_228000_96000 2.678118
R2415 n1_m1_230400_96000 n1_m1_228000_96000 2.678118
R2416 n1_m1_230400_96000 n1_m1_235200_96000 5.356235
R2417 n1_m1_235200_96000 n1_m1_240000_96000 5.356235
R2418 n1_m1_240000_96000 n1_m1_244800_96000 5.356235
R2419 n1_m1_244800_96000 n1_m1_249600_96000 5.356235
R2420 n1_m1_249600_96000 n1_m1_254400_96000 5.356235
R2421 n1_m1_254400_96000 n1_m1_256000_96000 1.785412
R2422 n1_m1_259200_96000 n1_m1_256000_96000 3.570824
R2423 n1_m1_259200_96000 n1_m1_264000_96000 5.356235
R2424 n1_m1_264000_96000 n1_m1_268800_96000 5.356235
R2425 n1_m1_268800_96000 n1_m1_273600_96000 5.356235
R2426 n1_m1_273600_96000 n1_m1_278400_96000 5.356235
R2427 n1_m1_278400_96000 n1_m1_283200_96000 5.356235
R2428 n1_m1_283200_96000 n1_m1_284000_96000 0.892706
R2429 n1_m1_288000_96000 n1_m1_284000_96000 4.463529
R2430 n1_m1_288000_96000 n1_m1_292800_96000 5.356235
R2431 n1_m1_292800_96000 n1_m1_297600_96000 5.356235
R2432 n1_m1_297600_96000 n1_m1_302400_96000 5.356235
R2433 n1_m1_302400_96000 n1_m1_307200_96000 5.356235
R2434 n1_m1_307200_96000 n1_m1_312000_96000 5.356235
R2435 n1_m1_312000_96000 n1_m1_316800_96000 5.356235
R2436 n1_m1_316800_96000 n1_m1_321600_96000 5.356235
R2437 n1_m1_321600_96000 n1_m1_326400_96000 5.356235
R2438 n1_m1_326400_96000 n1_m1_331200_96000 5.356235
R2439 n1_m1_331200_96000 n1_m1_336000_96000 5.356235
R2440 n1_m1_336000_96000 n1_m1_340000_96000 4.463529
R2441 n1_m1_340800_96000 n1_m1_340000_96000 0.892706
R2442 n1_m1_340800_96000 n1_m1_345600_96000 5.356235
R2443 n1_m1_345600_96000 n1_m1_350400_96000 5.356235
R2444 n1_m1_350400_96000 n1_m1_355200_96000 5.356235
R2445 n1_m1_355200_96000 n1_m1_360000_96000 5.356235
R2446 n1_m1_360000_96000 n1_m1_364800_96000 5.356235
R2447 n1_m1_364800_96000 n1_m1_368000_96000 3.570824
R2448 n1_m1_369600_96000 n1_m1_368000_96000 1.785412
R2449 n1_m1_369600_96000 n1_m1_374400_96000 5.356235
R2450 n1_m1_374400_96000 n1_m1_379200_96000 5.356235
R2451 n1_m1_379200_96000 n1_m1_384000_96000 5.356235
R2452 n1_m1_384000_96000 n1_m1_388800_96000 5.356235
R2453 n1_m1_388800_96000 n1_m1_393600_96000 5.356235
R2454 n1_m1_393600_96000 n1_m1_396000_96000 2.678118
R2455 n1_m1_398400_96000 n1_m1_396000_96000 2.678118
R2456 n1_m1_398400_96000 n1_m1_403200_96000 5.356235
R2457 n1_m1_403200_96000 n1_m1_408000_96000 5.356235
R2458 n1_m1_408000_96000 n1_m1_412800_96000 5.356235
R2459 n1_m1_412800_96000 n1_m1_417600_96000 5.356235
R2460 n1_m1_417600_96000 n1_m1_422400_96000 5.356235
R2461 n1_m1_422400_96000 n1_m1_424000_96000 1.785412
R2462 n1_m1_427200_96000 n1_m1_424000_96000 3.570824
R2463 n1_m1_427200_96000 n1_m1_432000_96000 5.356235
R2464 n1_m1_432000_96000 n1_m1_436800_96000 5.356235
R2465 n1_m1_436800_96000 n1_m1_441600_96000 5.356235
R2466 n1_m1_441600_96000 n1_m1_446400_96000 5.356235
R2467 n1_m1_446400_96000 n1_m1_451200_96000 5.356235
R2468 n1_m1_451200_96000 n1_m1_452000_96000 0.892706
R2469 n1_m1_456000_96000 n1_m1_452000_96000 4.463529
R2470 n1_m1_456000_96000 n1_m1_460800_96000 5.356235
R2471 n1_m1_460800_96000 n1_m1_465600_96000 5.356235
R2472 n1_m1_465600_96000 n1_m1_470400_96000 5.356235
R2473 n1_m1_470400_96000 n1_m1_475200_96000 5.356235
R2474 n1_m1_475200_96000 n1_m1_480000_96000 5.356235
R2475 n1_m1_480000_96000 n1_m1_484800_96000 5.356235
R2476 n1_m1_484800_96000 n1_m1_489600_96000 5.356235
R2477 n1_m1_489600_96000 n1_m1_494400_96000 5.356235
R2478 n1_m1_0_100800 n1_m1_4000_100800 4.463529
R2479 n1_m1_4800_100800 n1_m1_4000_100800 0.892706
R2480 n1_m1_4800_100800 n1_m1_9600_100800 5.356235
R2481 n1_m1_9600_100800 n1_m1_14400_100800 5.356235
R2482 n1_m1_14400_100800 n1_m1_19200_100800 5.356235
R2483 n1_m1_19200_100800 n1_m1_24000_100800 5.356235
R2484 n1_m1_24000_100800 n1_m1_28800_100800 5.356235
R2485 n1_m1_28800_100800 n1_m1_32000_100800 3.570824
R2486 n1_m1_33600_100800 n1_m1_32000_100800 1.785412
R2487 n1_m1_33600_100800 n1_m1_38400_100800 5.356235
R2488 n1_m1_38400_100800 n1_m1_43200_100800 5.356235
R2489 n1_m1_43200_100800 n1_m1_48000_100800 5.356235
R2490 n1_m1_48000_100800 n1_m1_52800_100800 5.356235
R2491 n1_m1_52800_100800 n1_m1_57600_100800 5.356235
R2492 n1_m1_57600_100800 n1_m1_60000_100800 2.678118
R2493 n1_m1_62400_100800 n1_m1_60000_100800 2.678118
R2494 n1_m1_62400_100800 n1_m1_67200_100800 5.356235
R2495 n1_m1_67200_100800 n1_m1_72000_100800 5.356235
R2496 n1_m1_72000_100800 n1_m1_76800_100800 5.356235
R2497 n1_m1_76800_100800 n1_m1_81600_100800 5.356235
R2498 n1_m1_81600_100800 n1_m1_86400_100800 5.356235
R2499 n1_m1_86400_100800 n1_m1_88000_100800 1.785412
R2500 n1_m1_91200_100800 n1_m1_88000_100800 3.570824
R2501 n1_m1_91200_100800 n1_m1_96000_100800 5.356235
R2502 n1_m1_96000_100800 n1_m1_100800_100800 5.356235
R2503 n1_m1_100800_100800 n1_m1_105600_100800 5.356235
R2504 n1_m1_105600_100800 n1_m1_110400_100800 5.356235
R2505 n1_m1_110400_100800 n1_m1_115200_100800 5.356235
R2506 n1_m1_115200_100800 n1_m1_116000_100800 0.892706
R2507 n1_m1_120000_100800 n1_m1_116000_100800 4.463529
R2508 n1_m1_120000_100800 n1_m1_124800_100800 5.356235
R2509 n1_m1_124800_100800 n1_m1_129600_100800 5.356235
R2510 n1_m1_129600_100800 n1_m1_134400_100800 5.356235
R2511 n1_m1_134400_100800 n1_m1_139200_100800 5.356235
R2512 n1_m1_139200_100800 n1_m1_144000_100800 5.356235
R2513 n1_m1_144000_100800 n1_m1_148800_100800 5.356235
R2514 n1_m1_148800_100800 n1_m1_153600_100800 5.356235
R2515 n1_m1_153600_100800 n1_m1_158400_100800 5.356235
R2516 n1_m1_158400_100800 n1_m1_163200_100800 5.356235
R2517 n1_m1_163200_100800 n1_m1_168000_100800 5.356235
R2518 n1_m1_168000_100800 n1_m1_172000_100800 4.463529
R2519 n1_m1_172800_100800 n1_m1_172000_100800 0.892706
R2520 n1_m1_172800_100800 n1_m1_177600_100800 5.356235
R2521 n1_m1_177600_100800 n1_m1_182400_100800 5.356235
R2522 n1_m1_182400_100800 n1_m1_187200_100800 5.356235
R2523 n1_m1_187200_100800 n1_m1_192000_100800 5.356235
R2524 n1_m1_192000_100800 n1_m1_196800_100800 5.356235
R2525 n1_m1_196800_100800 n1_m1_200000_100800 3.570824
R2526 n1_m1_201600_100800 n1_m1_200000_100800 1.785412
R2527 n1_m1_201600_100800 n1_m1_206400_100800 5.356235
R2528 n1_m1_206400_100800 n1_m1_211200_100800 5.356235
R2529 n1_m1_211200_100800 n1_m1_216000_100800 5.356235
R2530 n1_m1_216000_100800 n1_m1_220800_100800 5.356235
R2531 n1_m1_220800_100800 n1_m1_225600_100800 5.356235
R2532 n1_m1_225600_100800 n1_m1_228000_100800 2.678118
R2533 n1_m1_230400_100800 n1_m1_228000_100800 2.678118
R2534 n1_m1_230400_100800 n1_m1_235200_100800 5.356235
R2535 n1_m1_235200_100800 n1_m1_240000_100800 5.356235
R2536 n1_m1_240000_100800 n1_m1_244800_100800 5.356235
R2537 n1_m1_244800_100800 n1_m1_249600_100800 5.356235
R2538 n1_m1_249600_100800 n1_m1_254400_100800 5.356235
R2539 n1_m1_254400_100800 n1_m1_256000_100800 1.785412
R2540 n1_m1_259200_100800 n1_m1_256000_100800 3.570824
R2541 n1_m1_259200_100800 n1_m1_264000_100800 5.356235
R2542 n1_m1_264000_100800 n1_m1_268800_100800 5.356235
R2543 n1_m1_268800_100800 n1_m1_273600_100800 5.356235
R2544 n1_m1_273600_100800 n1_m1_278400_100800 5.356235
R2545 n1_m1_278400_100800 n1_m1_283200_100800 5.356235
R2546 n1_m1_283200_100800 n1_m1_284000_100800 0.892706
R2547 n1_m1_288000_100800 n1_m1_284000_100800 4.463529
R2548 n1_m1_288000_100800 n1_m1_292800_100800 5.356235
R2549 n1_m1_292800_100800 n1_m1_297600_100800 5.356235
R2550 n1_m1_297600_100800 n1_m1_302400_100800 5.356235
R2551 n1_m1_302400_100800 n1_m1_307200_100800 5.356235
R2552 n1_m1_307200_100800 n1_m1_312000_100800 5.356235
R2553 n1_m1_312000_100800 n1_m1_316800_100800 5.356235
R2554 n1_m1_316800_100800 n1_m1_321600_100800 5.356235
R2555 n1_m1_321600_100800 n1_m1_326400_100800 5.356235
R2556 n1_m1_326400_100800 n1_m1_331200_100800 5.356235
R2557 n1_m1_331200_100800 n1_m1_336000_100800 5.356235
R2558 n1_m1_336000_100800 n1_m1_340000_100800 4.463529
R2559 n1_m1_340800_100800 n1_m1_340000_100800 0.892706
R2560 n1_m1_340800_100800 n1_m1_345600_100800 5.356235
R2561 n1_m1_345600_100800 n1_m1_350400_100800 5.356235
R2562 n1_m1_350400_100800 n1_m1_355200_100800 5.356235
R2563 n1_m1_355200_100800 n1_m1_360000_100800 5.356235
R2564 n1_m1_360000_100800 n1_m1_364800_100800 5.356235
R2565 n1_m1_364800_100800 n1_m1_368000_100800 3.570824
R2566 n1_m1_369600_100800 n1_m1_368000_100800 1.785412
R2567 n1_m1_369600_100800 n1_m1_374400_100800 5.356235
R2568 n1_m1_374400_100800 n1_m1_379200_100800 5.356235
R2569 n1_m1_379200_100800 n1_m1_384000_100800 5.356235
R2570 n1_m1_384000_100800 n1_m1_388800_100800 5.356235
R2571 n1_m1_388800_100800 n1_m1_393600_100800 5.356235
R2572 n1_m1_393600_100800 n1_m1_396000_100800 2.678118
R2573 n1_m1_398400_100800 n1_m1_396000_100800 2.678118
R2574 n1_m1_398400_100800 n1_m1_403200_100800 5.356235
R2575 n1_m1_403200_100800 n1_m1_408000_100800 5.356235
R2576 n1_m1_408000_100800 n1_m1_412800_100800 5.356235
R2577 n1_m1_412800_100800 n1_m1_417600_100800 5.356235
R2578 n1_m1_417600_100800 n1_m1_422400_100800 5.356235
R2579 n1_m1_422400_100800 n1_m1_424000_100800 1.785412
R2580 n1_m1_427200_100800 n1_m1_424000_100800 3.570824
R2581 n1_m1_427200_100800 n1_m1_432000_100800 5.356235
R2582 n1_m1_432000_100800 n1_m1_436800_100800 5.356235
R2583 n1_m1_436800_100800 n1_m1_441600_100800 5.356235
R2584 n1_m1_441600_100800 n1_m1_446400_100800 5.356235
R2585 n1_m1_446400_100800 n1_m1_451200_100800 5.356235
R2586 n1_m1_451200_100800 n1_m1_452000_100800 0.892706
R2587 n1_m1_456000_100800 n1_m1_452000_100800 4.463529
R2588 n1_m1_456000_100800 n1_m1_460800_100800 5.356235
R2589 n1_m1_460800_100800 n1_m1_465600_100800 5.356235
R2590 n1_m1_465600_100800 n1_m1_470400_100800 5.356235
R2591 n1_m1_470400_100800 n1_m1_475200_100800 5.356235
R2592 n1_m1_475200_100800 n1_m1_480000_100800 5.356235
R2593 n1_m1_480000_100800 n1_m1_484800_100800 5.356235
R2594 n1_m1_484800_100800 n1_m1_489600_100800 5.356235
R2595 n1_m1_489600_100800 n1_m1_494400_100800 5.356235
R2596 n1_m1_0_105600 n1_m1_4000_105600 4.463529
R2597 n1_m1_4800_105600 n1_m1_4000_105600 0.892706
R2598 n1_m1_4800_105600 n1_m1_9600_105600 5.356235
R2599 n1_m1_9600_105600 n1_m1_14400_105600 5.356235
R2600 n1_m1_14400_105600 n1_m1_19200_105600 5.356235
R2601 n1_m1_19200_105600 n1_m1_24000_105600 5.356235
R2602 n1_m1_24000_105600 n1_m1_28800_105600 5.356235
R2603 n1_m1_28800_105600 n1_m1_32000_105600 3.570824
R2604 n1_m1_33600_105600 n1_m1_32000_105600 1.785412
R2605 n1_m1_33600_105600 n1_m1_38400_105600 5.356235
R2606 n1_m1_38400_105600 n1_m1_43200_105600 5.356235
R2607 n1_m1_43200_105600 n1_m1_48000_105600 5.356235
R2608 n1_m1_48000_105600 n1_m1_52800_105600 5.356235
R2609 n1_m1_52800_105600 n1_m1_57600_105600 5.356235
R2610 n1_m1_57600_105600 n1_m1_60000_105600 2.678118
R2611 n1_m1_62400_105600 n1_m1_60000_105600 2.678118
R2612 n1_m1_62400_105600 n1_m1_67200_105600 5.356235
R2613 n1_m1_67200_105600 n1_m1_72000_105600 5.356235
R2614 n1_m1_72000_105600 n1_m1_76800_105600 5.356235
R2615 n1_m1_76800_105600 n1_m1_81600_105600 5.356235
R2616 n1_m1_81600_105600 n1_m1_86400_105600 5.356235
R2617 n1_m1_86400_105600 n1_m1_88000_105600 1.785412
R2618 n1_m1_91200_105600 n1_m1_88000_105600 3.570824
R2619 n1_m1_91200_105600 n1_m1_96000_105600 5.356235
R2620 n1_m1_96000_105600 n1_m1_100800_105600 5.356235
R2621 n1_m1_100800_105600 n1_m1_105600_105600 5.356235
R2622 n1_m1_105600_105600 n1_m1_110400_105600 5.356235
R2623 n1_m1_110400_105600 n1_m1_115200_105600 5.356235
R2624 n1_m1_115200_105600 n1_m1_116000_105600 0.892706
R2625 n1_m1_120000_105600 n1_m1_116000_105600 4.463529
R2626 n1_m1_120000_105600 n1_m1_124800_105600 5.356235
R2627 n1_m1_124800_105600 n1_m1_129600_105600 5.356235
R2628 n1_m1_129600_105600 n1_m1_134400_105600 5.356235
R2629 n1_m1_134400_105600 n1_m1_139200_105600 5.356235
R2630 n1_m1_139200_105600 n1_m1_144000_105600 5.356235
R2631 n1_m1_144000_105600 n1_m1_148800_105600 5.356235
R2632 n1_m1_148800_105600 n1_m1_153600_105600 5.356235
R2633 n1_m1_153600_105600 n1_m1_158400_105600 5.356235
R2634 n1_m1_158400_105600 n1_m1_163200_105600 5.356235
R2635 n1_m1_163200_105600 n1_m1_168000_105600 5.356235
R2636 n1_m1_168000_105600 n1_m1_172000_105600 4.463529
R2637 n1_m1_172800_105600 n1_m1_172000_105600 0.892706
R2638 n1_m1_172800_105600 n1_m1_177600_105600 5.356235
R2639 n1_m1_177600_105600 n1_m1_182400_105600 5.356235
R2640 n1_m1_182400_105600 n1_m1_187200_105600 5.356235
R2641 n1_m1_187200_105600 n1_m1_192000_105600 5.356235
R2642 n1_m1_192000_105600 n1_m1_196800_105600 5.356235
R2643 n1_m1_196800_105600 n1_m1_200000_105600 3.570824
R2644 n1_m1_201600_105600 n1_m1_200000_105600 1.785412
R2645 n1_m1_201600_105600 n1_m1_206400_105600 5.356235
R2646 n1_m1_206400_105600 n1_m1_211200_105600 5.356235
R2647 n1_m1_211200_105600 n1_m1_216000_105600 5.356235
R2648 n1_m1_216000_105600 n1_m1_220800_105600 5.356235
R2649 n1_m1_220800_105600 n1_m1_225600_105600 5.356235
R2650 n1_m1_225600_105600 n1_m1_228000_105600 2.678118
R2651 n1_m1_230400_105600 n1_m1_228000_105600 2.678118
R2652 n1_m1_230400_105600 n1_m1_235200_105600 5.356235
R2653 n1_m1_235200_105600 n1_m1_240000_105600 5.356235
R2654 n1_m1_240000_105600 n1_m1_244800_105600 5.356235
R2655 n1_m1_244800_105600 n1_m1_249600_105600 5.356235
R2656 n1_m1_249600_105600 n1_m1_254400_105600 5.356235
R2657 n1_m1_254400_105600 n1_m1_256000_105600 1.785412
R2658 n1_m1_259200_105600 n1_m1_256000_105600 3.570824
R2659 n1_m1_259200_105600 n1_m1_264000_105600 5.356235
R2660 n1_m1_264000_105600 n1_m1_268800_105600 5.356235
R2661 n1_m1_268800_105600 n1_m1_273600_105600 5.356235
R2662 n1_m1_273600_105600 n1_m1_278400_105600 5.356235
R2663 n1_m1_278400_105600 n1_m1_283200_105600 5.356235
R2664 n1_m1_283200_105600 n1_m1_284000_105600 0.892706
R2665 n1_m1_288000_105600 n1_m1_284000_105600 4.463529
R2666 n1_m1_288000_105600 n1_m1_292800_105600 5.356235
R2667 n1_m1_292800_105600 n1_m1_297600_105600 5.356235
R2668 n1_m1_297600_105600 n1_m1_302400_105600 5.356235
R2669 n1_m1_302400_105600 n1_m1_307200_105600 5.356235
R2670 n1_m1_307200_105600 n1_m1_312000_105600 5.356235
R2671 n1_m1_312000_105600 n1_m1_316800_105600 5.356235
R2672 n1_m1_316800_105600 n1_m1_321600_105600 5.356235
R2673 n1_m1_321600_105600 n1_m1_326400_105600 5.356235
R2674 n1_m1_326400_105600 n1_m1_331200_105600 5.356235
R2675 n1_m1_331200_105600 n1_m1_336000_105600 5.356235
R2676 n1_m1_336000_105600 n1_m1_340000_105600 4.463529
R2677 n1_m1_340800_105600 n1_m1_340000_105600 0.892706
R2678 n1_m1_340800_105600 n1_m1_345600_105600 5.356235
R2679 n1_m1_345600_105600 n1_m1_350400_105600 5.356235
R2680 n1_m1_350400_105600 n1_m1_355200_105600 5.356235
R2681 n1_m1_355200_105600 n1_m1_360000_105600 5.356235
R2682 n1_m1_360000_105600 n1_m1_364800_105600 5.356235
R2683 n1_m1_364800_105600 n1_m1_368000_105600 3.570824
R2684 n1_m1_369600_105600 n1_m1_368000_105600 1.785412
R2685 n1_m1_369600_105600 n1_m1_374400_105600 5.356235
R2686 n1_m1_374400_105600 n1_m1_379200_105600 5.356235
R2687 n1_m1_379200_105600 n1_m1_384000_105600 5.356235
R2688 n1_m1_384000_105600 n1_m1_388800_105600 5.356235
R2689 n1_m1_388800_105600 n1_m1_393600_105600 5.356235
R2690 n1_m1_393600_105600 n1_m1_396000_105600 2.678118
R2691 n1_m1_398400_105600 n1_m1_396000_105600 2.678118
R2692 n1_m1_398400_105600 n1_m1_403200_105600 5.356235
R2693 n1_m1_403200_105600 n1_m1_408000_105600 5.356235
R2694 n1_m1_408000_105600 n1_m1_412800_105600 5.356235
R2695 n1_m1_412800_105600 n1_m1_417600_105600 5.356235
R2696 n1_m1_417600_105600 n1_m1_422400_105600 5.356235
R2697 n1_m1_422400_105600 n1_m1_424000_105600 1.785412
R2698 n1_m1_427200_105600 n1_m1_424000_105600 3.570824
R2699 n1_m1_427200_105600 n1_m1_432000_105600 5.356235
R2700 n1_m1_432000_105600 n1_m1_436800_105600 5.356235
R2701 n1_m1_436800_105600 n1_m1_441600_105600 5.356235
R2702 n1_m1_441600_105600 n1_m1_446400_105600 5.356235
R2703 n1_m1_446400_105600 n1_m1_451200_105600 5.356235
R2704 n1_m1_451200_105600 n1_m1_452000_105600 0.892706
R2705 n1_m1_456000_105600 n1_m1_452000_105600 4.463529
R2706 n1_m1_456000_105600 n1_m1_460800_105600 5.356235
R2707 n1_m1_460800_105600 n1_m1_465600_105600 5.356235
R2708 n1_m1_465600_105600 n1_m1_470400_105600 5.356235
R2709 n1_m1_470400_105600 n1_m1_475200_105600 5.356235
R2710 n1_m1_475200_105600 n1_m1_480000_105600 5.356235
R2711 n1_m1_480000_105600 n1_m1_484800_105600 5.356235
R2712 n1_m1_484800_105600 n1_m1_489600_105600 5.356235
R2713 n1_m1_489600_105600 n1_m1_494400_105600 5.356235
R2714 n1_m1_0_110400 n1_m1_4000_110400 4.463529
R2715 n1_m1_4800_110400 n1_m1_4000_110400 0.892706
R2716 n1_m1_4800_110400 n1_m1_9600_110400 5.356235
R2717 n1_m1_9600_110400 n1_m1_14400_110400 5.356235
R2718 n1_m1_14400_110400 n1_m1_19200_110400 5.356235
R2719 n1_m1_19200_110400 n1_m1_24000_110400 5.356235
R2720 n1_m1_24000_110400 n1_m1_28800_110400 5.356235
R2721 n1_m1_28800_110400 n1_m1_32000_110400 3.570824
R2722 n1_m1_33600_110400 n1_m1_32000_110400 1.785412
R2723 n1_m1_33600_110400 n1_m1_38400_110400 5.356235
R2724 n1_m1_38400_110400 n1_m1_43200_110400 5.356235
R2725 n1_m1_43200_110400 n1_m1_48000_110400 5.356235
R2726 n1_m1_48000_110400 n1_m1_52800_110400 5.356235
R2727 n1_m1_52800_110400 n1_m1_57600_110400 5.356235
R2728 n1_m1_57600_110400 n1_m1_60000_110400 2.678118
R2729 n1_m1_62400_110400 n1_m1_60000_110400 2.678118
R2730 n1_m1_62400_110400 n1_m1_67200_110400 5.356235
R2731 n1_m1_67200_110400 n1_m1_72000_110400 5.356235
R2732 n1_m1_72000_110400 n1_m1_76800_110400 5.356235
R2733 n1_m1_76800_110400 n1_m1_81600_110400 5.356235
R2734 n1_m1_81600_110400 n1_m1_86400_110400 5.356235
R2735 n1_m1_86400_110400 n1_m1_88000_110400 1.785412
R2736 n1_m1_91200_110400 n1_m1_88000_110400 3.570824
R2737 n1_m1_91200_110400 n1_m1_96000_110400 5.356235
R2738 n1_m1_96000_110400 n1_m1_100800_110400 5.356235
R2739 n1_m1_100800_110400 n1_m1_105600_110400 5.356235
R2740 n1_m1_105600_110400 n1_m1_110400_110400 5.356235
R2741 n1_m1_110400_110400 n1_m1_115200_110400 5.356235
R2742 n1_m1_115200_110400 n1_m1_116000_110400 0.892706
R2743 n1_m1_120000_110400 n1_m1_116000_110400 4.463529
R2744 n1_m1_120000_110400 n1_m1_124800_110400 5.356235
R2745 n1_m1_124800_110400 n1_m1_129600_110400 5.356235
R2746 n1_m1_129600_110400 n1_m1_134400_110400 5.356235
R2747 n1_m1_134400_110400 n1_m1_139200_110400 5.356235
R2748 n1_m1_139200_110400 n1_m1_144000_110400 5.356235
R2749 n1_m1_144000_110400 n1_m1_148800_110400 5.356235
R2750 n1_m1_148800_110400 n1_m1_153600_110400 5.356235
R2751 n1_m1_153600_110400 n1_m1_158400_110400 5.356235
R2752 n1_m1_158400_110400 n1_m1_163200_110400 5.356235
R2753 n1_m1_163200_110400 n1_m1_168000_110400 5.356235
R2754 n1_m1_168000_110400 n1_m1_172000_110400 4.463529
R2755 n1_m1_172800_110400 n1_m1_172000_110400 0.892706
R2756 n1_m1_172800_110400 n1_m1_177600_110400 5.356235
R2757 n1_m1_177600_110400 n1_m1_182400_110400 5.356235
R2758 n1_m1_182400_110400 n1_m1_187200_110400 5.356235
R2759 n1_m1_187200_110400 n1_m1_192000_110400 5.356235
R2760 n1_m1_192000_110400 n1_m1_196800_110400 5.356235
R2761 n1_m1_196800_110400 n1_m1_200000_110400 3.570824
R2762 n1_m1_201600_110400 n1_m1_200000_110400 1.785412
R2763 n1_m1_201600_110400 n1_m1_206400_110400 5.356235
R2764 n1_m1_206400_110400 n1_m1_211200_110400 5.356235
R2765 n1_m1_211200_110400 n1_m1_216000_110400 5.356235
R2766 n1_m1_216000_110400 n1_m1_220800_110400 5.356235
R2767 n1_m1_220800_110400 n1_m1_225600_110400 5.356235
R2768 n1_m1_225600_110400 n1_m1_228000_110400 2.678118
R2769 n1_m1_230400_110400 n1_m1_228000_110400 2.678118
R2770 n1_m1_230400_110400 n1_m1_235200_110400 5.356235
R2771 n1_m1_235200_110400 n1_m1_240000_110400 5.356235
R2772 n1_m1_240000_110400 n1_m1_244800_110400 5.356235
R2773 n1_m1_244800_110400 n1_m1_249600_110400 5.356235
R2774 n1_m1_249600_110400 n1_m1_254400_110400 5.356235
R2775 n1_m1_254400_110400 n1_m1_256000_110400 1.785412
R2776 n1_m1_259200_110400 n1_m1_256000_110400 3.570824
R2777 n1_m1_259200_110400 n1_m1_264000_110400 5.356235
R2778 n1_m1_264000_110400 n1_m1_268800_110400 5.356235
R2779 n1_m1_268800_110400 n1_m1_273600_110400 5.356235
R2780 n1_m1_273600_110400 n1_m1_278400_110400 5.356235
R2781 n1_m1_278400_110400 n1_m1_283200_110400 5.356235
R2782 n1_m1_283200_110400 n1_m1_284000_110400 0.892706
R2783 n1_m1_288000_110400 n1_m1_284000_110400 4.463529
R2784 n1_m1_288000_110400 n1_m1_292800_110400 5.356235
R2785 n1_m1_292800_110400 n1_m1_297600_110400 5.356235
R2786 n1_m1_297600_110400 n1_m1_302400_110400 5.356235
R2787 n1_m1_302400_110400 n1_m1_307200_110400 5.356235
R2788 n1_m1_307200_110400 n1_m1_312000_110400 5.356235
R2789 n1_m1_312000_110400 n1_m1_316800_110400 5.356235
R2790 n1_m1_316800_110400 n1_m1_321600_110400 5.356235
R2791 n1_m1_321600_110400 n1_m1_326400_110400 5.356235
R2792 n1_m1_326400_110400 n1_m1_331200_110400 5.356235
R2793 n1_m1_331200_110400 n1_m1_336000_110400 5.356235
R2794 n1_m1_336000_110400 n1_m1_340000_110400 4.463529
R2795 n1_m1_340800_110400 n1_m1_340000_110400 0.892706
R2796 n1_m1_340800_110400 n1_m1_345600_110400 5.356235
R2797 n1_m1_345600_110400 n1_m1_350400_110400 5.356235
R2798 n1_m1_350400_110400 n1_m1_355200_110400 5.356235
R2799 n1_m1_355200_110400 n1_m1_360000_110400 5.356235
R2800 n1_m1_360000_110400 n1_m1_364800_110400 5.356235
R2801 n1_m1_364800_110400 n1_m1_368000_110400 3.570824
R2802 n1_m1_369600_110400 n1_m1_368000_110400 1.785412
R2803 n1_m1_369600_110400 n1_m1_374400_110400 5.356235
R2804 n1_m1_374400_110400 n1_m1_379200_110400 5.356235
R2805 n1_m1_379200_110400 n1_m1_384000_110400 5.356235
R2806 n1_m1_384000_110400 n1_m1_388800_110400 5.356235
R2807 n1_m1_388800_110400 n1_m1_393600_110400 5.356235
R2808 n1_m1_393600_110400 n1_m1_396000_110400 2.678118
R2809 n1_m1_398400_110400 n1_m1_396000_110400 2.678118
R2810 n1_m1_398400_110400 n1_m1_403200_110400 5.356235
R2811 n1_m1_403200_110400 n1_m1_408000_110400 5.356235
R2812 n1_m1_408000_110400 n1_m1_412800_110400 5.356235
R2813 n1_m1_412800_110400 n1_m1_417600_110400 5.356235
R2814 n1_m1_417600_110400 n1_m1_422400_110400 5.356235
R2815 n1_m1_422400_110400 n1_m1_424000_110400 1.785412
R2816 n1_m1_427200_110400 n1_m1_424000_110400 3.570824
R2817 n1_m1_427200_110400 n1_m1_432000_110400 5.356235
R2818 n1_m1_432000_110400 n1_m1_436800_110400 5.356235
R2819 n1_m1_436800_110400 n1_m1_441600_110400 5.356235
R2820 n1_m1_441600_110400 n1_m1_446400_110400 5.356235
R2821 n1_m1_446400_110400 n1_m1_451200_110400 5.356235
R2822 n1_m1_451200_110400 n1_m1_452000_110400 0.892706
R2823 n1_m1_456000_110400 n1_m1_452000_110400 4.463529
R2824 n1_m1_456000_110400 n1_m1_460800_110400 5.356235
R2825 n1_m1_460800_110400 n1_m1_465600_110400 5.356235
R2826 n1_m1_465600_110400 n1_m1_470400_110400 5.356235
R2827 n1_m1_470400_110400 n1_m1_475200_110400 5.356235
R2828 n1_m1_475200_110400 n1_m1_480000_110400 5.356235
R2829 n1_m1_480000_110400 n1_m1_484800_110400 5.356235
R2830 n1_m1_484800_110400 n1_m1_489600_110400 5.356235
R2831 n1_m1_489600_110400 n1_m1_494400_110400 5.356235
R2832 n1_m1_0_115200 n1_m1_4000_115200 4.463529
R2833 n1_m1_4800_115200 n1_m1_4000_115200 0.892706
R2834 n1_m1_4800_115200 n1_m1_9600_115200 5.356235
R2835 n1_m1_9600_115200 n1_m1_14400_115200 5.356235
R2836 n1_m1_14400_115200 n1_m1_19200_115200 5.356235
R2837 n1_m1_19200_115200 n1_m1_24000_115200 5.356235
R2838 n1_m1_24000_115200 n1_m1_28800_115200 5.356235
R2839 n1_m1_28800_115200 n1_m1_32000_115200 3.570824
R2840 n1_m1_33600_115200 n1_m1_32000_115200 1.785412
R2841 n1_m1_33600_115200 n1_m1_38400_115200 5.356235
R2842 n1_m1_38400_115200 n1_m1_43200_115200 5.356235
R2843 n1_m1_43200_115200 n1_m1_48000_115200 5.356235
R2844 n1_m1_48000_115200 n1_m1_52800_115200 5.356235
R2845 n1_m1_52800_115200 n1_m1_57600_115200 5.356235
R2846 n1_m1_57600_115200 n1_m1_60000_115200 2.678118
R2847 n1_m1_62400_115200 n1_m1_60000_115200 2.678118
R2848 n1_m1_62400_115200 n1_m1_67200_115200 5.356235
R2849 n1_m1_67200_115200 n1_m1_72000_115200 5.356235
R2850 n1_m1_72000_115200 n1_m1_76800_115200 5.356235
R2851 n1_m1_76800_115200 n1_m1_81600_115200 5.356235
R2852 n1_m1_81600_115200 n1_m1_86400_115200 5.356235
R2853 n1_m1_86400_115200 n1_m1_88000_115200 1.785412
R2854 n1_m1_91200_115200 n1_m1_88000_115200 3.570824
R2855 n1_m1_91200_115200 n1_m1_96000_115200 5.356235
R2856 n1_m1_96000_115200 n1_m1_100800_115200 5.356235
R2857 n1_m1_100800_115200 n1_m1_105600_115200 5.356235
R2858 n1_m1_105600_115200 n1_m1_110400_115200 5.356235
R2859 n1_m1_110400_115200 n1_m1_115200_115200 5.356235
R2860 n1_m1_115200_115200 n1_m1_116000_115200 0.892706
R2861 n1_m1_120000_115200 n1_m1_116000_115200 4.463529
R2862 n1_m1_120000_115200 n1_m1_124800_115200 5.356235
R2863 n1_m1_124800_115200 n1_m1_129600_115200 5.356235
R2864 n1_m1_129600_115200 n1_m1_134400_115200 5.356235
R2865 n1_m1_134400_115200 n1_m1_139200_115200 5.356235
R2866 n1_m1_139200_115200 n1_m1_144000_115200 5.356235
R2867 n1_m1_144000_115200 n1_m1_148800_115200 5.356235
R2868 n1_m1_148800_115200 n1_m1_153600_115200 5.356235
R2869 n1_m1_153600_115200 n1_m1_158400_115200 5.356235
R2870 n1_m1_158400_115200 n1_m1_163200_115200 5.356235
R2871 n1_m1_163200_115200 n1_m1_168000_115200 5.356235
R2872 n1_m1_168000_115200 n1_m1_172000_115200 4.463529
R2873 n1_m1_172800_115200 n1_m1_172000_115200 0.892706
R2874 n1_m1_172800_115200 n1_m1_177600_115200 5.356235
R2875 n1_m1_177600_115200 n1_m1_182400_115200 5.356235
R2876 n1_m1_182400_115200 n1_m1_187200_115200 5.356235
R2877 n1_m1_187200_115200 n1_m1_192000_115200 5.356235
R2878 n1_m1_192000_115200 n1_m1_196800_115200 5.356235
R2879 n1_m1_196800_115200 n1_m1_200000_115200 3.570824
R2880 n1_m1_201600_115200 n1_m1_200000_115200 1.785412
R2881 n1_m1_201600_115200 n1_m1_206400_115200 5.356235
R2882 n1_m1_206400_115200 n1_m1_211200_115200 5.356235
R2883 n1_m1_211200_115200 n1_m1_216000_115200 5.356235
R2884 n1_m1_216000_115200 n1_m1_220800_115200 5.356235
R2885 n1_m1_220800_115200 n1_m1_225600_115200 5.356235
R2886 n1_m1_225600_115200 n1_m1_228000_115200 2.678118
R2887 n1_m1_230400_115200 n1_m1_228000_115200 2.678118
R2888 n1_m1_230400_115200 n1_m1_235200_115200 5.356235
R2889 n1_m1_235200_115200 n1_m1_240000_115200 5.356235
R2890 n1_m1_240000_115200 n1_m1_244800_115200 5.356235
R2891 n1_m1_244800_115200 n1_m1_249600_115200 5.356235
R2892 n1_m1_249600_115200 n1_m1_254400_115200 5.356235
R2893 n1_m1_254400_115200 n1_m1_256000_115200 1.785412
R2894 n1_m1_259200_115200 n1_m1_256000_115200 3.570824
R2895 n1_m1_259200_115200 n1_m1_264000_115200 5.356235
R2896 n1_m1_264000_115200 n1_m1_268800_115200 5.356235
R2897 n1_m1_268800_115200 n1_m1_273600_115200 5.356235
R2898 n1_m1_273600_115200 n1_m1_278400_115200 5.356235
R2899 n1_m1_278400_115200 n1_m1_283200_115200 5.356235
R2900 n1_m1_283200_115200 n1_m1_284000_115200 0.892706
R2901 n1_m1_288000_115200 n1_m1_284000_115200 4.463529
R2902 n1_m1_288000_115200 n1_m1_292800_115200 5.356235
R2903 n1_m1_292800_115200 n1_m1_297600_115200 5.356235
R2904 n1_m1_297600_115200 n1_m1_302400_115200 5.356235
R2905 n1_m1_302400_115200 n1_m1_307200_115200 5.356235
R2906 n1_m1_307200_115200 n1_m1_312000_115200 5.356235
R2907 n1_m1_312000_115200 n1_m1_316800_115200 5.356235
R2908 n1_m1_316800_115200 n1_m1_321600_115200 5.356235
R2909 n1_m1_321600_115200 n1_m1_326400_115200 5.356235
R2910 n1_m1_326400_115200 n1_m1_331200_115200 5.356235
R2911 n1_m1_331200_115200 n1_m1_336000_115200 5.356235
R2912 n1_m1_336000_115200 n1_m1_340000_115200 4.463529
R2913 n1_m1_340800_115200 n1_m1_340000_115200 0.892706
R2914 n1_m1_340800_115200 n1_m1_345600_115200 5.356235
R2915 n1_m1_345600_115200 n1_m1_350400_115200 5.356235
R2916 n1_m1_350400_115200 n1_m1_355200_115200 5.356235
R2917 n1_m1_355200_115200 n1_m1_360000_115200 5.356235
R2918 n1_m1_360000_115200 n1_m1_364800_115200 5.356235
R2919 n1_m1_364800_115200 n1_m1_368000_115200 3.570824
R2920 n1_m1_369600_115200 n1_m1_368000_115200 1.785412
R2921 n1_m1_369600_115200 n1_m1_374400_115200 5.356235
R2922 n1_m1_374400_115200 n1_m1_379200_115200 5.356235
R2923 n1_m1_379200_115200 n1_m1_384000_115200 5.356235
R2924 n1_m1_384000_115200 n1_m1_388800_115200 5.356235
R2925 n1_m1_388800_115200 n1_m1_393600_115200 5.356235
R2926 n1_m1_393600_115200 n1_m1_396000_115200 2.678118
R2927 n1_m1_398400_115200 n1_m1_396000_115200 2.678118
R2928 n1_m1_398400_115200 n1_m1_403200_115200 5.356235
R2929 n1_m1_403200_115200 n1_m1_408000_115200 5.356235
R2930 n1_m1_408000_115200 n1_m1_412800_115200 5.356235
R2931 n1_m1_412800_115200 n1_m1_417600_115200 5.356235
R2932 n1_m1_417600_115200 n1_m1_422400_115200 5.356235
R2933 n1_m1_422400_115200 n1_m1_424000_115200 1.785412
R2934 n1_m1_427200_115200 n1_m1_424000_115200 3.570824
R2935 n1_m1_427200_115200 n1_m1_432000_115200 5.356235
R2936 n1_m1_432000_115200 n1_m1_436800_115200 5.356235
R2937 n1_m1_436800_115200 n1_m1_441600_115200 5.356235
R2938 n1_m1_441600_115200 n1_m1_446400_115200 5.356235
R2939 n1_m1_446400_115200 n1_m1_451200_115200 5.356235
R2940 n1_m1_451200_115200 n1_m1_452000_115200 0.892706
R2941 n1_m1_456000_115200 n1_m1_452000_115200 4.463529
R2942 n1_m1_456000_115200 n1_m1_460800_115200 5.356235
R2943 n1_m1_460800_115200 n1_m1_465600_115200 5.356235
R2944 n1_m1_465600_115200 n1_m1_470400_115200 5.356235
R2945 n1_m1_470400_115200 n1_m1_475200_115200 5.356235
R2946 n1_m1_475200_115200 n1_m1_480000_115200 5.356235
R2947 n1_m1_480000_115200 n1_m1_484800_115200 5.356235
R2948 n1_m1_484800_115200 n1_m1_489600_115200 5.356235
R2949 n1_m1_489600_115200 n1_m1_494400_115200 5.356235
R2950 n1_m1_0_120000 n1_m1_4000_120000 4.463529
R2951 n1_m1_4800_120000 n1_m1_4000_120000 0.892706
R2952 n1_m1_4800_120000 n1_m1_9600_120000 5.356235
R2953 n1_m1_9600_120000 n1_m1_14400_120000 5.356235
R2954 n1_m1_14400_120000 n1_m1_19200_120000 5.356235
R2955 n1_m1_19200_120000 n1_m1_24000_120000 5.356235
R2956 n1_m1_24000_120000 n1_m1_28800_120000 5.356235
R2957 n1_m1_28800_120000 n1_m1_32000_120000 3.570824
R2958 n1_m1_33600_120000 n1_m1_32000_120000 1.785412
R2959 n1_m1_33600_120000 n1_m1_38400_120000 5.356235
R2960 n1_m1_38400_120000 n1_m1_43200_120000 5.356235
R2961 n1_m1_43200_120000 n1_m1_48000_120000 5.356235
R2962 n1_m1_48000_120000 n1_m1_52800_120000 5.356235
R2963 n1_m1_52800_120000 n1_m1_57600_120000 5.356235
R2964 n1_m1_57600_120000 n1_m1_60000_120000 2.678118
R2965 n1_m1_62400_120000 n1_m1_60000_120000 2.678118
R2966 n1_m1_62400_120000 n1_m1_67200_120000 5.356235
R2967 n1_m1_67200_120000 n1_m1_72000_120000 5.356235
R2968 n1_m1_72000_120000 n1_m1_76800_120000 5.356235
R2969 n1_m1_76800_120000 n1_m1_81600_120000 5.356235
R2970 n1_m1_81600_120000 n1_m1_86400_120000 5.356235
R2971 n1_m1_86400_120000 n1_m1_88000_120000 1.785412
R2972 n1_m1_91200_120000 n1_m1_88000_120000 3.570824
R2973 n1_m1_91200_120000 n1_m1_96000_120000 5.356235
R2974 n1_m1_96000_120000 n1_m1_100800_120000 5.356235
R2975 n1_m1_100800_120000 n1_m1_105600_120000 5.356235
R2976 n1_m1_105600_120000 n1_m1_110400_120000 5.356235
R2977 n1_m1_110400_120000 n1_m1_115200_120000 5.356235
R2978 n1_m1_115200_120000 n1_m1_116000_120000 0.892706
R2979 n1_m1_120000_120000 n1_m1_116000_120000 4.463529
R2980 n1_m1_120000_120000 n1_m1_124800_120000 5.356235
R2981 n1_m1_124800_120000 n1_m1_129600_120000 5.356235
R2982 n1_m1_129600_120000 n1_m1_134400_120000 5.356235
R2983 n1_m1_134400_120000 n1_m1_139200_120000 5.356235
R2984 n1_m1_139200_120000 n1_m1_144000_120000 5.356235
R2985 n1_m1_144000_120000 n1_m1_148800_120000 5.356235
R2986 n1_m1_148800_120000 n1_m1_153600_120000 5.356235
R2987 n1_m1_153600_120000 n1_m1_158400_120000 5.356235
R2988 n1_m1_158400_120000 n1_m1_163200_120000 5.356235
R2989 n1_m1_163200_120000 n1_m1_168000_120000 5.356235
R2990 n1_m1_168000_120000 n1_m1_172000_120000 4.463529
R2991 n1_m1_172800_120000 n1_m1_172000_120000 0.892706
R2992 n1_m1_172800_120000 n1_m1_177600_120000 5.356235
R2993 n1_m1_177600_120000 n1_m1_182400_120000 5.356235
R2994 n1_m1_182400_120000 n1_m1_187200_120000 5.356235
R2995 n1_m1_187200_120000 n1_m1_192000_120000 5.356235
R2996 n1_m1_192000_120000 n1_m1_196800_120000 5.356235
R2997 n1_m1_196800_120000 n1_m1_200000_120000 3.570824
R2998 n1_m1_201600_120000 n1_m1_200000_120000 1.785412
R2999 n1_m1_201600_120000 n1_m1_206400_120000 5.356235
R3000 n1_m1_206400_120000 n1_m1_211200_120000 5.356235
R3001 n1_m1_211200_120000 n1_m1_216000_120000 5.356235
R3002 n1_m1_216000_120000 n1_m1_220800_120000 5.356235
R3003 n1_m1_220800_120000 n1_m1_225600_120000 5.356235
R3004 n1_m1_225600_120000 n1_m1_228000_120000 2.678118
R3005 n1_m1_230400_120000 n1_m1_228000_120000 2.678118
R3006 n1_m1_230400_120000 n1_m1_235200_120000 5.356235
R3007 n1_m1_235200_120000 n1_m1_240000_120000 5.356235
R3008 n1_m1_240000_120000 n1_m1_244800_120000 5.356235
R3009 n1_m1_244800_120000 n1_m1_249600_120000 5.356235
R3010 n1_m1_249600_120000 n1_m1_254400_120000 5.356235
R3011 n1_m1_254400_120000 n1_m1_256000_120000 1.785412
R3012 n1_m1_259200_120000 n1_m1_256000_120000 3.570824
R3013 n1_m1_259200_120000 n1_m1_264000_120000 5.356235
R3014 n1_m1_264000_120000 n1_m1_268800_120000 5.356235
R3015 n1_m1_268800_120000 n1_m1_273600_120000 5.356235
R3016 n1_m1_273600_120000 n1_m1_278400_120000 5.356235
R3017 n1_m1_278400_120000 n1_m1_283200_120000 5.356235
R3018 n1_m1_283200_120000 n1_m1_284000_120000 0.892706
R3019 n1_m1_288000_120000 n1_m1_284000_120000 4.463529
R3020 n1_m1_288000_120000 n1_m1_292800_120000 5.356235
R3021 n1_m1_292800_120000 n1_m1_297600_120000 5.356235
R3022 n1_m1_297600_120000 n1_m1_302400_120000 5.356235
R3023 n1_m1_302400_120000 n1_m1_307200_120000 5.356235
R3024 n1_m1_307200_120000 n1_m1_312000_120000 5.356235
R3025 n1_m1_312000_120000 n1_m1_316800_120000 5.356235
R3026 n1_m1_316800_120000 n1_m1_321600_120000 5.356235
R3027 n1_m1_321600_120000 n1_m1_326400_120000 5.356235
R3028 n1_m1_326400_120000 n1_m1_331200_120000 5.356235
R3029 n1_m1_331200_120000 n1_m1_336000_120000 5.356235
R3030 n1_m1_336000_120000 n1_m1_340000_120000 4.463529
R3031 n1_m1_340800_120000 n1_m1_340000_120000 0.892706
R3032 n1_m1_340800_120000 n1_m1_345600_120000 5.356235
R3033 n1_m1_345600_120000 n1_m1_350400_120000 5.356235
R3034 n1_m1_350400_120000 n1_m1_355200_120000 5.356235
R3035 n1_m1_355200_120000 n1_m1_360000_120000 5.356235
R3036 n1_m1_360000_120000 n1_m1_364800_120000 5.356235
R3037 n1_m1_364800_120000 n1_m1_368000_120000 3.570824
R3038 n1_m1_369600_120000 n1_m1_368000_120000 1.785412
R3039 n1_m1_369600_120000 n1_m1_374400_120000 5.356235
R3040 n1_m1_374400_120000 n1_m1_379200_120000 5.356235
R3041 n1_m1_379200_120000 n1_m1_384000_120000 5.356235
R3042 n1_m1_384000_120000 n1_m1_388800_120000 5.356235
R3043 n1_m1_388800_120000 n1_m1_393600_120000 5.356235
R3044 n1_m1_393600_120000 n1_m1_396000_120000 2.678118
R3045 n1_m1_398400_120000 n1_m1_396000_120000 2.678118
R3046 n1_m1_398400_120000 n1_m1_403200_120000 5.356235
R3047 n1_m1_403200_120000 n1_m1_408000_120000 5.356235
R3048 n1_m1_408000_120000 n1_m1_412800_120000 5.356235
R3049 n1_m1_412800_120000 n1_m1_417600_120000 5.356235
R3050 n1_m1_417600_120000 n1_m1_422400_120000 5.356235
R3051 n1_m1_422400_120000 n1_m1_424000_120000 1.785412
R3052 n1_m1_427200_120000 n1_m1_424000_120000 3.570824
R3053 n1_m1_427200_120000 n1_m1_432000_120000 5.356235
R3054 n1_m1_432000_120000 n1_m1_436800_120000 5.356235
R3055 n1_m1_436800_120000 n1_m1_441600_120000 5.356235
R3056 n1_m1_441600_120000 n1_m1_446400_120000 5.356235
R3057 n1_m1_446400_120000 n1_m1_451200_120000 5.356235
R3058 n1_m1_451200_120000 n1_m1_452000_120000 0.892706
R3059 n1_m1_456000_120000 n1_m1_452000_120000 4.463529
R3060 n1_m1_456000_120000 n1_m1_460800_120000 5.356235
R3061 n1_m1_460800_120000 n1_m1_465600_120000 5.356235
R3062 n1_m1_465600_120000 n1_m1_470400_120000 5.356235
R3063 n1_m1_470400_120000 n1_m1_475200_120000 5.356235
R3064 n1_m1_475200_120000 n1_m1_480000_120000 5.356235
R3065 n1_m1_480000_120000 n1_m1_484800_120000 5.356235
R3066 n1_m1_484800_120000 n1_m1_489600_120000 5.356235
R3067 n1_m1_489600_120000 n1_m1_494400_120000 5.356235
R3068 n1_m1_0_124800 n1_m1_4000_124800 4.463529
R3069 n1_m1_4800_124800 n1_m1_4000_124800 0.892706
R3070 n1_m1_4800_124800 n1_m1_9600_124800 5.356235
R3071 n1_m1_9600_124800 n1_m1_14400_124800 5.356235
R3072 n1_m1_14400_124800 n1_m1_19200_124800 5.356235
R3073 n1_m1_19200_124800 n1_m1_24000_124800 5.356235
R3074 n1_m1_24000_124800 n1_m1_28800_124800 5.356235
R3075 n1_m1_28800_124800 n1_m1_32000_124800 3.570824
R3076 n1_m1_33600_124800 n1_m1_32000_124800 1.785412
R3077 n1_m1_33600_124800 n1_m1_38400_124800 5.356235
R3078 n1_m1_38400_124800 n1_m1_43200_124800 5.356235
R3079 n1_m1_43200_124800 n1_m1_48000_124800 5.356235
R3080 n1_m1_48000_124800 n1_m1_52800_124800 5.356235
R3081 n1_m1_52800_124800 n1_m1_57600_124800 5.356235
R3082 n1_m1_57600_124800 n1_m1_60000_124800 2.678118
R3083 n1_m1_62400_124800 n1_m1_60000_124800 2.678118
R3084 n1_m1_62400_124800 n1_m1_67200_124800 5.356235
R3085 n1_m1_67200_124800 n1_m1_72000_124800 5.356235
R3086 n1_m1_72000_124800 n1_m1_76800_124800 5.356235
R3087 n1_m1_76800_124800 n1_m1_81600_124800 5.356235
R3088 n1_m1_81600_124800 n1_m1_86400_124800 5.356235
R3089 n1_m1_86400_124800 n1_m1_88000_124800 1.785412
R3090 n1_m1_91200_124800 n1_m1_88000_124800 3.570824
R3091 n1_m1_91200_124800 n1_m1_96000_124800 5.356235
R3092 n1_m1_96000_124800 n1_m1_100800_124800 5.356235
R3093 n1_m1_100800_124800 n1_m1_105600_124800 5.356235
R3094 n1_m1_105600_124800 n1_m1_110400_124800 5.356235
R3095 n1_m1_110400_124800 n1_m1_115200_124800 5.356235
R3096 n1_m1_115200_124800 n1_m1_116000_124800 0.892706
R3097 n1_m1_120000_124800 n1_m1_116000_124800 4.463529
R3098 n1_m1_120000_124800 n1_m1_124800_124800 5.356235
R3099 n1_m1_124800_124800 n1_m1_129600_124800 5.356235
R3100 n1_m1_129600_124800 n1_m1_134400_124800 5.356235
R3101 n1_m1_134400_124800 n1_m1_139200_124800 5.356235
R3102 n1_m1_139200_124800 n1_m1_144000_124800 5.356235
R3103 n1_m1_144000_124800 n1_m1_148800_124800 5.356235
R3104 n1_m1_148800_124800 n1_m1_153600_124800 5.356235
R3105 n1_m1_153600_124800 n1_m1_158400_124800 5.356235
R3106 n1_m1_158400_124800 n1_m1_163200_124800 5.356235
R3107 n1_m1_163200_124800 n1_m1_168000_124800 5.356235
R3108 n1_m1_168000_124800 n1_m1_172000_124800 4.463529
R3109 n1_m1_172800_124800 n1_m1_172000_124800 0.892706
R3110 n1_m1_172800_124800 n1_m1_177600_124800 5.356235
R3111 n1_m1_177600_124800 n1_m1_182400_124800 5.356235
R3112 n1_m1_182400_124800 n1_m1_187200_124800 5.356235
R3113 n1_m1_187200_124800 n1_m1_192000_124800 5.356235
R3114 n1_m1_192000_124800 n1_m1_196800_124800 5.356235
R3115 n1_m1_196800_124800 n1_m1_200000_124800 3.570824
R3116 n1_m1_201600_124800 n1_m1_200000_124800 1.785412
R3117 n1_m1_201600_124800 n1_m1_206400_124800 5.356235
R3118 n1_m1_206400_124800 n1_m1_211200_124800 5.356235
R3119 n1_m1_211200_124800 n1_m1_216000_124800 5.356235
R3120 n1_m1_216000_124800 n1_m1_220800_124800 5.356235
R3121 n1_m1_220800_124800 n1_m1_225600_124800 5.356235
R3122 n1_m1_225600_124800 n1_m1_228000_124800 2.678118
R3123 n1_m1_230400_124800 n1_m1_228000_124800 2.678118
R3124 n1_m1_230400_124800 n1_m1_235200_124800 5.356235
R3125 n1_m1_235200_124800 n1_m1_240000_124800 5.356235
R3126 n1_m1_240000_124800 n1_m1_244800_124800 5.356235
R3127 n1_m1_244800_124800 n1_m1_249600_124800 5.356235
R3128 n1_m1_249600_124800 n1_m1_254400_124800 5.356235
R3129 n1_m1_254400_124800 n1_m1_256000_124800 1.785412
R3130 n1_m1_259200_124800 n1_m1_256000_124800 3.570824
R3131 n1_m1_259200_124800 n1_m1_264000_124800 5.356235
R3132 n1_m1_264000_124800 n1_m1_268800_124800 5.356235
R3133 n1_m1_268800_124800 n1_m1_273600_124800 5.356235
R3134 n1_m1_273600_124800 n1_m1_278400_124800 5.356235
R3135 n1_m1_278400_124800 n1_m1_283200_124800 5.356235
R3136 n1_m1_283200_124800 n1_m1_284000_124800 0.892706
R3137 n1_m1_288000_124800 n1_m1_284000_124800 4.463529
R3138 n1_m1_288000_124800 n1_m1_292800_124800 5.356235
R3139 n1_m1_292800_124800 n1_m1_297600_124800 5.356235
R3140 n1_m1_297600_124800 n1_m1_302400_124800 5.356235
R3141 n1_m1_302400_124800 n1_m1_307200_124800 5.356235
R3142 n1_m1_307200_124800 n1_m1_312000_124800 5.356235
R3143 n1_m1_312000_124800 n1_m1_316800_124800 5.356235
R3144 n1_m1_316800_124800 n1_m1_321600_124800 5.356235
R3145 n1_m1_321600_124800 n1_m1_326400_124800 5.356235
R3146 n1_m1_326400_124800 n1_m1_331200_124800 5.356235
R3147 n1_m1_331200_124800 n1_m1_336000_124800 5.356235
R3148 n1_m1_336000_124800 n1_m1_340000_124800 4.463529
R3149 n1_m1_340800_124800 n1_m1_340000_124800 0.892706
R3150 n1_m1_340800_124800 n1_m1_345600_124800 5.356235
R3151 n1_m1_345600_124800 n1_m1_350400_124800 5.356235
R3152 n1_m1_350400_124800 n1_m1_355200_124800 5.356235
R3153 n1_m1_355200_124800 n1_m1_360000_124800 5.356235
R3154 n1_m1_360000_124800 n1_m1_364800_124800 5.356235
R3155 n1_m1_364800_124800 n1_m1_368000_124800 3.570824
R3156 n1_m1_369600_124800 n1_m1_368000_124800 1.785412
R3157 n1_m1_369600_124800 n1_m1_374400_124800 5.356235
R3158 n1_m1_374400_124800 n1_m1_379200_124800 5.356235
R3159 n1_m1_379200_124800 n1_m1_384000_124800 5.356235
R3160 n1_m1_384000_124800 n1_m1_388800_124800 5.356235
R3161 n1_m1_388800_124800 n1_m1_393600_124800 5.356235
R3162 n1_m1_393600_124800 n1_m1_396000_124800 2.678118
R3163 n1_m1_398400_124800 n1_m1_396000_124800 2.678118
R3164 n1_m1_398400_124800 n1_m1_403200_124800 5.356235
R3165 n1_m1_403200_124800 n1_m1_408000_124800 5.356235
R3166 n1_m1_408000_124800 n1_m1_412800_124800 5.356235
R3167 n1_m1_412800_124800 n1_m1_417600_124800 5.356235
R3168 n1_m1_417600_124800 n1_m1_422400_124800 5.356235
R3169 n1_m1_422400_124800 n1_m1_424000_124800 1.785412
R3170 n1_m1_427200_124800 n1_m1_424000_124800 3.570824
R3171 n1_m1_427200_124800 n1_m1_432000_124800 5.356235
R3172 n1_m1_432000_124800 n1_m1_436800_124800 5.356235
R3173 n1_m1_436800_124800 n1_m1_441600_124800 5.356235
R3174 n1_m1_441600_124800 n1_m1_446400_124800 5.356235
R3175 n1_m1_446400_124800 n1_m1_451200_124800 5.356235
R3176 n1_m1_451200_124800 n1_m1_452000_124800 0.892706
R3177 n1_m1_456000_124800 n1_m1_452000_124800 4.463529
R3178 n1_m1_456000_124800 n1_m1_460800_124800 5.356235
R3179 n1_m1_460800_124800 n1_m1_465600_124800 5.356235
R3180 n1_m1_465600_124800 n1_m1_470400_124800 5.356235
R3181 n1_m1_470400_124800 n1_m1_475200_124800 5.356235
R3182 n1_m1_475200_124800 n1_m1_480000_124800 5.356235
R3183 n1_m1_480000_124800 n1_m1_484800_124800 5.356235
R3184 n1_m1_484800_124800 n1_m1_489600_124800 5.356235
R3185 n1_m1_489600_124800 n1_m1_494400_124800 5.356235
R3186 n1_m1_0_129600 n1_m1_4000_129600 4.463529
R3187 n1_m1_4800_129600 n1_m1_4000_129600 0.892706
R3188 n1_m1_4800_129600 n1_m1_9600_129600 5.356235
R3189 n1_m1_9600_129600 n1_m1_14400_129600 5.356235
R3190 n1_m1_14400_129600 n1_m1_19200_129600 5.356235
R3191 n1_m1_19200_129600 n1_m1_24000_129600 5.356235
R3192 n1_m1_24000_129600 n1_m1_28800_129600 5.356235
R3193 n1_m1_28800_129600 n1_m1_32000_129600 3.570824
R3194 n1_m1_33600_129600 n1_m1_32000_129600 1.785412
R3195 n1_m1_33600_129600 n1_m1_38400_129600 5.356235
R3196 n1_m1_38400_129600 n1_m1_43200_129600 5.356235
R3197 n1_m1_43200_129600 n1_m1_48000_129600 5.356235
R3198 n1_m1_48000_129600 n1_m1_52800_129600 5.356235
R3199 n1_m1_52800_129600 n1_m1_57600_129600 5.356235
R3200 n1_m1_57600_129600 n1_m1_60000_129600 2.678118
R3201 n1_m1_62400_129600 n1_m1_60000_129600 2.678118
R3202 n1_m1_62400_129600 n1_m1_67200_129600 5.356235
R3203 n1_m1_67200_129600 n1_m1_72000_129600 5.356235
R3204 n1_m1_72000_129600 n1_m1_76800_129600 5.356235
R3205 n1_m1_76800_129600 n1_m1_81600_129600 5.356235
R3206 n1_m1_81600_129600 n1_m1_86400_129600 5.356235
R3207 n1_m1_86400_129600 n1_m1_88000_129600 1.785412
R3208 n1_m1_91200_129600 n1_m1_88000_129600 3.570824
R3209 n1_m1_91200_129600 n1_m1_96000_129600 5.356235
R3210 n1_m1_96000_129600 n1_m1_100800_129600 5.356235
R3211 n1_m1_100800_129600 n1_m1_105600_129600 5.356235
R3212 n1_m1_105600_129600 n1_m1_110400_129600 5.356235
R3213 n1_m1_110400_129600 n1_m1_115200_129600 5.356235
R3214 n1_m1_115200_129600 n1_m1_116000_129600 0.892706
R3215 n1_m1_120000_129600 n1_m1_116000_129600 4.463529
R3216 n1_m1_120000_129600 n1_m1_124800_129600 5.356235
R3217 n1_m1_124800_129600 n1_m1_129600_129600 5.356235
R3218 n1_m1_129600_129600 n1_m1_134400_129600 5.356235
R3219 n1_m1_134400_129600 n1_m1_139200_129600 5.356235
R3220 n1_m1_139200_129600 n1_m1_144000_129600 5.356235
R3221 n1_m1_144000_129600 n1_m1_148800_129600 5.356235
R3222 n1_m1_148800_129600 n1_m1_153600_129600 5.356235
R3223 n1_m1_153600_129600 n1_m1_158400_129600 5.356235
R3224 n1_m1_158400_129600 n1_m1_163200_129600 5.356235
R3225 n1_m1_163200_129600 n1_m1_168000_129600 5.356235
R3226 n1_m1_168000_129600 n1_m1_172000_129600 4.463529
R3227 n1_m1_172800_129600 n1_m1_172000_129600 0.892706
R3228 n1_m1_172800_129600 n1_m1_177600_129600 5.356235
R3229 n1_m1_177600_129600 n1_m1_182400_129600 5.356235
R3230 n1_m1_182400_129600 n1_m1_187200_129600 5.356235
R3231 n1_m1_187200_129600 n1_m1_192000_129600 5.356235
R3232 n1_m1_192000_129600 n1_m1_196800_129600 5.356235
R3233 n1_m1_196800_129600 n1_m1_200000_129600 3.570824
R3234 n1_m1_201600_129600 n1_m1_200000_129600 1.785412
R3235 n1_m1_201600_129600 n1_m1_206400_129600 5.356235
R3236 n1_m1_206400_129600 n1_m1_211200_129600 5.356235
R3237 n1_m1_211200_129600 n1_m1_216000_129600 5.356235
R3238 n1_m1_216000_129600 n1_m1_220800_129600 5.356235
R3239 n1_m1_220800_129600 n1_m1_225600_129600 5.356235
R3240 n1_m1_225600_129600 n1_m1_228000_129600 2.678118
R3241 n1_m1_230400_129600 n1_m1_228000_129600 2.678118
R3242 n1_m1_230400_129600 n1_m1_235200_129600 5.356235
R3243 n1_m1_235200_129600 n1_m1_240000_129600 5.356235
R3244 n1_m1_240000_129600 n1_m1_244800_129600 5.356235
R3245 n1_m1_244800_129600 n1_m1_249600_129600 5.356235
R3246 n1_m1_249600_129600 n1_m1_254400_129600 5.356235
R3247 n1_m1_254400_129600 n1_m1_256000_129600 1.785412
R3248 n1_m1_259200_129600 n1_m1_256000_129600 3.570824
R3249 n1_m1_259200_129600 n1_m1_264000_129600 5.356235
R3250 n1_m1_264000_129600 n1_m1_268800_129600 5.356235
R3251 n1_m1_268800_129600 n1_m1_273600_129600 5.356235
R3252 n1_m1_273600_129600 n1_m1_278400_129600 5.356235
R3253 n1_m1_278400_129600 n1_m1_283200_129600 5.356235
R3254 n1_m1_283200_129600 n1_m1_284000_129600 0.892706
R3255 n1_m1_288000_129600 n1_m1_284000_129600 4.463529
R3256 n1_m1_288000_129600 n1_m1_292800_129600 5.356235
R3257 n1_m1_292800_129600 n1_m1_297600_129600 5.356235
R3258 n1_m1_297600_129600 n1_m1_302400_129600 5.356235
R3259 n1_m1_302400_129600 n1_m1_307200_129600 5.356235
R3260 n1_m1_307200_129600 n1_m1_312000_129600 5.356235
R3261 n1_m1_312000_129600 n1_m1_316800_129600 5.356235
R3262 n1_m1_316800_129600 n1_m1_321600_129600 5.356235
R3263 n1_m1_321600_129600 n1_m1_326400_129600 5.356235
R3264 n1_m1_326400_129600 n1_m1_331200_129600 5.356235
R3265 n1_m1_331200_129600 n1_m1_336000_129600 5.356235
R3266 n1_m1_336000_129600 n1_m1_340000_129600 4.463529
R3267 n1_m1_340800_129600 n1_m1_340000_129600 0.892706
R3268 n1_m1_340800_129600 n1_m1_345600_129600 5.356235
R3269 n1_m1_345600_129600 n1_m1_350400_129600 5.356235
R3270 n1_m1_350400_129600 n1_m1_355200_129600 5.356235
R3271 n1_m1_355200_129600 n1_m1_360000_129600 5.356235
R3272 n1_m1_360000_129600 n1_m1_364800_129600 5.356235
R3273 n1_m1_364800_129600 n1_m1_368000_129600 3.570824
R3274 n1_m1_369600_129600 n1_m1_368000_129600 1.785412
R3275 n1_m1_369600_129600 n1_m1_374400_129600 5.356235
R3276 n1_m1_374400_129600 n1_m1_379200_129600 5.356235
R3277 n1_m1_379200_129600 n1_m1_384000_129600 5.356235
R3278 n1_m1_384000_129600 n1_m1_388800_129600 5.356235
R3279 n1_m1_388800_129600 n1_m1_393600_129600 5.356235
R3280 n1_m1_393600_129600 n1_m1_396000_129600 2.678118
R3281 n1_m1_398400_129600 n1_m1_396000_129600 2.678118
R3282 n1_m1_398400_129600 n1_m1_403200_129600 5.356235
R3283 n1_m1_403200_129600 n1_m1_408000_129600 5.356235
R3284 n1_m1_408000_129600 n1_m1_412800_129600 5.356235
R3285 n1_m1_412800_129600 n1_m1_417600_129600 5.356235
R3286 n1_m1_417600_129600 n1_m1_422400_129600 5.356235
R3287 n1_m1_422400_129600 n1_m1_424000_129600 1.785412
R3288 n1_m1_427200_129600 n1_m1_424000_129600 3.570824
R3289 n1_m1_427200_129600 n1_m1_432000_129600 5.356235
R3290 n1_m1_432000_129600 n1_m1_436800_129600 5.356235
R3291 n1_m1_436800_129600 n1_m1_441600_129600 5.356235
R3292 n1_m1_441600_129600 n1_m1_446400_129600 5.356235
R3293 n1_m1_446400_129600 n1_m1_451200_129600 5.356235
R3294 n1_m1_451200_129600 n1_m1_452000_129600 0.892706
R3295 n1_m1_456000_129600 n1_m1_452000_129600 4.463529
R3296 n1_m1_456000_129600 n1_m1_460800_129600 5.356235
R3297 n1_m1_460800_129600 n1_m1_465600_129600 5.356235
R3298 n1_m1_465600_129600 n1_m1_470400_129600 5.356235
R3299 n1_m1_470400_129600 n1_m1_475200_129600 5.356235
R3300 n1_m1_475200_129600 n1_m1_480000_129600 5.356235
R3301 n1_m1_480000_129600 n1_m1_484800_129600 5.356235
R3302 n1_m1_484800_129600 n1_m1_489600_129600 5.356235
R3303 n1_m1_489600_129600 n1_m1_494400_129600 5.356235
R3304 n1_m1_0_134400 n1_m1_4000_134400 4.463529
R3305 n1_m1_4800_134400 n1_m1_4000_134400 0.892706
R3306 n1_m1_4800_134400 n1_m1_9600_134400 5.356235
R3307 n1_m1_9600_134400 n1_m1_14400_134400 5.356235
R3308 n1_m1_14400_134400 n1_m1_19200_134400 5.356235
R3309 n1_m1_19200_134400 n1_m1_24000_134400 5.356235
R3310 n1_m1_24000_134400 n1_m1_28800_134400 5.356235
R3311 n1_m1_28800_134400 n1_m1_32000_134400 3.570824
R3312 n1_m1_33600_134400 n1_m1_32000_134400 1.785412
R3313 n1_m1_33600_134400 n1_m1_38400_134400 5.356235
R3314 n1_m1_38400_134400 n1_m1_43200_134400 5.356235
R3315 n1_m1_43200_134400 n1_m1_48000_134400 5.356235
R3316 n1_m1_48000_134400 n1_m1_52800_134400 5.356235
R3317 n1_m1_52800_134400 n1_m1_57600_134400 5.356235
R3318 n1_m1_57600_134400 n1_m1_60000_134400 2.678118
R3319 n1_m1_62400_134400 n1_m1_60000_134400 2.678118
R3320 n1_m1_62400_134400 n1_m1_67200_134400 5.356235
R3321 n1_m1_67200_134400 n1_m1_72000_134400 5.356235
R3322 n1_m1_72000_134400 n1_m1_76800_134400 5.356235
R3323 n1_m1_76800_134400 n1_m1_81600_134400 5.356235
R3324 n1_m1_81600_134400 n1_m1_86400_134400 5.356235
R3325 n1_m1_86400_134400 n1_m1_88000_134400 1.785412
R3326 n1_m1_91200_134400 n1_m1_88000_134400 3.570824
R3327 n1_m1_91200_134400 n1_m1_96000_134400 5.356235
R3328 n1_m1_96000_134400 n1_m1_100800_134400 5.356235
R3329 n1_m1_100800_134400 n1_m1_105600_134400 5.356235
R3330 n1_m1_105600_134400 n1_m1_110400_134400 5.356235
R3331 n1_m1_110400_134400 n1_m1_115200_134400 5.356235
R3332 n1_m1_115200_134400 n1_m1_116000_134400 0.892706
R3333 n1_m1_120000_134400 n1_m1_116000_134400 4.463529
R3334 n1_m1_120000_134400 n1_m1_124800_134400 5.356235
R3335 n1_m1_124800_134400 n1_m1_129600_134400 5.356235
R3336 n1_m1_129600_134400 n1_m1_134400_134400 5.356235
R3337 n1_m1_134400_134400 n1_m1_139200_134400 5.356235
R3338 n1_m1_139200_134400 n1_m1_144000_134400 5.356235
R3339 n1_m1_144000_134400 n1_m1_148800_134400 5.356235
R3340 n1_m1_148800_134400 n1_m1_153600_134400 5.356235
R3341 n1_m1_153600_134400 n1_m1_158400_134400 5.356235
R3342 n1_m1_158400_134400 n1_m1_163200_134400 5.356235
R3343 n1_m1_163200_134400 n1_m1_168000_134400 5.356235
R3344 n1_m1_168000_134400 n1_m1_172000_134400 4.463529
R3345 n1_m1_172800_134400 n1_m1_172000_134400 0.892706
R3346 n1_m1_172800_134400 n1_m1_177600_134400 5.356235
R3347 n1_m1_177600_134400 n1_m1_182400_134400 5.356235
R3348 n1_m1_182400_134400 n1_m1_187200_134400 5.356235
R3349 n1_m1_187200_134400 n1_m1_192000_134400 5.356235
R3350 n1_m1_192000_134400 n1_m1_196800_134400 5.356235
R3351 n1_m1_196800_134400 n1_m1_200000_134400 3.570824
R3352 n1_m1_201600_134400 n1_m1_200000_134400 1.785412
R3353 n1_m1_201600_134400 n1_m1_206400_134400 5.356235
R3354 n1_m1_206400_134400 n1_m1_211200_134400 5.356235
R3355 n1_m1_211200_134400 n1_m1_216000_134400 5.356235
R3356 n1_m1_216000_134400 n1_m1_220800_134400 5.356235
R3357 n1_m1_220800_134400 n1_m1_225600_134400 5.356235
R3358 n1_m1_225600_134400 n1_m1_228000_134400 2.678118
R3359 n1_m1_230400_134400 n1_m1_228000_134400 2.678118
R3360 n1_m1_230400_134400 n1_m1_235200_134400 5.356235
R3361 n1_m1_235200_134400 n1_m1_240000_134400 5.356235
R3362 n1_m1_240000_134400 n1_m1_244800_134400 5.356235
R3363 n1_m1_244800_134400 n1_m1_249600_134400 5.356235
R3364 n1_m1_249600_134400 n1_m1_254400_134400 5.356235
R3365 n1_m1_254400_134400 n1_m1_256000_134400 1.785412
R3366 n1_m1_259200_134400 n1_m1_256000_134400 3.570824
R3367 n1_m1_259200_134400 n1_m1_264000_134400 5.356235
R3368 n1_m1_264000_134400 n1_m1_268800_134400 5.356235
R3369 n1_m1_268800_134400 n1_m1_273600_134400 5.356235
R3370 n1_m1_273600_134400 n1_m1_278400_134400 5.356235
R3371 n1_m1_278400_134400 n1_m1_283200_134400 5.356235
R3372 n1_m1_283200_134400 n1_m1_284000_134400 0.892706
R3373 n1_m1_288000_134400 n1_m1_284000_134400 4.463529
R3374 n1_m1_288000_134400 n1_m1_292800_134400 5.356235
R3375 n1_m1_292800_134400 n1_m1_297600_134400 5.356235
R3376 n1_m1_297600_134400 n1_m1_302400_134400 5.356235
R3377 n1_m1_302400_134400 n1_m1_307200_134400 5.356235
R3378 n1_m1_307200_134400 n1_m1_312000_134400 5.356235
R3379 n1_m1_312000_134400 n1_m1_316800_134400 5.356235
R3380 n1_m1_316800_134400 n1_m1_321600_134400 5.356235
R3381 n1_m1_321600_134400 n1_m1_326400_134400 5.356235
R3382 n1_m1_326400_134400 n1_m1_331200_134400 5.356235
R3383 n1_m1_331200_134400 n1_m1_336000_134400 5.356235
R3384 n1_m1_336000_134400 n1_m1_340000_134400 4.463529
R3385 n1_m1_340800_134400 n1_m1_340000_134400 0.892706
R3386 n1_m1_340800_134400 n1_m1_345600_134400 5.356235
R3387 n1_m1_345600_134400 n1_m1_350400_134400 5.356235
R3388 n1_m1_350400_134400 n1_m1_355200_134400 5.356235
R3389 n1_m1_355200_134400 n1_m1_360000_134400 5.356235
R3390 n1_m1_360000_134400 n1_m1_364800_134400 5.356235
R3391 n1_m1_364800_134400 n1_m1_368000_134400 3.570824
R3392 n1_m1_369600_134400 n1_m1_368000_134400 1.785412
R3393 n1_m1_369600_134400 n1_m1_374400_134400 5.356235
R3394 n1_m1_374400_134400 n1_m1_379200_134400 5.356235
R3395 n1_m1_379200_134400 n1_m1_384000_134400 5.356235
R3396 n1_m1_384000_134400 n1_m1_388800_134400 5.356235
R3397 n1_m1_388800_134400 n1_m1_393600_134400 5.356235
R3398 n1_m1_393600_134400 n1_m1_396000_134400 2.678118
R3399 n1_m1_398400_134400 n1_m1_396000_134400 2.678118
R3400 n1_m1_398400_134400 n1_m1_403200_134400 5.356235
R3401 n1_m1_403200_134400 n1_m1_408000_134400 5.356235
R3402 n1_m1_408000_134400 n1_m1_412800_134400 5.356235
R3403 n1_m1_412800_134400 n1_m1_417600_134400 5.356235
R3404 n1_m1_417600_134400 n1_m1_422400_134400 5.356235
R3405 n1_m1_422400_134400 n1_m1_424000_134400 1.785412
R3406 n1_m1_427200_134400 n1_m1_424000_134400 3.570824
R3407 n1_m1_427200_134400 n1_m1_432000_134400 5.356235
R3408 n1_m1_432000_134400 n1_m1_436800_134400 5.356235
R3409 n1_m1_436800_134400 n1_m1_441600_134400 5.356235
R3410 n1_m1_441600_134400 n1_m1_446400_134400 5.356235
R3411 n1_m1_446400_134400 n1_m1_451200_134400 5.356235
R3412 n1_m1_451200_134400 n1_m1_452000_134400 0.892706
R3413 n1_m1_456000_134400 n1_m1_452000_134400 4.463529
R3414 n1_m1_456000_134400 n1_m1_460800_134400 5.356235
R3415 n1_m1_460800_134400 n1_m1_465600_134400 5.356235
R3416 n1_m1_465600_134400 n1_m1_470400_134400 5.356235
R3417 n1_m1_470400_134400 n1_m1_475200_134400 5.356235
R3418 n1_m1_475200_134400 n1_m1_480000_134400 5.356235
R3419 n1_m1_480000_134400 n1_m1_484800_134400 5.356235
R3420 n1_m1_484800_134400 n1_m1_489600_134400 5.356235
R3421 n1_m1_489600_134400 n1_m1_494400_134400 5.356235
R3422 n1_m1_0_139200 n1_m1_4000_139200 4.463529
R3423 n1_m1_4800_139200 n1_m1_4000_139200 0.892706
R3424 n1_m1_4800_139200 n1_m1_9600_139200 5.356235
R3425 n1_m1_9600_139200 n1_m1_14400_139200 5.356235
R3426 n1_m1_14400_139200 n1_m1_19200_139200 5.356235
R3427 n1_m1_19200_139200 n1_m1_24000_139200 5.356235
R3428 n1_m1_24000_139200 n1_m1_28800_139200 5.356235
R3429 n1_m1_28800_139200 n1_m1_32000_139200 3.570824
R3430 n1_m1_33600_139200 n1_m1_32000_139200 1.785412
R3431 n1_m1_33600_139200 n1_m1_38400_139200 5.356235
R3432 n1_m1_38400_139200 n1_m1_43200_139200 5.356235
R3433 n1_m1_43200_139200 n1_m1_48000_139200 5.356235
R3434 n1_m1_48000_139200 n1_m1_52800_139200 5.356235
R3435 n1_m1_52800_139200 n1_m1_57600_139200 5.356235
R3436 n1_m1_57600_139200 n1_m1_60000_139200 2.678118
R3437 n1_m1_62400_139200 n1_m1_60000_139200 2.678118
R3438 n1_m1_62400_139200 n1_m1_67200_139200 5.356235
R3439 n1_m1_67200_139200 n1_m1_72000_139200 5.356235
R3440 n1_m1_72000_139200 n1_m1_76800_139200 5.356235
R3441 n1_m1_76800_139200 n1_m1_81600_139200 5.356235
R3442 n1_m1_81600_139200 n1_m1_86400_139200 5.356235
R3443 n1_m1_86400_139200 n1_m1_88000_139200 1.785412
R3444 n1_m1_91200_139200 n1_m1_88000_139200 3.570824
R3445 n1_m1_91200_139200 n1_m1_96000_139200 5.356235
R3446 n1_m1_96000_139200 n1_m1_100800_139200 5.356235
R3447 n1_m1_100800_139200 n1_m1_105600_139200 5.356235
R3448 n1_m1_105600_139200 n1_m1_110400_139200 5.356235
R3449 n1_m1_110400_139200 n1_m1_115200_139200 5.356235
R3450 n1_m1_115200_139200 n1_m1_116000_139200 0.892706
R3451 n1_m1_120000_139200 n1_m1_116000_139200 4.463529
R3452 n1_m1_120000_139200 n1_m1_124800_139200 5.356235
R3453 n1_m1_124800_139200 n1_m1_129600_139200 5.356235
R3454 n1_m1_129600_139200 n1_m1_134400_139200 5.356235
R3455 n1_m1_134400_139200 n1_m1_139200_139200 5.356235
R3456 n1_m1_139200_139200 n1_m1_144000_139200 5.356235
R3457 n1_m1_144000_139200 n1_m1_148800_139200 5.356235
R3458 n1_m1_148800_139200 n1_m1_153600_139200 5.356235
R3459 n1_m1_153600_139200 n1_m1_158400_139200 5.356235
R3460 n1_m1_158400_139200 n1_m1_163200_139200 5.356235
R3461 n1_m1_163200_139200 n1_m1_168000_139200 5.356235
R3462 n1_m1_168000_139200 n1_m1_172000_139200 4.463529
R3463 n1_m1_172800_139200 n1_m1_172000_139200 0.892706
R3464 n1_m1_172800_139200 n1_m1_177600_139200 5.356235
R3465 n1_m1_177600_139200 n1_m1_182400_139200 5.356235
R3466 n1_m1_182400_139200 n1_m1_187200_139200 5.356235
R3467 n1_m1_187200_139200 n1_m1_192000_139200 5.356235
R3468 n1_m1_192000_139200 n1_m1_196800_139200 5.356235
R3469 n1_m1_196800_139200 n1_m1_200000_139200 3.570824
R3470 n1_m1_201600_139200 n1_m1_200000_139200 1.785412
R3471 n1_m1_201600_139200 n1_m1_206400_139200 5.356235
R3472 n1_m1_206400_139200 n1_m1_211200_139200 5.356235
R3473 n1_m1_211200_139200 n1_m1_216000_139200 5.356235
R3474 n1_m1_216000_139200 n1_m1_220800_139200 5.356235
R3475 n1_m1_220800_139200 n1_m1_225600_139200 5.356235
R3476 n1_m1_225600_139200 n1_m1_228000_139200 2.678118
R3477 n1_m1_230400_139200 n1_m1_228000_139200 2.678118
R3478 n1_m1_230400_139200 n1_m1_235200_139200 5.356235
R3479 n1_m1_235200_139200 n1_m1_240000_139200 5.356235
R3480 n1_m1_240000_139200 n1_m1_244800_139200 5.356235
R3481 n1_m1_244800_139200 n1_m1_249600_139200 5.356235
R3482 n1_m1_249600_139200 n1_m1_254400_139200 5.356235
R3483 n1_m1_254400_139200 n1_m1_256000_139200 1.785412
R3484 n1_m1_259200_139200 n1_m1_256000_139200 3.570824
R3485 n1_m1_259200_139200 n1_m1_264000_139200 5.356235
R3486 n1_m1_264000_139200 n1_m1_268800_139200 5.356235
R3487 n1_m1_268800_139200 n1_m1_273600_139200 5.356235
R3488 n1_m1_273600_139200 n1_m1_278400_139200 5.356235
R3489 n1_m1_278400_139200 n1_m1_283200_139200 5.356235
R3490 n1_m1_283200_139200 n1_m1_284000_139200 0.892706
R3491 n1_m1_288000_139200 n1_m1_284000_139200 4.463529
R3492 n1_m1_288000_139200 n1_m1_292800_139200 5.356235
R3493 n1_m1_292800_139200 n1_m1_297600_139200 5.356235
R3494 n1_m1_297600_139200 n1_m1_302400_139200 5.356235
R3495 n1_m1_302400_139200 n1_m1_307200_139200 5.356235
R3496 n1_m1_307200_139200 n1_m1_312000_139200 5.356235
R3497 n1_m1_312000_139200 n1_m1_316800_139200 5.356235
R3498 n1_m1_316800_139200 n1_m1_321600_139200 5.356235
R3499 n1_m1_321600_139200 n1_m1_326400_139200 5.356235
R3500 n1_m1_326400_139200 n1_m1_331200_139200 5.356235
R3501 n1_m1_331200_139200 n1_m1_336000_139200 5.356235
R3502 n1_m1_336000_139200 n1_m1_340000_139200 4.463529
R3503 n1_m1_340800_139200 n1_m1_340000_139200 0.892706
R3504 n1_m1_340800_139200 n1_m1_345600_139200 5.356235
R3505 n1_m1_345600_139200 n1_m1_350400_139200 5.356235
R3506 n1_m1_350400_139200 n1_m1_355200_139200 5.356235
R3507 n1_m1_355200_139200 n1_m1_360000_139200 5.356235
R3508 n1_m1_360000_139200 n1_m1_364800_139200 5.356235
R3509 n1_m1_364800_139200 n1_m1_368000_139200 3.570824
R3510 n1_m1_369600_139200 n1_m1_368000_139200 1.785412
R3511 n1_m1_369600_139200 n1_m1_374400_139200 5.356235
R3512 n1_m1_374400_139200 n1_m1_379200_139200 5.356235
R3513 n1_m1_379200_139200 n1_m1_384000_139200 5.356235
R3514 n1_m1_384000_139200 n1_m1_388800_139200 5.356235
R3515 n1_m1_388800_139200 n1_m1_393600_139200 5.356235
R3516 n1_m1_393600_139200 n1_m1_396000_139200 2.678118
R3517 n1_m1_398400_139200 n1_m1_396000_139200 2.678118
R3518 n1_m1_398400_139200 n1_m1_403200_139200 5.356235
R3519 n1_m1_403200_139200 n1_m1_408000_139200 5.356235
R3520 n1_m1_408000_139200 n1_m1_412800_139200 5.356235
R3521 n1_m1_412800_139200 n1_m1_417600_139200 5.356235
R3522 n1_m1_417600_139200 n1_m1_422400_139200 5.356235
R3523 n1_m1_422400_139200 n1_m1_424000_139200 1.785412
R3524 n1_m1_427200_139200 n1_m1_424000_139200 3.570824
R3525 n1_m1_427200_139200 n1_m1_432000_139200 5.356235
R3526 n1_m1_432000_139200 n1_m1_436800_139200 5.356235
R3527 n1_m1_436800_139200 n1_m1_441600_139200 5.356235
R3528 n1_m1_441600_139200 n1_m1_446400_139200 5.356235
R3529 n1_m1_446400_139200 n1_m1_451200_139200 5.356235
R3530 n1_m1_451200_139200 n1_m1_452000_139200 0.892706
R3531 n1_m1_456000_139200 n1_m1_452000_139200 4.463529
R3532 n1_m1_456000_139200 n1_m1_460800_139200 5.356235
R3533 n1_m1_460800_139200 n1_m1_465600_139200 5.356235
R3534 n1_m1_465600_139200 n1_m1_470400_139200 5.356235
R3535 n1_m1_470400_139200 n1_m1_475200_139200 5.356235
R3536 n1_m1_475200_139200 n1_m1_480000_139200 5.356235
R3537 n1_m1_480000_139200 n1_m1_484800_139200 5.356235
R3538 n1_m1_484800_139200 n1_m1_489600_139200 5.356235
R3539 n1_m1_489600_139200 n1_m1_494400_139200 5.356235
R3540 n1_m1_0_144000 n1_m1_4000_144000 4.463529
R3541 n1_m1_4800_144000 n1_m1_4000_144000 0.892706
R3542 n1_m1_4800_144000 n1_m1_9600_144000 5.356235
R3543 n1_m1_9600_144000 n1_m1_14400_144000 5.356235
R3544 n1_m1_14400_144000 n1_m1_19200_144000 5.356235
R3545 n1_m1_19200_144000 n1_m1_24000_144000 5.356235
R3546 n1_m1_24000_144000 n1_m1_28800_144000 5.356235
R3547 n1_m1_28800_144000 n1_m1_32000_144000 3.570824
R3548 n1_m1_33600_144000 n1_m1_32000_144000 1.785412
R3549 n1_m1_33600_144000 n1_m1_38400_144000 5.356235
R3550 n1_m1_38400_144000 n1_m1_43200_144000 5.356235
R3551 n1_m1_43200_144000 n1_m1_48000_144000 5.356235
R3552 n1_m1_48000_144000 n1_m1_52800_144000 5.356235
R3553 n1_m1_52800_144000 n1_m1_57600_144000 5.356235
R3554 n1_m1_57600_144000 n1_m1_60000_144000 2.678118
R3555 n1_m1_62400_144000 n1_m1_60000_144000 2.678118
R3556 n1_m1_62400_144000 n1_m1_67200_144000 5.356235
R3557 n1_m1_67200_144000 n1_m1_72000_144000 5.356235
R3558 n1_m1_72000_144000 n1_m1_76800_144000 5.356235
R3559 n1_m1_76800_144000 n1_m1_81600_144000 5.356235
R3560 n1_m1_81600_144000 n1_m1_86400_144000 5.356235
R3561 n1_m1_86400_144000 n1_m1_88000_144000 1.785412
R3562 n1_m1_91200_144000 n1_m1_88000_144000 3.570824
R3563 n1_m1_91200_144000 n1_m1_96000_144000 5.356235
R3564 n1_m1_96000_144000 n1_m1_100800_144000 5.356235
R3565 n1_m1_100800_144000 n1_m1_105600_144000 5.356235
R3566 n1_m1_105600_144000 n1_m1_110400_144000 5.356235
R3567 n1_m1_110400_144000 n1_m1_115200_144000 5.356235
R3568 n1_m1_115200_144000 n1_m1_116000_144000 0.892706
R3569 n1_m1_120000_144000 n1_m1_116000_144000 4.463529
R3570 n1_m1_120000_144000 n1_m1_124800_144000 5.356235
R3571 n1_m1_124800_144000 n1_m1_129600_144000 5.356235
R3572 n1_m1_129600_144000 n1_m1_134400_144000 5.356235
R3573 n1_m1_134400_144000 n1_m1_139200_144000 5.356235
R3574 n1_m1_139200_144000 n1_m1_144000_144000 5.356235
R3575 n1_m1_144000_144000 n1_m1_148800_144000 5.356235
R3576 n1_m1_148800_144000 n1_m1_153600_144000 5.356235
R3577 n1_m1_153600_144000 n1_m1_158400_144000 5.356235
R3578 n1_m1_158400_144000 n1_m1_163200_144000 5.356235
R3579 n1_m1_163200_144000 n1_m1_168000_144000 5.356235
R3580 n1_m1_168000_144000 n1_m1_172000_144000 4.463529
R3581 n1_m1_172800_144000 n1_m1_172000_144000 0.892706
R3582 n1_m1_172800_144000 n1_m1_177600_144000 5.356235
R3583 n1_m1_177600_144000 n1_m1_182400_144000 5.356235
R3584 n1_m1_182400_144000 n1_m1_187200_144000 5.356235
R3585 n1_m1_187200_144000 n1_m1_192000_144000 5.356235
R3586 n1_m1_192000_144000 n1_m1_196800_144000 5.356235
R3587 n1_m1_196800_144000 n1_m1_200000_144000 3.570824
R3588 n1_m1_201600_144000 n1_m1_200000_144000 1.785412
R3589 n1_m1_201600_144000 n1_m1_206400_144000 5.356235
R3590 n1_m1_206400_144000 n1_m1_211200_144000 5.356235
R3591 n1_m1_211200_144000 n1_m1_216000_144000 5.356235
R3592 n1_m1_216000_144000 n1_m1_220800_144000 5.356235
R3593 n1_m1_220800_144000 n1_m1_225600_144000 5.356235
R3594 n1_m1_225600_144000 n1_m1_228000_144000 2.678118
R3595 n1_m1_230400_144000 n1_m1_228000_144000 2.678118
R3596 n1_m1_230400_144000 n1_m1_235200_144000 5.356235
R3597 n1_m1_235200_144000 n1_m1_240000_144000 5.356235
R3598 n1_m1_240000_144000 n1_m1_244800_144000 5.356235
R3599 n1_m1_244800_144000 n1_m1_249600_144000 5.356235
R3600 n1_m1_249600_144000 n1_m1_254400_144000 5.356235
R3601 n1_m1_254400_144000 n1_m1_256000_144000 1.785412
R3602 n1_m1_259200_144000 n1_m1_256000_144000 3.570824
R3603 n1_m1_259200_144000 n1_m1_264000_144000 5.356235
R3604 n1_m1_264000_144000 n1_m1_268800_144000 5.356235
R3605 n1_m1_268800_144000 n1_m1_273600_144000 5.356235
R3606 n1_m1_273600_144000 n1_m1_278400_144000 5.356235
R3607 n1_m1_278400_144000 n1_m1_283200_144000 5.356235
R3608 n1_m1_283200_144000 n1_m1_284000_144000 0.892706
R3609 n1_m1_288000_144000 n1_m1_284000_144000 4.463529
R3610 n1_m1_288000_144000 n1_m1_292800_144000 5.356235
R3611 n1_m1_292800_144000 n1_m1_297600_144000 5.356235
R3612 n1_m1_297600_144000 n1_m1_302400_144000 5.356235
R3613 n1_m1_302400_144000 n1_m1_307200_144000 5.356235
R3614 n1_m1_307200_144000 n1_m1_312000_144000 5.356235
R3615 n1_m1_312000_144000 n1_m1_316800_144000 5.356235
R3616 n1_m1_316800_144000 n1_m1_321600_144000 5.356235
R3617 n1_m1_321600_144000 n1_m1_326400_144000 5.356235
R3618 n1_m1_326400_144000 n1_m1_331200_144000 5.356235
R3619 n1_m1_331200_144000 n1_m1_336000_144000 5.356235
R3620 n1_m1_336000_144000 n1_m1_340000_144000 4.463529
R3621 n1_m1_340800_144000 n1_m1_340000_144000 0.892706
R3622 n1_m1_340800_144000 n1_m1_345600_144000 5.356235
R3623 n1_m1_345600_144000 n1_m1_350400_144000 5.356235
R3624 n1_m1_350400_144000 n1_m1_355200_144000 5.356235
R3625 n1_m1_355200_144000 n1_m1_360000_144000 5.356235
R3626 n1_m1_360000_144000 n1_m1_364800_144000 5.356235
R3627 n1_m1_364800_144000 n1_m1_368000_144000 3.570824
R3628 n1_m1_369600_144000 n1_m1_368000_144000 1.785412
R3629 n1_m1_369600_144000 n1_m1_374400_144000 5.356235
R3630 n1_m1_374400_144000 n1_m1_379200_144000 5.356235
R3631 n1_m1_379200_144000 n1_m1_384000_144000 5.356235
R3632 n1_m1_384000_144000 n1_m1_388800_144000 5.356235
R3633 n1_m1_388800_144000 n1_m1_393600_144000 5.356235
R3634 n1_m1_393600_144000 n1_m1_396000_144000 2.678118
R3635 n1_m1_398400_144000 n1_m1_396000_144000 2.678118
R3636 n1_m1_398400_144000 n1_m1_403200_144000 5.356235
R3637 n1_m1_403200_144000 n1_m1_408000_144000 5.356235
R3638 n1_m1_408000_144000 n1_m1_412800_144000 5.356235
R3639 n1_m1_412800_144000 n1_m1_417600_144000 5.356235
R3640 n1_m1_417600_144000 n1_m1_422400_144000 5.356235
R3641 n1_m1_422400_144000 n1_m1_424000_144000 1.785412
R3642 n1_m1_427200_144000 n1_m1_424000_144000 3.570824
R3643 n1_m1_427200_144000 n1_m1_432000_144000 5.356235
R3644 n1_m1_432000_144000 n1_m1_436800_144000 5.356235
R3645 n1_m1_436800_144000 n1_m1_441600_144000 5.356235
R3646 n1_m1_441600_144000 n1_m1_446400_144000 5.356235
R3647 n1_m1_446400_144000 n1_m1_451200_144000 5.356235
R3648 n1_m1_451200_144000 n1_m1_452000_144000 0.892706
R3649 n1_m1_456000_144000 n1_m1_452000_144000 4.463529
R3650 n1_m1_456000_144000 n1_m1_460800_144000 5.356235
R3651 n1_m1_460800_144000 n1_m1_465600_144000 5.356235
R3652 n1_m1_465600_144000 n1_m1_470400_144000 5.356235
R3653 n1_m1_470400_144000 n1_m1_475200_144000 5.356235
R3654 n1_m1_475200_144000 n1_m1_480000_144000 5.356235
R3655 n1_m1_480000_144000 n1_m1_484800_144000 5.356235
R3656 n1_m1_484800_144000 n1_m1_489600_144000 5.356235
R3657 n1_m1_489600_144000 n1_m1_494400_144000 5.356235
R3658 n1_m1_0_148800 n1_m1_4000_148800 4.463529
R3659 n1_m1_4800_148800 n1_m1_4000_148800 0.892706
R3660 n1_m1_4800_148800 n1_m1_9600_148800 5.356235
R3661 n1_m1_9600_148800 n1_m1_14400_148800 5.356235
R3662 n1_m1_14400_148800 n1_m1_19200_148800 5.356235
R3663 n1_m1_19200_148800 n1_m1_24000_148800 5.356235
R3664 n1_m1_24000_148800 n1_m1_28800_148800 5.356235
R3665 n1_m1_28800_148800 n1_m1_32000_148800 3.570824
R3666 n1_m1_33600_148800 n1_m1_32000_148800 1.785412
R3667 n1_m1_33600_148800 n1_m1_38400_148800 5.356235
R3668 n1_m1_38400_148800 n1_m1_43200_148800 5.356235
R3669 n1_m1_43200_148800 n1_m1_48000_148800 5.356235
R3670 n1_m1_48000_148800 n1_m1_52800_148800 5.356235
R3671 n1_m1_52800_148800 n1_m1_57600_148800 5.356235
R3672 n1_m1_57600_148800 n1_m1_60000_148800 2.678118
R3673 n1_m1_62400_148800 n1_m1_60000_148800 2.678118
R3674 n1_m1_62400_148800 n1_m1_67200_148800 5.356235
R3675 n1_m1_67200_148800 n1_m1_72000_148800 5.356235
R3676 n1_m1_72000_148800 n1_m1_76800_148800 5.356235
R3677 n1_m1_76800_148800 n1_m1_81600_148800 5.356235
R3678 n1_m1_81600_148800 n1_m1_86400_148800 5.356235
R3679 n1_m1_86400_148800 n1_m1_88000_148800 1.785412
R3680 n1_m1_91200_148800 n1_m1_88000_148800 3.570824
R3681 n1_m1_91200_148800 n1_m1_96000_148800 5.356235
R3682 n1_m1_96000_148800 n1_m1_100800_148800 5.356235
R3683 n1_m1_100800_148800 n1_m1_105600_148800 5.356235
R3684 n1_m1_105600_148800 n1_m1_110400_148800 5.356235
R3685 n1_m1_110400_148800 n1_m1_115200_148800 5.356235
R3686 n1_m1_115200_148800 n1_m1_116000_148800 0.892706
R3687 n1_m1_120000_148800 n1_m1_116000_148800 4.463529
R3688 n1_m1_120000_148800 n1_m1_124800_148800 5.356235
R3689 n1_m1_124800_148800 n1_m1_129600_148800 5.356235
R3690 n1_m1_129600_148800 n1_m1_134400_148800 5.356235
R3691 n1_m1_134400_148800 n1_m1_139200_148800 5.356235
R3692 n1_m1_139200_148800 n1_m1_144000_148800 5.356235
R3693 n1_m1_144000_148800 n1_m1_148800_148800 5.356235
R3694 n1_m1_148800_148800 n1_m1_153600_148800 5.356235
R3695 n1_m1_153600_148800 n1_m1_158400_148800 5.356235
R3696 n1_m1_158400_148800 n1_m1_163200_148800 5.356235
R3697 n1_m1_163200_148800 n1_m1_168000_148800 5.356235
R3698 n1_m1_168000_148800 n1_m1_172000_148800 4.463529
R3699 n1_m1_172800_148800 n1_m1_172000_148800 0.892706
R3700 n1_m1_172800_148800 n1_m1_177600_148800 5.356235
R3701 n1_m1_177600_148800 n1_m1_182400_148800 5.356235
R3702 n1_m1_182400_148800 n1_m1_187200_148800 5.356235
R3703 n1_m1_187200_148800 n1_m1_192000_148800 5.356235
R3704 n1_m1_192000_148800 n1_m1_196800_148800 5.356235
R3705 n1_m1_196800_148800 n1_m1_200000_148800 3.570824
R3706 n1_m1_201600_148800 n1_m1_200000_148800 1.785412
R3707 n1_m1_201600_148800 n1_m1_206400_148800 5.356235
R3708 n1_m1_206400_148800 n1_m1_211200_148800 5.356235
R3709 n1_m1_211200_148800 n1_m1_216000_148800 5.356235
R3710 n1_m1_216000_148800 n1_m1_220800_148800 5.356235
R3711 n1_m1_220800_148800 n1_m1_225600_148800 5.356235
R3712 n1_m1_225600_148800 n1_m1_228000_148800 2.678118
R3713 n1_m1_230400_148800 n1_m1_228000_148800 2.678118
R3714 n1_m1_230400_148800 n1_m1_235200_148800 5.356235
R3715 n1_m1_235200_148800 n1_m1_240000_148800 5.356235
R3716 n1_m1_240000_148800 n1_m1_244800_148800 5.356235
R3717 n1_m1_244800_148800 n1_m1_249600_148800 5.356235
R3718 n1_m1_249600_148800 n1_m1_254400_148800 5.356235
R3719 n1_m1_254400_148800 n1_m1_256000_148800 1.785412
R3720 n1_m1_259200_148800 n1_m1_256000_148800 3.570824
R3721 n1_m1_259200_148800 n1_m1_264000_148800 5.356235
R3722 n1_m1_264000_148800 n1_m1_268800_148800 5.356235
R3723 n1_m1_268800_148800 n1_m1_273600_148800 5.356235
R3724 n1_m1_273600_148800 n1_m1_278400_148800 5.356235
R3725 n1_m1_278400_148800 n1_m1_283200_148800 5.356235
R3726 n1_m1_283200_148800 n1_m1_284000_148800 0.892706
R3727 n1_m1_288000_148800 n1_m1_284000_148800 4.463529
R3728 n1_m1_288000_148800 n1_m1_292800_148800 5.356235
R3729 n1_m1_292800_148800 n1_m1_297600_148800 5.356235
R3730 n1_m1_297600_148800 n1_m1_302400_148800 5.356235
R3731 n1_m1_302400_148800 n1_m1_307200_148800 5.356235
R3732 n1_m1_307200_148800 n1_m1_312000_148800 5.356235
R3733 n1_m1_312000_148800 n1_m1_316800_148800 5.356235
R3734 n1_m1_316800_148800 n1_m1_321600_148800 5.356235
R3735 n1_m1_321600_148800 n1_m1_326400_148800 5.356235
R3736 n1_m1_326400_148800 n1_m1_331200_148800 5.356235
R3737 n1_m1_331200_148800 n1_m1_336000_148800 5.356235
R3738 n1_m1_336000_148800 n1_m1_340000_148800 4.463529
R3739 n1_m1_340800_148800 n1_m1_340000_148800 0.892706
R3740 n1_m1_340800_148800 n1_m1_345600_148800 5.356235
R3741 n1_m1_345600_148800 n1_m1_350400_148800 5.356235
R3742 n1_m1_350400_148800 n1_m1_355200_148800 5.356235
R3743 n1_m1_355200_148800 n1_m1_360000_148800 5.356235
R3744 n1_m1_360000_148800 n1_m1_364800_148800 5.356235
R3745 n1_m1_364800_148800 n1_m1_368000_148800 3.570824
R3746 n1_m1_369600_148800 n1_m1_368000_148800 1.785412
R3747 n1_m1_369600_148800 n1_m1_374400_148800 5.356235
R3748 n1_m1_374400_148800 n1_m1_379200_148800 5.356235
R3749 n1_m1_379200_148800 n1_m1_384000_148800 5.356235
R3750 n1_m1_384000_148800 n1_m1_388800_148800 5.356235
R3751 n1_m1_388800_148800 n1_m1_393600_148800 5.356235
R3752 n1_m1_393600_148800 n1_m1_396000_148800 2.678118
R3753 n1_m1_398400_148800 n1_m1_396000_148800 2.678118
R3754 n1_m1_398400_148800 n1_m1_403200_148800 5.356235
R3755 n1_m1_403200_148800 n1_m1_408000_148800 5.356235
R3756 n1_m1_408000_148800 n1_m1_412800_148800 5.356235
R3757 n1_m1_412800_148800 n1_m1_417600_148800 5.356235
R3758 n1_m1_417600_148800 n1_m1_422400_148800 5.356235
R3759 n1_m1_422400_148800 n1_m1_424000_148800 1.785412
R3760 n1_m1_427200_148800 n1_m1_424000_148800 3.570824
R3761 n1_m1_427200_148800 n1_m1_432000_148800 5.356235
R3762 n1_m1_432000_148800 n1_m1_436800_148800 5.356235
R3763 n1_m1_436800_148800 n1_m1_441600_148800 5.356235
R3764 n1_m1_441600_148800 n1_m1_446400_148800 5.356235
R3765 n1_m1_446400_148800 n1_m1_451200_148800 5.356235
R3766 n1_m1_451200_148800 n1_m1_452000_148800 0.892706
R3767 n1_m1_456000_148800 n1_m1_452000_148800 4.463529
R3768 n1_m1_456000_148800 n1_m1_460800_148800 5.356235
R3769 n1_m1_460800_148800 n1_m1_465600_148800 5.356235
R3770 n1_m1_465600_148800 n1_m1_470400_148800 5.356235
R3771 n1_m1_470400_148800 n1_m1_475200_148800 5.356235
R3772 n1_m1_475200_148800 n1_m1_480000_148800 5.356235
R3773 n1_m1_480000_148800 n1_m1_484800_148800 5.356235
R3774 n1_m1_484800_148800 n1_m1_489600_148800 5.356235
R3775 n1_m1_489600_148800 n1_m1_494400_148800 5.356235
R3776 n1_m1_0_153600 n1_m1_4000_153600 4.463529
R3777 n1_m1_4800_153600 n1_m1_4000_153600 0.892706
R3778 n1_m1_4800_153600 n1_m1_9600_153600 5.356235
R3779 n1_m1_9600_153600 n1_m1_14400_153600 5.356235
R3780 n1_m1_14400_153600 n1_m1_19200_153600 5.356235
R3781 n1_m1_19200_153600 n1_m1_24000_153600 5.356235
R3782 n1_m1_24000_153600 n1_m1_28800_153600 5.356235
R3783 n1_m1_28800_153600 n1_m1_32000_153600 3.570824
R3784 n1_m1_33600_153600 n1_m1_32000_153600 1.785412
R3785 n1_m1_33600_153600 n1_m1_38400_153600 5.356235
R3786 n1_m1_38400_153600 n1_m1_43200_153600 5.356235
R3787 n1_m1_43200_153600 n1_m1_48000_153600 5.356235
R3788 n1_m1_48000_153600 n1_m1_52800_153600 5.356235
R3789 n1_m1_52800_153600 n1_m1_57600_153600 5.356235
R3790 n1_m1_57600_153600 n1_m1_60000_153600 2.678118
R3791 n1_m1_62400_153600 n1_m1_60000_153600 2.678118
R3792 n1_m1_62400_153600 n1_m1_67200_153600 5.356235
R3793 n1_m1_67200_153600 n1_m1_72000_153600 5.356235
R3794 n1_m1_72000_153600 n1_m1_76800_153600 5.356235
R3795 n1_m1_76800_153600 n1_m1_81600_153600 5.356235
R3796 n1_m1_81600_153600 n1_m1_86400_153600 5.356235
R3797 n1_m1_86400_153600 n1_m1_88000_153600 1.785412
R3798 n1_m1_91200_153600 n1_m1_88000_153600 3.570824
R3799 n1_m1_91200_153600 n1_m1_96000_153600 5.356235
R3800 n1_m1_96000_153600 n1_m1_100800_153600 5.356235
R3801 n1_m1_100800_153600 n1_m1_105600_153600 5.356235
R3802 n1_m1_105600_153600 n1_m1_110400_153600 5.356235
R3803 n1_m1_110400_153600 n1_m1_115200_153600 5.356235
R3804 n1_m1_115200_153600 n1_m1_116000_153600 0.892706
R3805 n1_m1_120000_153600 n1_m1_116000_153600 4.463529
R3806 n1_m1_120000_153600 n1_m1_124800_153600 5.356235
R3807 n1_m1_124800_153600 n1_m1_129600_153600 5.356235
R3808 n1_m1_129600_153600 n1_m1_134400_153600 5.356235
R3809 n1_m1_134400_153600 n1_m1_139200_153600 5.356235
R3810 n1_m1_139200_153600 n1_m1_144000_153600 5.356235
R3811 n1_m1_144000_153600 n1_m1_148800_153600 5.356235
R3812 n1_m1_148800_153600 n1_m1_153600_153600 5.356235
R3813 n1_m1_153600_153600 n1_m1_158400_153600 5.356235
R3814 n1_m1_158400_153600 n1_m1_163200_153600 5.356235
R3815 n1_m1_163200_153600 n1_m1_168000_153600 5.356235
R3816 n1_m1_168000_153600 n1_m1_172000_153600 4.463529
R3817 n1_m1_172800_153600 n1_m1_172000_153600 0.892706
R3818 n1_m1_172800_153600 n1_m1_177600_153600 5.356235
R3819 n1_m1_177600_153600 n1_m1_182400_153600 5.356235
R3820 n1_m1_182400_153600 n1_m1_187200_153600 5.356235
R3821 n1_m1_187200_153600 n1_m1_192000_153600 5.356235
R3822 n1_m1_192000_153600 n1_m1_196800_153600 5.356235
R3823 n1_m1_196800_153600 n1_m1_200000_153600 3.570824
R3824 n1_m1_201600_153600 n1_m1_200000_153600 1.785412
R3825 n1_m1_201600_153600 n1_m1_206400_153600 5.356235
R3826 n1_m1_206400_153600 n1_m1_211200_153600 5.356235
R3827 n1_m1_211200_153600 n1_m1_216000_153600 5.356235
R3828 n1_m1_216000_153600 n1_m1_220800_153600 5.356235
R3829 n1_m1_220800_153600 n1_m1_225600_153600 5.356235
R3830 n1_m1_225600_153600 n1_m1_228000_153600 2.678118
R3831 n1_m1_230400_153600 n1_m1_228000_153600 2.678118
R3832 n1_m1_230400_153600 n1_m1_235200_153600 5.356235
R3833 n1_m1_235200_153600 n1_m1_240000_153600 5.356235
R3834 n1_m1_240000_153600 n1_m1_244800_153600 5.356235
R3835 n1_m1_244800_153600 n1_m1_249600_153600 5.356235
R3836 n1_m1_249600_153600 n1_m1_254400_153600 5.356235
R3837 n1_m1_254400_153600 n1_m1_256000_153600 1.785412
R3838 n1_m1_259200_153600 n1_m1_256000_153600 3.570824
R3839 n1_m1_259200_153600 n1_m1_264000_153600 5.356235
R3840 n1_m1_264000_153600 n1_m1_268800_153600 5.356235
R3841 n1_m1_268800_153600 n1_m1_273600_153600 5.356235
R3842 n1_m1_273600_153600 n1_m1_278400_153600 5.356235
R3843 n1_m1_278400_153600 n1_m1_283200_153600 5.356235
R3844 n1_m1_283200_153600 n1_m1_284000_153600 0.892706
R3845 n1_m1_288000_153600 n1_m1_284000_153600 4.463529
R3846 n1_m1_288000_153600 n1_m1_292800_153600 5.356235
R3847 n1_m1_292800_153600 n1_m1_297600_153600 5.356235
R3848 n1_m1_297600_153600 n1_m1_302400_153600 5.356235
R3849 n1_m1_302400_153600 n1_m1_307200_153600 5.356235
R3850 n1_m1_307200_153600 n1_m1_312000_153600 5.356235
R3851 n1_m1_312000_153600 n1_m1_316800_153600 5.356235
R3852 n1_m1_316800_153600 n1_m1_321600_153600 5.356235
R3853 n1_m1_321600_153600 n1_m1_326400_153600 5.356235
R3854 n1_m1_326400_153600 n1_m1_331200_153600 5.356235
R3855 n1_m1_331200_153600 n1_m1_336000_153600 5.356235
R3856 n1_m1_336000_153600 n1_m1_340000_153600 4.463529
R3857 n1_m1_340800_153600 n1_m1_340000_153600 0.892706
R3858 n1_m1_340800_153600 n1_m1_345600_153600 5.356235
R3859 n1_m1_345600_153600 n1_m1_350400_153600 5.356235
R3860 n1_m1_350400_153600 n1_m1_355200_153600 5.356235
R3861 n1_m1_355200_153600 n1_m1_360000_153600 5.356235
R3862 n1_m1_360000_153600 n1_m1_364800_153600 5.356235
R3863 n1_m1_364800_153600 n1_m1_368000_153600 3.570824
R3864 n1_m1_369600_153600 n1_m1_368000_153600 1.785412
R3865 n1_m1_369600_153600 n1_m1_374400_153600 5.356235
R3866 n1_m1_374400_153600 n1_m1_379200_153600 5.356235
R3867 n1_m1_379200_153600 n1_m1_384000_153600 5.356235
R3868 n1_m1_384000_153600 n1_m1_388800_153600 5.356235
R3869 n1_m1_388800_153600 n1_m1_393600_153600 5.356235
R3870 n1_m1_393600_153600 n1_m1_396000_153600 2.678118
R3871 n1_m1_398400_153600 n1_m1_396000_153600 2.678118
R3872 n1_m1_398400_153600 n1_m1_403200_153600 5.356235
R3873 n1_m1_403200_153600 n1_m1_408000_153600 5.356235
R3874 n1_m1_408000_153600 n1_m1_412800_153600 5.356235
R3875 n1_m1_412800_153600 n1_m1_417600_153600 5.356235
R3876 n1_m1_417600_153600 n1_m1_422400_153600 5.356235
R3877 n1_m1_422400_153600 n1_m1_424000_153600 1.785412
R3878 n1_m1_427200_153600 n1_m1_424000_153600 3.570824
R3879 n1_m1_427200_153600 n1_m1_432000_153600 5.356235
R3880 n1_m1_432000_153600 n1_m1_436800_153600 5.356235
R3881 n1_m1_436800_153600 n1_m1_441600_153600 5.356235
R3882 n1_m1_441600_153600 n1_m1_446400_153600 5.356235
R3883 n1_m1_446400_153600 n1_m1_451200_153600 5.356235
R3884 n1_m1_451200_153600 n1_m1_452000_153600 0.892706
R3885 n1_m1_456000_153600 n1_m1_452000_153600 4.463529
R3886 n1_m1_456000_153600 n1_m1_460800_153600 5.356235
R3887 n1_m1_460800_153600 n1_m1_465600_153600 5.356235
R3888 n1_m1_465600_153600 n1_m1_470400_153600 5.356235
R3889 n1_m1_470400_153600 n1_m1_475200_153600 5.356235
R3890 n1_m1_475200_153600 n1_m1_480000_153600 5.356235
R3891 n1_m1_480000_153600 n1_m1_484800_153600 5.356235
R3892 n1_m1_484800_153600 n1_m1_489600_153600 5.356235
R3893 n1_m1_489600_153600 n1_m1_494400_153600 5.356235
R3894 n1_m1_0_158400 n1_m1_4000_158400 4.463529
R3895 n1_m1_4800_158400 n1_m1_4000_158400 0.892706
R3896 n1_m1_4800_158400 n1_m1_9600_158400 5.356235
R3897 n1_m1_9600_158400 n1_m1_14400_158400 5.356235
R3898 n1_m1_14400_158400 n1_m1_19200_158400 5.356235
R3899 n1_m1_19200_158400 n1_m1_24000_158400 5.356235
R3900 n1_m1_24000_158400 n1_m1_28800_158400 5.356235
R3901 n1_m1_28800_158400 n1_m1_32000_158400 3.570824
R3902 n1_m1_33600_158400 n1_m1_32000_158400 1.785412
R3903 n1_m1_33600_158400 n1_m1_38400_158400 5.356235
R3904 n1_m1_38400_158400 n1_m1_43200_158400 5.356235
R3905 n1_m1_43200_158400 n1_m1_48000_158400 5.356235
R3906 n1_m1_48000_158400 n1_m1_52800_158400 5.356235
R3907 n1_m1_52800_158400 n1_m1_57600_158400 5.356235
R3908 n1_m1_57600_158400 n1_m1_60000_158400 2.678118
R3909 n1_m1_62400_158400 n1_m1_60000_158400 2.678118
R3910 n1_m1_62400_158400 n1_m1_67200_158400 5.356235
R3911 n1_m1_67200_158400 n1_m1_72000_158400 5.356235
R3912 n1_m1_72000_158400 n1_m1_76800_158400 5.356235
R3913 n1_m1_76800_158400 n1_m1_81600_158400 5.356235
R3914 n1_m1_81600_158400 n1_m1_86400_158400 5.356235
R3915 n1_m1_86400_158400 n1_m1_88000_158400 1.785412
R3916 n1_m1_91200_158400 n1_m1_88000_158400 3.570824
R3917 n1_m1_91200_158400 n1_m1_96000_158400 5.356235
R3918 n1_m1_96000_158400 n1_m1_100800_158400 5.356235
R3919 n1_m1_100800_158400 n1_m1_105600_158400 5.356235
R3920 n1_m1_105600_158400 n1_m1_110400_158400 5.356235
R3921 n1_m1_110400_158400 n1_m1_115200_158400 5.356235
R3922 n1_m1_115200_158400 n1_m1_116000_158400 0.892706
R3923 n1_m1_120000_158400 n1_m1_116000_158400 4.463529
R3924 n1_m1_120000_158400 n1_m1_124800_158400 5.356235
R3925 n1_m1_124800_158400 n1_m1_129600_158400 5.356235
R3926 n1_m1_129600_158400 n1_m1_134400_158400 5.356235
R3927 n1_m1_134400_158400 n1_m1_139200_158400 5.356235
R3928 n1_m1_139200_158400 n1_m1_144000_158400 5.356235
R3929 n1_m1_144000_158400 n1_m1_148800_158400 5.356235
R3930 n1_m1_148800_158400 n1_m1_153600_158400 5.356235
R3931 n1_m1_153600_158400 n1_m1_158400_158400 5.356235
R3932 n1_m1_158400_158400 n1_m1_163200_158400 5.356235
R3933 n1_m1_163200_158400 n1_m1_168000_158400 5.356235
R3934 n1_m1_168000_158400 n1_m1_172000_158400 4.463529
R3935 n1_m1_172800_158400 n1_m1_172000_158400 0.892706
R3936 n1_m1_172800_158400 n1_m1_177600_158400 5.356235
R3937 n1_m1_177600_158400 n1_m1_182400_158400 5.356235
R3938 n1_m1_182400_158400 n1_m1_187200_158400 5.356235
R3939 n1_m1_187200_158400 n1_m1_192000_158400 5.356235
R3940 n1_m1_192000_158400 n1_m1_196800_158400 5.356235
R3941 n1_m1_196800_158400 n1_m1_200000_158400 3.570824
R3942 n1_m1_201600_158400 n1_m1_200000_158400 1.785412
R3943 n1_m1_201600_158400 n1_m1_206400_158400 5.356235
R3944 n1_m1_206400_158400 n1_m1_211200_158400 5.356235
R3945 n1_m1_211200_158400 n1_m1_216000_158400 5.356235
R3946 n1_m1_216000_158400 n1_m1_220800_158400 5.356235
R3947 n1_m1_220800_158400 n1_m1_225600_158400 5.356235
R3948 n1_m1_225600_158400 n1_m1_228000_158400 2.678118
R3949 n1_m1_230400_158400 n1_m1_228000_158400 2.678118
R3950 n1_m1_230400_158400 n1_m1_235200_158400 5.356235
R3951 n1_m1_235200_158400 n1_m1_240000_158400 5.356235
R3952 n1_m1_240000_158400 n1_m1_244800_158400 5.356235
R3953 n1_m1_244800_158400 n1_m1_249600_158400 5.356235
R3954 n1_m1_249600_158400 n1_m1_254400_158400 5.356235
R3955 n1_m1_254400_158400 n1_m1_256000_158400 1.785412
R3956 n1_m1_259200_158400 n1_m1_256000_158400 3.570824
R3957 n1_m1_259200_158400 n1_m1_264000_158400 5.356235
R3958 n1_m1_264000_158400 n1_m1_268800_158400 5.356235
R3959 n1_m1_268800_158400 n1_m1_273600_158400 5.356235
R3960 n1_m1_273600_158400 n1_m1_278400_158400 5.356235
R3961 n1_m1_278400_158400 n1_m1_283200_158400 5.356235
R3962 n1_m1_283200_158400 n1_m1_284000_158400 0.892706
R3963 n1_m1_288000_158400 n1_m1_284000_158400 4.463529
R3964 n1_m1_288000_158400 n1_m1_292800_158400 5.356235
R3965 n1_m1_292800_158400 n1_m1_297600_158400 5.356235
R3966 n1_m1_297600_158400 n1_m1_302400_158400 5.356235
R3967 n1_m1_302400_158400 n1_m1_307200_158400 5.356235
R3968 n1_m1_307200_158400 n1_m1_312000_158400 5.356235
R3969 n1_m1_312000_158400 n1_m1_316800_158400 5.356235
R3970 n1_m1_316800_158400 n1_m1_321600_158400 5.356235
R3971 n1_m1_321600_158400 n1_m1_326400_158400 5.356235
R3972 n1_m1_326400_158400 n1_m1_331200_158400 5.356235
R3973 n1_m1_331200_158400 n1_m1_336000_158400 5.356235
R3974 n1_m1_336000_158400 n1_m1_340000_158400 4.463529
R3975 n1_m1_340800_158400 n1_m1_340000_158400 0.892706
R3976 n1_m1_340800_158400 n1_m1_345600_158400 5.356235
R3977 n1_m1_345600_158400 n1_m1_350400_158400 5.356235
R3978 n1_m1_350400_158400 n1_m1_355200_158400 5.356235
R3979 n1_m1_355200_158400 n1_m1_360000_158400 5.356235
R3980 n1_m1_360000_158400 n1_m1_364800_158400 5.356235
R3981 n1_m1_364800_158400 n1_m1_368000_158400 3.570824
R3982 n1_m1_369600_158400 n1_m1_368000_158400 1.785412
R3983 n1_m1_369600_158400 n1_m1_374400_158400 5.356235
R3984 n1_m1_374400_158400 n1_m1_379200_158400 5.356235
R3985 n1_m1_379200_158400 n1_m1_384000_158400 5.356235
R3986 n1_m1_384000_158400 n1_m1_388800_158400 5.356235
R3987 n1_m1_388800_158400 n1_m1_393600_158400 5.356235
R3988 n1_m1_393600_158400 n1_m1_396000_158400 2.678118
R3989 n1_m1_398400_158400 n1_m1_396000_158400 2.678118
R3990 n1_m1_398400_158400 n1_m1_403200_158400 5.356235
R3991 n1_m1_403200_158400 n1_m1_408000_158400 5.356235
R3992 n1_m1_408000_158400 n1_m1_412800_158400 5.356235
R3993 n1_m1_412800_158400 n1_m1_417600_158400 5.356235
R3994 n1_m1_417600_158400 n1_m1_422400_158400 5.356235
R3995 n1_m1_422400_158400 n1_m1_424000_158400 1.785412
R3996 n1_m1_427200_158400 n1_m1_424000_158400 3.570824
R3997 n1_m1_427200_158400 n1_m1_432000_158400 5.356235
R3998 n1_m1_432000_158400 n1_m1_436800_158400 5.356235
R3999 n1_m1_436800_158400 n1_m1_441600_158400 5.356235
R4000 n1_m1_441600_158400 n1_m1_446400_158400 5.356235
R4001 n1_m1_446400_158400 n1_m1_451200_158400 5.356235
R4002 n1_m1_451200_158400 n1_m1_452000_158400 0.892706
R4003 n1_m1_456000_158400 n1_m1_452000_158400 4.463529
R4004 n1_m1_456000_158400 n1_m1_460800_158400 5.356235
R4005 n1_m1_460800_158400 n1_m1_465600_158400 5.356235
R4006 n1_m1_465600_158400 n1_m1_470400_158400 5.356235
R4007 n1_m1_470400_158400 n1_m1_475200_158400 5.356235
R4008 n1_m1_475200_158400 n1_m1_480000_158400 5.356235
R4009 n1_m1_480000_158400 n1_m1_484800_158400 5.356235
R4010 n1_m1_484800_158400 n1_m1_489600_158400 5.356235
R4011 n1_m1_489600_158400 n1_m1_494400_158400 5.356235
R4012 n1_m1_0_163200 n1_m1_4000_163200 4.463529
R4013 n1_m1_4800_163200 n1_m1_4000_163200 0.892706
R4014 n1_m1_4800_163200 n1_m1_9600_163200 5.356235
R4015 n1_m1_9600_163200 n1_m1_14400_163200 5.356235
R4016 n1_m1_14400_163200 n1_m1_19200_163200 5.356235
R4017 n1_m1_19200_163200 n1_m1_24000_163200 5.356235
R4018 n1_m1_24000_163200 n1_m1_28800_163200 5.356235
R4019 n1_m1_28800_163200 n1_m1_32000_163200 3.570824
R4020 n1_m1_33600_163200 n1_m1_32000_163200 1.785412
R4021 n1_m1_33600_163200 n1_m1_38400_163200 5.356235
R4022 n1_m1_38400_163200 n1_m1_43200_163200 5.356235
R4023 n1_m1_43200_163200 n1_m1_48000_163200 5.356235
R4024 n1_m1_48000_163200 n1_m1_52800_163200 5.356235
R4025 n1_m1_52800_163200 n1_m1_57600_163200 5.356235
R4026 n1_m1_57600_163200 n1_m1_60000_163200 2.678118
R4027 n1_m1_62400_163200 n1_m1_60000_163200 2.678118
R4028 n1_m1_62400_163200 n1_m1_67200_163200 5.356235
R4029 n1_m1_67200_163200 n1_m1_72000_163200 5.356235
R4030 n1_m1_72000_163200 n1_m1_76800_163200 5.356235
R4031 n1_m1_76800_163200 n1_m1_81600_163200 5.356235
R4032 n1_m1_81600_163200 n1_m1_86400_163200 5.356235
R4033 n1_m1_86400_163200 n1_m1_88000_163200 1.785412
R4034 n1_m1_91200_163200 n1_m1_88000_163200 3.570824
R4035 n1_m1_91200_163200 n1_m1_96000_163200 5.356235
R4036 n1_m1_96000_163200 n1_m1_100800_163200 5.356235
R4037 n1_m1_100800_163200 n1_m1_105600_163200 5.356235
R4038 n1_m1_105600_163200 n1_m1_110400_163200 5.356235
R4039 n1_m1_110400_163200 n1_m1_115200_163200 5.356235
R4040 n1_m1_115200_163200 n1_m1_116000_163200 0.892706
R4041 n1_m1_120000_163200 n1_m1_116000_163200 4.463529
R4042 n1_m1_120000_163200 n1_m1_124800_163200 5.356235
R4043 n1_m1_124800_163200 n1_m1_129600_163200 5.356235
R4044 n1_m1_129600_163200 n1_m1_134400_163200 5.356235
R4045 n1_m1_134400_163200 n1_m1_139200_163200 5.356235
R4046 n1_m1_139200_163200 n1_m1_144000_163200 5.356235
R4047 n1_m1_144000_163200 n1_m1_148800_163200 5.356235
R4048 n1_m1_148800_163200 n1_m1_153600_163200 5.356235
R4049 n1_m1_153600_163200 n1_m1_158400_163200 5.356235
R4050 n1_m1_158400_163200 n1_m1_163200_163200 5.356235
R4051 n1_m1_163200_163200 n1_m1_168000_163200 5.356235
R4052 n1_m1_168000_163200 n1_m1_172000_163200 4.463529
R4053 n1_m1_172800_163200 n1_m1_172000_163200 0.892706
R4054 n1_m1_172800_163200 n1_m1_177600_163200 5.356235
R4055 n1_m1_177600_163200 n1_m1_182400_163200 5.356235
R4056 n1_m1_182400_163200 n1_m1_187200_163200 5.356235
R4057 n1_m1_187200_163200 n1_m1_192000_163200 5.356235
R4058 n1_m1_192000_163200 n1_m1_196800_163200 5.356235
R4059 n1_m1_196800_163200 n1_m1_200000_163200 3.570824
R4060 n1_m1_201600_163200 n1_m1_200000_163200 1.785412
R4061 n1_m1_201600_163200 n1_m1_206400_163200 5.356235
R4062 n1_m1_206400_163200 n1_m1_211200_163200 5.356235
R4063 n1_m1_211200_163200 n1_m1_216000_163200 5.356235
R4064 n1_m1_216000_163200 n1_m1_220800_163200 5.356235
R4065 n1_m1_220800_163200 n1_m1_225600_163200 5.356235
R4066 n1_m1_225600_163200 n1_m1_228000_163200 2.678118
R4067 n1_m1_230400_163200 n1_m1_228000_163200 2.678118
R4068 n1_m1_230400_163200 n1_m1_235200_163200 5.356235
R4069 n1_m1_235200_163200 n1_m1_240000_163200 5.356235
R4070 n1_m1_240000_163200 n1_m1_244800_163200 5.356235
R4071 n1_m1_244800_163200 n1_m1_249600_163200 5.356235
R4072 n1_m1_249600_163200 n1_m1_254400_163200 5.356235
R4073 n1_m1_254400_163200 n1_m1_256000_163200 1.785412
R4074 n1_m1_259200_163200 n1_m1_256000_163200 3.570824
R4075 n1_m1_259200_163200 n1_m1_264000_163200 5.356235
R4076 n1_m1_264000_163200 n1_m1_268800_163200 5.356235
R4077 n1_m1_268800_163200 n1_m1_273600_163200 5.356235
R4078 n1_m1_273600_163200 n1_m1_278400_163200 5.356235
R4079 n1_m1_278400_163200 n1_m1_283200_163200 5.356235
R4080 n1_m1_283200_163200 n1_m1_284000_163200 0.892706
R4081 n1_m1_288000_163200 n1_m1_284000_163200 4.463529
R4082 n1_m1_288000_163200 n1_m1_292800_163200 5.356235
R4083 n1_m1_292800_163200 n1_m1_297600_163200 5.356235
R4084 n1_m1_297600_163200 n1_m1_302400_163200 5.356235
R4085 n1_m1_302400_163200 n1_m1_307200_163200 5.356235
R4086 n1_m1_307200_163200 n1_m1_312000_163200 5.356235
R4087 n1_m1_312000_163200 n1_m1_316800_163200 5.356235
R4088 n1_m1_316800_163200 n1_m1_321600_163200 5.356235
R4089 n1_m1_321600_163200 n1_m1_326400_163200 5.356235
R4090 n1_m1_326400_163200 n1_m1_331200_163200 5.356235
R4091 n1_m1_331200_163200 n1_m1_336000_163200 5.356235
R4092 n1_m1_336000_163200 n1_m1_340000_163200 4.463529
R4093 n1_m1_340800_163200 n1_m1_340000_163200 0.892706
R4094 n1_m1_340800_163200 n1_m1_345600_163200 5.356235
R4095 n1_m1_345600_163200 n1_m1_350400_163200 5.356235
R4096 n1_m1_350400_163200 n1_m1_355200_163200 5.356235
R4097 n1_m1_355200_163200 n1_m1_360000_163200 5.356235
R4098 n1_m1_360000_163200 n1_m1_364800_163200 5.356235
R4099 n1_m1_364800_163200 n1_m1_368000_163200 3.570824
R4100 n1_m1_369600_163200 n1_m1_368000_163200 1.785412
R4101 n1_m1_369600_163200 n1_m1_374400_163200 5.356235
R4102 n1_m1_374400_163200 n1_m1_379200_163200 5.356235
R4103 n1_m1_379200_163200 n1_m1_384000_163200 5.356235
R4104 n1_m1_384000_163200 n1_m1_388800_163200 5.356235
R4105 n1_m1_388800_163200 n1_m1_393600_163200 5.356235
R4106 n1_m1_393600_163200 n1_m1_396000_163200 2.678118
R4107 n1_m1_398400_163200 n1_m1_396000_163200 2.678118
R4108 n1_m1_398400_163200 n1_m1_403200_163200 5.356235
R4109 n1_m1_403200_163200 n1_m1_408000_163200 5.356235
R4110 n1_m1_408000_163200 n1_m1_412800_163200 5.356235
R4111 n1_m1_412800_163200 n1_m1_417600_163200 5.356235
R4112 n1_m1_417600_163200 n1_m1_422400_163200 5.356235
R4113 n1_m1_422400_163200 n1_m1_424000_163200 1.785412
R4114 n1_m1_427200_163200 n1_m1_424000_163200 3.570824
R4115 n1_m1_427200_163200 n1_m1_432000_163200 5.356235
R4116 n1_m1_432000_163200 n1_m1_436800_163200 5.356235
R4117 n1_m1_436800_163200 n1_m1_441600_163200 5.356235
R4118 n1_m1_441600_163200 n1_m1_446400_163200 5.356235
R4119 n1_m1_446400_163200 n1_m1_451200_163200 5.356235
R4120 n1_m1_451200_163200 n1_m1_452000_163200 0.892706
R4121 n1_m1_456000_163200 n1_m1_452000_163200 4.463529
R4122 n1_m1_456000_163200 n1_m1_460800_163200 5.356235
R4123 n1_m1_460800_163200 n1_m1_465600_163200 5.356235
R4124 n1_m1_465600_163200 n1_m1_470400_163200 5.356235
R4125 n1_m1_470400_163200 n1_m1_475200_163200 5.356235
R4126 n1_m1_475200_163200 n1_m1_480000_163200 5.356235
R4127 n1_m1_480000_163200 n1_m1_484800_163200 5.356235
R4128 n1_m1_484800_163200 n1_m1_489600_163200 5.356235
R4129 n1_m1_489600_163200 n1_m1_494400_163200 5.356235
R4130 n1_m1_0_168000 n1_m1_4000_168000 4.463529
R4131 n1_m1_4800_168000 n1_m1_4000_168000 0.892706
R4132 n1_m1_4800_168000 n1_m1_9600_168000 5.356235
R4133 n1_m1_9600_168000 n1_m1_14400_168000 5.356235
R4134 n1_m1_14400_168000 n1_m1_19200_168000 5.356235
R4135 n1_m1_19200_168000 n1_m1_24000_168000 5.356235
R4136 n1_m1_24000_168000 n1_m1_28800_168000 5.356235
R4137 n1_m1_28800_168000 n1_m1_32000_168000 3.570824
R4138 n1_m1_33600_168000 n1_m1_32000_168000 1.785412
R4139 n1_m1_33600_168000 n1_m1_38400_168000 5.356235
R4140 n1_m1_38400_168000 n1_m1_43200_168000 5.356235
R4141 n1_m1_43200_168000 n1_m1_48000_168000 5.356235
R4142 n1_m1_48000_168000 n1_m1_52800_168000 5.356235
R4143 n1_m1_52800_168000 n1_m1_57600_168000 5.356235
R4144 n1_m1_57600_168000 n1_m1_60000_168000 2.678118
R4145 n1_m1_62400_168000 n1_m1_60000_168000 2.678118
R4146 n1_m1_62400_168000 n1_m1_67200_168000 5.356235
R4147 n1_m1_67200_168000 n1_m1_72000_168000 5.356235
R4148 n1_m1_72000_168000 n1_m1_76800_168000 5.356235
R4149 n1_m1_76800_168000 n1_m1_81600_168000 5.356235
R4150 n1_m1_81600_168000 n1_m1_86400_168000 5.356235
R4151 n1_m1_86400_168000 n1_m1_88000_168000 1.785412
R4152 n1_m1_91200_168000 n1_m1_88000_168000 3.570824
R4153 n1_m1_91200_168000 n1_m1_96000_168000 5.356235
R4154 n1_m1_96000_168000 n1_m1_100800_168000 5.356235
R4155 n1_m1_100800_168000 n1_m1_105600_168000 5.356235
R4156 n1_m1_105600_168000 n1_m1_110400_168000 5.356235
R4157 n1_m1_110400_168000 n1_m1_115200_168000 5.356235
R4158 n1_m1_115200_168000 n1_m1_116000_168000 0.892706
R4159 n1_m1_120000_168000 n1_m1_116000_168000 4.463529
R4160 n1_m1_120000_168000 n1_m1_124800_168000 5.356235
R4161 n1_m1_124800_168000 n1_m1_129600_168000 5.356235
R4162 n1_m1_129600_168000 n1_m1_134400_168000 5.356235
R4163 n1_m1_134400_168000 n1_m1_139200_168000 5.356235
R4164 n1_m1_139200_168000 n1_m1_144000_168000 5.356235
R4165 n1_m1_144000_168000 n1_m1_148800_168000 5.356235
R4166 n1_m1_148800_168000 n1_m1_153600_168000 5.356235
R4167 n1_m1_153600_168000 n1_m1_158400_168000 5.356235
R4168 n1_m1_158400_168000 n1_m1_163200_168000 5.356235
R4169 n1_m1_163200_168000 n1_m1_168000_168000 5.356235
R4170 n1_m1_168000_168000 n1_m1_172000_168000 4.463529
R4171 n1_m1_172800_168000 n1_m1_172000_168000 0.892706
R4172 n1_m1_172800_168000 n1_m1_177600_168000 5.356235
R4173 n1_m1_177600_168000 n1_m1_182400_168000 5.356235
R4174 n1_m1_182400_168000 n1_m1_187200_168000 5.356235
R4175 n1_m1_187200_168000 n1_m1_192000_168000 5.356235
R4176 n1_m1_192000_168000 n1_m1_196800_168000 5.356235
R4177 n1_m1_196800_168000 n1_m1_200000_168000 3.570824
R4178 n1_m1_201600_168000 n1_m1_200000_168000 1.785412
R4179 n1_m1_201600_168000 n1_m1_206400_168000 5.356235
R4180 n1_m1_206400_168000 n1_m1_211200_168000 5.356235
R4181 n1_m1_211200_168000 n1_m1_216000_168000 5.356235
R4182 n1_m1_216000_168000 n1_m1_220800_168000 5.356235
R4183 n1_m1_220800_168000 n1_m1_225600_168000 5.356235
R4184 n1_m1_225600_168000 n1_m1_228000_168000 2.678118
R4185 n1_m1_230400_168000 n1_m1_228000_168000 2.678118
R4186 n1_m1_230400_168000 n1_m1_235200_168000 5.356235
R4187 n1_m1_235200_168000 n1_m1_240000_168000 5.356235
R4188 n1_m1_240000_168000 n1_m1_244800_168000 5.356235
R4189 n1_m1_244800_168000 n1_m1_249600_168000 5.356235
R4190 n1_m1_249600_168000 n1_m1_254400_168000 5.356235
R4191 n1_m1_254400_168000 n1_m1_256000_168000 1.785412
R4192 n1_m1_259200_168000 n1_m1_256000_168000 3.570824
R4193 n1_m1_259200_168000 n1_m1_264000_168000 5.356235
R4194 n1_m1_264000_168000 n1_m1_268800_168000 5.356235
R4195 n1_m1_268800_168000 n1_m1_273600_168000 5.356235
R4196 n1_m1_273600_168000 n1_m1_278400_168000 5.356235
R4197 n1_m1_278400_168000 n1_m1_283200_168000 5.356235
R4198 n1_m1_283200_168000 n1_m1_284000_168000 0.892706
R4199 n1_m1_288000_168000 n1_m1_284000_168000 4.463529
R4200 n1_m1_288000_168000 n1_m1_292800_168000 5.356235
R4201 n1_m1_292800_168000 n1_m1_297600_168000 5.356235
R4202 n1_m1_297600_168000 n1_m1_302400_168000 5.356235
R4203 n1_m1_302400_168000 n1_m1_307200_168000 5.356235
R4204 n1_m1_307200_168000 n1_m1_312000_168000 5.356235
R4205 n1_m1_312000_168000 n1_m1_316800_168000 5.356235
R4206 n1_m1_316800_168000 n1_m1_321600_168000 5.356235
R4207 n1_m1_321600_168000 n1_m1_326400_168000 5.356235
R4208 n1_m1_326400_168000 n1_m1_331200_168000 5.356235
R4209 n1_m1_331200_168000 n1_m1_336000_168000 5.356235
R4210 n1_m1_336000_168000 n1_m1_340000_168000 4.463529
R4211 n1_m1_340800_168000 n1_m1_340000_168000 0.892706
R4212 n1_m1_340800_168000 n1_m1_345600_168000 5.356235
R4213 n1_m1_345600_168000 n1_m1_350400_168000 5.356235
R4214 n1_m1_350400_168000 n1_m1_355200_168000 5.356235
R4215 n1_m1_355200_168000 n1_m1_360000_168000 5.356235
R4216 n1_m1_360000_168000 n1_m1_364800_168000 5.356235
R4217 n1_m1_364800_168000 n1_m1_368000_168000 3.570824
R4218 n1_m1_369600_168000 n1_m1_368000_168000 1.785412
R4219 n1_m1_369600_168000 n1_m1_374400_168000 5.356235
R4220 n1_m1_374400_168000 n1_m1_379200_168000 5.356235
R4221 n1_m1_379200_168000 n1_m1_384000_168000 5.356235
R4222 n1_m1_384000_168000 n1_m1_388800_168000 5.356235
R4223 n1_m1_388800_168000 n1_m1_393600_168000 5.356235
R4224 n1_m1_393600_168000 n1_m1_396000_168000 2.678118
R4225 n1_m1_398400_168000 n1_m1_396000_168000 2.678118
R4226 n1_m1_398400_168000 n1_m1_403200_168000 5.356235
R4227 n1_m1_403200_168000 n1_m1_408000_168000 5.356235
R4228 n1_m1_408000_168000 n1_m1_412800_168000 5.356235
R4229 n1_m1_412800_168000 n1_m1_417600_168000 5.356235
R4230 n1_m1_417600_168000 n1_m1_422400_168000 5.356235
R4231 n1_m1_422400_168000 n1_m1_424000_168000 1.785412
R4232 n1_m1_427200_168000 n1_m1_424000_168000 3.570824
R4233 n1_m1_427200_168000 n1_m1_432000_168000 5.356235
R4234 n1_m1_432000_168000 n1_m1_436800_168000 5.356235
R4235 n1_m1_436800_168000 n1_m1_441600_168000 5.356235
R4236 n1_m1_441600_168000 n1_m1_446400_168000 5.356235
R4237 n1_m1_446400_168000 n1_m1_451200_168000 5.356235
R4238 n1_m1_451200_168000 n1_m1_452000_168000 0.892706
R4239 n1_m1_456000_168000 n1_m1_452000_168000 4.463529
R4240 n1_m1_456000_168000 n1_m1_460800_168000 5.356235
R4241 n1_m1_460800_168000 n1_m1_465600_168000 5.356235
R4242 n1_m1_465600_168000 n1_m1_470400_168000 5.356235
R4243 n1_m1_470400_168000 n1_m1_475200_168000 5.356235
R4244 n1_m1_475200_168000 n1_m1_480000_168000 5.356235
R4245 n1_m1_480000_168000 n1_m1_484800_168000 5.356235
R4246 n1_m1_484800_168000 n1_m1_489600_168000 5.356235
R4247 n1_m1_489600_168000 n1_m1_494400_168000 5.356235
R4248 n1_m1_0_172800 n1_m1_4000_172800 4.463529
R4249 n1_m1_4800_172800 n1_m1_4000_172800 0.892706
R4250 n1_m1_4800_172800 n1_m1_9600_172800 5.356235
R4251 n1_m1_9600_172800 n1_m1_14400_172800 5.356235
R4252 n1_m1_14400_172800 n1_m1_19200_172800 5.356235
R4253 n1_m1_19200_172800 n1_m1_24000_172800 5.356235
R4254 n1_m1_24000_172800 n1_m1_28800_172800 5.356235
R4255 n1_m1_28800_172800 n1_m1_32000_172800 3.570824
R4256 n1_m1_33600_172800 n1_m1_32000_172800 1.785412
R4257 n1_m1_33600_172800 n1_m1_38400_172800 5.356235
R4258 n1_m1_38400_172800 n1_m1_43200_172800 5.356235
R4259 n1_m1_43200_172800 n1_m1_48000_172800 5.356235
R4260 n1_m1_48000_172800 n1_m1_52800_172800 5.356235
R4261 n1_m1_52800_172800 n1_m1_57600_172800 5.356235
R4262 n1_m1_57600_172800 n1_m1_60000_172800 2.678118
R4263 n1_m1_62400_172800 n1_m1_60000_172800 2.678118
R4264 n1_m1_62400_172800 n1_m1_67200_172800 5.356235
R4265 n1_m1_67200_172800 n1_m1_72000_172800 5.356235
R4266 n1_m1_72000_172800 n1_m1_76800_172800 5.356235
R4267 n1_m1_76800_172800 n1_m1_81600_172800 5.356235
R4268 n1_m1_81600_172800 n1_m1_86400_172800 5.356235
R4269 n1_m1_86400_172800 n1_m1_88000_172800 1.785412
R4270 n1_m1_91200_172800 n1_m1_88000_172800 3.570824
R4271 n1_m1_91200_172800 n1_m1_96000_172800 5.356235
R4272 n1_m1_96000_172800 n1_m1_100800_172800 5.356235
R4273 n1_m1_100800_172800 n1_m1_105600_172800 5.356235
R4274 n1_m1_105600_172800 n1_m1_110400_172800 5.356235
R4275 n1_m1_110400_172800 n1_m1_115200_172800 5.356235
R4276 n1_m1_115200_172800 n1_m1_116000_172800 0.892706
R4277 n1_m1_120000_172800 n1_m1_116000_172800 4.463529
R4278 n1_m1_120000_172800 n1_m1_124800_172800 5.356235
R4279 n1_m1_124800_172800 n1_m1_129600_172800 5.356235
R4280 n1_m1_129600_172800 n1_m1_134400_172800 5.356235
R4281 n1_m1_134400_172800 n1_m1_139200_172800 5.356235
R4282 n1_m1_139200_172800 n1_m1_144000_172800 5.356235
R4283 n1_m1_144000_172800 n1_m1_148800_172800 5.356235
R4284 n1_m1_148800_172800 n1_m1_153600_172800 5.356235
R4285 n1_m1_153600_172800 n1_m1_158400_172800 5.356235
R4286 n1_m1_158400_172800 n1_m1_163200_172800 5.356235
R4287 n1_m1_163200_172800 n1_m1_168000_172800 5.356235
R4288 n1_m1_168000_172800 n1_m1_172000_172800 4.463529
R4289 n1_m1_172800_172800 n1_m1_172000_172800 0.892706
R4290 n1_m1_172800_172800 n1_m1_177600_172800 5.356235
R4291 n1_m1_177600_172800 n1_m1_182400_172800 5.356235
R4292 n1_m1_182400_172800 n1_m1_187200_172800 5.356235
R4293 n1_m1_187200_172800 n1_m1_192000_172800 5.356235
R4294 n1_m1_192000_172800 n1_m1_196800_172800 5.356235
R4295 n1_m1_196800_172800 n1_m1_200000_172800 3.570824
R4296 n1_m1_201600_172800 n1_m1_200000_172800 1.785412
R4297 n1_m1_201600_172800 n1_m1_206400_172800 5.356235
R4298 n1_m1_206400_172800 n1_m1_211200_172800 5.356235
R4299 n1_m1_211200_172800 n1_m1_216000_172800 5.356235
R4300 n1_m1_216000_172800 n1_m1_220800_172800 5.356235
R4301 n1_m1_220800_172800 n1_m1_225600_172800 5.356235
R4302 n1_m1_225600_172800 n1_m1_228000_172800 2.678118
R4303 n1_m1_230400_172800 n1_m1_228000_172800 2.678118
R4304 n1_m1_230400_172800 n1_m1_235200_172800 5.356235
R4305 n1_m1_235200_172800 n1_m1_240000_172800 5.356235
R4306 n1_m1_240000_172800 n1_m1_244800_172800 5.356235
R4307 n1_m1_244800_172800 n1_m1_249600_172800 5.356235
R4308 n1_m1_249600_172800 n1_m1_254400_172800 5.356235
R4309 n1_m1_254400_172800 n1_m1_256000_172800 1.785412
R4310 n1_m1_259200_172800 n1_m1_256000_172800 3.570824
R4311 n1_m1_259200_172800 n1_m1_264000_172800 5.356235
R4312 n1_m1_264000_172800 n1_m1_268800_172800 5.356235
R4313 n1_m1_268800_172800 n1_m1_273600_172800 5.356235
R4314 n1_m1_273600_172800 n1_m1_278400_172800 5.356235
R4315 n1_m1_278400_172800 n1_m1_283200_172800 5.356235
R4316 n1_m1_283200_172800 n1_m1_284000_172800 0.892706
R4317 n1_m1_288000_172800 n1_m1_284000_172800 4.463529
R4318 n1_m1_288000_172800 n1_m1_292800_172800 5.356235
R4319 n1_m1_292800_172800 n1_m1_297600_172800 5.356235
R4320 n1_m1_297600_172800 n1_m1_302400_172800 5.356235
R4321 n1_m1_302400_172800 n1_m1_307200_172800 5.356235
R4322 n1_m1_307200_172800 n1_m1_312000_172800 5.356235
R4323 n1_m1_312000_172800 n1_m1_316800_172800 5.356235
R4324 n1_m1_316800_172800 n1_m1_321600_172800 5.356235
R4325 n1_m1_321600_172800 n1_m1_326400_172800 5.356235
R4326 n1_m1_326400_172800 n1_m1_331200_172800 5.356235
R4327 n1_m1_331200_172800 n1_m1_336000_172800 5.356235
R4328 n1_m1_336000_172800 n1_m1_340000_172800 4.463529
R4329 n1_m1_340800_172800 n1_m1_340000_172800 0.892706
R4330 n1_m1_340800_172800 n1_m1_345600_172800 5.356235
R4331 n1_m1_345600_172800 n1_m1_350400_172800 5.356235
R4332 n1_m1_350400_172800 n1_m1_355200_172800 5.356235
R4333 n1_m1_355200_172800 n1_m1_360000_172800 5.356235
R4334 n1_m1_360000_172800 n1_m1_364800_172800 5.356235
R4335 n1_m1_364800_172800 n1_m1_368000_172800 3.570824
R4336 n1_m1_369600_172800 n1_m1_368000_172800 1.785412
R4337 n1_m1_369600_172800 n1_m1_374400_172800 5.356235
R4338 n1_m1_374400_172800 n1_m1_379200_172800 5.356235
R4339 n1_m1_379200_172800 n1_m1_384000_172800 5.356235
R4340 n1_m1_384000_172800 n1_m1_388800_172800 5.356235
R4341 n1_m1_388800_172800 n1_m1_393600_172800 5.356235
R4342 n1_m1_393600_172800 n1_m1_396000_172800 2.678118
R4343 n1_m1_398400_172800 n1_m1_396000_172800 2.678118
R4344 n1_m1_398400_172800 n1_m1_403200_172800 5.356235
R4345 n1_m1_403200_172800 n1_m1_408000_172800 5.356235
R4346 n1_m1_408000_172800 n1_m1_412800_172800 5.356235
R4347 n1_m1_412800_172800 n1_m1_417600_172800 5.356235
R4348 n1_m1_417600_172800 n1_m1_422400_172800 5.356235
R4349 n1_m1_422400_172800 n1_m1_424000_172800 1.785412
R4350 n1_m1_427200_172800 n1_m1_424000_172800 3.570824
R4351 n1_m1_427200_172800 n1_m1_432000_172800 5.356235
R4352 n1_m1_432000_172800 n1_m1_436800_172800 5.356235
R4353 n1_m1_436800_172800 n1_m1_441600_172800 5.356235
R4354 n1_m1_441600_172800 n1_m1_446400_172800 5.356235
R4355 n1_m1_446400_172800 n1_m1_451200_172800 5.356235
R4356 n1_m1_451200_172800 n1_m1_452000_172800 0.892706
R4357 n1_m1_456000_172800 n1_m1_452000_172800 4.463529
R4358 n1_m1_456000_172800 n1_m1_460800_172800 5.356235
R4359 n1_m1_460800_172800 n1_m1_465600_172800 5.356235
R4360 n1_m1_465600_172800 n1_m1_470400_172800 5.356235
R4361 n1_m1_470400_172800 n1_m1_475200_172800 5.356235
R4362 n1_m1_475200_172800 n1_m1_480000_172800 5.356235
R4363 n1_m1_480000_172800 n1_m1_484800_172800 5.356235
R4364 n1_m1_484800_172800 n1_m1_489600_172800 5.356235
R4365 n1_m1_489600_172800 n1_m1_494400_172800 5.356235
R4366 n1_m1_0_177600 n1_m1_4000_177600 4.463529
R4367 n1_m1_4800_177600 n1_m1_4000_177600 0.892706
R4368 n1_m1_4800_177600 n1_m1_9600_177600 5.356235
R4369 n1_m1_9600_177600 n1_m1_14400_177600 5.356235
R4370 n1_m1_14400_177600 n1_m1_19200_177600 5.356235
R4371 n1_m1_19200_177600 n1_m1_24000_177600 5.356235
R4372 n1_m1_24000_177600 n1_m1_28800_177600 5.356235
R4373 n1_m1_28800_177600 n1_m1_32000_177600 3.570824
R4374 n1_m1_33600_177600 n1_m1_32000_177600 1.785412
R4375 n1_m1_33600_177600 n1_m1_38400_177600 5.356235
R4376 n1_m1_38400_177600 n1_m1_43200_177600 5.356235
R4377 n1_m1_43200_177600 n1_m1_48000_177600 5.356235
R4378 n1_m1_48000_177600 n1_m1_52800_177600 5.356235
R4379 n1_m1_52800_177600 n1_m1_57600_177600 5.356235
R4380 n1_m1_57600_177600 n1_m1_60000_177600 2.678118
R4381 n1_m1_62400_177600 n1_m1_60000_177600 2.678118
R4382 n1_m1_62400_177600 n1_m1_67200_177600 5.356235
R4383 n1_m1_67200_177600 n1_m1_72000_177600 5.356235
R4384 n1_m1_72000_177600 n1_m1_76800_177600 5.356235
R4385 n1_m1_76800_177600 n1_m1_81600_177600 5.356235
R4386 n1_m1_81600_177600 n1_m1_86400_177600 5.356235
R4387 n1_m1_86400_177600 n1_m1_88000_177600 1.785412
R4388 n1_m1_91200_177600 n1_m1_88000_177600 3.570824
R4389 n1_m1_91200_177600 n1_m1_96000_177600 5.356235
R4390 n1_m1_96000_177600 n1_m1_100800_177600 5.356235
R4391 n1_m1_100800_177600 n1_m1_105600_177600 5.356235
R4392 n1_m1_105600_177600 n1_m1_110400_177600 5.356235
R4393 n1_m1_110400_177600 n1_m1_115200_177600 5.356235
R4394 n1_m1_115200_177600 n1_m1_116000_177600 0.892706
R4395 n1_m1_120000_177600 n1_m1_116000_177600 4.463529
R4396 n1_m1_120000_177600 n1_m1_124800_177600 5.356235
R4397 n1_m1_124800_177600 n1_m1_129600_177600 5.356235
R4398 n1_m1_129600_177600 n1_m1_134400_177600 5.356235
R4399 n1_m1_134400_177600 n1_m1_139200_177600 5.356235
R4400 n1_m1_139200_177600 n1_m1_144000_177600 5.356235
R4401 n1_m1_144000_177600 n1_m1_148800_177600 5.356235
R4402 n1_m1_148800_177600 n1_m1_153600_177600 5.356235
R4403 n1_m1_153600_177600 n1_m1_158400_177600 5.356235
R4404 n1_m1_158400_177600 n1_m1_163200_177600 5.356235
R4405 n1_m1_163200_177600 n1_m1_168000_177600 5.356235
R4406 n1_m1_168000_177600 n1_m1_172000_177600 4.463529
R4407 n1_m1_172800_177600 n1_m1_172000_177600 0.892706
R4408 n1_m1_172800_177600 n1_m1_177600_177600 5.356235
R4409 n1_m1_177600_177600 n1_m1_182400_177600 5.356235
R4410 n1_m1_182400_177600 n1_m1_187200_177600 5.356235
R4411 n1_m1_187200_177600 n1_m1_192000_177600 5.356235
R4412 n1_m1_192000_177600 n1_m1_196800_177600 5.356235
R4413 n1_m1_196800_177600 n1_m1_200000_177600 3.570824
R4414 n1_m1_201600_177600 n1_m1_200000_177600 1.785412
R4415 n1_m1_201600_177600 n1_m1_206400_177600 5.356235
R4416 n1_m1_206400_177600 n1_m1_211200_177600 5.356235
R4417 n1_m1_211200_177600 n1_m1_216000_177600 5.356235
R4418 n1_m1_216000_177600 n1_m1_220800_177600 5.356235
R4419 n1_m1_220800_177600 n1_m1_225600_177600 5.356235
R4420 n1_m1_225600_177600 n1_m1_228000_177600 2.678118
R4421 n1_m1_230400_177600 n1_m1_228000_177600 2.678118
R4422 n1_m1_230400_177600 n1_m1_235200_177600 5.356235
R4423 n1_m1_235200_177600 n1_m1_240000_177600 5.356235
R4424 n1_m1_240000_177600 n1_m1_244800_177600 5.356235
R4425 n1_m1_244800_177600 n1_m1_249600_177600 5.356235
R4426 n1_m1_249600_177600 n1_m1_254400_177600 5.356235
R4427 n1_m1_254400_177600 n1_m1_256000_177600 1.785412
R4428 n1_m1_259200_177600 n1_m1_256000_177600 3.570824
R4429 n1_m1_259200_177600 n1_m1_264000_177600 5.356235
R4430 n1_m1_264000_177600 n1_m1_268800_177600 5.356235
R4431 n1_m1_268800_177600 n1_m1_273600_177600 5.356235
R4432 n1_m1_273600_177600 n1_m1_278400_177600 5.356235
R4433 n1_m1_278400_177600 n1_m1_283200_177600 5.356235
R4434 n1_m1_283200_177600 n1_m1_284000_177600 0.892706
R4435 n1_m1_288000_177600 n1_m1_284000_177600 4.463529
R4436 n1_m1_288000_177600 n1_m1_292800_177600 5.356235
R4437 n1_m1_292800_177600 n1_m1_297600_177600 5.356235
R4438 n1_m1_297600_177600 n1_m1_302400_177600 5.356235
R4439 n1_m1_302400_177600 n1_m1_307200_177600 5.356235
R4440 n1_m1_307200_177600 n1_m1_312000_177600 5.356235
R4441 n1_m1_312000_177600 n1_m1_316800_177600 5.356235
R4442 n1_m1_316800_177600 n1_m1_321600_177600 5.356235
R4443 n1_m1_321600_177600 n1_m1_326400_177600 5.356235
R4444 n1_m1_326400_177600 n1_m1_331200_177600 5.356235
R4445 n1_m1_331200_177600 n1_m1_336000_177600 5.356235
R4446 n1_m1_336000_177600 n1_m1_340000_177600 4.463529
R4447 n1_m1_340800_177600 n1_m1_340000_177600 0.892706
R4448 n1_m1_340800_177600 n1_m1_345600_177600 5.356235
R4449 n1_m1_345600_177600 n1_m1_350400_177600 5.356235
R4450 n1_m1_350400_177600 n1_m1_355200_177600 5.356235
R4451 n1_m1_355200_177600 n1_m1_360000_177600 5.356235
R4452 n1_m1_360000_177600 n1_m1_364800_177600 5.356235
R4453 n1_m1_364800_177600 n1_m1_368000_177600 3.570824
R4454 n1_m1_369600_177600 n1_m1_368000_177600 1.785412
R4455 n1_m1_369600_177600 n1_m1_374400_177600 5.356235
R4456 n1_m1_374400_177600 n1_m1_379200_177600 5.356235
R4457 n1_m1_379200_177600 n1_m1_384000_177600 5.356235
R4458 n1_m1_384000_177600 n1_m1_388800_177600 5.356235
R4459 n1_m1_388800_177600 n1_m1_393600_177600 5.356235
R4460 n1_m1_393600_177600 n1_m1_396000_177600 2.678118
R4461 n1_m1_398400_177600 n1_m1_396000_177600 2.678118
R4462 n1_m1_398400_177600 n1_m1_403200_177600 5.356235
R4463 n1_m1_403200_177600 n1_m1_408000_177600 5.356235
R4464 n1_m1_408000_177600 n1_m1_412800_177600 5.356235
R4465 n1_m1_412800_177600 n1_m1_417600_177600 5.356235
R4466 n1_m1_417600_177600 n1_m1_422400_177600 5.356235
R4467 n1_m1_422400_177600 n1_m1_424000_177600 1.785412
R4468 n1_m1_427200_177600 n1_m1_424000_177600 3.570824
R4469 n1_m1_427200_177600 n1_m1_432000_177600 5.356235
R4470 n1_m1_432000_177600 n1_m1_436800_177600 5.356235
R4471 n1_m1_436800_177600 n1_m1_441600_177600 5.356235
R4472 n1_m1_441600_177600 n1_m1_446400_177600 5.356235
R4473 n1_m1_446400_177600 n1_m1_451200_177600 5.356235
R4474 n1_m1_451200_177600 n1_m1_452000_177600 0.892706
R4475 n1_m1_456000_177600 n1_m1_452000_177600 4.463529
R4476 n1_m1_456000_177600 n1_m1_460800_177600 5.356235
R4477 n1_m1_460800_177600 n1_m1_465600_177600 5.356235
R4478 n1_m1_465600_177600 n1_m1_470400_177600 5.356235
R4479 n1_m1_470400_177600 n1_m1_475200_177600 5.356235
R4480 n1_m1_475200_177600 n1_m1_480000_177600 5.356235
R4481 n1_m1_480000_177600 n1_m1_484800_177600 5.356235
R4482 n1_m1_484800_177600 n1_m1_489600_177600 5.356235
R4483 n1_m1_489600_177600 n1_m1_494400_177600 5.356235
R4484 n1_m1_0_182400 n1_m1_4000_182400 4.463529
R4485 n1_m1_4800_182400 n1_m1_4000_182400 0.892706
R4486 n1_m1_4800_182400 n1_m1_9600_182400 5.356235
R4487 n1_m1_9600_182400 n1_m1_14400_182400 5.356235
R4488 n1_m1_14400_182400 n1_m1_19200_182400 5.356235
R4489 n1_m1_19200_182400 n1_m1_24000_182400 5.356235
R4490 n1_m1_24000_182400 n1_m1_28800_182400 5.356235
R4491 n1_m1_28800_182400 n1_m1_32000_182400 3.570824
R4492 n1_m1_33600_182400 n1_m1_32000_182400 1.785412
R4493 n1_m1_33600_182400 n1_m1_38400_182400 5.356235
R4494 n1_m1_38400_182400 n1_m1_43200_182400 5.356235
R4495 n1_m1_43200_182400 n1_m1_48000_182400 5.356235
R4496 n1_m1_48000_182400 n1_m1_52800_182400 5.356235
R4497 n1_m1_52800_182400 n1_m1_57600_182400 5.356235
R4498 n1_m1_57600_182400 n1_m1_60000_182400 2.678118
R4499 n1_m1_62400_182400 n1_m1_60000_182400 2.678118
R4500 n1_m1_62400_182400 n1_m1_67200_182400 5.356235
R4501 n1_m1_67200_182400 n1_m1_72000_182400 5.356235
R4502 n1_m1_72000_182400 n1_m1_76800_182400 5.356235
R4503 n1_m1_76800_182400 n1_m1_81600_182400 5.356235
R4504 n1_m1_81600_182400 n1_m1_86400_182400 5.356235
R4505 n1_m1_86400_182400 n1_m1_88000_182400 1.785412
R4506 n1_m1_91200_182400 n1_m1_88000_182400 3.570824
R4507 n1_m1_91200_182400 n1_m1_96000_182400 5.356235
R4508 n1_m1_96000_182400 n1_m1_100800_182400 5.356235
R4509 n1_m1_100800_182400 n1_m1_105600_182400 5.356235
R4510 n1_m1_105600_182400 n1_m1_110400_182400 5.356235
R4511 n1_m1_110400_182400 n1_m1_115200_182400 5.356235
R4512 n1_m1_115200_182400 n1_m1_116000_182400 0.892706
R4513 n1_m1_120000_182400 n1_m1_116000_182400 4.463529
R4514 n1_m1_120000_182400 n1_m1_124800_182400 5.356235
R4515 n1_m1_124800_182400 n1_m1_129600_182400 5.356235
R4516 n1_m1_129600_182400 n1_m1_134400_182400 5.356235
R4517 n1_m1_134400_182400 n1_m1_139200_182400 5.356235
R4518 n1_m1_139200_182400 n1_m1_144000_182400 5.356235
R4519 n1_m1_144000_182400 n1_m1_148800_182400 5.356235
R4520 n1_m1_148800_182400 n1_m1_153600_182400 5.356235
R4521 n1_m1_153600_182400 n1_m1_158400_182400 5.356235
R4522 n1_m1_158400_182400 n1_m1_163200_182400 5.356235
R4523 n1_m1_163200_182400 n1_m1_168000_182400 5.356235
R4524 n1_m1_168000_182400 n1_m1_172000_182400 4.463529
R4525 n1_m1_172800_182400 n1_m1_172000_182400 0.892706
R4526 n1_m1_172800_182400 n1_m1_177600_182400 5.356235
R4527 n1_m1_177600_182400 n1_m1_182400_182400 5.356235
R4528 n1_m1_182400_182400 n1_m1_187200_182400 5.356235
R4529 n1_m1_187200_182400 n1_m1_192000_182400 5.356235
R4530 n1_m1_192000_182400 n1_m1_196800_182400 5.356235
R4531 n1_m1_196800_182400 n1_m1_200000_182400 3.570824
R4532 n1_m1_201600_182400 n1_m1_200000_182400 1.785412
R4533 n1_m1_201600_182400 n1_m1_206400_182400 5.356235
R4534 n1_m1_206400_182400 n1_m1_211200_182400 5.356235
R4535 n1_m1_211200_182400 n1_m1_216000_182400 5.356235
R4536 n1_m1_216000_182400 n1_m1_220800_182400 5.356235
R4537 n1_m1_220800_182400 n1_m1_225600_182400 5.356235
R4538 n1_m1_225600_182400 n1_m1_228000_182400 2.678118
R4539 n1_m1_230400_182400 n1_m1_228000_182400 2.678118
R4540 n1_m1_230400_182400 n1_m1_235200_182400 5.356235
R4541 n1_m1_235200_182400 n1_m1_240000_182400 5.356235
R4542 n1_m1_240000_182400 n1_m1_244800_182400 5.356235
R4543 n1_m1_244800_182400 n1_m1_249600_182400 5.356235
R4544 n1_m1_249600_182400 n1_m1_254400_182400 5.356235
R4545 n1_m1_254400_182400 n1_m1_256000_182400 1.785412
R4546 n1_m1_259200_182400 n1_m1_256000_182400 3.570824
R4547 n1_m1_259200_182400 n1_m1_264000_182400 5.356235
R4548 n1_m1_264000_182400 n1_m1_268800_182400 5.356235
R4549 n1_m1_268800_182400 n1_m1_273600_182400 5.356235
R4550 n1_m1_273600_182400 n1_m1_278400_182400 5.356235
R4551 n1_m1_278400_182400 n1_m1_283200_182400 5.356235
R4552 n1_m1_283200_182400 n1_m1_284000_182400 0.892706
R4553 n1_m1_288000_182400 n1_m1_284000_182400 4.463529
R4554 n1_m1_288000_182400 n1_m1_292800_182400 5.356235
R4555 n1_m1_292800_182400 n1_m1_297600_182400 5.356235
R4556 n1_m1_297600_182400 n1_m1_302400_182400 5.356235
R4557 n1_m1_302400_182400 n1_m1_307200_182400 5.356235
R4558 n1_m1_307200_182400 n1_m1_312000_182400 5.356235
R4559 n1_m1_312000_182400 n1_m1_316800_182400 5.356235
R4560 n1_m1_316800_182400 n1_m1_321600_182400 5.356235
R4561 n1_m1_321600_182400 n1_m1_326400_182400 5.356235
R4562 n1_m1_326400_182400 n1_m1_331200_182400 5.356235
R4563 n1_m1_331200_182400 n1_m1_336000_182400 5.356235
R4564 n1_m1_336000_182400 n1_m1_340000_182400 4.463529
R4565 n1_m1_340800_182400 n1_m1_340000_182400 0.892706
R4566 n1_m1_340800_182400 n1_m1_345600_182400 5.356235
R4567 n1_m1_345600_182400 n1_m1_350400_182400 5.356235
R4568 n1_m1_350400_182400 n1_m1_355200_182400 5.356235
R4569 n1_m1_355200_182400 n1_m1_360000_182400 5.356235
R4570 n1_m1_360000_182400 n1_m1_364800_182400 5.356235
R4571 n1_m1_364800_182400 n1_m1_368000_182400 3.570824
R4572 n1_m1_369600_182400 n1_m1_368000_182400 1.785412
R4573 n1_m1_369600_182400 n1_m1_374400_182400 5.356235
R4574 n1_m1_374400_182400 n1_m1_379200_182400 5.356235
R4575 n1_m1_379200_182400 n1_m1_384000_182400 5.356235
R4576 n1_m1_384000_182400 n1_m1_388800_182400 5.356235
R4577 n1_m1_388800_182400 n1_m1_393600_182400 5.356235
R4578 n1_m1_393600_182400 n1_m1_396000_182400 2.678118
R4579 n1_m1_398400_182400 n1_m1_396000_182400 2.678118
R4580 n1_m1_398400_182400 n1_m1_403200_182400 5.356235
R4581 n1_m1_403200_182400 n1_m1_408000_182400 5.356235
R4582 n1_m1_408000_182400 n1_m1_412800_182400 5.356235
R4583 n1_m1_412800_182400 n1_m1_417600_182400 5.356235
R4584 n1_m1_417600_182400 n1_m1_422400_182400 5.356235
R4585 n1_m1_422400_182400 n1_m1_424000_182400 1.785412
R4586 n1_m1_427200_182400 n1_m1_424000_182400 3.570824
R4587 n1_m1_427200_182400 n1_m1_432000_182400 5.356235
R4588 n1_m1_432000_182400 n1_m1_436800_182400 5.356235
R4589 n1_m1_436800_182400 n1_m1_441600_182400 5.356235
R4590 n1_m1_441600_182400 n1_m1_446400_182400 5.356235
R4591 n1_m1_446400_182400 n1_m1_451200_182400 5.356235
R4592 n1_m1_451200_182400 n1_m1_452000_182400 0.892706
R4593 n1_m1_456000_182400 n1_m1_452000_182400 4.463529
R4594 n1_m1_456000_182400 n1_m1_460800_182400 5.356235
R4595 n1_m1_460800_182400 n1_m1_465600_182400 5.356235
R4596 n1_m1_465600_182400 n1_m1_470400_182400 5.356235
R4597 n1_m1_470400_182400 n1_m1_475200_182400 5.356235
R4598 n1_m1_475200_182400 n1_m1_480000_182400 5.356235
R4599 n1_m1_480000_182400 n1_m1_484800_182400 5.356235
R4600 n1_m1_484800_182400 n1_m1_489600_182400 5.356235
R4601 n1_m1_489600_182400 n1_m1_494400_182400 5.356235
R4602 n1_m1_0_187200 n1_m1_4000_187200 4.463529
R4603 n1_m1_4800_187200 n1_m1_4000_187200 0.892706
R4604 n1_m1_4800_187200 n1_m1_9600_187200 5.356235
R4605 n1_m1_9600_187200 n1_m1_14400_187200 5.356235
R4606 n1_m1_14400_187200 n1_m1_19200_187200 5.356235
R4607 n1_m1_19200_187200 n1_m1_24000_187200 5.356235
R4608 n1_m1_24000_187200 n1_m1_28800_187200 5.356235
R4609 n1_m1_28800_187200 n1_m1_32000_187200 3.570824
R4610 n1_m1_33600_187200 n1_m1_32000_187200 1.785412
R4611 n1_m1_33600_187200 n1_m1_38400_187200 5.356235
R4612 n1_m1_38400_187200 n1_m1_43200_187200 5.356235
R4613 n1_m1_43200_187200 n1_m1_48000_187200 5.356235
R4614 n1_m1_48000_187200 n1_m1_52800_187200 5.356235
R4615 n1_m1_52800_187200 n1_m1_57600_187200 5.356235
R4616 n1_m1_57600_187200 n1_m1_60000_187200 2.678118
R4617 n1_m1_62400_187200 n1_m1_60000_187200 2.678118
R4618 n1_m1_62400_187200 n1_m1_67200_187200 5.356235
R4619 n1_m1_67200_187200 n1_m1_72000_187200 5.356235
R4620 n1_m1_72000_187200 n1_m1_76800_187200 5.356235
R4621 n1_m1_76800_187200 n1_m1_81600_187200 5.356235
R4622 n1_m1_81600_187200 n1_m1_86400_187200 5.356235
R4623 n1_m1_86400_187200 n1_m1_88000_187200 1.785412
R4624 n1_m1_91200_187200 n1_m1_88000_187200 3.570824
R4625 n1_m1_91200_187200 n1_m1_96000_187200 5.356235
R4626 n1_m1_96000_187200 n1_m1_100800_187200 5.356235
R4627 n1_m1_100800_187200 n1_m1_105600_187200 5.356235
R4628 n1_m1_105600_187200 n1_m1_110400_187200 5.356235
R4629 n1_m1_110400_187200 n1_m1_115200_187200 5.356235
R4630 n1_m1_115200_187200 n1_m1_116000_187200 0.892706
R4631 n1_m1_120000_187200 n1_m1_116000_187200 4.463529
R4632 n1_m1_120000_187200 n1_m1_124800_187200 5.356235
R4633 n1_m1_124800_187200 n1_m1_129600_187200 5.356235
R4634 n1_m1_129600_187200 n1_m1_134400_187200 5.356235
R4635 n1_m1_134400_187200 n1_m1_139200_187200 5.356235
R4636 n1_m1_139200_187200 n1_m1_144000_187200 5.356235
R4637 n1_m1_144000_187200 n1_m1_148800_187200 5.356235
R4638 n1_m1_148800_187200 n1_m1_153600_187200 5.356235
R4639 n1_m1_153600_187200 n1_m1_158400_187200 5.356235
R4640 n1_m1_158400_187200 n1_m1_163200_187200 5.356235
R4641 n1_m1_163200_187200 n1_m1_168000_187200 5.356235
R4642 n1_m1_168000_187200 n1_m1_172000_187200 4.463529
R4643 n1_m1_172800_187200 n1_m1_172000_187200 0.892706
R4644 n1_m1_172800_187200 n1_m1_177600_187200 5.356235
R4645 n1_m1_177600_187200 n1_m1_182400_187200 5.356235
R4646 n1_m1_182400_187200 n1_m1_187200_187200 5.356235
R4647 n1_m1_187200_187200 n1_m1_192000_187200 5.356235
R4648 n1_m1_192000_187200 n1_m1_196800_187200 5.356235
R4649 n1_m1_196800_187200 n1_m1_200000_187200 3.570824
R4650 n1_m1_201600_187200 n1_m1_200000_187200 1.785412
R4651 n1_m1_201600_187200 n1_m1_206400_187200 5.356235
R4652 n1_m1_206400_187200 n1_m1_211200_187200 5.356235
R4653 n1_m1_211200_187200 n1_m1_216000_187200 5.356235
R4654 n1_m1_216000_187200 n1_m1_220800_187200 5.356235
R4655 n1_m1_220800_187200 n1_m1_225600_187200 5.356235
R4656 n1_m1_225600_187200 n1_m1_228000_187200 2.678118
R4657 n1_m1_230400_187200 n1_m1_228000_187200 2.678118
R4658 n1_m1_230400_187200 n1_m1_235200_187200 5.356235
R4659 n1_m1_235200_187200 n1_m1_240000_187200 5.356235
R4660 n1_m1_240000_187200 n1_m1_244800_187200 5.356235
R4661 n1_m1_244800_187200 n1_m1_249600_187200 5.356235
R4662 n1_m1_249600_187200 n1_m1_254400_187200 5.356235
R4663 n1_m1_254400_187200 n1_m1_256000_187200 1.785412
R4664 n1_m1_259200_187200 n1_m1_256000_187200 3.570824
R4665 n1_m1_259200_187200 n1_m1_264000_187200 5.356235
R4666 n1_m1_264000_187200 n1_m1_268800_187200 5.356235
R4667 n1_m1_268800_187200 n1_m1_273600_187200 5.356235
R4668 n1_m1_273600_187200 n1_m1_278400_187200 5.356235
R4669 n1_m1_278400_187200 n1_m1_283200_187200 5.356235
R4670 n1_m1_283200_187200 n1_m1_284000_187200 0.892706
R4671 n1_m1_288000_187200 n1_m1_284000_187200 4.463529
R4672 n1_m1_288000_187200 n1_m1_292800_187200 5.356235
R4673 n1_m1_292800_187200 n1_m1_297600_187200 5.356235
R4674 n1_m1_297600_187200 n1_m1_302400_187200 5.356235
R4675 n1_m1_302400_187200 n1_m1_307200_187200 5.356235
R4676 n1_m1_307200_187200 n1_m1_312000_187200 5.356235
R4677 n1_m1_312000_187200 n1_m1_316800_187200 5.356235
R4678 n1_m1_316800_187200 n1_m1_321600_187200 5.356235
R4679 n1_m1_321600_187200 n1_m1_326400_187200 5.356235
R4680 n1_m1_326400_187200 n1_m1_331200_187200 5.356235
R4681 n1_m1_331200_187200 n1_m1_336000_187200 5.356235
R4682 n1_m1_336000_187200 n1_m1_340000_187200 4.463529
R4683 n1_m1_340800_187200 n1_m1_340000_187200 0.892706
R4684 n1_m1_340800_187200 n1_m1_345600_187200 5.356235
R4685 n1_m1_345600_187200 n1_m1_350400_187200 5.356235
R4686 n1_m1_350400_187200 n1_m1_355200_187200 5.356235
R4687 n1_m1_355200_187200 n1_m1_360000_187200 5.356235
R4688 n1_m1_360000_187200 n1_m1_364800_187200 5.356235
R4689 n1_m1_364800_187200 n1_m1_368000_187200 3.570824
R4690 n1_m1_369600_187200 n1_m1_368000_187200 1.785412
R4691 n1_m1_369600_187200 n1_m1_374400_187200 5.356235
R4692 n1_m1_374400_187200 n1_m1_379200_187200 5.356235
R4693 n1_m1_379200_187200 n1_m1_384000_187200 5.356235
R4694 n1_m1_384000_187200 n1_m1_388800_187200 5.356235
R4695 n1_m1_388800_187200 n1_m1_393600_187200 5.356235
R4696 n1_m1_393600_187200 n1_m1_396000_187200 2.678118
R4697 n1_m1_398400_187200 n1_m1_396000_187200 2.678118
R4698 n1_m1_398400_187200 n1_m1_403200_187200 5.356235
R4699 n1_m1_403200_187200 n1_m1_408000_187200 5.356235
R4700 n1_m1_408000_187200 n1_m1_412800_187200 5.356235
R4701 n1_m1_412800_187200 n1_m1_417600_187200 5.356235
R4702 n1_m1_417600_187200 n1_m1_422400_187200 5.356235
R4703 n1_m1_422400_187200 n1_m1_424000_187200 1.785412
R4704 n1_m1_427200_187200 n1_m1_424000_187200 3.570824
R4705 n1_m1_427200_187200 n1_m1_432000_187200 5.356235
R4706 n1_m1_432000_187200 n1_m1_436800_187200 5.356235
R4707 n1_m1_436800_187200 n1_m1_441600_187200 5.356235
R4708 n1_m1_441600_187200 n1_m1_446400_187200 5.356235
R4709 n1_m1_446400_187200 n1_m1_451200_187200 5.356235
R4710 n1_m1_451200_187200 n1_m1_452000_187200 0.892706
R4711 n1_m1_456000_187200 n1_m1_452000_187200 4.463529
R4712 n1_m1_456000_187200 n1_m1_460800_187200 5.356235
R4713 n1_m1_460800_187200 n1_m1_465600_187200 5.356235
R4714 n1_m1_465600_187200 n1_m1_470400_187200 5.356235
R4715 n1_m1_470400_187200 n1_m1_475200_187200 5.356235
R4716 n1_m1_475200_187200 n1_m1_480000_187200 5.356235
R4717 n1_m1_480000_187200 n1_m1_484800_187200 5.356235
R4718 n1_m1_484800_187200 n1_m1_489600_187200 5.356235
R4719 n1_m1_489600_187200 n1_m1_494400_187200 5.356235
R4720 n1_m1_0_192000 n1_m1_4000_192000 4.463529
R4721 n1_m1_4800_192000 n1_m1_4000_192000 0.892706
R4722 n1_m1_4800_192000 n1_m1_9600_192000 5.356235
R4723 n1_m1_9600_192000 n1_m1_14400_192000 5.356235
R4724 n1_m1_14400_192000 n1_m1_19200_192000 5.356235
R4725 n1_m1_19200_192000 n1_m1_24000_192000 5.356235
R4726 n1_m1_24000_192000 n1_m1_28800_192000 5.356235
R4727 n1_m1_28800_192000 n1_m1_32000_192000 3.570824
R4728 n1_m1_33600_192000 n1_m1_32000_192000 1.785412
R4729 n1_m1_33600_192000 n1_m1_38400_192000 5.356235
R4730 n1_m1_38400_192000 n1_m1_43200_192000 5.356235
R4731 n1_m1_43200_192000 n1_m1_48000_192000 5.356235
R4732 n1_m1_48000_192000 n1_m1_52800_192000 5.356235
R4733 n1_m1_52800_192000 n1_m1_57600_192000 5.356235
R4734 n1_m1_57600_192000 n1_m1_60000_192000 2.678118
R4735 n1_m1_62400_192000 n1_m1_60000_192000 2.678118
R4736 n1_m1_62400_192000 n1_m1_67200_192000 5.356235
R4737 n1_m1_67200_192000 n1_m1_72000_192000 5.356235
R4738 n1_m1_72000_192000 n1_m1_76800_192000 5.356235
R4739 n1_m1_76800_192000 n1_m1_81600_192000 5.356235
R4740 n1_m1_81600_192000 n1_m1_86400_192000 5.356235
R4741 n1_m1_86400_192000 n1_m1_88000_192000 1.785412
R4742 n1_m1_91200_192000 n1_m1_88000_192000 3.570824
R4743 n1_m1_91200_192000 n1_m1_96000_192000 5.356235
R4744 n1_m1_96000_192000 n1_m1_100800_192000 5.356235
R4745 n1_m1_100800_192000 n1_m1_105600_192000 5.356235
R4746 n1_m1_105600_192000 n1_m1_110400_192000 5.356235
R4747 n1_m1_110400_192000 n1_m1_115200_192000 5.356235
R4748 n1_m1_115200_192000 n1_m1_116000_192000 0.892706
R4749 n1_m1_120000_192000 n1_m1_116000_192000 4.463529
R4750 n1_m1_120000_192000 n1_m1_124800_192000 5.356235
R4751 n1_m1_124800_192000 n1_m1_129600_192000 5.356235
R4752 n1_m1_129600_192000 n1_m1_134400_192000 5.356235
R4753 n1_m1_134400_192000 n1_m1_139200_192000 5.356235
R4754 n1_m1_139200_192000 n1_m1_144000_192000 5.356235
R4755 n1_m1_144000_192000 n1_m1_148800_192000 5.356235
R4756 n1_m1_148800_192000 n1_m1_153600_192000 5.356235
R4757 n1_m1_153600_192000 n1_m1_158400_192000 5.356235
R4758 n1_m1_158400_192000 n1_m1_163200_192000 5.356235
R4759 n1_m1_163200_192000 n1_m1_168000_192000 5.356235
R4760 n1_m1_168000_192000 n1_m1_172000_192000 4.463529
R4761 n1_m1_172800_192000 n1_m1_172000_192000 0.892706
R4762 n1_m1_172800_192000 n1_m1_177600_192000 5.356235
R4763 n1_m1_177600_192000 n1_m1_182400_192000 5.356235
R4764 n1_m1_182400_192000 n1_m1_187200_192000 5.356235
R4765 n1_m1_187200_192000 n1_m1_192000_192000 5.356235
R4766 n1_m1_192000_192000 n1_m1_196800_192000 5.356235
R4767 n1_m1_196800_192000 n1_m1_200000_192000 3.570824
R4768 n1_m1_201600_192000 n1_m1_200000_192000 1.785412
R4769 n1_m1_201600_192000 n1_m1_206400_192000 5.356235
R4770 n1_m1_206400_192000 n1_m1_211200_192000 5.356235
R4771 n1_m1_211200_192000 n1_m1_216000_192000 5.356235
R4772 n1_m1_216000_192000 n1_m1_220800_192000 5.356235
R4773 n1_m1_220800_192000 n1_m1_225600_192000 5.356235
R4774 n1_m1_225600_192000 n1_m1_228000_192000 2.678118
R4775 n1_m1_230400_192000 n1_m1_228000_192000 2.678118
R4776 n1_m1_230400_192000 n1_m1_235200_192000 5.356235
R4777 n1_m1_235200_192000 n1_m1_240000_192000 5.356235
R4778 n1_m1_240000_192000 n1_m1_244800_192000 5.356235
R4779 n1_m1_244800_192000 n1_m1_249600_192000 5.356235
R4780 n1_m1_249600_192000 n1_m1_254400_192000 5.356235
R4781 n1_m1_254400_192000 n1_m1_256000_192000 1.785412
R4782 n1_m1_259200_192000 n1_m1_256000_192000 3.570824
R4783 n1_m1_259200_192000 n1_m1_264000_192000 5.356235
R4784 n1_m1_264000_192000 n1_m1_268800_192000 5.356235
R4785 n1_m1_268800_192000 n1_m1_273600_192000 5.356235
R4786 n1_m1_273600_192000 n1_m1_278400_192000 5.356235
R4787 n1_m1_278400_192000 n1_m1_283200_192000 5.356235
R4788 n1_m1_283200_192000 n1_m1_284000_192000 0.892706
R4789 n1_m1_288000_192000 n1_m1_284000_192000 4.463529
R4790 n1_m1_288000_192000 n1_m1_292800_192000 5.356235
R4791 n1_m1_292800_192000 n1_m1_297600_192000 5.356235
R4792 n1_m1_297600_192000 n1_m1_302400_192000 5.356235
R4793 n1_m1_302400_192000 n1_m1_307200_192000 5.356235
R4794 n1_m1_307200_192000 n1_m1_312000_192000 5.356235
R4795 n1_m1_312000_192000 n1_m1_316800_192000 5.356235
R4796 n1_m1_316800_192000 n1_m1_321600_192000 5.356235
R4797 n1_m1_321600_192000 n1_m1_326400_192000 5.356235
R4798 n1_m1_326400_192000 n1_m1_331200_192000 5.356235
R4799 n1_m1_331200_192000 n1_m1_336000_192000 5.356235
R4800 n1_m1_336000_192000 n1_m1_340000_192000 4.463529
R4801 n1_m1_340800_192000 n1_m1_340000_192000 0.892706
R4802 n1_m1_340800_192000 n1_m1_345600_192000 5.356235
R4803 n1_m1_345600_192000 n1_m1_350400_192000 5.356235
R4804 n1_m1_350400_192000 n1_m1_355200_192000 5.356235
R4805 n1_m1_355200_192000 n1_m1_360000_192000 5.356235
R4806 n1_m1_360000_192000 n1_m1_364800_192000 5.356235
R4807 n1_m1_364800_192000 n1_m1_368000_192000 3.570824
R4808 n1_m1_369600_192000 n1_m1_368000_192000 1.785412
R4809 n1_m1_369600_192000 n1_m1_374400_192000 5.356235
R4810 n1_m1_374400_192000 n1_m1_379200_192000 5.356235
R4811 n1_m1_379200_192000 n1_m1_384000_192000 5.356235
R4812 n1_m1_384000_192000 n1_m1_388800_192000 5.356235
R4813 n1_m1_388800_192000 n1_m1_393600_192000 5.356235
R4814 n1_m1_393600_192000 n1_m1_396000_192000 2.678118
R4815 n1_m1_398400_192000 n1_m1_396000_192000 2.678118
R4816 n1_m1_398400_192000 n1_m1_403200_192000 5.356235
R4817 n1_m1_403200_192000 n1_m1_408000_192000 5.356235
R4818 n1_m1_408000_192000 n1_m1_412800_192000 5.356235
R4819 n1_m1_412800_192000 n1_m1_417600_192000 5.356235
R4820 n1_m1_417600_192000 n1_m1_422400_192000 5.356235
R4821 n1_m1_422400_192000 n1_m1_424000_192000 1.785412
R4822 n1_m1_427200_192000 n1_m1_424000_192000 3.570824
R4823 n1_m1_427200_192000 n1_m1_432000_192000 5.356235
R4824 n1_m1_432000_192000 n1_m1_436800_192000 5.356235
R4825 n1_m1_436800_192000 n1_m1_441600_192000 5.356235
R4826 n1_m1_441600_192000 n1_m1_446400_192000 5.356235
R4827 n1_m1_446400_192000 n1_m1_451200_192000 5.356235
R4828 n1_m1_451200_192000 n1_m1_452000_192000 0.892706
R4829 n1_m1_456000_192000 n1_m1_452000_192000 4.463529
R4830 n1_m1_456000_192000 n1_m1_460800_192000 5.356235
R4831 n1_m1_460800_192000 n1_m1_465600_192000 5.356235
R4832 n1_m1_465600_192000 n1_m1_470400_192000 5.356235
R4833 n1_m1_470400_192000 n1_m1_475200_192000 5.356235
R4834 n1_m1_475200_192000 n1_m1_480000_192000 5.356235
R4835 n1_m1_480000_192000 n1_m1_484800_192000 5.356235
R4836 n1_m1_484800_192000 n1_m1_489600_192000 5.356235
R4837 n1_m1_489600_192000 n1_m1_494400_192000 5.356235
R4838 n1_m1_0_196800 n1_m1_4000_196800 4.463529
R4839 n1_m1_4800_196800 n1_m1_4000_196800 0.892706
R4840 n1_m1_4800_196800 n1_m1_9600_196800 5.356235
R4841 n1_m1_9600_196800 n1_m1_14400_196800 5.356235
R4842 n1_m1_14400_196800 n1_m1_19200_196800 5.356235
R4843 n1_m1_19200_196800 n1_m1_24000_196800 5.356235
R4844 n1_m1_24000_196800 n1_m1_28800_196800 5.356235
R4845 n1_m1_28800_196800 n1_m1_32000_196800 3.570824
R4846 n1_m1_33600_196800 n1_m1_32000_196800 1.785412
R4847 n1_m1_33600_196800 n1_m1_38400_196800 5.356235
R4848 n1_m1_38400_196800 n1_m1_43200_196800 5.356235
R4849 n1_m1_43200_196800 n1_m1_48000_196800 5.356235
R4850 n1_m1_48000_196800 n1_m1_52800_196800 5.356235
R4851 n1_m1_52800_196800 n1_m1_57600_196800 5.356235
R4852 n1_m1_57600_196800 n1_m1_60000_196800 2.678118
R4853 n1_m1_62400_196800 n1_m1_60000_196800 2.678118
R4854 n1_m1_62400_196800 n1_m1_67200_196800 5.356235
R4855 n1_m1_67200_196800 n1_m1_72000_196800 5.356235
R4856 n1_m1_72000_196800 n1_m1_76800_196800 5.356235
R4857 n1_m1_76800_196800 n1_m1_81600_196800 5.356235
R4858 n1_m1_81600_196800 n1_m1_86400_196800 5.356235
R4859 n1_m1_86400_196800 n1_m1_88000_196800 1.785412
R4860 n1_m1_91200_196800 n1_m1_88000_196800 3.570824
R4861 n1_m1_91200_196800 n1_m1_96000_196800 5.356235
R4862 n1_m1_96000_196800 n1_m1_100800_196800 5.356235
R4863 n1_m1_100800_196800 n1_m1_105600_196800 5.356235
R4864 n1_m1_105600_196800 n1_m1_110400_196800 5.356235
R4865 n1_m1_110400_196800 n1_m1_115200_196800 5.356235
R4866 n1_m1_115200_196800 n1_m1_116000_196800 0.892706
R4867 n1_m1_120000_196800 n1_m1_116000_196800 4.463529
R4868 n1_m1_120000_196800 n1_m1_124800_196800 5.356235
R4869 n1_m1_124800_196800 n1_m1_129600_196800 5.356235
R4870 n1_m1_129600_196800 n1_m1_134400_196800 5.356235
R4871 n1_m1_134400_196800 n1_m1_139200_196800 5.356235
R4872 n1_m1_139200_196800 n1_m1_144000_196800 5.356235
R4873 n1_m1_144000_196800 n1_m1_148800_196800 5.356235
R4874 n1_m1_148800_196800 n1_m1_153600_196800 5.356235
R4875 n1_m1_153600_196800 n1_m1_158400_196800 5.356235
R4876 n1_m1_158400_196800 n1_m1_163200_196800 5.356235
R4877 n1_m1_163200_196800 n1_m1_168000_196800 5.356235
R4878 n1_m1_168000_196800 n1_m1_172000_196800 4.463529
R4879 n1_m1_172800_196800 n1_m1_172000_196800 0.892706
R4880 n1_m1_172800_196800 n1_m1_177600_196800 5.356235
R4881 n1_m1_177600_196800 n1_m1_182400_196800 5.356235
R4882 n1_m1_182400_196800 n1_m1_187200_196800 5.356235
R4883 n1_m1_187200_196800 n1_m1_192000_196800 5.356235
R4884 n1_m1_192000_196800 n1_m1_196800_196800 5.356235
R4885 n1_m1_196800_196800 n1_m1_200000_196800 3.570824
R4886 n1_m1_201600_196800 n1_m1_200000_196800 1.785412
R4887 n1_m1_201600_196800 n1_m1_206400_196800 5.356235
R4888 n1_m1_206400_196800 n1_m1_211200_196800 5.356235
R4889 n1_m1_211200_196800 n1_m1_216000_196800 5.356235
R4890 n1_m1_216000_196800 n1_m1_220800_196800 5.356235
R4891 n1_m1_220800_196800 n1_m1_225600_196800 5.356235
R4892 n1_m1_225600_196800 n1_m1_228000_196800 2.678118
R4893 n1_m1_230400_196800 n1_m1_228000_196800 2.678118
R4894 n1_m1_230400_196800 n1_m1_235200_196800 5.356235
R4895 n1_m1_235200_196800 n1_m1_240000_196800 5.356235
R4896 n1_m1_240000_196800 n1_m1_244800_196800 5.356235
R4897 n1_m1_244800_196800 n1_m1_249600_196800 5.356235
R4898 n1_m1_249600_196800 n1_m1_254400_196800 5.356235
R4899 n1_m1_254400_196800 n1_m1_256000_196800 1.785412
R4900 n1_m1_259200_196800 n1_m1_256000_196800 3.570824
R4901 n1_m1_259200_196800 n1_m1_264000_196800 5.356235
R4902 n1_m1_264000_196800 n1_m1_268800_196800 5.356235
R4903 n1_m1_268800_196800 n1_m1_273600_196800 5.356235
R4904 n1_m1_273600_196800 n1_m1_278400_196800 5.356235
R4905 n1_m1_278400_196800 n1_m1_283200_196800 5.356235
R4906 n1_m1_283200_196800 n1_m1_284000_196800 0.892706
R4907 n1_m1_288000_196800 n1_m1_284000_196800 4.463529
R4908 n1_m1_288000_196800 n1_m1_292800_196800 5.356235
R4909 n1_m1_292800_196800 n1_m1_297600_196800 5.356235
R4910 n1_m1_297600_196800 n1_m1_302400_196800 5.356235
R4911 n1_m1_302400_196800 n1_m1_307200_196800 5.356235
R4912 n1_m1_307200_196800 n1_m1_312000_196800 5.356235
R4913 n1_m1_312000_196800 n1_m1_316800_196800 5.356235
R4914 n1_m1_316800_196800 n1_m1_321600_196800 5.356235
R4915 n1_m1_321600_196800 n1_m1_326400_196800 5.356235
R4916 n1_m1_326400_196800 n1_m1_331200_196800 5.356235
R4917 n1_m1_331200_196800 n1_m1_336000_196800 5.356235
R4918 n1_m1_336000_196800 n1_m1_340000_196800 4.463529
R4919 n1_m1_340800_196800 n1_m1_340000_196800 0.892706
R4920 n1_m1_340800_196800 n1_m1_345600_196800 5.356235
R4921 n1_m1_345600_196800 n1_m1_350400_196800 5.356235
R4922 n1_m1_350400_196800 n1_m1_355200_196800 5.356235
R4923 n1_m1_355200_196800 n1_m1_360000_196800 5.356235
R4924 n1_m1_360000_196800 n1_m1_364800_196800 5.356235
R4925 n1_m1_364800_196800 n1_m1_368000_196800 3.570824
R4926 n1_m1_369600_196800 n1_m1_368000_196800 1.785412
R4927 n1_m1_369600_196800 n1_m1_374400_196800 5.356235
R4928 n1_m1_374400_196800 n1_m1_379200_196800 5.356235
R4929 n1_m1_379200_196800 n1_m1_384000_196800 5.356235
R4930 n1_m1_384000_196800 n1_m1_388800_196800 5.356235
R4931 n1_m1_388800_196800 n1_m1_393600_196800 5.356235
R4932 n1_m1_393600_196800 n1_m1_396000_196800 2.678118
R4933 n1_m1_398400_196800 n1_m1_396000_196800 2.678118
R4934 n1_m1_398400_196800 n1_m1_403200_196800 5.356235
R4935 n1_m1_403200_196800 n1_m1_408000_196800 5.356235
R4936 n1_m1_408000_196800 n1_m1_412800_196800 5.356235
R4937 n1_m1_412800_196800 n1_m1_417600_196800 5.356235
R4938 n1_m1_417600_196800 n1_m1_422400_196800 5.356235
R4939 n1_m1_422400_196800 n1_m1_424000_196800 1.785412
R4940 n1_m1_427200_196800 n1_m1_424000_196800 3.570824
R4941 n1_m1_427200_196800 n1_m1_432000_196800 5.356235
R4942 n1_m1_432000_196800 n1_m1_436800_196800 5.356235
R4943 n1_m1_436800_196800 n1_m1_441600_196800 5.356235
R4944 n1_m1_441600_196800 n1_m1_446400_196800 5.356235
R4945 n1_m1_446400_196800 n1_m1_451200_196800 5.356235
R4946 n1_m1_451200_196800 n1_m1_452000_196800 0.892706
R4947 n1_m1_456000_196800 n1_m1_452000_196800 4.463529
R4948 n1_m1_456000_196800 n1_m1_460800_196800 5.356235
R4949 n1_m1_460800_196800 n1_m1_465600_196800 5.356235
R4950 n1_m1_465600_196800 n1_m1_470400_196800 5.356235
R4951 n1_m1_470400_196800 n1_m1_475200_196800 5.356235
R4952 n1_m1_475200_196800 n1_m1_480000_196800 5.356235
R4953 n1_m1_480000_196800 n1_m1_484800_196800 5.356235
R4954 n1_m1_484800_196800 n1_m1_489600_196800 5.356235
R4955 n1_m1_489600_196800 n1_m1_494400_196800 5.356235
R4956 n1_m1_0_201600 n1_m1_4000_201600 4.463529
R4957 n1_m1_4800_201600 n1_m1_4000_201600 0.892706
R4958 n1_m1_4800_201600 n1_m1_9600_201600 5.356235
R4959 n1_m1_9600_201600 n1_m1_14400_201600 5.356235
R4960 n1_m1_14400_201600 n1_m1_19200_201600 5.356235
R4961 n1_m1_19200_201600 n1_m1_24000_201600 5.356235
R4962 n1_m1_24000_201600 n1_m1_28800_201600 5.356235
R4963 n1_m1_28800_201600 n1_m1_32000_201600 3.570824
R4964 n1_m1_33600_201600 n1_m1_32000_201600 1.785412
R4965 n1_m1_33600_201600 n1_m1_38400_201600 5.356235
R4966 n1_m1_38400_201600 n1_m1_43200_201600 5.356235
R4967 n1_m1_43200_201600 n1_m1_48000_201600 5.356235
R4968 n1_m1_48000_201600 n1_m1_52800_201600 5.356235
R4969 n1_m1_52800_201600 n1_m1_57600_201600 5.356235
R4970 n1_m1_57600_201600 n1_m1_60000_201600 2.678118
R4971 n1_m1_62400_201600 n1_m1_60000_201600 2.678118
R4972 n1_m1_62400_201600 n1_m1_67200_201600 5.356235
R4973 n1_m1_67200_201600 n1_m1_72000_201600 5.356235
R4974 n1_m1_72000_201600 n1_m1_76800_201600 5.356235
R4975 n1_m1_76800_201600 n1_m1_81600_201600 5.356235
R4976 n1_m1_81600_201600 n1_m1_86400_201600 5.356235
R4977 n1_m1_86400_201600 n1_m1_88000_201600 1.785412
R4978 n1_m1_91200_201600 n1_m1_88000_201600 3.570824
R4979 n1_m1_91200_201600 n1_m1_96000_201600 5.356235
R4980 n1_m1_96000_201600 n1_m1_100800_201600 5.356235
R4981 n1_m1_100800_201600 n1_m1_105600_201600 5.356235
R4982 n1_m1_105600_201600 n1_m1_110400_201600 5.356235
R4983 n1_m1_110400_201600 n1_m1_115200_201600 5.356235
R4984 n1_m1_115200_201600 n1_m1_116000_201600 0.892706
R4985 n1_m1_120000_201600 n1_m1_116000_201600 4.463529
R4986 n1_m1_120000_201600 n1_m1_124800_201600 5.356235
R4987 n1_m1_124800_201600 n1_m1_129600_201600 5.356235
R4988 n1_m1_129600_201600 n1_m1_134400_201600 5.356235
R4989 n1_m1_134400_201600 n1_m1_139200_201600 5.356235
R4990 n1_m1_139200_201600 n1_m1_144000_201600 5.356235
R4991 n1_m1_144000_201600 n1_m1_148800_201600 5.356235
R4992 n1_m1_148800_201600 n1_m1_153600_201600 5.356235
R4993 n1_m1_153600_201600 n1_m1_158400_201600 5.356235
R4994 n1_m1_158400_201600 n1_m1_163200_201600 5.356235
R4995 n1_m1_163200_201600 n1_m1_168000_201600 5.356235
R4996 n1_m1_168000_201600 n1_m1_172000_201600 4.463529
R4997 n1_m1_172800_201600 n1_m1_172000_201600 0.892706
R4998 n1_m1_172800_201600 n1_m1_177600_201600 5.356235
R4999 n1_m1_177600_201600 n1_m1_182400_201600 5.356235
R5000 n1_m1_182400_201600 n1_m1_187200_201600 5.356235
R5001 n1_m1_187200_201600 n1_m1_192000_201600 5.356235
R5002 n1_m1_192000_201600 n1_m1_196800_201600 5.356235
R5003 n1_m1_196800_201600 n1_m1_200000_201600 3.570824
R5004 n1_m1_201600_201600 n1_m1_200000_201600 1.785412
R5005 n1_m1_201600_201600 n1_m1_206400_201600 5.356235
R5006 n1_m1_206400_201600 n1_m1_211200_201600 5.356235
R5007 n1_m1_211200_201600 n1_m1_216000_201600 5.356235
R5008 n1_m1_216000_201600 n1_m1_220800_201600 5.356235
R5009 n1_m1_220800_201600 n1_m1_225600_201600 5.356235
R5010 n1_m1_225600_201600 n1_m1_228000_201600 2.678118
R5011 n1_m1_230400_201600 n1_m1_228000_201600 2.678118
R5012 n1_m1_230400_201600 n1_m1_235200_201600 5.356235
R5013 n1_m1_235200_201600 n1_m1_240000_201600 5.356235
R5014 n1_m1_240000_201600 n1_m1_244800_201600 5.356235
R5015 n1_m1_244800_201600 n1_m1_249600_201600 5.356235
R5016 n1_m1_249600_201600 n1_m1_254400_201600 5.356235
R5017 n1_m1_254400_201600 n1_m1_256000_201600 1.785412
R5018 n1_m1_259200_201600 n1_m1_256000_201600 3.570824
R5019 n1_m1_259200_201600 n1_m1_264000_201600 5.356235
R5020 n1_m1_264000_201600 n1_m1_268800_201600 5.356235
R5021 n1_m1_268800_201600 n1_m1_273600_201600 5.356235
R5022 n1_m1_273600_201600 n1_m1_278400_201600 5.356235
R5023 n1_m1_278400_201600 n1_m1_283200_201600 5.356235
R5024 n1_m1_283200_201600 n1_m1_284000_201600 0.892706
R5025 n1_m1_288000_201600 n1_m1_284000_201600 4.463529
R5026 n1_m1_288000_201600 n1_m1_292800_201600 5.356235
R5027 n1_m1_292800_201600 n1_m1_297600_201600 5.356235
R5028 n1_m1_297600_201600 n1_m1_302400_201600 5.356235
R5029 n1_m1_302400_201600 n1_m1_307200_201600 5.356235
R5030 n1_m1_307200_201600 n1_m1_312000_201600 5.356235
R5031 n1_m1_312000_201600 n1_m1_316800_201600 5.356235
R5032 n1_m1_316800_201600 n1_m1_321600_201600 5.356235
R5033 n1_m1_321600_201600 n1_m1_326400_201600 5.356235
R5034 n1_m1_326400_201600 n1_m1_331200_201600 5.356235
R5035 n1_m1_331200_201600 n1_m1_336000_201600 5.356235
R5036 n1_m1_336000_201600 n1_m1_340000_201600 4.463529
R5037 n1_m1_340800_201600 n1_m1_340000_201600 0.892706
R5038 n1_m1_340800_201600 n1_m1_345600_201600 5.356235
R5039 n1_m1_345600_201600 n1_m1_350400_201600 5.356235
R5040 n1_m1_350400_201600 n1_m1_355200_201600 5.356235
R5041 n1_m1_355200_201600 n1_m1_360000_201600 5.356235
R5042 n1_m1_360000_201600 n1_m1_364800_201600 5.356235
R5043 n1_m1_364800_201600 n1_m1_368000_201600 3.570824
R5044 n1_m1_369600_201600 n1_m1_368000_201600 1.785412
R5045 n1_m1_369600_201600 n1_m1_374400_201600 5.356235
R5046 n1_m1_374400_201600 n1_m1_379200_201600 5.356235
R5047 n1_m1_379200_201600 n1_m1_384000_201600 5.356235
R5048 n1_m1_384000_201600 n1_m1_388800_201600 5.356235
R5049 n1_m1_388800_201600 n1_m1_393600_201600 5.356235
R5050 n1_m1_393600_201600 n1_m1_396000_201600 2.678118
R5051 n1_m1_398400_201600 n1_m1_396000_201600 2.678118
R5052 n1_m1_398400_201600 n1_m1_403200_201600 5.356235
R5053 n1_m1_403200_201600 n1_m1_408000_201600 5.356235
R5054 n1_m1_408000_201600 n1_m1_412800_201600 5.356235
R5055 n1_m1_412800_201600 n1_m1_417600_201600 5.356235
R5056 n1_m1_417600_201600 n1_m1_422400_201600 5.356235
R5057 n1_m1_422400_201600 n1_m1_424000_201600 1.785412
R5058 n1_m1_427200_201600 n1_m1_424000_201600 3.570824
R5059 n1_m1_427200_201600 n1_m1_432000_201600 5.356235
R5060 n1_m1_432000_201600 n1_m1_436800_201600 5.356235
R5061 n1_m1_436800_201600 n1_m1_441600_201600 5.356235
R5062 n1_m1_441600_201600 n1_m1_446400_201600 5.356235
R5063 n1_m1_446400_201600 n1_m1_451200_201600 5.356235
R5064 n1_m1_451200_201600 n1_m1_452000_201600 0.892706
R5065 n1_m1_456000_201600 n1_m1_452000_201600 4.463529
R5066 n1_m1_456000_201600 n1_m1_460800_201600 5.356235
R5067 n1_m1_460800_201600 n1_m1_465600_201600 5.356235
R5068 n1_m1_465600_201600 n1_m1_470400_201600 5.356235
R5069 n1_m1_470400_201600 n1_m1_475200_201600 5.356235
R5070 n1_m1_475200_201600 n1_m1_480000_201600 5.356235
R5071 n1_m1_480000_201600 n1_m1_484800_201600 5.356235
R5072 n1_m1_484800_201600 n1_m1_489600_201600 5.356235
R5073 n1_m1_489600_201600 n1_m1_494400_201600 5.356235
R5074 n1_m1_0_206400 n1_m1_4000_206400 4.463529
R5075 n1_m1_4800_206400 n1_m1_4000_206400 0.892706
R5076 n1_m1_4800_206400 n1_m1_9600_206400 5.356235
R5077 n1_m1_9600_206400 n1_m1_14400_206400 5.356235
R5078 n1_m1_14400_206400 n1_m1_19200_206400 5.356235
R5079 n1_m1_19200_206400 n1_m1_24000_206400 5.356235
R5080 n1_m1_24000_206400 n1_m1_28800_206400 5.356235
R5081 n1_m1_28800_206400 n1_m1_32000_206400 3.570824
R5082 n1_m1_33600_206400 n1_m1_32000_206400 1.785412
R5083 n1_m1_33600_206400 n1_m1_38400_206400 5.356235
R5084 n1_m1_38400_206400 n1_m1_43200_206400 5.356235
R5085 n1_m1_43200_206400 n1_m1_48000_206400 5.356235
R5086 n1_m1_48000_206400 n1_m1_52800_206400 5.356235
R5087 n1_m1_52800_206400 n1_m1_57600_206400 5.356235
R5088 n1_m1_57600_206400 n1_m1_60000_206400 2.678118
R5089 n1_m1_62400_206400 n1_m1_60000_206400 2.678118
R5090 n1_m1_62400_206400 n1_m1_67200_206400 5.356235
R5091 n1_m1_67200_206400 n1_m1_72000_206400 5.356235
R5092 n1_m1_72000_206400 n1_m1_76800_206400 5.356235
R5093 n1_m1_76800_206400 n1_m1_81600_206400 5.356235
R5094 n1_m1_81600_206400 n1_m1_86400_206400 5.356235
R5095 n1_m1_86400_206400 n1_m1_88000_206400 1.785412
R5096 n1_m1_91200_206400 n1_m1_88000_206400 3.570824
R5097 n1_m1_91200_206400 n1_m1_96000_206400 5.356235
R5098 n1_m1_96000_206400 n1_m1_100800_206400 5.356235
R5099 n1_m1_100800_206400 n1_m1_105600_206400 5.356235
R5100 n1_m1_105600_206400 n1_m1_110400_206400 5.356235
R5101 n1_m1_110400_206400 n1_m1_115200_206400 5.356235
R5102 n1_m1_115200_206400 n1_m1_116000_206400 0.892706
R5103 n1_m1_120000_206400 n1_m1_116000_206400 4.463529
R5104 n1_m1_120000_206400 n1_m1_124800_206400 5.356235
R5105 n1_m1_124800_206400 n1_m1_129600_206400 5.356235
R5106 n1_m1_129600_206400 n1_m1_134400_206400 5.356235
R5107 n1_m1_134400_206400 n1_m1_139200_206400 5.356235
R5108 n1_m1_139200_206400 n1_m1_144000_206400 5.356235
R5109 n1_m1_144000_206400 n1_m1_148800_206400 5.356235
R5110 n1_m1_148800_206400 n1_m1_153600_206400 5.356235
R5111 n1_m1_153600_206400 n1_m1_158400_206400 5.356235
R5112 n1_m1_158400_206400 n1_m1_163200_206400 5.356235
R5113 n1_m1_163200_206400 n1_m1_168000_206400 5.356235
R5114 n1_m1_168000_206400 n1_m1_172000_206400 4.463529
R5115 n1_m1_172800_206400 n1_m1_172000_206400 0.892706
R5116 n1_m1_172800_206400 n1_m1_177600_206400 5.356235
R5117 n1_m1_177600_206400 n1_m1_182400_206400 5.356235
R5118 n1_m1_182400_206400 n1_m1_187200_206400 5.356235
R5119 n1_m1_187200_206400 n1_m1_192000_206400 5.356235
R5120 n1_m1_192000_206400 n1_m1_196800_206400 5.356235
R5121 n1_m1_196800_206400 n1_m1_200000_206400 3.570824
R5122 n1_m1_201600_206400 n1_m1_200000_206400 1.785412
R5123 n1_m1_201600_206400 n1_m1_206400_206400 5.356235
R5124 n1_m1_206400_206400 n1_m1_211200_206400 5.356235
R5125 n1_m1_211200_206400 n1_m1_216000_206400 5.356235
R5126 n1_m1_216000_206400 n1_m1_220800_206400 5.356235
R5127 n1_m1_220800_206400 n1_m1_225600_206400 5.356235
R5128 n1_m1_225600_206400 n1_m1_228000_206400 2.678118
R5129 n1_m1_230400_206400 n1_m1_228000_206400 2.678118
R5130 n1_m1_230400_206400 n1_m1_235200_206400 5.356235
R5131 n1_m1_235200_206400 n1_m1_240000_206400 5.356235
R5132 n1_m1_240000_206400 n1_m1_244800_206400 5.356235
R5133 n1_m1_244800_206400 n1_m1_249600_206400 5.356235
R5134 n1_m1_249600_206400 n1_m1_254400_206400 5.356235
R5135 n1_m1_254400_206400 n1_m1_256000_206400 1.785412
R5136 n1_m1_259200_206400 n1_m1_256000_206400 3.570824
R5137 n1_m1_259200_206400 n1_m1_264000_206400 5.356235
R5138 n1_m1_264000_206400 n1_m1_268800_206400 5.356235
R5139 n1_m1_268800_206400 n1_m1_273600_206400 5.356235
R5140 n1_m1_273600_206400 n1_m1_278400_206400 5.356235
R5141 n1_m1_278400_206400 n1_m1_283200_206400 5.356235
R5142 n1_m1_283200_206400 n1_m1_284000_206400 0.892706
R5143 n1_m1_288000_206400 n1_m1_284000_206400 4.463529
R5144 n1_m1_288000_206400 n1_m1_292800_206400 5.356235
R5145 n1_m1_292800_206400 n1_m1_297600_206400 5.356235
R5146 n1_m1_297600_206400 n1_m1_302400_206400 5.356235
R5147 n1_m1_302400_206400 n1_m1_307200_206400 5.356235
R5148 n1_m1_307200_206400 n1_m1_312000_206400 5.356235
R5149 n1_m1_312000_206400 n1_m1_316800_206400 5.356235
R5150 n1_m1_316800_206400 n1_m1_321600_206400 5.356235
R5151 n1_m1_321600_206400 n1_m1_326400_206400 5.356235
R5152 n1_m1_326400_206400 n1_m1_331200_206400 5.356235
R5153 n1_m1_331200_206400 n1_m1_336000_206400 5.356235
R5154 n1_m1_336000_206400 n1_m1_340000_206400 4.463529
R5155 n1_m1_340800_206400 n1_m1_340000_206400 0.892706
R5156 n1_m1_340800_206400 n1_m1_345600_206400 5.356235
R5157 n1_m1_345600_206400 n1_m1_350400_206400 5.356235
R5158 n1_m1_350400_206400 n1_m1_355200_206400 5.356235
R5159 n1_m1_355200_206400 n1_m1_360000_206400 5.356235
R5160 n1_m1_360000_206400 n1_m1_364800_206400 5.356235
R5161 n1_m1_364800_206400 n1_m1_368000_206400 3.570824
R5162 n1_m1_369600_206400 n1_m1_368000_206400 1.785412
R5163 n1_m1_369600_206400 n1_m1_374400_206400 5.356235
R5164 n1_m1_374400_206400 n1_m1_379200_206400 5.356235
R5165 n1_m1_379200_206400 n1_m1_384000_206400 5.356235
R5166 n1_m1_384000_206400 n1_m1_388800_206400 5.356235
R5167 n1_m1_388800_206400 n1_m1_393600_206400 5.356235
R5168 n1_m1_393600_206400 n1_m1_396000_206400 2.678118
R5169 n1_m1_398400_206400 n1_m1_396000_206400 2.678118
R5170 n1_m1_398400_206400 n1_m1_403200_206400 5.356235
R5171 n1_m1_403200_206400 n1_m1_408000_206400 5.356235
R5172 n1_m1_408000_206400 n1_m1_412800_206400 5.356235
R5173 n1_m1_412800_206400 n1_m1_417600_206400 5.356235
R5174 n1_m1_417600_206400 n1_m1_422400_206400 5.356235
R5175 n1_m1_422400_206400 n1_m1_424000_206400 1.785412
R5176 n1_m1_427200_206400 n1_m1_424000_206400 3.570824
R5177 n1_m1_427200_206400 n1_m1_432000_206400 5.356235
R5178 n1_m1_432000_206400 n1_m1_436800_206400 5.356235
R5179 n1_m1_436800_206400 n1_m1_441600_206400 5.356235
R5180 n1_m1_441600_206400 n1_m1_446400_206400 5.356235
R5181 n1_m1_446400_206400 n1_m1_451200_206400 5.356235
R5182 n1_m1_451200_206400 n1_m1_452000_206400 0.892706
R5183 n1_m1_456000_206400 n1_m1_452000_206400 4.463529
R5184 n1_m1_456000_206400 n1_m1_460800_206400 5.356235
R5185 n1_m1_460800_206400 n1_m1_465600_206400 5.356235
R5186 n1_m1_465600_206400 n1_m1_470400_206400 5.356235
R5187 n1_m1_470400_206400 n1_m1_475200_206400 5.356235
R5188 n1_m1_475200_206400 n1_m1_480000_206400 5.356235
R5189 n1_m1_480000_206400 n1_m1_484800_206400 5.356235
R5190 n1_m1_484800_206400 n1_m1_489600_206400 5.356235
R5191 n1_m1_489600_206400 n1_m1_494400_206400 5.356235
R5192 n1_m1_0_211200 n1_m1_4000_211200 4.463529
R5193 n1_m1_4800_211200 n1_m1_4000_211200 0.892706
R5194 n1_m1_4800_211200 n1_m1_9600_211200 5.356235
R5195 n1_m1_9600_211200 n1_m1_14400_211200 5.356235
R5196 n1_m1_14400_211200 n1_m1_19200_211200 5.356235
R5197 n1_m1_19200_211200 n1_m1_24000_211200 5.356235
R5198 n1_m1_24000_211200 n1_m1_28800_211200 5.356235
R5199 n1_m1_28800_211200 n1_m1_32000_211200 3.570824
R5200 n1_m1_33600_211200 n1_m1_32000_211200 1.785412
R5201 n1_m1_33600_211200 n1_m1_38400_211200 5.356235
R5202 n1_m1_38400_211200 n1_m1_43200_211200 5.356235
R5203 n1_m1_43200_211200 n1_m1_48000_211200 5.356235
R5204 n1_m1_48000_211200 n1_m1_52800_211200 5.356235
R5205 n1_m1_52800_211200 n1_m1_57600_211200 5.356235
R5206 n1_m1_57600_211200 n1_m1_60000_211200 2.678118
R5207 n1_m1_62400_211200 n1_m1_60000_211200 2.678118
R5208 n1_m1_62400_211200 n1_m1_67200_211200 5.356235
R5209 n1_m1_67200_211200 n1_m1_72000_211200 5.356235
R5210 n1_m1_72000_211200 n1_m1_76800_211200 5.356235
R5211 n1_m1_76800_211200 n1_m1_81600_211200 5.356235
R5212 n1_m1_81600_211200 n1_m1_86400_211200 5.356235
R5213 n1_m1_86400_211200 n1_m1_88000_211200 1.785412
R5214 n1_m1_91200_211200 n1_m1_88000_211200 3.570824
R5215 n1_m1_91200_211200 n1_m1_96000_211200 5.356235
R5216 n1_m1_96000_211200 n1_m1_100800_211200 5.356235
R5217 n1_m1_100800_211200 n1_m1_105600_211200 5.356235
R5218 n1_m1_105600_211200 n1_m1_110400_211200 5.356235
R5219 n1_m1_110400_211200 n1_m1_115200_211200 5.356235
R5220 n1_m1_115200_211200 n1_m1_116000_211200 0.892706
R5221 n1_m1_120000_211200 n1_m1_116000_211200 4.463529
R5222 n1_m1_120000_211200 n1_m1_124800_211200 5.356235
R5223 n1_m1_124800_211200 n1_m1_129600_211200 5.356235
R5224 n1_m1_129600_211200 n1_m1_134400_211200 5.356235
R5225 n1_m1_134400_211200 n1_m1_139200_211200 5.356235
R5226 n1_m1_139200_211200 n1_m1_144000_211200 5.356235
R5227 n1_m1_144000_211200 n1_m1_148800_211200 5.356235
R5228 n1_m1_148800_211200 n1_m1_153600_211200 5.356235
R5229 n1_m1_153600_211200 n1_m1_158400_211200 5.356235
R5230 n1_m1_158400_211200 n1_m1_163200_211200 5.356235
R5231 n1_m1_163200_211200 n1_m1_168000_211200 5.356235
R5232 n1_m1_168000_211200 n1_m1_172000_211200 4.463529
R5233 n1_m1_172800_211200 n1_m1_172000_211200 0.892706
R5234 n1_m1_172800_211200 n1_m1_177600_211200 5.356235
R5235 n1_m1_177600_211200 n1_m1_182400_211200 5.356235
R5236 n1_m1_182400_211200 n1_m1_187200_211200 5.356235
R5237 n1_m1_187200_211200 n1_m1_192000_211200 5.356235
R5238 n1_m1_192000_211200 n1_m1_196800_211200 5.356235
R5239 n1_m1_196800_211200 n1_m1_200000_211200 3.570824
R5240 n1_m1_201600_211200 n1_m1_200000_211200 1.785412
R5241 n1_m1_201600_211200 n1_m1_206400_211200 5.356235
R5242 n1_m1_206400_211200 n1_m1_211200_211200 5.356235
R5243 n1_m1_211200_211200 n1_m1_216000_211200 5.356235
R5244 n1_m1_216000_211200 n1_m1_220800_211200 5.356235
R5245 n1_m1_220800_211200 n1_m1_225600_211200 5.356235
R5246 n1_m1_225600_211200 n1_m1_228000_211200 2.678118
R5247 n1_m1_230400_211200 n1_m1_228000_211200 2.678118
R5248 n1_m1_230400_211200 n1_m1_235200_211200 5.356235
R5249 n1_m1_235200_211200 n1_m1_240000_211200 5.356235
R5250 n1_m1_240000_211200 n1_m1_244800_211200 5.356235
R5251 n1_m1_244800_211200 n1_m1_249600_211200 5.356235
R5252 n1_m1_249600_211200 n1_m1_254400_211200 5.356235
R5253 n1_m1_254400_211200 n1_m1_256000_211200 1.785412
R5254 n1_m1_259200_211200 n1_m1_256000_211200 3.570824
R5255 n1_m1_259200_211200 n1_m1_264000_211200 5.356235
R5256 n1_m1_264000_211200 n1_m1_268800_211200 5.356235
R5257 n1_m1_268800_211200 n1_m1_273600_211200 5.356235
R5258 n1_m1_273600_211200 n1_m1_278400_211200 5.356235
R5259 n1_m1_278400_211200 n1_m1_283200_211200 5.356235
R5260 n1_m1_283200_211200 n1_m1_284000_211200 0.892706
R5261 n1_m1_288000_211200 n1_m1_284000_211200 4.463529
R5262 n1_m1_288000_211200 n1_m1_292800_211200 5.356235
R5263 n1_m1_292800_211200 n1_m1_297600_211200 5.356235
R5264 n1_m1_297600_211200 n1_m1_302400_211200 5.356235
R5265 n1_m1_302400_211200 n1_m1_307200_211200 5.356235
R5266 n1_m1_307200_211200 n1_m1_312000_211200 5.356235
R5267 n1_m1_312000_211200 n1_m1_316800_211200 5.356235
R5268 n1_m1_316800_211200 n1_m1_321600_211200 5.356235
R5269 n1_m1_321600_211200 n1_m1_326400_211200 5.356235
R5270 n1_m1_326400_211200 n1_m1_331200_211200 5.356235
R5271 n1_m1_331200_211200 n1_m1_336000_211200 5.356235
R5272 n1_m1_336000_211200 n1_m1_340000_211200 4.463529
R5273 n1_m1_340800_211200 n1_m1_340000_211200 0.892706
R5274 n1_m1_340800_211200 n1_m1_345600_211200 5.356235
R5275 n1_m1_345600_211200 n1_m1_350400_211200 5.356235
R5276 n1_m1_350400_211200 n1_m1_355200_211200 5.356235
R5277 n1_m1_355200_211200 n1_m1_360000_211200 5.356235
R5278 n1_m1_360000_211200 n1_m1_364800_211200 5.356235
R5279 n1_m1_364800_211200 n1_m1_368000_211200 3.570824
R5280 n1_m1_369600_211200 n1_m1_368000_211200 1.785412
R5281 n1_m1_369600_211200 n1_m1_374400_211200 5.356235
R5282 n1_m1_374400_211200 n1_m1_379200_211200 5.356235
R5283 n1_m1_379200_211200 n1_m1_384000_211200 5.356235
R5284 n1_m1_384000_211200 n1_m1_388800_211200 5.356235
R5285 n1_m1_388800_211200 n1_m1_393600_211200 5.356235
R5286 n1_m1_393600_211200 n1_m1_396000_211200 2.678118
R5287 n1_m1_398400_211200 n1_m1_396000_211200 2.678118
R5288 n1_m1_398400_211200 n1_m1_403200_211200 5.356235
R5289 n1_m1_403200_211200 n1_m1_408000_211200 5.356235
R5290 n1_m1_408000_211200 n1_m1_412800_211200 5.356235
R5291 n1_m1_412800_211200 n1_m1_417600_211200 5.356235
R5292 n1_m1_417600_211200 n1_m1_422400_211200 5.356235
R5293 n1_m1_422400_211200 n1_m1_424000_211200 1.785412
R5294 n1_m1_427200_211200 n1_m1_424000_211200 3.570824
R5295 n1_m1_427200_211200 n1_m1_432000_211200 5.356235
R5296 n1_m1_432000_211200 n1_m1_436800_211200 5.356235
R5297 n1_m1_436800_211200 n1_m1_441600_211200 5.356235
R5298 n1_m1_441600_211200 n1_m1_446400_211200 5.356235
R5299 n1_m1_446400_211200 n1_m1_451200_211200 5.356235
R5300 n1_m1_451200_211200 n1_m1_452000_211200 0.892706
R5301 n1_m1_456000_211200 n1_m1_452000_211200 4.463529
R5302 n1_m1_456000_211200 n1_m1_460800_211200 5.356235
R5303 n1_m1_460800_211200 n1_m1_465600_211200 5.356235
R5304 n1_m1_465600_211200 n1_m1_470400_211200 5.356235
R5305 n1_m1_470400_211200 n1_m1_475200_211200 5.356235
R5306 n1_m1_475200_211200 n1_m1_480000_211200 5.356235
R5307 n1_m1_480000_211200 n1_m1_484800_211200 5.356235
R5308 n1_m1_484800_211200 n1_m1_489600_211200 5.356235
R5309 n1_m1_489600_211200 n1_m1_494400_211200 5.356235
R5310 n1_m1_0_216000 n1_m1_4000_216000 4.463529
R5311 n1_m1_4800_216000 n1_m1_4000_216000 0.892706
R5312 n1_m1_4800_216000 n1_m1_9600_216000 5.356235
R5313 n1_m1_9600_216000 n1_m1_14400_216000 5.356235
R5314 n1_m1_14400_216000 n1_m1_19200_216000 5.356235
R5315 n1_m1_19200_216000 n1_m1_24000_216000 5.356235
R5316 n1_m1_24000_216000 n1_m1_28800_216000 5.356235
R5317 n1_m1_28800_216000 n1_m1_32000_216000 3.570824
R5318 n1_m1_33600_216000 n1_m1_32000_216000 1.785412
R5319 n1_m1_33600_216000 n1_m1_38400_216000 5.356235
R5320 n1_m1_38400_216000 n1_m1_43200_216000 5.356235
R5321 n1_m1_43200_216000 n1_m1_48000_216000 5.356235
R5322 n1_m1_48000_216000 n1_m1_52800_216000 5.356235
R5323 n1_m1_52800_216000 n1_m1_57600_216000 5.356235
R5324 n1_m1_57600_216000 n1_m1_60000_216000 2.678118
R5325 n1_m1_62400_216000 n1_m1_60000_216000 2.678118
R5326 n1_m1_62400_216000 n1_m1_67200_216000 5.356235
R5327 n1_m1_67200_216000 n1_m1_72000_216000 5.356235
R5328 n1_m1_72000_216000 n1_m1_76800_216000 5.356235
R5329 n1_m1_76800_216000 n1_m1_81600_216000 5.356235
R5330 n1_m1_81600_216000 n1_m1_86400_216000 5.356235
R5331 n1_m1_86400_216000 n1_m1_88000_216000 1.785412
R5332 n1_m1_91200_216000 n1_m1_88000_216000 3.570824
R5333 n1_m1_91200_216000 n1_m1_96000_216000 5.356235
R5334 n1_m1_96000_216000 n1_m1_100800_216000 5.356235
R5335 n1_m1_100800_216000 n1_m1_105600_216000 5.356235
R5336 n1_m1_105600_216000 n1_m1_110400_216000 5.356235
R5337 n1_m1_110400_216000 n1_m1_115200_216000 5.356235
R5338 n1_m1_115200_216000 n1_m1_116000_216000 0.892706
R5339 n1_m1_120000_216000 n1_m1_116000_216000 4.463529
R5340 n1_m1_120000_216000 n1_m1_124800_216000 5.356235
R5341 n1_m1_124800_216000 n1_m1_129600_216000 5.356235
R5342 n1_m1_129600_216000 n1_m1_134400_216000 5.356235
R5343 n1_m1_134400_216000 n1_m1_139200_216000 5.356235
R5344 n1_m1_139200_216000 n1_m1_144000_216000 5.356235
R5345 n1_m1_144000_216000 n1_m1_148800_216000 5.356235
R5346 n1_m1_148800_216000 n1_m1_153600_216000 5.356235
R5347 n1_m1_153600_216000 n1_m1_158400_216000 5.356235
R5348 n1_m1_158400_216000 n1_m1_163200_216000 5.356235
R5349 n1_m1_163200_216000 n1_m1_168000_216000 5.356235
R5350 n1_m1_168000_216000 n1_m1_172000_216000 4.463529
R5351 n1_m1_172800_216000 n1_m1_172000_216000 0.892706
R5352 n1_m1_172800_216000 n1_m1_177600_216000 5.356235
R5353 n1_m1_177600_216000 n1_m1_182400_216000 5.356235
R5354 n1_m1_182400_216000 n1_m1_187200_216000 5.356235
R5355 n1_m1_187200_216000 n1_m1_192000_216000 5.356235
R5356 n1_m1_192000_216000 n1_m1_196800_216000 5.356235
R5357 n1_m1_196800_216000 n1_m1_200000_216000 3.570824
R5358 n1_m1_201600_216000 n1_m1_200000_216000 1.785412
R5359 n1_m1_201600_216000 n1_m1_206400_216000 5.356235
R5360 n1_m1_206400_216000 n1_m1_211200_216000 5.356235
R5361 n1_m1_211200_216000 n1_m1_216000_216000 5.356235
R5362 n1_m1_216000_216000 n1_m1_220800_216000 5.356235
R5363 n1_m1_220800_216000 n1_m1_225600_216000 5.356235
R5364 n1_m1_225600_216000 n1_m1_228000_216000 2.678118
R5365 n1_m1_230400_216000 n1_m1_228000_216000 2.678118
R5366 n1_m1_230400_216000 n1_m1_235200_216000 5.356235
R5367 n1_m1_235200_216000 n1_m1_240000_216000 5.356235
R5368 n1_m1_240000_216000 n1_m1_244800_216000 5.356235
R5369 n1_m1_244800_216000 n1_m1_249600_216000 5.356235
R5370 n1_m1_249600_216000 n1_m1_254400_216000 5.356235
R5371 n1_m1_254400_216000 n1_m1_256000_216000 1.785412
R5372 n1_m1_259200_216000 n1_m1_256000_216000 3.570824
R5373 n1_m1_259200_216000 n1_m1_264000_216000 5.356235
R5374 n1_m1_264000_216000 n1_m1_268800_216000 5.356235
R5375 n1_m1_268800_216000 n1_m1_273600_216000 5.356235
R5376 n1_m1_273600_216000 n1_m1_278400_216000 5.356235
R5377 n1_m1_278400_216000 n1_m1_283200_216000 5.356235
R5378 n1_m1_283200_216000 n1_m1_284000_216000 0.892706
R5379 n1_m1_288000_216000 n1_m1_284000_216000 4.463529
R5380 n1_m1_288000_216000 n1_m1_292800_216000 5.356235
R5381 n1_m1_292800_216000 n1_m1_297600_216000 5.356235
R5382 n1_m1_297600_216000 n1_m1_302400_216000 5.356235
R5383 n1_m1_302400_216000 n1_m1_307200_216000 5.356235
R5384 n1_m1_307200_216000 n1_m1_312000_216000 5.356235
R5385 n1_m1_312000_216000 n1_m1_316800_216000 5.356235
R5386 n1_m1_316800_216000 n1_m1_321600_216000 5.356235
R5387 n1_m1_321600_216000 n1_m1_326400_216000 5.356235
R5388 n1_m1_326400_216000 n1_m1_331200_216000 5.356235
R5389 n1_m1_331200_216000 n1_m1_336000_216000 5.356235
R5390 n1_m1_336000_216000 n1_m1_340000_216000 4.463529
R5391 n1_m1_340800_216000 n1_m1_340000_216000 0.892706
R5392 n1_m1_340800_216000 n1_m1_345600_216000 5.356235
R5393 n1_m1_345600_216000 n1_m1_350400_216000 5.356235
R5394 n1_m1_350400_216000 n1_m1_355200_216000 5.356235
R5395 n1_m1_355200_216000 n1_m1_360000_216000 5.356235
R5396 n1_m1_360000_216000 n1_m1_364800_216000 5.356235
R5397 n1_m1_364800_216000 n1_m1_368000_216000 3.570824
R5398 n1_m1_369600_216000 n1_m1_368000_216000 1.785412
R5399 n1_m1_369600_216000 n1_m1_374400_216000 5.356235
R5400 n1_m1_374400_216000 n1_m1_379200_216000 5.356235
R5401 n1_m1_379200_216000 n1_m1_384000_216000 5.356235
R5402 n1_m1_384000_216000 n1_m1_388800_216000 5.356235
R5403 n1_m1_388800_216000 n1_m1_393600_216000 5.356235
R5404 n1_m1_393600_216000 n1_m1_396000_216000 2.678118
R5405 n1_m1_398400_216000 n1_m1_396000_216000 2.678118
R5406 n1_m1_398400_216000 n1_m1_403200_216000 5.356235
R5407 n1_m1_403200_216000 n1_m1_408000_216000 5.356235
R5408 n1_m1_408000_216000 n1_m1_412800_216000 5.356235
R5409 n1_m1_412800_216000 n1_m1_417600_216000 5.356235
R5410 n1_m1_417600_216000 n1_m1_422400_216000 5.356235
R5411 n1_m1_422400_216000 n1_m1_424000_216000 1.785412
R5412 n1_m1_427200_216000 n1_m1_424000_216000 3.570824
R5413 n1_m1_427200_216000 n1_m1_432000_216000 5.356235
R5414 n1_m1_432000_216000 n1_m1_436800_216000 5.356235
R5415 n1_m1_436800_216000 n1_m1_441600_216000 5.356235
R5416 n1_m1_441600_216000 n1_m1_446400_216000 5.356235
R5417 n1_m1_446400_216000 n1_m1_451200_216000 5.356235
R5418 n1_m1_451200_216000 n1_m1_452000_216000 0.892706
R5419 n1_m1_456000_216000 n1_m1_452000_216000 4.463529
R5420 n1_m1_456000_216000 n1_m1_460800_216000 5.356235
R5421 n1_m1_460800_216000 n1_m1_465600_216000 5.356235
R5422 n1_m1_465600_216000 n1_m1_470400_216000 5.356235
R5423 n1_m1_470400_216000 n1_m1_475200_216000 5.356235
R5424 n1_m1_475200_216000 n1_m1_480000_216000 5.356235
R5425 n1_m1_480000_216000 n1_m1_484800_216000 5.356235
R5426 n1_m1_484800_216000 n1_m1_489600_216000 5.356235
R5427 n1_m1_489600_216000 n1_m1_494400_216000 5.356235
R5428 n1_m1_0_220800 n1_m1_4000_220800 4.463529
R5429 n1_m1_4800_220800 n1_m1_4000_220800 0.892706
R5430 n1_m1_4800_220800 n1_m1_9600_220800 5.356235
R5431 n1_m1_9600_220800 n1_m1_14400_220800 5.356235
R5432 n1_m1_14400_220800 n1_m1_19200_220800 5.356235
R5433 n1_m1_19200_220800 n1_m1_24000_220800 5.356235
R5434 n1_m1_24000_220800 n1_m1_28800_220800 5.356235
R5435 n1_m1_28800_220800 n1_m1_32000_220800 3.570824
R5436 n1_m1_33600_220800 n1_m1_32000_220800 1.785412
R5437 n1_m1_33600_220800 n1_m1_38400_220800 5.356235
R5438 n1_m1_38400_220800 n1_m1_43200_220800 5.356235
R5439 n1_m1_43200_220800 n1_m1_48000_220800 5.356235
R5440 n1_m1_48000_220800 n1_m1_52800_220800 5.356235
R5441 n1_m1_52800_220800 n1_m1_57600_220800 5.356235
R5442 n1_m1_57600_220800 n1_m1_60000_220800 2.678118
R5443 n1_m1_62400_220800 n1_m1_60000_220800 2.678118
R5444 n1_m1_62400_220800 n1_m1_67200_220800 5.356235
R5445 n1_m1_67200_220800 n1_m1_72000_220800 5.356235
R5446 n1_m1_72000_220800 n1_m1_76800_220800 5.356235
R5447 n1_m1_76800_220800 n1_m1_81600_220800 5.356235
R5448 n1_m1_81600_220800 n1_m1_86400_220800 5.356235
R5449 n1_m1_86400_220800 n1_m1_88000_220800 1.785412
R5450 n1_m1_91200_220800 n1_m1_88000_220800 3.570824
R5451 n1_m1_91200_220800 n1_m1_96000_220800 5.356235
R5452 n1_m1_96000_220800 n1_m1_100800_220800 5.356235
R5453 n1_m1_100800_220800 n1_m1_105600_220800 5.356235
R5454 n1_m1_105600_220800 n1_m1_110400_220800 5.356235
R5455 n1_m1_110400_220800 n1_m1_115200_220800 5.356235
R5456 n1_m1_115200_220800 n1_m1_116000_220800 0.892706
R5457 n1_m1_120000_220800 n1_m1_116000_220800 4.463529
R5458 n1_m1_120000_220800 n1_m1_124800_220800 5.356235
R5459 n1_m1_124800_220800 n1_m1_129600_220800 5.356235
R5460 n1_m1_129600_220800 n1_m1_134400_220800 5.356235
R5461 n1_m1_134400_220800 n1_m1_139200_220800 5.356235
R5462 n1_m1_139200_220800 n1_m1_144000_220800 5.356235
R5463 n1_m1_144000_220800 n1_m1_148800_220800 5.356235
R5464 n1_m1_148800_220800 n1_m1_153600_220800 5.356235
R5465 n1_m1_153600_220800 n1_m1_158400_220800 5.356235
R5466 n1_m1_158400_220800 n1_m1_163200_220800 5.356235
R5467 n1_m1_163200_220800 n1_m1_168000_220800 5.356235
R5468 n1_m1_168000_220800 n1_m1_172000_220800 4.463529
R5469 n1_m1_172800_220800 n1_m1_172000_220800 0.892706
R5470 n1_m1_172800_220800 n1_m1_177600_220800 5.356235
R5471 n1_m1_177600_220800 n1_m1_182400_220800 5.356235
R5472 n1_m1_182400_220800 n1_m1_187200_220800 5.356235
R5473 n1_m1_187200_220800 n1_m1_192000_220800 5.356235
R5474 n1_m1_192000_220800 n1_m1_196800_220800 5.356235
R5475 n1_m1_196800_220800 n1_m1_200000_220800 3.570824
R5476 n1_m1_201600_220800 n1_m1_200000_220800 1.785412
R5477 n1_m1_201600_220800 n1_m1_206400_220800 5.356235
R5478 n1_m1_206400_220800 n1_m1_211200_220800 5.356235
R5479 n1_m1_211200_220800 n1_m1_216000_220800 5.356235
R5480 n1_m1_216000_220800 n1_m1_220800_220800 5.356235
R5481 n1_m1_220800_220800 n1_m1_225600_220800 5.356235
R5482 n1_m1_225600_220800 n1_m1_228000_220800 2.678118
R5483 n1_m1_230400_220800 n1_m1_228000_220800 2.678118
R5484 n1_m1_230400_220800 n1_m1_235200_220800 5.356235
R5485 n1_m1_235200_220800 n1_m1_240000_220800 5.356235
R5486 n1_m1_240000_220800 n1_m1_244800_220800 5.356235
R5487 n1_m1_244800_220800 n1_m1_249600_220800 5.356235
R5488 n1_m1_249600_220800 n1_m1_254400_220800 5.356235
R5489 n1_m1_254400_220800 n1_m1_256000_220800 1.785412
R5490 n1_m1_259200_220800 n1_m1_256000_220800 3.570824
R5491 n1_m1_259200_220800 n1_m1_264000_220800 5.356235
R5492 n1_m1_264000_220800 n1_m1_268800_220800 5.356235
R5493 n1_m1_268800_220800 n1_m1_273600_220800 5.356235
R5494 n1_m1_273600_220800 n1_m1_278400_220800 5.356235
R5495 n1_m1_278400_220800 n1_m1_283200_220800 5.356235
R5496 n1_m1_283200_220800 n1_m1_284000_220800 0.892706
R5497 n1_m1_288000_220800 n1_m1_284000_220800 4.463529
R5498 n1_m1_288000_220800 n1_m1_292800_220800 5.356235
R5499 n1_m1_292800_220800 n1_m1_297600_220800 5.356235
R5500 n1_m1_297600_220800 n1_m1_302400_220800 5.356235
R5501 n1_m1_302400_220800 n1_m1_307200_220800 5.356235
R5502 n1_m1_307200_220800 n1_m1_312000_220800 5.356235
R5503 n1_m1_312000_220800 n1_m1_316800_220800 5.356235
R5504 n1_m1_316800_220800 n1_m1_321600_220800 5.356235
R5505 n1_m1_321600_220800 n1_m1_326400_220800 5.356235
R5506 n1_m1_326400_220800 n1_m1_331200_220800 5.356235
R5507 n1_m1_331200_220800 n1_m1_336000_220800 5.356235
R5508 n1_m1_336000_220800 n1_m1_340000_220800 4.463529
R5509 n1_m1_340800_220800 n1_m1_340000_220800 0.892706
R5510 n1_m1_340800_220800 n1_m1_345600_220800 5.356235
R5511 n1_m1_345600_220800 n1_m1_350400_220800 5.356235
R5512 n1_m1_350400_220800 n1_m1_355200_220800 5.356235
R5513 n1_m1_355200_220800 n1_m1_360000_220800 5.356235
R5514 n1_m1_360000_220800 n1_m1_364800_220800 5.356235
R5515 n1_m1_364800_220800 n1_m1_368000_220800 3.570824
R5516 n1_m1_369600_220800 n1_m1_368000_220800 1.785412
R5517 n1_m1_369600_220800 n1_m1_374400_220800 5.356235
R5518 n1_m1_374400_220800 n1_m1_379200_220800 5.356235
R5519 n1_m1_379200_220800 n1_m1_384000_220800 5.356235
R5520 n1_m1_384000_220800 n1_m1_388800_220800 5.356235
R5521 n1_m1_388800_220800 n1_m1_393600_220800 5.356235
R5522 n1_m1_393600_220800 n1_m1_396000_220800 2.678118
R5523 n1_m1_398400_220800 n1_m1_396000_220800 2.678118
R5524 n1_m1_398400_220800 n1_m1_403200_220800 5.356235
R5525 n1_m1_403200_220800 n1_m1_408000_220800 5.356235
R5526 n1_m1_408000_220800 n1_m1_412800_220800 5.356235
R5527 n1_m1_412800_220800 n1_m1_417600_220800 5.356235
R5528 n1_m1_417600_220800 n1_m1_422400_220800 5.356235
R5529 n1_m1_422400_220800 n1_m1_424000_220800 1.785412
R5530 n1_m1_427200_220800 n1_m1_424000_220800 3.570824
R5531 n1_m1_427200_220800 n1_m1_432000_220800 5.356235
R5532 n1_m1_432000_220800 n1_m1_436800_220800 5.356235
R5533 n1_m1_436800_220800 n1_m1_441600_220800 5.356235
R5534 n1_m1_441600_220800 n1_m1_446400_220800 5.356235
R5535 n1_m1_446400_220800 n1_m1_451200_220800 5.356235
R5536 n1_m1_451200_220800 n1_m1_452000_220800 0.892706
R5537 n1_m1_456000_220800 n1_m1_452000_220800 4.463529
R5538 n1_m1_456000_220800 n1_m1_460800_220800 5.356235
R5539 n1_m1_460800_220800 n1_m1_465600_220800 5.356235
R5540 n1_m1_465600_220800 n1_m1_470400_220800 5.356235
R5541 n1_m1_470400_220800 n1_m1_475200_220800 5.356235
R5542 n1_m1_475200_220800 n1_m1_480000_220800 5.356235
R5543 n1_m1_480000_220800 n1_m1_484800_220800 5.356235
R5544 n1_m1_484800_220800 n1_m1_489600_220800 5.356235
R5545 n1_m1_489600_220800 n1_m1_494400_220800 5.356235
R5546 n1_m1_0_225600 n1_m1_4000_225600 4.463529
R5547 n1_m1_4800_225600 n1_m1_4000_225600 0.892706
R5548 n1_m1_4800_225600 n1_m1_9600_225600 5.356235
R5549 n1_m1_9600_225600 n1_m1_14400_225600 5.356235
R5550 n1_m1_14400_225600 n1_m1_19200_225600 5.356235
R5551 n1_m1_19200_225600 n1_m1_24000_225600 5.356235
R5552 n1_m1_24000_225600 n1_m1_28800_225600 5.356235
R5553 n1_m1_28800_225600 n1_m1_32000_225600 3.570824
R5554 n1_m1_33600_225600 n1_m1_32000_225600 1.785412
R5555 n1_m1_33600_225600 n1_m1_38400_225600 5.356235
R5556 n1_m1_38400_225600 n1_m1_43200_225600 5.356235
R5557 n1_m1_43200_225600 n1_m1_48000_225600 5.356235
R5558 n1_m1_48000_225600 n1_m1_52800_225600 5.356235
R5559 n1_m1_52800_225600 n1_m1_57600_225600 5.356235
R5560 n1_m1_57600_225600 n1_m1_60000_225600 2.678118
R5561 n1_m1_62400_225600 n1_m1_60000_225600 2.678118
R5562 n1_m1_62400_225600 n1_m1_67200_225600 5.356235
R5563 n1_m1_67200_225600 n1_m1_72000_225600 5.356235
R5564 n1_m1_72000_225600 n1_m1_76800_225600 5.356235
R5565 n1_m1_76800_225600 n1_m1_81600_225600 5.356235
R5566 n1_m1_81600_225600 n1_m1_86400_225600 5.356235
R5567 n1_m1_86400_225600 n1_m1_88000_225600 1.785412
R5568 n1_m1_91200_225600 n1_m1_88000_225600 3.570824
R5569 n1_m1_91200_225600 n1_m1_96000_225600 5.356235
R5570 n1_m1_96000_225600 n1_m1_100800_225600 5.356235
R5571 n1_m1_100800_225600 n1_m1_105600_225600 5.356235
R5572 n1_m1_105600_225600 n1_m1_110400_225600 5.356235
R5573 n1_m1_110400_225600 n1_m1_115200_225600 5.356235
R5574 n1_m1_115200_225600 n1_m1_116000_225600 0.892706
R5575 n1_m1_120000_225600 n1_m1_116000_225600 4.463529
R5576 n1_m1_120000_225600 n1_m1_124800_225600 5.356235
R5577 n1_m1_124800_225600 n1_m1_129600_225600 5.356235
R5578 n1_m1_129600_225600 n1_m1_134400_225600 5.356235
R5579 n1_m1_134400_225600 n1_m1_139200_225600 5.356235
R5580 n1_m1_139200_225600 n1_m1_144000_225600 5.356235
R5581 n1_m1_144000_225600 n1_m1_148800_225600 5.356235
R5582 n1_m1_148800_225600 n1_m1_153600_225600 5.356235
R5583 n1_m1_153600_225600 n1_m1_158400_225600 5.356235
R5584 n1_m1_158400_225600 n1_m1_163200_225600 5.356235
R5585 n1_m1_163200_225600 n1_m1_168000_225600 5.356235
R5586 n1_m1_168000_225600 n1_m1_172000_225600 4.463529
R5587 n1_m1_172800_225600 n1_m1_172000_225600 0.892706
R5588 n1_m1_172800_225600 n1_m1_177600_225600 5.356235
R5589 n1_m1_177600_225600 n1_m1_182400_225600 5.356235
R5590 n1_m1_182400_225600 n1_m1_187200_225600 5.356235
R5591 n1_m1_187200_225600 n1_m1_192000_225600 5.356235
R5592 n1_m1_192000_225600 n1_m1_196800_225600 5.356235
R5593 n1_m1_196800_225600 n1_m1_200000_225600 3.570824
R5594 n1_m1_201600_225600 n1_m1_200000_225600 1.785412
R5595 n1_m1_201600_225600 n1_m1_206400_225600 5.356235
R5596 n1_m1_206400_225600 n1_m1_211200_225600 5.356235
R5597 n1_m1_211200_225600 n1_m1_216000_225600 5.356235
R5598 n1_m1_216000_225600 n1_m1_220800_225600 5.356235
R5599 n1_m1_220800_225600 n1_m1_225600_225600 5.356235
R5600 n1_m1_225600_225600 n1_m1_228000_225600 2.678118
R5601 n1_m1_230400_225600 n1_m1_228000_225600 2.678118
R5602 n1_m1_230400_225600 n1_m1_235200_225600 5.356235
R5603 n1_m1_235200_225600 n1_m1_240000_225600 5.356235
R5604 n1_m1_240000_225600 n1_m1_244800_225600 5.356235
R5605 n1_m1_244800_225600 n1_m1_249600_225600 5.356235
R5606 n1_m1_249600_225600 n1_m1_254400_225600 5.356235
R5607 n1_m1_254400_225600 n1_m1_256000_225600 1.785412
R5608 n1_m1_259200_225600 n1_m1_256000_225600 3.570824
R5609 n1_m1_259200_225600 n1_m1_264000_225600 5.356235
R5610 n1_m1_264000_225600 n1_m1_268800_225600 5.356235
R5611 n1_m1_268800_225600 n1_m1_273600_225600 5.356235
R5612 n1_m1_273600_225600 n1_m1_278400_225600 5.356235
R5613 n1_m1_278400_225600 n1_m1_283200_225600 5.356235
R5614 n1_m1_283200_225600 n1_m1_284000_225600 0.892706
R5615 n1_m1_288000_225600 n1_m1_284000_225600 4.463529
R5616 n1_m1_288000_225600 n1_m1_292800_225600 5.356235
R5617 n1_m1_292800_225600 n1_m1_297600_225600 5.356235
R5618 n1_m1_297600_225600 n1_m1_302400_225600 5.356235
R5619 n1_m1_302400_225600 n1_m1_307200_225600 5.356235
R5620 n1_m1_307200_225600 n1_m1_312000_225600 5.356235
R5621 n1_m1_312000_225600 n1_m1_316800_225600 5.356235
R5622 n1_m1_316800_225600 n1_m1_321600_225600 5.356235
R5623 n1_m1_321600_225600 n1_m1_326400_225600 5.356235
R5624 n1_m1_326400_225600 n1_m1_331200_225600 5.356235
R5625 n1_m1_331200_225600 n1_m1_336000_225600 5.356235
R5626 n1_m1_336000_225600 n1_m1_340000_225600 4.463529
R5627 n1_m1_340800_225600 n1_m1_340000_225600 0.892706
R5628 n1_m1_340800_225600 n1_m1_345600_225600 5.356235
R5629 n1_m1_345600_225600 n1_m1_350400_225600 5.356235
R5630 n1_m1_350400_225600 n1_m1_355200_225600 5.356235
R5631 n1_m1_355200_225600 n1_m1_360000_225600 5.356235
R5632 n1_m1_360000_225600 n1_m1_364800_225600 5.356235
R5633 n1_m1_364800_225600 n1_m1_368000_225600 3.570824
R5634 n1_m1_369600_225600 n1_m1_368000_225600 1.785412
R5635 n1_m1_369600_225600 n1_m1_374400_225600 5.356235
R5636 n1_m1_374400_225600 n1_m1_379200_225600 5.356235
R5637 n1_m1_379200_225600 n1_m1_384000_225600 5.356235
R5638 n1_m1_384000_225600 n1_m1_388800_225600 5.356235
R5639 n1_m1_388800_225600 n1_m1_393600_225600 5.356235
R5640 n1_m1_393600_225600 n1_m1_396000_225600 2.678118
R5641 n1_m1_398400_225600 n1_m1_396000_225600 2.678118
R5642 n1_m1_398400_225600 n1_m1_403200_225600 5.356235
R5643 n1_m1_403200_225600 n1_m1_408000_225600 5.356235
R5644 n1_m1_408000_225600 n1_m1_412800_225600 5.356235
R5645 n1_m1_412800_225600 n1_m1_417600_225600 5.356235
R5646 n1_m1_417600_225600 n1_m1_422400_225600 5.356235
R5647 n1_m1_422400_225600 n1_m1_424000_225600 1.785412
R5648 n1_m1_427200_225600 n1_m1_424000_225600 3.570824
R5649 n1_m1_427200_225600 n1_m1_432000_225600 5.356235
R5650 n1_m1_432000_225600 n1_m1_436800_225600 5.356235
R5651 n1_m1_436800_225600 n1_m1_441600_225600 5.356235
R5652 n1_m1_441600_225600 n1_m1_446400_225600 5.356235
R5653 n1_m1_446400_225600 n1_m1_451200_225600 5.356235
R5654 n1_m1_451200_225600 n1_m1_452000_225600 0.892706
R5655 n1_m1_456000_225600 n1_m1_452000_225600 4.463529
R5656 n1_m1_456000_225600 n1_m1_460800_225600 5.356235
R5657 n1_m1_460800_225600 n1_m1_465600_225600 5.356235
R5658 n1_m1_465600_225600 n1_m1_470400_225600 5.356235
R5659 n1_m1_470400_225600 n1_m1_475200_225600 5.356235
R5660 n1_m1_475200_225600 n1_m1_480000_225600 5.356235
R5661 n1_m1_480000_225600 n1_m1_484800_225600 5.356235
R5662 n1_m1_484800_225600 n1_m1_489600_225600 5.356235
R5663 n1_m1_489600_225600 n1_m1_494400_225600 5.356235
R5664 n1_m1_0_230400 n1_m1_4000_230400 4.463529
R5665 n1_m1_4800_230400 n1_m1_4000_230400 0.892706
R5666 n1_m1_4800_230400 n1_m1_9600_230400 5.356235
R5667 n1_m1_9600_230400 n1_m1_14400_230400 5.356235
R5668 n1_m1_14400_230400 n1_m1_19200_230400 5.356235
R5669 n1_m1_19200_230400 n1_m1_24000_230400 5.356235
R5670 n1_m1_24000_230400 n1_m1_28800_230400 5.356235
R5671 n1_m1_28800_230400 n1_m1_32000_230400 3.570824
R5672 n1_m1_33600_230400 n1_m1_32000_230400 1.785412
R5673 n1_m1_33600_230400 n1_m1_38400_230400 5.356235
R5674 n1_m1_38400_230400 n1_m1_43200_230400 5.356235
R5675 n1_m1_43200_230400 n1_m1_48000_230400 5.356235
R5676 n1_m1_48000_230400 n1_m1_52800_230400 5.356235
R5677 n1_m1_52800_230400 n1_m1_57600_230400 5.356235
R5678 n1_m1_57600_230400 n1_m1_60000_230400 2.678118
R5679 n1_m1_62400_230400 n1_m1_60000_230400 2.678118
R5680 n1_m1_62400_230400 n1_m1_67200_230400 5.356235
R5681 n1_m1_67200_230400 n1_m1_72000_230400 5.356235
R5682 n1_m1_72000_230400 n1_m1_76800_230400 5.356235
R5683 n1_m1_76800_230400 n1_m1_81600_230400 5.356235
R5684 n1_m1_81600_230400 n1_m1_86400_230400 5.356235
R5685 n1_m1_86400_230400 n1_m1_88000_230400 1.785412
R5686 n1_m1_91200_230400 n1_m1_88000_230400 3.570824
R5687 n1_m1_91200_230400 n1_m1_96000_230400 5.356235
R5688 n1_m1_96000_230400 n1_m1_100800_230400 5.356235
R5689 n1_m1_100800_230400 n1_m1_105600_230400 5.356235
R5690 n1_m1_105600_230400 n1_m1_110400_230400 5.356235
R5691 n1_m1_110400_230400 n1_m1_115200_230400 5.356235
R5692 n1_m1_115200_230400 n1_m1_116000_230400 0.892706
R5693 n1_m1_120000_230400 n1_m1_116000_230400 4.463529
R5694 n1_m1_120000_230400 n1_m1_124800_230400 5.356235
R5695 n1_m1_124800_230400 n1_m1_129600_230400 5.356235
R5696 n1_m1_129600_230400 n1_m1_134400_230400 5.356235
R5697 n1_m1_134400_230400 n1_m1_139200_230400 5.356235
R5698 n1_m1_139200_230400 n1_m1_144000_230400 5.356235
R5699 n1_m1_144000_230400 n1_m1_148800_230400 5.356235
R5700 n1_m1_148800_230400 n1_m1_153600_230400 5.356235
R5701 n1_m1_153600_230400 n1_m1_158400_230400 5.356235
R5702 n1_m1_158400_230400 n1_m1_163200_230400 5.356235
R5703 n1_m1_163200_230400 n1_m1_168000_230400 5.356235
R5704 n1_m1_168000_230400 n1_m1_172000_230400 4.463529
R5705 n1_m1_172800_230400 n1_m1_172000_230400 0.892706
R5706 n1_m1_172800_230400 n1_m1_177600_230400 5.356235
R5707 n1_m1_177600_230400 n1_m1_182400_230400 5.356235
R5708 n1_m1_182400_230400 n1_m1_187200_230400 5.356235
R5709 n1_m1_187200_230400 n1_m1_192000_230400 5.356235
R5710 n1_m1_192000_230400 n1_m1_196800_230400 5.356235
R5711 n1_m1_196800_230400 n1_m1_200000_230400 3.570824
R5712 n1_m1_201600_230400 n1_m1_200000_230400 1.785412
R5713 n1_m1_201600_230400 n1_m1_206400_230400 5.356235
R5714 n1_m1_206400_230400 n1_m1_211200_230400 5.356235
R5715 n1_m1_211200_230400 n1_m1_216000_230400 5.356235
R5716 n1_m1_216000_230400 n1_m1_220800_230400 5.356235
R5717 n1_m1_220800_230400 n1_m1_225600_230400 5.356235
R5718 n1_m1_225600_230400 n1_m1_228000_230400 2.678118
R5719 n1_m1_230400_230400 n1_m1_228000_230400 2.678118
R5720 n1_m1_230400_230400 n1_m1_235200_230400 5.356235
R5721 n1_m1_235200_230400 n1_m1_240000_230400 5.356235
R5722 n1_m1_240000_230400 n1_m1_244800_230400 5.356235
R5723 n1_m1_244800_230400 n1_m1_249600_230400 5.356235
R5724 n1_m1_249600_230400 n1_m1_254400_230400 5.356235
R5725 n1_m1_254400_230400 n1_m1_256000_230400 1.785412
R5726 n1_m1_259200_230400 n1_m1_256000_230400 3.570824
R5727 n1_m1_259200_230400 n1_m1_264000_230400 5.356235
R5728 n1_m1_264000_230400 n1_m1_268800_230400 5.356235
R5729 n1_m1_268800_230400 n1_m1_273600_230400 5.356235
R5730 n1_m1_273600_230400 n1_m1_278400_230400 5.356235
R5731 n1_m1_278400_230400 n1_m1_283200_230400 5.356235
R5732 n1_m1_283200_230400 n1_m1_284000_230400 0.892706
R5733 n1_m1_288000_230400 n1_m1_284000_230400 4.463529
R5734 n1_m1_288000_230400 n1_m1_292800_230400 5.356235
R5735 n1_m1_292800_230400 n1_m1_297600_230400 5.356235
R5736 n1_m1_297600_230400 n1_m1_302400_230400 5.356235
R5737 n1_m1_302400_230400 n1_m1_307200_230400 5.356235
R5738 n1_m1_307200_230400 n1_m1_312000_230400 5.356235
R5739 n1_m1_312000_230400 n1_m1_316800_230400 5.356235
R5740 n1_m1_316800_230400 n1_m1_321600_230400 5.356235
R5741 n1_m1_321600_230400 n1_m1_326400_230400 5.356235
R5742 n1_m1_326400_230400 n1_m1_331200_230400 5.356235
R5743 n1_m1_331200_230400 n1_m1_336000_230400 5.356235
R5744 n1_m1_336000_230400 n1_m1_340000_230400 4.463529
R5745 n1_m1_340800_230400 n1_m1_340000_230400 0.892706
R5746 n1_m1_340800_230400 n1_m1_345600_230400 5.356235
R5747 n1_m1_345600_230400 n1_m1_350400_230400 5.356235
R5748 n1_m1_350400_230400 n1_m1_355200_230400 5.356235
R5749 n1_m1_355200_230400 n1_m1_360000_230400 5.356235
R5750 n1_m1_360000_230400 n1_m1_364800_230400 5.356235
R5751 n1_m1_364800_230400 n1_m1_368000_230400 3.570824
R5752 n1_m1_369600_230400 n1_m1_368000_230400 1.785412
R5753 n1_m1_369600_230400 n1_m1_374400_230400 5.356235
R5754 n1_m1_374400_230400 n1_m1_379200_230400 5.356235
R5755 n1_m1_379200_230400 n1_m1_384000_230400 5.356235
R5756 n1_m1_384000_230400 n1_m1_388800_230400 5.356235
R5757 n1_m1_388800_230400 n1_m1_393600_230400 5.356235
R5758 n1_m1_393600_230400 n1_m1_396000_230400 2.678118
R5759 n1_m1_398400_230400 n1_m1_396000_230400 2.678118
R5760 n1_m1_398400_230400 n1_m1_403200_230400 5.356235
R5761 n1_m1_403200_230400 n1_m1_408000_230400 5.356235
R5762 n1_m1_408000_230400 n1_m1_412800_230400 5.356235
R5763 n1_m1_412800_230400 n1_m1_417600_230400 5.356235
R5764 n1_m1_417600_230400 n1_m1_422400_230400 5.356235
R5765 n1_m1_422400_230400 n1_m1_424000_230400 1.785412
R5766 n1_m1_427200_230400 n1_m1_424000_230400 3.570824
R5767 n1_m1_427200_230400 n1_m1_432000_230400 5.356235
R5768 n1_m1_432000_230400 n1_m1_436800_230400 5.356235
R5769 n1_m1_436800_230400 n1_m1_441600_230400 5.356235
R5770 n1_m1_441600_230400 n1_m1_446400_230400 5.356235
R5771 n1_m1_446400_230400 n1_m1_451200_230400 5.356235
R5772 n1_m1_451200_230400 n1_m1_452000_230400 0.892706
R5773 n1_m1_456000_230400 n1_m1_452000_230400 4.463529
R5774 n1_m1_456000_230400 n1_m1_460800_230400 5.356235
R5775 n1_m1_460800_230400 n1_m1_465600_230400 5.356235
R5776 n1_m1_465600_230400 n1_m1_470400_230400 5.356235
R5777 n1_m1_470400_230400 n1_m1_475200_230400 5.356235
R5778 n1_m1_475200_230400 n1_m1_480000_230400 5.356235
R5779 n1_m1_480000_230400 n1_m1_484800_230400 5.356235
R5780 n1_m1_484800_230400 n1_m1_489600_230400 5.356235
R5781 n1_m1_489600_230400 n1_m1_494400_230400 5.356235
R5782 n1_m1_0_235200 n1_m1_4000_235200 4.463529
R5783 n1_m1_4800_235200 n1_m1_4000_235200 0.892706
R5784 n1_m1_4800_235200 n1_m1_9600_235200 5.356235
R5785 n1_m1_9600_235200 n1_m1_14400_235200 5.356235
R5786 n1_m1_14400_235200 n1_m1_19200_235200 5.356235
R5787 n1_m1_19200_235200 n1_m1_24000_235200 5.356235
R5788 n1_m1_24000_235200 n1_m1_28800_235200 5.356235
R5789 n1_m1_28800_235200 n1_m1_32000_235200 3.570824
R5790 n1_m1_33600_235200 n1_m1_32000_235200 1.785412
R5791 n1_m1_33600_235200 n1_m1_38400_235200 5.356235
R5792 n1_m1_38400_235200 n1_m1_43200_235200 5.356235
R5793 n1_m1_43200_235200 n1_m1_48000_235200 5.356235
R5794 n1_m1_48000_235200 n1_m1_52800_235200 5.356235
R5795 n1_m1_52800_235200 n1_m1_57600_235200 5.356235
R5796 n1_m1_57600_235200 n1_m1_60000_235200 2.678118
R5797 n1_m1_62400_235200 n1_m1_60000_235200 2.678118
R5798 n1_m1_62400_235200 n1_m1_67200_235200 5.356235
R5799 n1_m1_67200_235200 n1_m1_72000_235200 5.356235
R5800 n1_m1_72000_235200 n1_m1_76800_235200 5.356235
R5801 n1_m1_76800_235200 n1_m1_81600_235200 5.356235
R5802 n1_m1_81600_235200 n1_m1_86400_235200 5.356235
R5803 n1_m1_86400_235200 n1_m1_88000_235200 1.785412
R5804 n1_m1_91200_235200 n1_m1_88000_235200 3.570824
R5805 n1_m1_91200_235200 n1_m1_96000_235200 5.356235
R5806 n1_m1_96000_235200 n1_m1_100800_235200 5.356235
R5807 n1_m1_100800_235200 n1_m1_105600_235200 5.356235
R5808 n1_m1_105600_235200 n1_m1_110400_235200 5.356235
R5809 n1_m1_110400_235200 n1_m1_115200_235200 5.356235
R5810 n1_m1_115200_235200 n1_m1_116000_235200 0.892706
R5811 n1_m1_120000_235200 n1_m1_116000_235200 4.463529
R5812 n1_m1_120000_235200 n1_m1_124800_235200 5.356235
R5813 n1_m1_124800_235200 n1_m1_129600_235200 5.356235
R5814 n1_m1_129600_235200 n1_m1_134400_235200 5.356235
R5815 n1_m1_134400_235200 n1_m1_139200_235200 5.356235
R5816 n1_m1_139200_235200 n1_m1_144000_235200 5.356235
R5817 n1_m1_144000_235200 n1_m1_148800_235200 5.356235
R5818 n1_m1_148800_235200 n1_m1_153600_235200 5.356235
R5819 n1_m1_153600_235200 n1_m1_158400_235200 5.356235
R5820 n1_m1_158400_235200 n1_m1_163200_235200 5.356235
R5821 n1_m1_163200_235200 n1_m1_168000_235200 5.356235
R5822 n1_m1_168000_235200 n1_m1_172000_235200 4.463529
R5823 n1_m1_172800_235200 n1_m1_172000_235200 0.892706
R5824 n1_m1_172800_235200 n1_m1_177600_235200 5.356235
R5825 n1_m1_177600_235200 n1_m1_182400_235200 5.356235
R5826 n1_m1_182400_235200 n1_m1_187200_235200 5.356235
R5827 n1_m1_187200_235200 n1_m1_192000_235200 5.356235
R5828 n1_m1_192000_235200 n1_m1_196800_235200 5.356235
R5829 n1_m1_196800_235200 n1_m1_200000_235200 3.570824
R5830 n1_m1_201600_235200 n1_m1_200000_235200 1.785412
R5831 n1_m1_201600_235200 n1_m1_206400_235200 5.356235
R5832 n1_m1_206400_235200 n1_m1_211200_235200 5.356235
R5833 n1_m1_211200_235200 n1_m1_216000_235200 5.356235
R5834 n1_m1_216000_235200 n1_m1_220800_235200 5.356235
R5835 n1_m1_220800_235200 n1_m1_225600_235200 5.356235
R5836 n1_m1_225600_235200 n1_m1_228000_235200 2.678118
R5837 n1_m1_230400_235200 n1_m1_228000_235200 2.678118
R5838 n1_m1_230400_235200 n1_m1_235200_235200 5.356235
R5839 n1_m1_235200_235200 n1_m1_240000_235200 5.356235
R5840 n1_m1_240000_235200 n1_m1_244800_235200 5.356235
R5841 n1_m1_244800_235200 n1_m1_249600_235200 5.356235
R5842 n1_m1_249600_235200 n1_m1_254400_235200 5.356235
R5843 n1_m1_254400_235200 n1_m1_256000_235200 1.785412
R5844 n1_m1_259200_235200 n1_m1_256000_235200 3.570824
R5845 n1_m1_259200_235200 n1_m1_264000_235200 5.356235
R5846 n1_m1_264000_235200 n1_m1_268800_235200 5.356235
R5847 n1_m1_268800_235200 n1_m1_273600_235200 5.356235
R5848 n1_m1_273600_235200 n1_m1_278400_235200 5.356235
R5849 n1_m1_278400_235200 n1_m1_283200_235200 5.356235
R5850 n1_m1_283200_235200 n1_m1_284000_235200 0.892706
R5851 n1_m1_288000_235200 n1_m1_284000_235200 4.463529
R5852 n1_m1_288000_235200 n1_m1_292800_235200 5.356235
R5853 n1_m1_292800_235200 n1_m1_297600_235200 5.356235
R5854 n1_m1_297600_235200 n1_m1_302400_235200 5.356235
R5855 n1_m1_302400_235200 n1_m1_307200_235200 5.356235
R5856 n1_m1_307200_235200 n1_m1_312000_235200 5.356235
R5857 n1_m1_312000_235200 n1_m1_316800_235200 5.356235
R5858 n1_m1_316800_235200 n1_m1_321600_235200 5.356235
R5859 n1_m1_321600_235200 n1_m1_326400_235200 5.356235
R5860 n1_m1_326400_235200 n1_m1_331200_235200 5.356235
R5861 n1_m1_331200_235200 n1_m1_336000_235200 5.356235
R5862 n1_m1_336000_235200 n1_m1_340000_235200 4.463529
R5863 n1_m1_340800_235200 n1_m1_340000_235200 0.892706
R5864 n1_m1_340800_235200 n1_m1_345600_235200 5.356235
R5865 n1_m1_345600_235200 n1_m1_350400_235200 5.356235
R5866 n1_m1_350400_235200 n1_m1_355200_235200 5.356235
R5867 n1_m1_355200_235200 n1_m1_360000_235200 5.356235
R5868 n1_m1_360000_235200 n1_m1_364800_235200 5.356235
R5869 n1_m1_364800_235200 n1_m1_368000_235200 3.570824
R5870 n1_m1_369600_235200 n1_m1_368000_235200 1.785412
R5871 n1_m1_369600_235200 n1_m1_374400_235200 5.356235
R5872 n1_m1_374400_235200 n1_m1_379200_235200 5.356235
R5873 n1_m1_379200_235200 n1_m1_384000_235200 5.356235
R5874 n1_m1_384000_235200 n1_m1_388800_235200 5.356235
R5875 n1_m1_388800_235200 n1_m1_393600_235200 5.356235
R5876 n1_m1_393600_235200 n1_m1_396000_235200 2.678118
R5877 n1_m1_398400_235200 n1_m1_396000_235200 2.678118
R5878 n1_m1_398400_235200 n1_m1_403200_235200 5.356235
R5879 n1_m1_403200_235200 n1_m1_408000_235200 5.356235
R5880 n1_m1_408000_235200 n1_m1_412800_235200 5.356235
R5881 n1_m1_412800_235200 n1_m1_417600_235200 5.356235
R5882 n1_m1_417600_235200 n1_m1_422400_235200 5.356235
R5883 n1_m1_422400_235200 n1_m1_424000_235200 1.785412
R5884 n1_m1_427200_235200 n1_m1_424000_235200 3.570824
R5885 n1_m1_427200_235200 n1_m1_432000_235200 5.356235
R5886 n1_m1_432000_235200 n1_m1_436800_235200 5.356235
R5887 n1_m1_436800_235200 n1_m1_441600_235200 5.356235
R5888 n1_m1_441600_235200 n1_m1_446400_235200 5.356235
R5889 n1_m1_446400_235200 n1_m1_451200_235200 5.356235
R5890 n1_m1_451200_235200 n1_m1_452000_235200 0.892706
R5891 n1_m1_456000_235200 n1_m1_452000_235200 4.463529
R5892 n1_m1_456000_235200 n1_m1_460800_235200 5.356235
R5893 n1_m1_460800_235200 n1_m1_465600_235200 5.356235
R5894 n1_m1_465600_235200 n1_m1_470400_235200 5.356235
R5895 n1_m1_470400_235200 n1_m1_475200_235200 5.356235
R5896 n1_m1_475200_235200 n1_m1_480000_235200 5.356235
R5897 n1_m1_480000_235200 n1_m1_484800_235200 5.356235
R5898 n1_m1_484800_235200 n1_m1_489600_235200 5.356235
R5899 n1_m1_489600_235200 n1_m1_494400_235200 5.356235
R5900 n1_m1_0_240000 n1_m1_4000_240000 4.463529
R5901 n1_m1_4800_240000 n1_m1_4000_240000 0.892706
R5902 n1_m1_4800_240000 n1_m1_9600_240000 5.356235
R5903 n1_m1_9600_240000 n1_m1_14400_240000 5.356235
R5904 n1_m1_14400_240000 n1_m1_19200_240000 5.356235
R5905 n1_m1_19200_240000 n1_m1_24000_240000 5.356235
R5906 n1_m1_24000_240000 n1_m1_28800_240000 5.356235
R5907 n1_m1_28800_240000 n1_m1_32000_240000 3.570824
R5908 n1_m1_33600_240000 n1_m1_32000_240000 1.785412
R5909 n1_m1_33600_240000 n1_m1_38400_240000 5.356235
R5910 n1_m1_38400_240000 n1_m1_43200_240000 5.356235
R5911 n1_m1_43200_240000 n1_m1_48000_240000 5.356235
R5912 n1_m1_48000_240000 n1_m1_52800_240000 5.356235
R5913 n1_m1_52800_240000 n1_m1_57600_240000 5.356235
R5914 n1_m1_57600_240000 n1_m1_60000_240000 2.678118
R5915 n1_m1_62400_240000 n1_m1_60000_240000 2.678118
R5916 n1_m1_62400_240000 n1_m1_67200_240000 5.356235
R5917 n1_m1_67200_240000 n1_m1_72000_240000 5.356235
R5918 n1_m1_72000_240000 n1_m1_76800_240000 5.356235
R5919 n1_m1_76800_240000 n1_m1_81600_240000 5.356235
R5920 n1_m1_81600_240000 n1_m1_86400_240000 5.356235
R5921 n1_m1_86400_240000 n1_m1_88000_240000 1.785412
R5922 n1_m1_91200_240000 n1_m1_88000_240000 3.570824
R5923 n1_m1_91200_240000 n1_m1_96000_240000 5.356235
R5924 n1_m1_96000_240000 n1_m1_100800_240000 5.356235
R5925 n1_m1_100800_240000 n1_m1_105600_240000 5.356235
R5926 n1_m1_105600_240000 n1_m1_110400_240000 5.356235
R5927 n1_m1_110400_240000 n1_m1_115200_240000 5.356235
R5928 n1_m1_115200_240000 n1_m1_116000_240000 0.892706
R5929 n1_m1_120000_240000 n1_m1_116000_240000 4.463529
R5930 n1_m1_120000_240000 n1_m1_124800_240000 5.356235
R5931 n1_m1_124800_240000 n1_m1_129600_240000 5.356235
R5932 n1_m1_129600_240000 n1_m1_134400_240000 5.356235
R5933 n1_m1_134400_240000 n1_m1_139200_240000 5.356235
R5934 n1_m1_139200_240000 n1_m1_144000_240000 5.356235
R5935 n1_m1_144000_240000 n1_m1_148800_240000 5.356235
R5936 n1_m1_148800_240000 n1_m1_153600_240000 5.356235
R5937 n1_m1_153600_240000 n1_m1_158400_240000 5.356235
R5938 n1_m1_158400_240000 n1_m1_163200_240000 5.356235
R5939 n1_m1_163200_240000 n1_m1_168000_240000 5.356235
R5940 n1_m1_168000_240000 n1_m1_172000_240000 4.463529
R5941 n1_m1_172800_240000 n1_m1_172000_240000 0.892706
R5942 n1_m1_172800_240000 n1_m1_177600_240000 5.356235
R5943 n1_m1_177600_240000 n1_m1_182400_240000 5.356235
R5944 n1_m1_182400_240000 n1_m1_187200_240000 5.356235
R5945 n1_m1_187200_240000 n1_m1_192000_240000 5.356235
R5946 n1_m1_192000_240000 n1_m1_196800_240000 5.356235
R5947 n1_m1_196800_240000 n1_m1_200000_240000 3.570824
R5948 n1_m1_201600_240000 n1_m1_200000_240000 1.785412
R5949 n1_m1_201600_240000 n1_m1_206400_240000 5.356235
R5950 n1_m1_206400_240000 n1_m1_211200_240000 5.356235
R5951 n1_m1_211200_240000 n1_m1_216000_240000 5.356235
R5952 n1_m1_216000_240000 n1_m1_220800_240000 5.356235
R5953 n1_m1_220800_240000 n1_m1_225600_240000 5.356235
R5954 n1_m1_225600_240000 n1_m1_228000_240000 2.678118
R5955 n1_m1_230400_240000 n1_m1_228000_240000 2.678118
R5956 n1_m1_230400_240000 n1_m1_235200_240000 5.356235
R5957 n1_m1_235200_240000 n1_m1_240000_240000 5.356235
R5958 n1_m1_240000_240000 n1_m1_244800_240000 5.356235
R5959 n1_m1_244800_240000 n1_m1_249600_240000 5.356235
R5960 n1_m1_249600_240000 n1_m1_254400_240000 5.356235
R5961 n1_m1_254400_240000 n1_m1_256000_240000 1.785412
R5962 n1_m1_259200_240000 n1_m1_256000_240000 3.570824
R5963 n1_m1_259200_240000 n1_m1_264000_240000 5.356235
R5964 n1_m1_264000_240000 n1_m1_268800_240000 5.356235
R5965 n1_m1_268800_240000 n1_m1_273600_240000 5.356235
R5966 n1_m1_273600_240000 n1_m1_278400_240000 5.356235
R5967 n1_m1_278400_240000 n1_m1_283200_240000 5.356235
R5968 n1_m1_283200_240000 n1_m1_284000_240000 0.892706
R5969 n1_m1_288000_240000 n1_m1_284000_240000 4.463529
R5970 n1_m1_288000_240000 n1_m1_292800_240000 5.356235
R5971 n1_m1_292800_240000 n1_m1_297600_240000 5.356235
R5972 n1_m1_297600_240000 n1_m1_302400_240000 5.356235
R5973 n1_m1_302400_240000 n1_m1_307200_240000 5.356235
R5974 n1_m1_307200_240000 n1_m1_312000_240000 5.356235
R5975 n1_m1_312000_240000 n1_m1_316800_240000 5.356235
R5976 n1_m1_316800_240000 n1_m1_321600_240000 5.356235
R5977 n1_m1_321600_240000 n1_m1_326400_240000 5.356235
R5978 n1_m1_326400_240000 n1_m1_331200_240000 5.356235
R5979 n1_m1_331200_240000 n1_m1_336000_240000 5.356235
R5980 n1_m1_336000_240000 n1_m1_340000_240000 4.463529
R5981 n1_m1_340800_240000 n1_m1_340000_240000 0.892706
R5982 n1_m1_340800_240000 n1_m1_345600_240000 5.356235
R5983 n1_m1_345600_240000 n1_m1_350400_240000 5.356235
R5984 n1_m1_350400_240000 n1_m1_355200_240000 5.356235
R5985 n1_m1_355200_240000 n1_m1_360000_240000 5.356235
R5986 n1_m1_360000_240000 n1_m1_364800_240000 5.356235
R5987 n1_m1_364800_240000 n1_m1_368000_240000 3.570824
R5988 n1_m1_369600_240000 n1_m1_368000_240000 1.785412
R5989 n1_m1_369600_240000 n1_m1_374400_240000 5.356235
R5990 n1_m1_374400_240000 n1_m1_379200_240000 5.356235
R5991 n1_m1_379200_240000 n1_m1_384000_240000 5.356235
R5992 n1_m1_384000_240000 n1_m1_388800_240000 5.356235
R5993 n1_m1_388800_240000 n1_m1_393600_240000 5.356235
R5994 n1_m1_393600_240000 n1_m1_396000_240000 2.678118
R5995 n1_m1_398400_240000 n1_m1_396000_240000 2.678118
R5996 n1_m1_398400_240000 n1_m1_403200_240000 5.356235
R5997 n1_m1_403200_240000 n1_m1_408000_240000 5.356235
R5998 n1_m1_408000_240000 n1_m1_412800_240000 5.356235
R5999 n1_m1_412800_240000 n1_m1_417600_240000 5.356235
R6000 n1_m1_417600_240000 n1_m1_422400_240000 5.356235
R6001 n1_m1_422400_240000 n1_m1_424000_240000 1.785412
R6002 n1_m1_427200_240000 n1_m1_424000_240000 3.570824
R6003 n1_m1_427200_240000 n1_m1_432000_240000 5.356235
R6004 n1_m1_432000_240000 n1_m1_436800_240000 5.356235
R6005 n1_m1_436800_240000 n1_m1_441600_240000 5.356235
R6006 n1_m1_441600_240000 n1_m1_446400_240000 5.356235
R6007 n1_m1_446400_240000 n1_m1_451200_240000 5.356235
R6008 n1_m1_451200_240000 n1_m1_452000_240000 0.892706
R6009 n1_m1_456000_240000 n1_m1_452000_240000 4.463529
R6010 n1_m1_456000_240000 n1_m1_460800_240000 5.356235
R6011 n1_m1_460800_240000 n1_m1_465600_240000 5.356235
R6012 n1_m1_465600_240000 n1_m1_470400_240000 5.356235
R6013 n1_m1_470400_240000 n1_m1_475200_240000 5.356235
R6014 n1_m1_475200_240000 n1_m1_480000_240000 5.356235
R6015 n1_m1_480000_240000 n1_m1_484800_240000 5.356235
R6016 n1_m1_484800_240000 n1_m1_489600_240000 5.356235
R6017 n1_m1_489600_240000 n1_m1_494400_240000 5.356235
R6018 n1_m1_0_244800 n1_m1_4000_244800 4.463529
R6019 n1_m1_4800_244800 n1_m1_4000_244800 0.892706
R6020 n1_m1_4800_244800 n1_m1_9600_244800 5.356235
R6021 n1_m1_9600_244800 n1_m1_14400_244800 5.356235
R6022 n1_m1_14400_244800 n1_m1_19200_244800 5.356235
R6023 n1_m1_19200_244800 n1_m1_24000_244800 5.356235
R6024 n1_m1_24000_244800 n1_m1_28800_244800 5.356235
R6025 n1_m1_28800_244800 n1_m1_32000_244800 3.570824
R6026 n1_m1_33600_244800 n1_m1_32000_244800 1.785412
R6027 n1_m1_33600_244800 n1_m1_38400_244800 5.356235
R6028 n1_m1_38400_244800 n1_m1_43200_244800 5.356235
R6029 n1_m1_43200_244800 n1_m1_48000_244800 5.356235
R6030 n1_m1_48000_244800 n1_m1_52800_244800 5.356235
R6031 n1_m1_52800_244800 n1_m1_57600_244800 5.356235
R6032 n1_m1_57600_244800 n1_m1_60000_244800 2.678118
R6033 n1_m1_62400_244800 n1_m1_60000_244800 2.678118
R6034 n1_m1_62400_244800 n1_m1_67200_244800 5.356235
R6035 n1_m1_67200_244800 n1_m1_72000_244800 5.356235
R6036 n1_m1_72000_244800 n1_m1_76800_244800 5.356235
R6037 n1_m1_76800_244800 n1_m1_81600_244800 5.356235
R6038 n1_m1_81600_244800 n1_m1_86400_244800 5.356235
R6039 n1_m1_86400_244800 n1_m1_88000_244800 1.785412
R6040 n1_m1_91200_244800 n1_m1_88000_244800 3.570824
R6041 n1_m1_91200_244800 n1_m1_96000_244800 5.356235
R6042 n1_m1_96000_244800 n1_m1_100800_244800 5.356235
R6043 n1_m1_100800_244800 n1_m1_105600_244800 5.356235
R6044 n1_m1_105600_244800 n1_m1_110400_244800 5.356235
R6045 n1_m1_110400_244800 n1_m1_115200_244800 5.356235
R6046 n1_m1_115200_244800 n1_m1_116000_244800 0.892706
R6047 n1_m1_120000_244800 n1_m1_116000_244800 4.463529
R6048 n1_m1_120000_244800 n1_m1_124800_244800 5.356235
R6049 n1_m1_124800_244800 n1_m1_129600_244800 5.356235
R6050 n1_m1_129600_244800 n1_m1_134400_244800 5.356235
R6051 n1_m1_134400_244800 n1_m1_139200_244800 5.356235
R6052 n1_m1_139200_244800 n1_m1_144000_244800 5.356235
R6053 n1_m1_144000_244800 n1_m1_148800_244800 5.356235
R6054 n1_m1_148800_244800 n1_m1_153600_244800 5.356235
R6055 n1_m1_153600_244800 n1_m1_158400_244800 5.356235
R6056 n1_m1_158400_244800 n1_m1_163200_244800 5.356235
R6057 n1_m1_163200_244800 n1_m1_168000_244800 5.356235
R6058 n1_m1_168000_244800 n1_m1_172000_244800 4.463529
R6059 n1_m1_172800_244800 n1_m1_172000_244800 0.892706
R6060 n1_m1_172800_244800 n1_m1_177600_244800 5.356235
R6061 n1_m1_177600_244800 n1_m1_182400_244800 5.356235
R6062 n1_m1_182400_244800 n1_m1_187200_244800 5.356235
R6063 n1_m1_187200_244800 n1_m1_192000_244800 5.356235
R6064 n1_m1_192000_244800 n1_m1_196800_244800 5.356235
R6065 n1_m1_196800_244800 n1_m1_200000_244800 3.570824
R6066 n1_m1_201600_244800 n1_m1_200000_244800 1.785412
R6067 n1_m1_201600_244800 n1_m1_206400_244800 5.356235
R6068 n1_m1_206400_244800 n1_m1_211200_244800 5.356235
R6069 n1_m1_211200_244800 n1_m1_216000_244800 5.356235
R6070 n1_m1_216000_244800 n1_m1_220800_244800 5.356235
R6071 n1_m1_220800_244800 n1_m1_225600_244800 5.356235
R6072 n1_m1_225600_244800 n1_m1_228000_244800 2.678118
R6073 n1_m1_230400_244800 n1_m1_228000_244800 2.678118
R6074 n1_m1_230400_244800 n1_m1_235200_244800 5.356235
R6075 n1_m1_235200_244800 n1_m1_240000_244800 5.356235
R6076 n1_m1_240000_244800 n1_m1_244800_244800 5.356235
R6077 n1_m1_244800_244800 n1_m1_249600_244800 5.356235
R6078 n1_m1_249600_244800 n1_m1_254400_244800 5.356235
R6079 n1_m1_254400_244800 n1_m1_256000_244800 1.785412
R6080 n1_m1_259200_244800 n1_m1_256000_244800 3.570824
R6081 n1_m1_259200_244800 n1_m1_264000_244800 5.356235
R6082 n1_m1_264000_244800 n1_m1_268800_244800 5.356235
R6083 n1_m1_268800_244800 n1_m1_273600_244800 5.356235
R6084 n1_m1_273600_244800 n1_m1_278400_244800 5.356235
R6085 n1_m1_278400_244800 n1_m1_283200_244800 5.356235
R6086 n1_m1_283200_244800 n1_m1_284000_244800 0.892706
R6087 n1_m1_288000_244800 n1_m1_284000_244800 4.463529
R6088 n1_m1_288000_244800 n1_m1_292800_244800 5.356235
R6089 n1_m1_292800_244800 n1_m1_297600_244800 5.356235
R6090 n1_m1_297600_244800 n1_m1_302400_244800 5.356235
R6091 n1_m1_302400_244800 n1_m1_307200_244800 5.356235
R6092 n1_m1_307200_244800 n1_m1_312000_244800 5.356235
R6093 n1_m1_312000_244800 n1_m1_316800_244800 5.356235
R6094 n1_m1_316800_244800 n1_m1_321600_244800 5.356235
R6095 n1_m1_321600_244800 n1_m1_326400_244800 5.356235
R6096 n1_m1_326400_244800 n1_m1_331200_244800 5.356235
R6097 n1_m1_331200_244800 n1_m1_336000_244800 5.356235
R6098 n1_m1_336000_244800 n1_m1_340000_244800 4.463529
R6099 n1_m1_340800_244800 n1_m1_340000_244800 0.892706
R6100 n1_m1_340800_244800 n1_m1_345600_244800 5.356235
R6101 n1_m1_345600_244800 n1_m1_350400_244800 5.356235
R6102 n1_m1_350400_244800 n1_m1_355200_244800 5.356235
R6103 n1_m1_355200_244800 n1_m1_360000_244800 5.356235
R6104 n1_m1_360000_244800 n1_m1_364800_244800 5.356235
R6105 n1_m1_364800_244800 n1_m1_368000_244800 3.570824
R6106 n1_m1_369600_244800 n1_m1_368000_244800 1.785412
R6107 n1_m1_369600_244800 n1_m1_374400_244800 5.356235
R6108 n1_m1_374400_244800 n1_m1_379200_244800 5.356235
R6109 n1_m1_379200_244800 n1_m1_384000_244800 5.356235
R6110 n1_m1_384000_244800 n1_m1_388800_244800 5.356235
R6111 n1_m1_388800_244800 n1_m1_393600_244800 5.356235
R6112 n1_m1_393600_244800 n1_m1_396000_244800 2.678118
R6113 n1_m1_398400_244800 n1_m1_396000_244800 2.678118
R6114 n1_m1_398400_244800 n1_m1_403200_244800 5.356235
R6115 n1_m1_403200_244800 n1_m1_408000_244800 5.356235
R6116 n1_m1_408000_244800 n1_m1_412800_244800 5.356235
R6117 n1_m1_412800_244800 n1_m1_417600_244800 5.356235
R6118 n1_m1_417600_244800 n1_m1_422400_244800 5.356235
R6119 n1_m1_422400_244800 n1_m1_424000_244800 1.785412
R6120 n1_m1_427200_244800 n1_m1_424000_244800 3.570824
R6121 n1_m1_427200_244800 n1_m1_432000_244800 5.356235
R6122 n1_m1_432000_244800 n1_m1_436800_244800 5.356235
R6123 n1_m1_436800_244800 n1_m1_441600_244800 5.356235
R6124 n1_m1_441600_244800 n1_m1_446400_244800 5.356235
R6125 n1_m1_446400_244800 n1_m1_451200_244800 5.356235
R6126 n1_m1_451200_244800 n1_m1_452000_244800 0.892706
R6127 n1_m1_456000_244800 n1_m1_452000_244800 4.463529
R6128 n1_m1_456000_244800 n1_m1_460800_244800 5.356235
R6129 n1_m1_460800_244800 n1_m1_465600_244800 5.356235
R6130 n1_m1_465600_244800 n1_m1_470400_244800 5.356235
R6131 n1_m1_470400_244800 n1_m1_475200_244800 5.356235
R6132 n1_m1_475200_244800 n1_m1_480000_244800 5.356235
R6133 n1_m1_480000_244800 n1_m1_484800_244800 5.356235
R6134 n1_m1_484800_244800 n1_m1_489600_244800 5.356235
R6135 n1_m1_489600_244800 n1_m1_494400_244800 5.356235
R6136 n1_m1_0_249600 n1_m1_4000_249600 4.463529
R6137 n1_m1_4800_249600 n1_m1_4000_249600 0.892706
R6138 n1_m1_4800_249600 n1_m1_9600_249600 5.356235
R6139 n1_m1_9600_249600 n1_m1_14400_249600 5.356235
R6140 n1_m1_14400_249600 n1_m1_19200_249600 5.356235
R6141 n1_m1_19200_249600 n1_m1_24000_249600 5.356235
R6142 n1_m1_24000_249600 n1_m1_28800_249600 5.356235
R6143 n1_m1_28800_249600 n1_m1_32000_249600 3.570824
R6144 n1_m1_33600_249600 n1_m1_32000_249600 1.785412
R6145 n1_m1_33600_249600 n1_m1_38400_249600 5.356235
R6146 n1_m1_38400_249600 n1_m1_43200_249600 5.356235
R6147 n1_m1_43200_249600 n1_m1_48000_249600 5.356235
R6148 n1_m1_48000_249600 n1_m1_52800_249600 5.356235
R6149 n1_m1_52800_249600 n1_m1_57600_249600 5.356235
R6150 n1_m1_57600_249600 n1_m1_60000_249600 2.678118
R6151 n1_m1_62400_249600 n1_m1_60000_249600 2.678118
R6152 n1_m1_62400_249600 n1_m1_67200_249600 5.356235
R6153 n1_m1_67200_249600 n1_m1_72000_249600 5.356235
R6154 n1_m1_72000_249600 n1_m1_76800_249600 5.356235
R6155 n1_m1_76800_249600 n1_m1_81600_249600 5.356235
R6156 n1_m1_81600_249600 n1_m1_86400_249600 5.356235
R6157 n1_m1_86400_249600 n1_m1_88000_249600 1.785412
R6158 n1_m1_91200_249600 n1_m1_88000_249600 3.570824
R6159 n1_m1_91200_249600 n1_m1_96000_249600 5.356235
R6160 n1_m1_96000_249600 n1_m1_100800_249600 5.356235
R6161 n1_m1_100800_249600 n1_m1_105600_249600 5.356235
R6162 n1_m1_105600_249600 n1_m1_110400_249600 5.356235
R6163 n1_m1_110400_249600 n1_m1_115200_249600 5.356235
R6164 n1_m1_115200_249600 n1_m1_116000_249600 0.892706
R6165 n1_m1_120000_249600 n1_m1_116000_249600 4.463529
R6166 n1_m1_120000_249600 n1_m1_124800_249600 5.356235
R6167 n1_m1_124800_249600 n1_m1_129600_249600 5.356235
R6168 n1_m1_129600_249600 n1_m1_134400_249600 5.356235
R6169 n1_m1_134400_249600 n1_m1_139200_249600 5.356235
R6170 n1_m1_139200_249600 n1_m1_144000_249600 5.356235
R6171 n1_m1_144000_249600 n1_m1_148800_249600 5.356235
R6172 n1_m1_148800_249600 n1_m1_153600_249600 5.356235
R6173 n1_m1_153600_249600 n1_m1_158400_249600 5.356235
R6174 n1_m1_158400_249600 n1_m1_163200_249600 5.356235
R6175 n1_m1_163200_249600 n1_m1_168000_249600 5.356235
R6176 n1_m1_168000_249600 n1_m1_172000_249600 4.463529
R6177 n1_m1_172800_249600 n1_m1_172000_249600 0.892706
R6178 n1_m1_172800_249600 n1_m1_177600_249600 5.356235
R6179 n1_m1_177600_249600 n1_m1_182400_249600 5.356235
R6180 n1_m1_182400_249600 n1_m1_187200_249600 5.356235
R6181 n1_m1_187200_249600 n1_m1_192000_249600 5.356235
R6182 n1_m1_192000_249600 n1_m1_196800_249600 5.356235
R6183 n1_m1_196800_249600 n1_m1_200000_249600 3.570824
R6184 n1_m1_201600_249600 n1_m1_200000_249600 1.785412
R6185 n1_m1_201600_249600 n1_m1_206400_249600 5.356235
R6186 n1_m1_206400_249600 n1_m1_211200_249600 5.356235
R6187 n1_m1_211200_249600 n1_m1_216000_249600 5.356235
R6188 n1_m1_216000_249600 n1_m1_220800_249600 5.356235
R6189 n1_m1_220800_249600 n1_m1_225600_249600 5.356235
R6190 n1_m1_225600_249600 n1_m1_228000_249600 2.678118
R6191 n1_m1_230400_249600 n1_m1_228000_249600 2.678118
R6192 n1_m1_230400_249600 n1_m1_235200_249600 5.356235
R6193 n1_m1_235200_249600 n1_m1_240000_249600 5.356235
R6194 n1_m1_240000_249600 n1_m1_244800_249600 5.356235
R6195 n1_m1_244800_249600 n1_m1_249600_249600 5.356235
R6196 n1_m1_249600_249600 n1_m1_254400_249600 5.356235
R6197 n1_m1_254400_249600 n1_m1_256000_249600 1.785412
R6198 n1_m1_259200_249600 n1_m1_256000_249600 3.570824
R6199 n1_m1_259200_249600 n1_m1_264000_249600 5.356235
R6200 n1_m1_264000_249600 n1_m1_268800_249600 5.356235
R6201 n1_m1_268800_249600 n1_m1_273600_249600 5.356235
R6202 n1_m1_273600_249600 n1_m1_278400_249600 5.356235
R6203 n1_m1_278400_249600 n1_m1_283200_249600 5.356235
R6204 n1_m1_283200_249600 n1_m1_284000_249600 0.892706
R6205 n1_m1_288000_249600 n1_m1_284000_249600 4.463529
R6206 n1_m1_288000_249600 n1_m1_292800_249600 5.356235
R6207 n1_m1_292800_249600 n1_m1_297600_249600 5.356235
R6208 n1_m1_297600_249600 n1_m1_302400_249600 5.356235
R6209 n1_m1_302400_249600 n1_m1_307200_249600 5.356235
R6210 n1_m1_307200_249600 n1_m1_312000_249600 5.356235
R6211 n1_m1_312000_249600 n1_m1_316800_249600 5.356235
R6212 n1_m1_316800_249600 n1_m1_321600_249600 5.356235
R6213 n1_m1_321600_249600 n1_m1_326400_249600 5.356235
R6214 n1_m1_326400_249600 n1_m1_331200_249600 5.356235
R6215 n1_m1_331200_249600 n1_m1_336000_249600 5.356235
R6216 n1_m1_336000_249600 n1_m1_340000_249600 4.463529
R6217 n1_m1_340800_249600 n1_m1_340000_249600 0.892706
R6218 n1_m1_340800_249600 n1_m1_345600_249600 5.356235
R6219 n1_m1_345600_249600 n1_m1_350400_249600 5.356235
R6220 n1_m1_350400_249600 n1_m1_355200_249600 5.356235
R6221 n1_m1_355200_249600 n1_m1_360000_249600 5.356235
R6222 n1_m1_360000_249600 n1_m1_364800_249600 5.356235
R6223 n1_m1_364800_249600 n1_m1_368000_249600 3.570824
R6224 n1_m1_369600_249600 n1_m1_368000_249600 1.785412
R6225 n1_m1_369600_249600 n1_m1_374400_249600 5.356235
R6226 n1_m1_374400_249600 n1_m1_379200_249600 5.356235
R6227 n1_m1_379200_249600 n1_m1_384000_249600 5.356235
R6228 n1_m1_384000_249600 n1_m1_388800_249600 5.356235
R6229 n1_m1_388800_249600 n1_m1_393600_249600 5.356235
R6230 n1_m1_393600_249600 n1_m1_396000_249600 2.678118
R6231 n1_m1_398400_249600 n1_m1_396000_249600 2.678118
R6232 n1_m1_398400_249600 n1_m1_403200_249600 5.356235
R6233 n1_m1_403200_249600 n1_m1_408000_249600 5.356235
R6234 n1_m1_408000_249600 n1_m1_412800_249600 5.356235
R6235 n1_m1_412800_249600 n1_m1_417600_249600 5.356235
R6236 n1_m1_417600_249600 n1_m1_422400_249600 5.356235
R6237 n1_m1_422400_249600 n1_m1_424000_249600 1.785412
R6238 n1_m1_427200_249600 n1_m1_424000_249600 3.570824
R6239 n1_m1_427200_249600 n1_m1_432000_249600 5.356235
R6240 n1_m1_432000_249600 n1_m1_436800_249600 5.356235
R6241 n1_m1_436800_249600 n1_m1_441600_249600 5.356235
R6242 n1_m1_441600_249600 n1_m1_446400_249600 5.356235
R6243 n1_m1_446400_249600 n1_m1_451200_249600 5.356235
R6244 n1_m1_451200_249600 n1_m1_452000_249600 0.892706
R6245 n1_m1_456000_249600 n1_m1_452000_249600 4.463529
R6246 n1_m1_456000_249600 n1_m1_460800_249600 5.356235
R6247 n1_m1_460800_249600 n1_m1_465600_249600 5.356235
R6248 n1_m1_465600_249600 n1_m1_470400_249600 5.356235
R6249 n1_m1_470400_249600 n1_m1_475200_249600 5.356235
R6250 n1_m1_475200_249600 n1_m1_480000_249600 5.356235
R6251 n1_m1_480000_249600 n1_m1_484800_249600 5.356235
R6252 n1_m1_484800_249600 n1_m1_489600_249600 5.356235
R6253 n1_m1_489600_249600 n1_m1_494400_249600 5.356235
R6254 n1_m1_0_254400 n1_m1_4000_254400 4.463529
R6255 n1_m1_4800_254400 n1_m1_4000_254400 0.892706
R6256 n1_m1_4800_254400 n1_m1_9600_254400 5.356235
R6257 n1_m1_9600_254400 n1_m1_14400_254400 5.356235
R6258 n1_m1_14400_254400 n1_m1_19200_254400 5.356235
R6259 n1_m1_19200_254400 n1_m1_24000_254400 5.356235
R6260 n1_m1_24000_254400 n1_m1_28800_254400 5.356235
R6261 n1_m1_28800_254400 n1_m1_32000_254400 3.570824
R6262 n1_m1_33600_254400 n1_m1_32000_254400 1.785412
R6263 n1_m1_33600_254400 n1_m1_38400_254400 5.356235
R6264 n1_m1_38400_254400 n1_m1_43200_254400 5.356235
R6265 n1_m1_43200_254400 n1_m1_48000_254400 5.356235
R6266 n1_m1_48000_254400 n1_m1_52800_254400 5.356235
R6267 n1_m1_52800_254400 n1_m1_57600_254400 5.356235
R6268 n1_m1_57600_254400 n1_m1_60000_254400 2.678118
R6269 n1_m1_62400_254400 n1_m1_60000_254400 2.678118
R6270 n1_m1_62400_254400 n1_m1_67200_254400 5.356235
R6271 n1_m1_67200_254400 n1_m1_72000_254400 5.356235
R6272 n1_m1_72000_254400 n1_m1_76800_254400 5.356235
R6273 n1_m1_76800_254400 n1_m1_81600_254400 5.356235
R6274 n1_m1_81600_254400 n1_m1_86400_254400 5.356235
R6275 n1_m1_86400_254400 n1_m1_88000_254400 1.785412
R6276 n1_m1_91200_254400 n1_m1_88000_254400 3.570824
R6277 n1_m1_91200_254400 n1_m1_96000_254400 5.356235
R6278 n1_m1_96000_254400 n1_m1_100800_254400 5.356235
R6279 n1_m1_100800_254400 n1_m1_105600_254400 5.356235
R6280 n1_m1_105600_254400 n1_m1_110400_254400 5.356235
R6281 n1_m1_110400_254400 n1_m1_115200_254400 5.356235
R6282 n1_m1_115200_254400 n1_m1_116000_254400 0.892706
R6283 n1_m1_120000_254400 n1_m1_116000_254400 4.463529
R6284 n1_m1_120000_254400 n1_m1_124800_254400 5.356235
R6285 n1_m1_124800_254400 n1_m1_129600_254400 5.356235
R6286 n1_m1_129600_254400 n1_m1_134400_254400 5.356235
R6287 n1_m1_134400_254400 n1_m1_139200_254400 5.356235
R6288 n1_m1_139200_254400 n1_m1_144000_254400 5.356235
R6289 n1_m1_144000_254400 n1_m1_148800_254400 5.356235
R6290 n1_m1_148800_254400 n1_m1_153600_254400 5.356235
R6291 n1_m1_153600_254400 n1_m1_158400_254400 5.356235
R6292 n1_m1_158400_254400 n1_m1_163200_254400 5.356235
R6293 n1_m1_163200_254400 n1_m1_168000_254400 5.356235
R6294 n1_m1_168000_254400 n1_m1_172000_254400 4.463529
R6295 n1_m1_172800_254400 n1_m1_172000_254400 0.892706
R6296 n1_m1_172800_254400 n1_m1_177600_254400 5.356235
R6297 n1_m1_177600_254400 n1_m1_182400_254400 5.356235
R6298 n1_m1_182400_254400 n1_m1_187200_254400 5.356235
R6299 n1_m1_187200_254400 n1_m1_192000_254400 5.356235
R6300 n1_m1_192000_254400 n1_m1_196800_254400 5.356235
R6301 n1_m1_196800_254400 n1_m1_200000_254400 3.570824
R6302 n1_m1_201600_254400 n1_m1_200000_254400 1.785412
R6303 n1_m1_201600_254400 n1_m1_206400_254400 5.356235
R6304 n1_m1_206400_254400 n1_m1_211200_254400 5.356235
R6305 n1_m1_211200_254400 n1_m1_216000_254400 5.356235
R6306 n1_m1_216000_254400 n1_m1_220800_254400 5.356235
R6307 n1_m1_220800_254400 n1_m1_225600_254400 5.356235
R6308 n1_m1_225600_254400 n1_m1_228000_254400 2.678118
R6309 n1_m1_230400_254400 n1_m1_228000_254400 2.678118
R6310 n1_m1_230400_254400 n1_m1_235200_254400 5.356235
R6311 n1_m1_235200_254400 n1_m1_240000_254400 5.356235
R6312 n1_m1_240000_254400 n1_m1_244800_254400 5.356235
R6313 n1_m1_244800_254400 n1_m1_249600_254400 5.356235
R6314 n1_m1_249600_254400 n1_m1_254400_254400 5.356235
R6315 n1_m1_254400_254400 n1_m1_256000_254400 1.785412
R6316 n1_m1_259200_254400 n1_m1_256000_254400 3.570824
R6317 n1_m1_259200_254400 n1_m1_264000_254400 5.356235
R6318 n1_m1_264000_254400 n1_m1_268800_254400 5.356235
R6319 n1_m1_268800_254400 n1_m1_273600_254400 5.356235
R6320 n1_m1_273600_254400 n1_m1_278400_254400 5.356235
R6321 n1_m1_278400_254400 n1_m1_283200_254400 5.356235
R6322 n1_m1_283200_254400 n1_m1_284000_254400 0.892706
R6323 n1_m1_288000_254400 n1_m1_284000_254400 4.463529
R6324 n1_m1_288000_254400 n1_m1_292800_254400 5.356235
R6325 n1_m1_292800_254400 n1_m1_297600_254400 5.356235
R6326 n1_m1_297600_254400 n1_m1_302400_254400 5.356235
R6327 n1_m1_302400_254400 n1_m1_307200_254400 5.356235
R6328 n1_m1_307200_254400 n1_m1_312000_254400 5.356235
R6329 n1_m1_312000_254400 n1_m1_316800_254400 5.356235
R6330 n1_m1_316800_254400 n1_m1_321600_254400 5.356235
R6331 n1_m1_321600_254400 n1_m1_326400_254400 5.356235
R6332 n1_m1_326400_254400 n1_m1_331200_254400 5.356235
R6333 n1_m1_331200_254400 n1_m1_336000_254400 5.356235
R6334 n1_m1_336000_254400 n1_m1_340000_254400 4.463529
R6335 n1_m1_340800_254400 n1_m1_340000_254400 0.892706
R6336 n1_m1_340800_254400 n1_m1_345600_254400 5.356235
R6337 n1_m1_345600_254400 n1_m1_350400_254400 5.356235
R6338 n1_m1_350400_254400 n1_m1_355200_254400 5.356235
R6339 n1_m1_355200_254400 n1_m1_360000_254400 5.356235
R6340 n1_m1_360000_254400 n1_m1_364800_254400 5.356235
R6341 n1_m1_364800_254400 n1_m1_368000_254400 3.570824
R6342 n1_m1_369600_254400 n1_m1_368000_254400 1.785412
R6343 n1_m1_369600_254400 n1_m1_374400_254400 5.356235
R6344 n1_m1_374400_254400 n1_m1_379200_254400 5.356235
R6345 n1_m1_379200_254400 n1_m1_384000_254400 5.356235
R6346 n1_m1_384000_254400 n1_m1_388800_254400 5.356235
R6347 n1_m1_388800_254400 n1_m1_393600_254400 5.356235
R6348 n1_m1_393600_254400 n1_m1_396000_254400 2.678118
R6349 n1_m1_398400_254400 n1_m1_396000_254400 2.678118
R6350 n1_m1_398400_254400 n1_m1_403200_254400 5.356235
R6351 n1_m1_403200_254400 n1_m1_408000_254400 5.356235
R6352 n1_m1_408000_254400 n1_m1_412800_254400 5.356235
R6353 n1_m1_412800_254400 n1_m1_417600_254400 5.356235
R6354 n1_m1_417600_254400 n1_m1_422400_254400 5.356235
R6355 n1_m1_422400_254400 n1_m1_424000_254400 1.785412
R6356 n1_m1_427200_254400 n1_m1_424000_254400 3.570824
R6357 n1_m1_427200_254400 n1_m1_432000_254400 5.356235
R6358 n1_m1_432000_254400 n1_m1_436800_254400 5.356235
R6359 n1_m1_436800_254400 n1_m1_441600_254400 5.356235
R6360 n1_m1_441600_254400 n1_m1_446400_254400 5.356235
R6361 n1_m1_446400_254400 n1_m1_451200_254400 5.356235
R6362 n1_m1_451200_254400 n1_m1_452000_254400 0.892706
R6363 n1_m1_456000_254400 n1_m1_452000_254400 4.463529
R6364 n1_m1_456000_254400 n1_m1_460800_254400 5.356235
R6365 n1_m1_460800_254400 n1_m1_465600_254400 5.356235
R6366 n1_m1_465600_254400 n1_m1_470400_254400 5.356235
R6367 n1_m1_470400_254400 n1_m1_475200_254400 5.356235
R6368 n1_m1_475200_254400 n1_m1_480000_254400 5.356235
R6369 n1_m1_480000_254400 n1_m1_484800_254400 5.356235
R6370 n1_m1_484800_254400 n1_m1_489600_254400 5.356235
R6371 n1_m1_489600_254400 n1_m1_494400_254400 5.356235
R6372 n1_m1_0_259200 n1_m1_4000_259200 4.463529
R6373 n1_m1_4800_259200 n1_m1_4000_259200 0.892706
R6374 n1_m1_4800_259200 n1_m1_9600_259200 5.356235
R6375 n1_m1_9600_259200 n1_m1_14400_259200 5.356235
R6376 n1_m1_14400_259200 n1_m1_19200_259200 5.356235
R6377 n1_m1_19200_259200 n1_m1_24000_259200 5.356235
R6378 n1_m1_24000_259200 n1_m1_28800_259200 5.356235
R6379 n1_m1_28800_259200 n1_m1_32000_259200 3.570824
R6380 n1_m1_33600_259200 n1_m1_32000_259200 1.785412
R6381 n1_m1_33600_259200 n1_m1_38400_259200 5.356235
R6382 n1_m1_38400_259200 n1_m1_43200_259200 5.356235
R6383 n1_m1_43200_259200 n1_m1_48000_259200 5.356235
R6384 n1_m1_48000_259200 n1_m1_52800_259200 5.356235
R6385 n1_m1_52800_259200 n1_m1_57600_259200 5.356235
R6386 n1_m1_57600_259200 n1_m1_60000_259200 2.678118
R6387 n1_m1_62400_259200 n1_m1_60000_259200 2.678118
R6388 n1_m1_62400_259200 n1_m1_67200_259200 5.356235
R6389 n1_m1_67200_259200 n1_m1_72000_259200 5.356235
R6390 n1_m1_72000_259200 n1_m1_76800_259200 5.356235
R6391 n1_m1_76800_259200 n1_m1_81600_259200 5.356235
R6392 n1_m1_81600_259200 n1_m1_86400_259200 5.356235
R6393 n1_m1_86400_259200 n1_m1_88000_259200 1.785412
R6394 n1_m1_91200_259200 n1_m1_88000_259200 3.570824
R6395 n1_m1_91200_259200 n1_m1_96000_259200 5.356235
R6396 n1_m1_96000_259200 n1_m1_100800_259200 5.356235
R6397 n1_m1_100800_259200 n1_m1_105600_259200 5.356235
R6398 n1_m1_105600_259200 n1_m1_110400_259200 5.356235
R6399 n1_m1_110400_259200 n1_m1_115200_259200 5.356235
R6400 n1_m1_115200_259200 n1_m1_116000_259200 0.892706
R6401 n1_m1_120000_259200 n1_m1_116000_259200 4.463529
R6402 n1_m1_120000_259200 n1_m1_124800_259200 5.356235
R6403 n1_m1_124800_259200 n1_m1_129600_259200 5.356235
R6404 n1_m1_129600_259200 n1_m1_134400_259200 5.356235
R6405 n1_m1_134400_259200 n1_m1_139200_259200 5.356235
R6406 n1_m1_139200_259200 n1_m1_144000_259200 5.356235
R6407 n1_m1_144000_259200 n1_m1_148800_259200 5.356235
R6408 n1_m1_148800_259200 n1_m1_153600_259200 5.356235
R6409 n1_m1_153600_259200 n1_m1_158400_259200 5.356235
R6410 n1_m1_158400_259200 n1_m1_163200_259200 5.356235
R6411 n1_m1_163200_259200 n1_m1_168000_259200 5.356235
R6412 n1_m1_168000_259200 n1_m1_172000_259200 4.463529
R6413 n1_m1_172800_259200 n1_m1_172000_259200 0.892706
R6414 n1_m1_172800_259200 n1_m1_177600_259200 5.356235
R6415 n1_m1_177600_259200 n1_m1_182400_259200 5.356235
R6416 n1_m1_182400_259200 n1_m1_187200_259200 5.356235
R6417 n1_m1_187200_259200 n1_m1_192000_259200 5.356235
R6418 n1_m1_192000_259200 n1_m1_196800_259200 5.356235
R6419 n1_m1_196800_259200 n1_m1_200000_259200 3.570824
R6420 n1_m1_201600_259200 n1_m1_200000_259200 1.785412
R6421 n1_m1_201600_259200 n1_m1_206400_259200 5.356235
R6422 n1_m1_206400_259200 n1_m1_211200_259200 5.356235
R6423 n1_m1_211200_259200 n1_m1_216000_259200 5.356235
R6424 n1_m1_216000_259200 n1_m1_220800_259200 5.356235
R6425 n1_m1_220800_259200 n1_m1_225600_259200 5.356235
R6426 n1_m1_225600_259200 n1_m1_228000_259200 2.678118
R6427 n1_m1_230400_259200 n1_m1_228000_259200 2.678118
R6428 n1_m1_230400_259200 n1_m1_235200_259200 5.356235
R6429 n1_m1_235200_259200 n1_m1_240000_259200 5.356235
R6430 n1_m1_240000_259200 n1_m1_244800_259200 5.356235
R6431 n1_m1_244800_259200 n1_m1_249600_259200 5.356235
R6432 n1_m1_249600_259200 n1_m1_254400_259200 5.356235
R6433 n1_m1_254400_259200 n1_m1_256000_259200 1.785412
R6434 n1_m1_259200_259200 n1_m1_256000_259200 3.570824
R6435 n1_m1_259200_259200 n1_m1_264000_259200 5.356235
R6436 n1_m1_264000_259200 n1_m1_268800_259200 5.356235
R6437 n1_m1_268800_259200 n1_m1_273600_259200 5.356235
R6438 n1_m1_273600_259200 n1_m1_278400_259200 5.356235
R6439 n1_m1_278400_259200 n1_m1_283200_259200 5.356235
R6440 n1_m1_283200_259200 n1_m1_284000_259200 0.892706
R6441 n1_m1_288000_259200 n1_m1_284000_259200 4.463529
R6442 n1_m1_288000_259200 n1_m1_292800_259200 5.356235
R6443 n1_m1_292800_259200 n1_m1_297600_259200 5.356235
R6444 n1_m1_297600_259200 n1_m1_302400_259200 5.356235
R6445 n1_m1_302400_259200 n1_m1_307200_259200 5.356235
R6446 n1_m1_307200_259200 n1_m1_312000_259200 5.356235
R6447 n1_m1_312000_259200 n1_m1_316800_259200 5.356235
R6448 n1_m1_316800_259200 n1_m1_321600_259200 5.356235
R6449 n1_m1_321600_259200 n1_m1_326400_259200 5.356235
R6450 n1_m1_326400_259200 n1_m1_331200_259200 5.356235
R6451 n1_m1_331200_259200 n1_m1_336000_259200 5.356235
R6452 n1_m1_336000_259200 n1_m1_340000_259200 4.463529
R6453 n1_m1_340800_259200 n1_m1_340000_259200 0.892706
R6454 n1_m1_340800_259200 n1_m1_345600_259200 5.356235
R6455 n1_m1_345600_259200 n1_m1_350400_259200 5.356235
R6456 n1_m1_350400_259200 n1_m1_355200_259200 5.356235
R6457 n1_m1_355200_259200 n1_m1_360000_259200 5.356235
R6458 n1_m1_360000_259200 n1_m1_364800_259200 5.356235
R6459 n1_m1_364800_259200 n1_m1_368000_259200 3.570824
R6460 n1_m1_369600_259200 n1_m1_368000_259200 1.785412
R6461 n1_m1_369600_259200 n1_m1_374400_259200 5.356235
R6462 n1_m1_374400_259200 n1_m1_379200_259200 5.356235
R6463 n1_m1_379200_259200 n1_m1_384000_259200 5.356235
R6464 n1_m1_384000_259200 n1_m1_388800_259200 5.356235
R6465 n1_m1_388800_259200 n1_m1_393600_259200 5.356235
R6466 n1_m1_393600_259200 n1_m1_396000_259200 2.678118
R6467 n1_m1_398400_259200 n1_m1_396000_259200 2.678118
R6468 n1_m1_398400_259200 n1_m1_403200_259200 5.356235
R6469 n1_m1_403200_259200 n1_m1_408000_259200 5.356235
R6470 n1_m1_408000_259200 n1_m1_412800_259200 5.356235
R6471 n1_m1_412800_259200 n1_m1_417600_259200 5.356235
R6472 n1_m1_417600_259200 n1_m1_422400_259200 5.356235
R6473 n1_m1_422400_259200 n1_m1_424000_259200 1.785412
R6474 n1_m1_427200_259200 n1_m1_424000_259200 3.570824
R6475 n1_m1_427200_259200 n1_m1_432000_259200 5.356235
R6476 n1_m1_432000_259200 n1_m1_436800_259200 5.356235
R6477 n1_m1_436800_259200 n1_m1_441600_259200 5.356235
R6478 n1_m1_441600_259200 n1_m1_446400_259200 5.356235
R6479 n1_m1_446400_259200 n1_m1_451200_259200 5.356235
R6480 n1_m1_451200_259200 n1_m1_452000_259200 0.892706
R6481 n1_m1_456000_259200 n1_m1_452000_259200 4.463529
R6482 n1_m1_456000_259200 n1_m1_460800_259200 5.356235
R6483 n1_m1_460800_259200 n1_m1_465600_259200 5.356235
R6484 n1_m1_465600_259200 n1_m1_470400_259200 5.356235
R6485 n1_m1_470400_259200 n1_m1_475200_259200 5.356235
R6486 n1_m1_475200_259200 n1_m1_480000_259200 5.356235
R6487 n1_m1_480000_259200 n1_m1_484800_259200 5.356235
R6488 n1_m1_484800_259200 n1_m1_489600_259200 5.356235
R6489 n1_m1_489600_259200 n1_m1_494400_259200 5.356235
R6490 n1_m1_0_264000 n1_m1_4000_264000 4.463529
R6491 n1_m1_4800_264000 n1_m1_4000_264000 0.892706
R6492 n1_m1_4800_264000 n1_m1_9600_264000 5.356235
R6493 n1_m1_9600_264000 n1_m1_14400_264000 5.356235
R6494 n1_m1_14400_264000 n1_m1_19200_264000 5.356235
R6495 n1_m1_19200_264000 n1_m1_24000_264000 5.356235
R6496 n1_m1_24000_264000 n1_m1_28800_264000 5.356235
R6497 n1_m1_28800_264000 n1_m1_32000_264000 3.570824
R6498 n1_m1_33600_264000 n1_m1_32000_264000 1.785412
R6499 n1_m1_33600_264000 n1_m1_38400_264000 5.356235
R6500 n1_m1_38400_264000 n1_m1_43200_264000 5.356235
R6501 n1_m1_43200_264000 n1_m1_48000_264000 5.356235
R6502 n1_m1_48000_264000 n1_m1_52800_264000 5.356235
R6503 n1_m1_52800_264000 n1_m1_57600_264000 5.356235
R6504 n1_m1_57600_264000 n1_m1_60000_264000 2.678118
R6505 n1_m1_62400_264000 n1_m1_60000_264000 2.678118
R6506 n1_m1_62400_264000 n1_m1_67200_264000 5.356235
R6507 n1_m1_67200_264000 n1_m1_72000_264000 5.356235
R6508 n1_m1_72000_264000 n1_m1_76800_264000 5.356235
R6509 n1_m1_76800_264000 n1_m1_81600_264000 5.356235
R6510 n1_m1_81600_264000 n1_m1_86400_264000 5.356235
R6511 n1_m1_86400_264000 n1_m1_88000_264000 1.785412
R6512 n1_m1_91200_264000 n1_m1_88000_264000 3.570824
R6513 n1_m1_91200_264000 n1_m1_96000_264000 5.356235
R6514 n1_m1_96000_264000 n1_m1_100800_264000 5.356235
R6515 n1_m1_100800_264000 n1_m1_105600_264000 5.356235
R6516 n1_m1_105600_264000 n1_m1_110400_264000 5.356235
R6517 n1_m1_110400_264000 n1_m1_115200_264000 5.356235
R6518 n1_m1_115200_264000 n1_m1_116000_264000 0.892706
R6519 n1_m1_120000_264000 n1_m1_116000_264000 4.463529
R6520 n1_m1_120000_264000 n1_m1_124800_264000 5.356235
R6521 n1_m1_124800_264000 n1_m1_129600_264000 5.356235
R6522 n1_m1_129600_264000 n1_m1_134400_264000 5.356235
R6523 n1_m1_134400_264000 n1_m1_139200_264000 5.356235
R6524 n1_m1_139200_264000 n1_m1_144000_264000 5.356235
R6525 n1_m1_144000_264000 n1_m1_148800_264000 5.356235
R6526 n1_m1_148800_264000 n1_m1_153600_264000 5.356235
R6527 n1_m1_153600_264000 n1_m1_158400_264000 5.356235
R6528 n1_m1_158400_264000 n1_m1_163200_264000 5.356235
R6529 n1_m1_163200_264000 n1_m1_168000_264000 5.356235
R6530 n1_m1_168000_264000 n1_m1_172000_264000 4.463529
R6531 n1_m1_172800_264000 n1_m1_172000_264000 0.892706
R6532 n1_m1_172800_264000 n1_m1_177600_264000 5.356235
R6533 n1_m1_177600_264000 n1_m1_182400_264000 5.356235
R6534 n1_m1_182400_264000 n1_m1_187200_264000 5.356235
R6535 n1_m1_187200_264000 n1_m1_192000_264000 5.356235
R6536 n1_m1_192000_264000 n1_m1_196800_264000 5.356235
R6537 n1_m1_196800_264000 n1_m1_200000_264000 3.570824
R6538 n1_m1_201600_264000 n1_m1_200000_264000 1.785412
R6539 n1_m1_201600_264000 n1_m1_206400_264000 5.356235
R6540 n1_m1_206400_264000 n1_m1_211200_264000 5.356235
R6541 n1_m1_211200_264000 n1_m1_216000_264000 5.356235
R6542 n1_m1_216000_264000 n1_m1_220800_264000 5.356235
R6543 n1_m1_220800_264000 n1_m1_225600_264000 5.356235
R6544 n1_m1_225600_264000 n1_m1_228000_264000 2.678118
R6545 n1_m1_230400_264000 n1_m1_228000_264000 2.678118
R6546 n1_m1_230400_264000 n1_m1_235200_264000 5.356235
R6547 n1_m1_235200_264000 n1_m1_240000_264000 5.356235
R6548 n1_m1_240000_264000 n1_m1_244800_264000 5.356235
R6549 n1_m1_244800_264000 n1_m1_249600_264000 5.356235
R6550 n1_m1_249600_264000 n1_m1_254400_264000 5.356235
R6551 n1_m1_254400_264000 n1_m1_256000_264000 1.785412
R6552 n1_m1_259200_264000 n1_m1_256000_264000 3.570824
R6553 n1_m1_259200_264000 n1_m1_264000_264000 5.356235
R6554 n1_m1_264000_264000 n1_m1_268800_264000 5.356235
R6555 n1_m1_268800_264000 n1_m1_273600_264000 5.356235
R6556 n1_m1_273600_264000 n1_m1_278400_264000 5.356235
R6557 n1_m1_278400_264000 n1_m1_283200_264000 5.356235
R6558 n1_m1_283200_264000 n1_m1_284000_264000 0.892706
R6559 n1_m1_288000_264000 n1_m1_284000_264000 4.463529
R6560 n1_m1_288000_264000 n1_m1_292800_264000 5.356235
R6561 n1_m1_292800_264000 n1_m1_297600_264000 5.356235
R6562 n1_m1_297600_264000 n1_m1_302400_264000 5.356235
R6563 n1_m1_302400_264000 n1_m1_307200_264000 5.356235
R6564 n1_m1_307200_264000 n1_m1_312000_264000 5.356235
R6565 n1_m1_312000_264000 n1_m1_316800_264000 5.356235
R6566 n1_m1_316800_264000 n1_m1_321600_264000 5.356235
R6567 n1_m1_321600_264000 n1_m1_326400_264000 5.356235
R6568 n1_m1_326400_264000 n1_m1_331200_264000 5.356235
R6569 n1_m1_331200_264000 n1_m1_336000_264000 5.356235
R6570 n1_m1_336000_264000 n1_m1_340000_264000 4.463529
R6571 n1_m1_340800_264000 n1_m1_340000_264000 0.892706
R6572 n1_m1_340800_264000 n1_m1_345600_264000 5.356235
R6573 n1_m1_345600_264000 n1_m1_350400_264000 5.356235
R6574 n1_m1_350400_264000 n1_m1_355200_264000 5.356235
R6575 n1_m1_355200_264000 n1_m1_360000_264000 5.356235
R6576 n1_m1_360000_264000 n1_m1_364800_264000 5.356235
R6577 n1_m1_364800_264000 n1_m1_368000_264000 3.570824
R6578 n1_m1_369600_264000 n1_m1_368000_264000 1.785412
R6579 n1_m1_369600_264000 n1_m1_374400_264000 5.356235
R6580 n1_m1_374400_264000 n1_m1_379200_264000 5.356235
R6581 n1_m1_379200_264000 n1_m1_384000_264000 5.356235
R6582 n1_m1_384000_264000 n1_m1_388800_264000 5.356235
R6583 n1_m1_388800_264000 n1_m1_393600_264000 5.356235
R6584 n1_m1_393600_264000 n1_m1_396000_264000 2.678118
R6585 n1_m1_398400_264000 n1_m1_396000_264000 2.678118
R6586 n1_m1_398400_264000 n1_m1_403200_264000 5.356235
R6587 n1_m1_403200_264000 n1_m1_408000_264000 5.356235
R6588 n1_m1_408000_264000 n1_m1_412800_264000 5.356235
R6589 n1_m1_412800_264000 n1_m1_417600_264000 5.356235
R6590 n1_m1_417600_264000 n1_m1_422400_264000 5.356235
R6591 n1_m1_422400_264000 n1_m1_424000_264000 1.785412
R6592 n1_m1_427200_264000 n1_m1_424000_264000 3.570824
R6593 n1_m1_427200_264000 n1_m1_432000_264000 5.356235
R6594 n1_m1_432000_264000 n1_m1_436800_264000 5.356235
R6595 n1_m1_436800_264000 n1_m1_441600_264000 5.356235
R6596 n1_m1_441600_264000 n1_m1_446400_264000 5.356235
R6597 n1_m1_446400_264000 n1_m1_451200_264000 5.356235
R6598 n1_m1_451200_264000 n1_m1_452000_264000 0.892706
R6599 n1_m1_456000_264000 n1_m1_452000_264000 4.463529
R6600 n1_m1_456000_264000 n1_m1_460800_264000 5.356235
R6601 n1_m1_460800_264000 n1_m1_465600_264000 5.356235
R6602 n1_m1_465600_264000 n1_m1_470400_264000 5.356235
R6603 n1_m1_470400_264000 n1_m1_475200_264000 5.356235
R6604 n1_m1_475200_264000 n1_m1_480000_264000 5.356235
R6605 n1_m1_480000_264000 n1_m1_484800_264000 5.356235
R6606 n1_m1_484800_264000 n1_m1_489600_264000 5.356235
R6607 n1_m1_489600_264000 n1_m1_494400_264000 5.356235
R6608 n1_m1_0_268800 n1_m1_4000_268800 4.463529
R6609 n1_m1_4800_268800 n1_m1_4000_268800 0.892706
R6610 n1_m1_4800_268800 n1_m1_9600_268800 5.356235
R6611 n1_m1_9600_268800 n1_m1_14400_268800 5.356235
R6612 n1_m1_14400_268800 n1_m1_19200_268800 5.356235
R6613 n1_m1_19200_268800 n1_m1_24000_268800 5.356235
R6614 n1_m1_24000_268800 n1_m1_28800_268800 5.356235
R6615 n1_m1_28800_268800 n1_m1_32000_268800 3.570824
R6616 n1_m1_33600_268800 n1_m1_32000_268800 1.785412
R6617 n1_m1_33600_268800 n1_m1_38400_268800 5.356235
R6618 n1_m1_38400_268800 n1_m1_43200_268800 5.356235
R6619 n1_m1_43200_268800 n1_m1_48000_268800 5.356235
R6620 n1_m1_48000_268800 n1_m1_52800_268800 5.356235
R6621 n1_m1_52800_268800 n1_m1_57600_268800 5.356235
R6622 n1_m1_57600_268800 n1_m1_60000_268800 2.678118
R6623 n1_m1_62400_268800 n1_m1_60000_268800 2.678118
R6624 n1_m1_62400_268800 n1_m1_67200_268800 5.356235
R6625 n1_m1_67200_268800 n1_m1_72000_268800 5.356235
R6626 n1_m1_72000_268800 n1_m1_76800_268800 5.356235
R6627 n1_m1_76800_268800 n1_m1_81600_268800 5.356235
R6628 n1_m1_81600_268800 n1_m1_86400_268800 5.356235
R6629 n1_m1_86400_268800 n1_m1_88000_268800 1.785412
R6630 n1_m1_91200_268800 n1_m1_88000_268800 3.570824
R6631 n1_m1_91200_268800 n1_m1_96000_268800 5.356235
R6632 n1_m1_96000_268800 n1_m1_100800_268800 5.356235
R6633 n1_m1_100800_268800 n1_m1_105600_268800 5.356235
R6634 n1_m1_105600_268800 n1_m1_110400_268800 5.356235
R6635 n1_m1_110400_268800 n1_m1_115200_268800 5.356235
R6636 n1_m1_115200_268800 n1_m1_116000_268800 0.892706
R6637 n1_m1_120000_268800 n1_m1_116000_268800 4.463529
R6638 n1_m1_120000_268800 n1_m1_124800_268800 5.356235
R6639 n1_m1_124800_268800 n1_m1_129600_268800 5.356235
R6640 n1_m1_129600_268800 n1_m1_134400_268800 5.356235
R6641 n1_m1_134400_268800 n1_m1_139200_268800 5.356235
R6642 n1_m1_139200_268800 n1_m1_144000_268800 5.356235
R6643 n1_m1_144000_268800 n1_m1_148800_268800 5.356235
R6644 n1_m1_148800_268800 n1_m1_153600_268800 5.356235
R6645 n1_m1_153600_268800 n1_m1_158400_268800 5.356235
R6646 n1_m1_158400_268800 n1_m1_163200_268800 5.356235
R6647 n1_m1_163200_268800 n1_m1_168000_268800 5.356235
R6648 n1_m1_168000_268800 n1_m1_172000_268800 4.463529
R6649 n1_m1_172800_268800 n1_m1_172000_268800 0.892706
R6650 n1_m1_172800_268800 n1_m1_177600_268800 5.356235
R6651 n1_m1_177600_268800 n1_m1_182400_268800 5.356235
R6652 n1_m1_182400_268800 n1_m1_187200_268800 5.356235
R6653 n1_m1_187200_268800 n1_m1_192000_268800 5.356235
R6654 n1_m1_192000_268800 n1_m1_196800_268800 5.356235
R6655 n1_m1_196800_268800 n1_m1_200000_268800 3.570824
R6656 n1_m1_201600_268800 n1_m1_200000_268800 1.785412
R6657 n1_m1_201600_268800 n1_m1_206400_268800 5.356235
R6658 n1_m1_206400_268800 n1_m1_211200_268800 5.356235
R6659 n1_m1_211200_268800 n1_m1_216000_268800 5.356235
R6660 n1_m1_216000_268800 n1_m1_220800_268800 5.356235
R6661 n1_m1_220800_268800 n1_m1_225600_268800 5.356235
R6662 n1_m1_225600_268800 n1_m1_228000_268800 2.678118
R6663 n1_m1_230400_268800 n1_m1_228000_268800 2.678118
R6664 n1_m1_230400_268800 n1_m1_235200_268800 5.356235
R6665 n1_m1_235200_268800 n1_m1_240000_268800 5.356235
R6666 n1_m1_240000_268800 n1_m1_244800_268800 5.356235
R6667 n1_m1_244800_268800 n1_m1_249600_268800 5.356235
R6668 n1_m1_249600_268800 n1_m1_254400_268800 5.356235
R6669 n1_m1_254400_268800 n1_m1_256000_268800 1.785412
R6670 n1_m1_259200_268800 n1_m1_256000_268800 3.570824
R6671 n1_m1_259200_268800 n1_m1_264000_268800 5.356235
R6672 n1_m1_264000_268800 n1_m1_268800_268800 5.356235
R6673 n1_m1_268800_268800 n1_m1_273600_268800 5.356235
R6674 n1_m1_273600_268800 n1_m1_278400_268800 5.356235
R6675 n1_m1_278400_268800 n1_m1_283200_268800 5.356235
R6676 n1_m1_283200_268800 n1_m1_284000_268800 0.892706
R6677 n1_m1_288000_268800 n1_m1_284000_268800 4.463529
R6678 n1_m1_288000_268800 n1_m1_292800_268800 5.356235
R6679 n1_m1_292800_268800 n1_m1_297600_268800 5.356235
R6680 n1_m1_297600_268800 n1_m1_302400_268800 5.356235
R6681 n1_m1_302400_268800 n1_m1_307200_268800 5.356235
R6682 n1_m1_307200_268800 n1_m1_312000_268800 5.356235
R6683 n1_m1_312000_268800 n1_m1_316800_268800 5.356235
R6684 n1_m1_316800_268800 n1_m1_321600_268800 5.356235
R6685 n1_m1_321600_268800 n1_m1_326400_268800 5.356235
R6686 n1_m1_326400_268800 n1_m1_331200_268800 5.356235
R6687 n1_m1_331200_268800 n1_m1_336000_268800 5.356235
R6688 n1_m1_336000_268800 n1_m1_340000_268800 4.463529
R6689 n1_m1_340800_268800 n1_m1_340000_268800 0.892706
R6690 n1_m1_340800_268800 n1_m1_345600_268800 5.356235
R6691 n1_m1_345600_268800 n1_m1_350400_268800 5.356235
R6692 n1_m1_350400_268800 n1_m1_355200_268800 5.356235
R6693 n1_m1_355200_268800 n1_m1_360000_268800 5.356235
R6694 n1_m1_360000_268800 n1_m1_364800_268800 5.356235
R6695 n1_m1_364800_268800 n1_m1_368000_268800 3.570824
R6696 n1_m1_369600_268800 n1_m1_368000_268800 1.785412
R6697 n1_m1_369600_268800 n1_m1_374400_268800 5.356235
R6698 n1_m1_374400_268800 n1_m1_379200_268800 5.356235
R6699 n1_m1_379200_268800 n1_m1_384000_268800 5.356235
R6700 n1_m1_384000_268800 n1_m1_388800_268800 5.356235
R6701 n1_m1_388800_268800 n1_m1_393600_268800 5.356235
R6702 n1_m1_393600_268800 n1_m1_396000_268800 2.678118
R6703 n1_m1_398400_268800 n1_m1_396000_268800 2.678118
R6704 n1_m1_398400_268800 n1_m1_403200_268800 5.356235
R6705 n1_m1_403200_268800 n1_m1_408000_268800 5.356235
R6706 n1_m1_408000_268800 n1_m1_412800_268800 5.356235
R6707 n1_m1_412800_268800 n1_m1_417600_268800 5.356235
R6708 n1_m1_417600_268800 n1_m1_422400_268800 5.356235
R6709 n1_m1_422400_268800 n1_m1_424000_268800 1.785412
R6710 n1_m1_427200_268800 n1_m1_424000_268800 3.570824
R6711 n1_m1_427200_268800 n1_m1_432000_268800 5.356235
R6712 n1_m1_432000_268800 n1_m1_436800_268800 5.356235
R6713 n1_m1_436800_268800 n1_m1_441600_268800 5.356235
R6714 n1_m1_441600_268800 n1_m1_446400_268800 5.356235
R6715 n1_m1_446400_268800 n1_m1_451200_268800 5.356235
R6716 n1_m1_451200_268800 n1_m1_452000_268800 0.892706
R6717 n1_m1_456000_268800 n1_m1_452000_268800 4.463529
R6718 n1_m1_456000_268800 n1_m1_460800_268800 5.356235
R6719 n1_m1_460800_268800 n1_m1_465600_268800 5.356235
R6720 n1_m1_465600_268800 n1_m1_470400_268800 5.356235
R6721 n1_m1_470400_268800 n1_m1_475200_268800 5.356235
R6722 n1_m1_475200_268800 n1_m1_480000_268800 5.356235
R6723 n1_m1_480000_268800 n1_m1_484800_268800 5.356235
R6724 n1_m1_484800_268800 n1_m1_489600_268800 5.356235
R6725 n1_m1_489600_268800 n1_m1_494400_268800 5.356235
R6726 n1_m1_0_273600 n1_m1_4000_273600 4.463529
R6727 n1_m1_4800_273600 n1_m1_4000_273600 0.892706
R6728 n1_m1_4800_273600 n1_m1_9600_273600 5.356235
R6729 n1_m1_9600_273600 n1_m1_14400_273600 5.356235
R6730 n1_m1_14400_273600 n1_m1_19200_273600 5.356235
R6731 n1_m1_19200_273600 n1_m1_24000_273600 5.356235
R6732 n1_m1_24000_273600 n1_m1_28800_273600 5.356235
R6733 n1_m1_28800_273600 n1_m1_32000_273600 3.570824
R6734 n1_m1_33600_273600 n1_m1_32000_273600 1.785412
R6735 n1_m1_33600_273600 n1_m1_38400_273600 5.356235
R6736 n1_m1_38400_273600 n1_m1_43200_273600 5.356235
R6737 n1_m1_43200_273600 n1_m1_48000_273600 5.356235
R6738 n1_m1_48000_273600 n1_m1_52800_273600 5.356235
R6739 n1_m1_52800_273600 n1_m1_57600_273600 5.356235
R6740 n1_m1_57600_273600 n1_m1_60000_273600 2.678118
R6741 n1_m1_62400_273600 n1_m1_60000_273600 2.678118
R6742 n1_m1_62400_273600 n1_m1_67200_273600 5.356235
R6743 n1_m1_67200_273600 n1_m1_72000_273600 5.356235
R6744 n1_m1_72000_273600 n1_m1_76800_273600 5.356235
R6745 n1_m1_76800_273600 n1_m1_81600_273600 5.356235
R6746 n1_m1_81600_273600 n1_m1_86400_273600 5.356235
R6747 n1_m1_86400_273600 n1_m1_88000_273600 1.785412
R6748 n1_m1_91200_273600 n1_m1_88000_273600 3.570824
R6749 n1_m1_91200_273600 n1_m1_96000_273600 5.356235
R6750 n1_m1_96000_273600 n1_m1_100800_273600 5.356235
R6751 n1_m1_100800_273600 n1_m1_105600_273600 5.356235
R6752 n1_m1_105600_273600 n1_m1_110400_273600 5.356235
R6753 n1_m1_110400_273600 n1_m1_115200_273600 5.356235
R6754 n1_m1_115200_273600 n1_m1_116000_273600 0.892706
R6755 n1_m1_120000_273600 n1_m1_116000_273600 4.463529
R6756 n1_m1_120000_273600 n1_m1_124800_273600 5.356235
R6757 n1_m1_124800_273600 n1_m1_129600_273600 5.356235
R6758 n1_m1_129600_273600 n1_m1_134400_273600 5.356235
R6759 n1_m1_134400_273600 n1_m1_139200_273600 5.356235
R6760 n1_m1_139200_273600 n1_m1_144000_273600 5.356235
R6761 n1_m1_144000_273600 n1_m1_148800_273600 5.356235
R6762 n1_m1_148800_273600 n1_m1_153600_273600 5.356235
R6763 n1_m1_153600_273600 n1_m1_158400_273600 5.356235
R6764 n1_m1_158400_273600 n1_m1_163200_273600 5.356235
R6765 n1_m1_163200_273600 n1_m1_168000_273600 5.356235
R6766 n1_m1_168000_273600 n1_m1_172000_273600 4.463529
R6767 n1_m1_172800_273600 n1_m1_172000_273600 0.892706
R6768 n1_m1_172800_273600 n1_m1_177600_273600 5.356235
R6769 n1_m1_177600_273600 n1_m1_182400_273600 5.356235
R6770 n1_m1_182400_273600 n1_m1_187200_273600 5.356235
R6771 n1_m1_187200_273600 n1_m1_192000_273600 5.356235
R6772 n1_m1_192000_273600 n1_m1_196800_273600 5.356235
R6773 n1_m1_196800_273600 n1_m1_200000_273600 3.570824
R6774 n1_m1_201600_273600 n1_m1_200000_273600 1.785412
R6775 n1_m1_201600_273600 n1_m1_206400_273600 5.356235
R6776 n1_m1_206400_273600 n1_m1_211200_273600 5.356235
R6777 n1_m1_211200_273600 n1_m1_216000_273600 5.356235
R6778 n1_m1_216000_273600 n1_m1_220800_273600 5.356235
R6779 n1_m1_220800_273600 n1_m1_225600_273600 5.356235
R6780 n1_m1_225600_273600 n1_m1_228000_273600 2.678118
R6781 n1_m1_230400_273600 n1_m1_228000_273600 2.678118
R6782 n1_m1_230400_273600 n1_m1_235200_273600 5.356235
R6783 n1_m1_235200_273600 n1_m1_240000_273600 5.356235
R6784 n1_m1_240000_273600 n1_m1_244800_273600 5.356235
R6785 n1_m1_244800_273600 n1_m1_249600_273600 5.356235
R6786 n1_m1_249600_273600 n1_m1_254400_273600 5.356235
R6787 n1_m1_254400_273600 n1_m1_256000_273600 1.785412
R6788 n1_m1_259200_273600 n1_m1_256000_273600 3.570824
R6789 n1_m1_259200_273600 n1_m1_264000_273600 5.356235
R6790 n1_m1_264000_273600 n1_m1_268800_273600 5.356235
R6791 n1_m1_268800_273600 n1_m1_273600_273600 5.356235
R6792 n1_m1_273600_273600 n1_m1_278400_273600 5.356235
R6793 n1_m1_278400_273600 n1_m1_283200_273600 5.356235
R6794 n1_m1_283200_273600 n1_m1_284000_273600 0.892706
R6795 n1_m1_288000_273600 n1_m1_284000_273600 4.463529
R6796 n1_m1_288000_273600 n1_m1_292800_273600 5.356235
R6797 n1_m1_292800_273600 n1_m1_297600_273600 5.356235
R6798 n1_m1_297600_273600 n1_m1_302400_273600 5.356235
R6799 n1_m1_302400_273600 n1_m1_307200_273600 5.356235
R6800 n1_m1_307200_273600 n1_m1_312000_273600 5.356235
R6801 n1_m1_312000_273600 n1_m1_316800_273600 5.356235
R6802 n1_m1_316800_273600 n1_m1_321600_273600 5.356235
R6803 n1_m1_321600_273600 n1_m1_326400_273600 5.356235
R6804 n1_m1_326400_273600 n1_m1_331200_273600 5.356235
R6805 n1_m1_331200_273600 n1_m1_336000_273600 5.356235
R6806 n1_m1_336000_273600 n1_m1_340000_273600 4.463529
R6807 n1_m1_340800_273600 n1_m1_340000_273600 0.892706
R6808 n1_m1_340800_273600 n1_m1_345600_273600 5.356235
R6809 n1_m1_345600_273600 n1_m1_350400_273600 5.356235
R6810 n1_m1_350400_273600 n1_m1_355200_273600 5.356235
R6811 n1_m1_355200_273600 n1_m1_360000_273600 5.356235
R6812 n1_m1_360000_273600 n1_m1_364800_273600 5.356235
R6813 n1_m1_364800_273600 n1_m1_368000_273600 3.570824
R6814 n1_m1_369600_273600 n1_m1_368000_273600 1.785412
R6815 n1_m1_369600_273600 n1_m1_374400_273600 5.356235
R6816 n1_m1_374400_273600 n1_m1_379200_273600 5.356235
R6817 n1_m1_379200_273600 n1_m1_384000_273600 5.356235
R6818 n1_m1_384000_273600 n1_m1_388800_273600 5.356235
R6819 n1_m1_388800_273600 n1_m1_393600_273600 5.356235
R6820 n1_m1_393600_273600 n1_m1_396000_273600 2.678118
R6821 n1_m1_398400_273600 n1_m1_396000_273600 2.678118
R6822 n1_m1_398400_273600 n1_m1_403200_273600 5.356235
R6823 n1_m1_403200_273600 n1_m1_408000_273600 5.356235
R6824 n1_m1_408000_273600 n1_m1_412800_273600 5.356235
R6825 n1_m1_412800_273600 n1_m1_417600_273600 5.356235
R6826 n1_m1_417600_273600 n1_m1_422400_273600 5.356235
R6827 n1_m1_422400_273600 n1_m1_424000_273600 1.785412
R6828 n1_m1_427200_273600 n1_m1_424000_273600 3.570824
R6829 n1_m1_427200_273600 n1_m1_432000_273600 5.356235
R6830 n1_m1_432000_273600 n1_m1_436800_273600 5.356235
R6831 n1_m1_436800_273600 n1_m1_441600_273600 5.356235
R6832 n1_m1_441600_273600 n1_m1_446400_273600 5.356235
R6833 n1_m1_446400_273600 n1_m1_451200_273600 5.356235
R6834 n1_m1_451200_273600 n1_m1_452000_273600 0.892706
R6835 n1_m1_456000_273600 n1_m1_452000_273600 4.463529
R6836 n1_m1_456000_273600 n1_m1_460800_273600 5.356235
R6837 n1_m1_460800_273600 n1_m1_465600_273600 5.356235
R6838 n1_m1_465600_273600 n1_m1_470400_273600 5.356235
R6839 n1_m1_470400_273600 n1_m1_475200_273600 5.356235
R6840 n1_m1_475200_273600 n1_m1_480000_273600 5.356235
R6841 n1_m1_480000_273600 n1_m1_484800_273600 5.356235
R6842 n1_m1_484800_273600 n1_m1_489600_273600 5.356235
R6843 n1_m1_489600_273600 n1_m1_494400_273600 5.356235
R6844 n1_m1_0_278400 n1_m1_4000_278400 4.463529
R6845 n1_m1_4800_278400 n1_m1_4000_278400 0.892706
R6846 n1_m1_4800_278400 n1_m1_9600_278400 5.356235
R6847 n1_m1_9600_278400 n1_m1_14400_278400 5.356235
R6848 n1_m1_14400_278400 n1_m1_19200_278400 5.356235
R6849 n1_m1_19200_278400 n1_m1_24000_278400 5.356235
R6850 n1_m1_24000_278400 n1_m1_28800_278400 5.356235
R6851 n1_m1_28800_278400 n1_m1_32000_278400 3.570824
R6852 n1_m1_33600_278400 n1_m1_32000_278400 1.785412
R6853 n1_m1_33600_278400 n1_m1_38400_278400 5.356235
R6854 n1_m1_38400_278400 n1_m1_43200_278400 5.356235
R6855 n1_m1_43200_278400 n1_m1_48000_278400 5.356235
R6856 n1_m1_48000_278400 n1_m1_52800_278400 5.356235
R6857 n1_m1_52800_278400 n1_m1_57600_278400 5.356235
R6858 n1_m1_57600_278400 n1_m1_60000_278400 2.678118
R6859 n1_m1_62400_278400 n1_m1_60000_278400 2.678118
R6860 n1_m1_62400_278400 n1_m1_67200_278400 5.356235
R6861 n1_m1_67200_278400 n1_m1_72000_278400 5.356235
R6862 n1_m1_72000_278400 n1_m1_76800_278400 5.356235
R6863 n1_m1_76800_278400 n1_m1_81600_278400 5.356235
R6864 n1_m1_81600_278400 n1_m1_86400_278400 5.356235
R6865 n1_m1_86400_278400 n1_m1_88000_278400 1.785412
R6866 n1_m1_91200_278400 n1_m1_88000_278400 3.570824
R6867 n1_m1_91200_278400 n1_m1_96000_278400 5.356235
R6868 n1_m1_96000_278400 n1_m1_100800_278400 5.356235
R6869 n1_m1_100800_278400 n1_m1_105600_278400 5.356235
R6870 n1_m1_105600_278400 n1_m1_110400_278400 5.356235
R6871 n1_m1_110400_278400 n1_m1_115200_278400 5.356235
R6872 n1_m1_115200_278400 n1_m1_116000_278400 0.892706
R6873 n1_m1_120000_278400 n1_m1_116000_278400 4.463529
R6874 n1_m1_120000_278400 n1_m1_124800_278400 5.356235
R6875 n1_m1_124800_278400 n1_m1_129600_278400 5.356235
R6876 n1_m1_129600_278400 n1_m1_134400_278400 5.356235
R6877 n1_m1_134400_278400 n1_m1_139200_278400 5.356235
R6878 n1_m1_139200_278400 n1_m1_144000_278400 5.356235
R6879 n1_m1_144000_278400 n1_m1_148800_278400 5.356235
R6880 n1_m1_148800_278400 n1_m1_153600_278400 5.356235
R6881 n1_m1_153600_278400 n1_m1_158400_278400 5.356235
R6882 n1_m1_158400_278400 n1_m1_163200_278400 5.356235
R6883 n1_m1_163200_278400 n1_m1_168000_278400 5.356235
R6884 n1_m1_168000_278400 n1_m1_172000_278400 4.463529
R6885 n1_m1_172800_278400 n1_m1_172000_278400 0.892706
R6886 n1_m1_172800_278400 n1_m1_177600_278400 5.356235
R6887 n1_m1_177600_278400 n1_m1_182400_278400 5.356235
R6888 n1_m1_182400_278400 n1_m1_187200_278400 5.356235
R6889 n1_m1_187200_278400 n1_m1_192000_278400 5.356235
R6890 n1_m1_192000_278400 n1_m1_196800_278400 5.356235
R6891 n1_m1_196800_278400 n1_m1_200000_278400 3.570824
R6892 n1_m1_201600_278400 n1_m1_200000_278400 1.785412
R6893 n1_m1_201600_278400 n1_m1_206400_278400 5.356235
R6894 n1_m1_206400_278400 n1_m1_211200_278400 5.356235
R6895 n1_m1_211200_278400 n1_m1_216000_278400 5.356235
R6896 n1_m1_216000_278400 n1_m1_220800_278400 5.356235
R6897 n1_m1_220800_278400 n1_m1_225600_278400 5.356235
R6898 n1_m1_225600_278400 n1_m1_228000_278400 2.678118
R6899 n1_m1_230400_278400 n1_m1_228000_278400 2.678118
R6900 n1_m1_230400_278400 n1_m1_235200_278400 5.356235
R6901 n1_m1_235200_278400 n1_m1_240000_278400 5.356235
R6902 n1_m1_240000_278400 n1_m1_244800_278400 5.356235
R6903 n1_m1_244800_278400 n1_m1_249600_278400 5.356235
R6904 n1_m1_249600_278400 n1_m1_254400_278400 5.356235
R6905 n1_m1_254400_278400 n1_m1_256000_278400 1.785412
R6906 n1_m1_259200_278400 n1_m1_256000_278400 3.570824
R6907 n1_m1_259200_278400 n1_m1_264000_278400 5.356235
R6908 n1_m1_264000_278400 n1_m1_268800_278400 5.356235
R6909 n1_m1_268800_278400 n1_m1_273600_278400 5.356235
R6910 n1_m1_273600_278400 n1_m1_278400_278400 5.356235
R6911 n1_m1_278400_278400 n1_m1_283200_278400 5.356235
R6912 n1_m1_283200_278400 n1_m1_284000_278400 0.892706
R6913 n1_m1_288000_278400 n1_m1_284000_278400 4.463529
R6914 n1_m1_288000_278400 n1_m1_292800_278400 5.356235
R6915 n1_m1_292800_278400 n1_m1_297600_278400 5.356235
R6916 n1_m1_297600_278400 n1_m1_302400_278400 5.356235
R6917 n1_m1_302400_278400 n1_m1_307200_278400 5.356235
R6918 n1_m1_307200_278400 n1_m1_312000_278400 5.356235
R6919 n1_m1_312000_278400 n1_m1_316800_278400 5.356235
R6920 n1_m1_316800_278400 n1_m1_321600_278400 5.356235
R6921 n1_m1_321600_278400 n1_m1_326400_278400 5.356235
R6922 n1_m1_326400_278400 n1_m1_331200_278400 5.356235
R6923 n1_m1_331200_278400 n1_m1_336000_278400 5.356235
R6924 n1_m1_336000_278400 n1_m1_340000_278400 4.463529
R6925 n1_m1_340800_278400 n1_m1_340000_278400 0.892706
R6926 n1_m1_340800_278400 n1_m1_345600_278400 5.356235
R6927 n1_m1_345600_278400 n1_m1_350400_278400 5.356235
R6928 n1_m1_350400_278400 n1_m1_355200_278400 5.356235
R6929 n1_m1_355200_278400 n1_m1_360000_278400 5.356235
R6930 n1_m1_360000_278400 n1_m1_364800_278400 5.356235
R6931 n1_m1_364800_278400 n1_m1_368000_278400 3.570824
R6932 n1_m1_369600_278400 n1_m1_368000_278400 1.785412
R6933 n1_m1_369600_278400 n1_m1_374400_278400 5.356235
R6934 n1_m1_374400_278400 n1_m1_379200_278400 5.356235
R6935 n1_m1_379200_278400 n1_m1_384000_278400 5.356235
R6936 n1_m1_384000_278400 n1_m1_388800_278400 5.356235
R6937 n1_m1_388800_278400 n1_m1_393600_278400 5.356235
R6938 n1_m1_393600_278400 n1_m1_396000_278400 2.678118
R6939 n1_m1_398400_278400 n1_m1_396000_278400 2.678118
R6940 n1_m1_398400_278400 n1_m1_403200_278400 5.356235
R6941 n1_m1_403200_278400 n1_m1_408000_278400 5.356235
R6942 n1_m1_408000_278400 n1_m1_412800_278400 5.356235
R6943 n1_m1_412800_278400 n1_m1_417600_278400 5.356235
R6944 n1_m1_417600_278400 n1_m1_422400_278400 5.356235
R6945 n1_m1_422400_278400 n1_m1_424000_278400 1.785412
R6946 n1_m1_427200_278400 n1_m1_424000_278400 3.570824
R6947 n1_m1_427200_278400 n1_m1_432000_278400 5.356235
R6948 n1_m1_432000_278400 n1_m1_436800_278400 5.356235
R6949 n1_m1_436800_278400 n1_m1_441600_278400 5.356235
R6950 n1_m1_441600_278400 n1_m1_446400_278400 5.356235
R6951 n1_m1_446400_278400 n1_m1_451200_278400 5.356235
R6952 n1_m1_451200_278400 n1_m1_452000_278400 0.892706
R6953 n1_m1_456000_278400 n1_m1_452000_278400 4.463529
R6954 n1_m1_456000_278400 n1_m1_460800_278400 5.356235
R6955 n1_m1_460800_278400 n1_m1_465600_278400 5.356235
R6956 n1_m1_465600_278400 n1_m1_470400_278400 5.356235
R6957 n1_m1_470400_278400 n1_m1_475200_278400 5.356235
R6958 n1_m1_475200_278400 n1_m1_480000_278400 5.356235
R6959 n1_m1_480000_278400 n1_m1_484800_278400 5.356235
R6960 n1_m1_484800_278400 n1_m1_489600_278400 5.356235
R6961 n1_m1_489600_278400 n1_m1_494400_278400 5.356235
R6962 n1_m1_0_283200 n1_m1_4000_283200 4.463529
R6963 n1_m1_4800_283200 n1_m1_4000_283200 0.892706
R6964 n1_m1_4800_283200 n1_m1_9600_283200 5.356235
R6965 n1_m1_9600_283200 n1_m1_14400_283200 5.356235
R6966 n1_m1_14400_283200 n1_m1_19200_283200 5.356235
R6967 n1_m1_19200_283200 n1_m1_24000_283200 5.356235
R6968 n1_m1_24000_283200 n1_m1_28800_283200 5.356235
R6969 n1_m1_28800_283200 n1_m1_32000_283200 3.570824
R6970 n1_m1_33600_283200 n1_m1_32000_283200 1.785412
R6971 n1_m1_33600_283200 n1_m1_38400_283200 5.356235
R6972 n1_m1_38400_283200 n1_m1_43200_283200 5.356235
R6973 n1_m1_43200_283200 n1_m1_48000_283200 5.356235
R6974 n1_m1_48000_283200 n1_m1_52800_283200 5.356235
R6975 n1_m1_52800_283200 n1_m1_57600_283200 5.356235
R6976 n1_m1_57600_283200 n1_m1_60000_283200 2.678118
R6977 n1_m1_62400_283200 n1_m1_60000_283200 2.678118
R6978 n1_m1_62400_283200 n1_m1_67200_283200 5.356235
R6979 n1_m1_67200_283200 n1_m1_72000_283200 5.356235
R6980 n1_m1_72000_283200 n1_m1_76800_283200 5.356235
R6981 n1_m1_76800_283200 n1_m1_81600_283200 5.356235
R6982 n1_m1_81600_283200 n1_m1_86400_283200 5.356235
R6983 n1_m1_86400_283200 n1_m1_88000_283200 1.785412
R6984 n1_m1_91200_283200 n1_m1_88000_283200 3.570824
R6985 n1_m1_91200_283200 n1_m1_96000_283200 5.356235
R6986 n1_m1_96000_283200 n1_m1_100800_283200 5.356235
R6987 n1_m1_100800_283200 n1_m1_105600_283200 5.356235
R6988 n1_m1_105600_283200 n1_m1_110400_283200 5.356235
R6989 n1_m1_110400_283200 n1_m1_115200_283200 5.356235
R6990 n1_m1_115200_283200 n1_m1_116000_283200 0.892706
R6991 n1_m1_120000_283200 n1_m1_116000_283200 4.463529
R6992 n1_m1_120000_283200 n1_m1_124800_283200 5.356235
R6993 n1_m1_124800_283200 n1_m1_129600_283200 5.356235
R6994 n1_m1_129600_283200 n1_m1_134400_283200 5.356235
R6995 n1_m1_134400_283200 n1_m1_139200_283200 5.356235
R6996 n1_m1_139200_283200 n1_m1_144000_283200 5.356235
R6997 n1_m1_144000_283200 n1_m1_148800_283200 5.356235
R6998 n1_m1_148800_283200 n1_m1_153600_283200 5.356235
R6999 n1_m1_153600_283200 n1_m1_158400_283200 5.356235
R7000 n1_m1_158400_283200 n1_m1_163200_283200 5.356235
R7001 n1_m1_163200_283200 n1_m1_168000_283200 5.356235
R7002 n1_m1_168000_283200 n1_m1_172000_283200 4.463529
R7003 n1_m1_172800_283200 n1_m1_172000_283200 0.892706
R7004 n1_m1_172800_283200 n1_m1_177600_283200 5.356235
R7005 n1_m1_177600_283200 n1_m1_182400_283200 5.356235
R7006 n1_m1_182400_283200 n1_m1_187200_283200 5.356235
R7007 n1_m1_187200_283200 n1_m1_192000_283200 5.356235
R7008 n1_m1_192000_283200 n1_m1_196800_283200 5.356235
R7009 n1_m1_196800_283200 n1_m1_200000_283200 3.570824
R7010 n1_m1_201600_283200 n1_m1_200000_283200 1.785412
R7011 n1_m1_201600_283200 n1_m1_206400_283200 5.356235
R7012 n1_m1_206400_283200 n1_m1_211200_283200 5.356235
R7013 n1_m1_211200_283200 n1_m1_216000_283200 5.356235
R7014 n1_m1_216000_283200 n1_m1_220800_283200 5.356235
R7015 n1_m1_220800_283200 n1_m1_225600_283200 5.356235
R7016 n1_m1_225600_283200 n1_m1_228000_283200 2.678118
R7017 n1_m1_230400_283200 n1_m1_228000_283200 2.678118
R7018 n1_m1_230400_283200 n1_m1_235200_283200 5.356235
R7019 n1_m1_235200_283200 n1_m1_240000_283200 5.356235
R7020 n1_m1_240000_283200 n1_m1_244800_283200 5.356235
R7021 n1_m1_244800_283200 n1_m1_249600_283200 5.356235
R7022 n1_m1_249600_283200 n1_m1_254400_283200 5.356235
R7023 n1_m1_254400_283200 n1_m1_256000_283200 1.785412
R7024 n1_m1_259200_283200 n1_m1_256000_283200 3.570824
R7025 n1_m1_259200_283200 n1_m1_264000_283200 5.356235
R7026 n1_m1_264000_283200 n1_m1_268800_283200 5.356235
R7027 n1_m1_268800_283200 n1_m1_273600_283200 5.356235
R7028 n1_m1_273600_283200 n1_m1_278400_283200 5.356235
R7029 n1_m1_278400_283200 n1_m1_283200_283200 5.356235
R7030 n1_m1_283200_283200 n1_m1_284000_283200 0.892706
R7031 n1_m1_288000_283200 n1_m1_284000_283200 4.463529
R7032 n1_m1_288000_283200 n1_m1_292800_283200 5.356235
R7033 n1_m1_292800_283200 n1_m1_297600_283200 5.356235
R7034 n1_m1_297600_283200 n1_m1_302400_283200 5.356235
R7035 n1_m1_302400_283200 n1_m1_307200_283200 5.356235
R7036 n1_m1_307200_283200 n1_m1_312000_283200 5.356235
R7037 n1_m1_312000_283200 n1_m1_316800_283200 5.356235
R7038 n1_m1_316800_283200 n1_m1_321600_283200 5.356235
R7039 n1_m1_321600_283200 n1_m1_326400_283200 5.356235
R7040 n1_m1_326400_283200 n1_m1_331200_283200 5.356235
R7041 n1_m1_331200_283200 n1_m1_336000_283200 5.356235
R7042 n1_m1_336000_283200 n1_m1_340000_283200 4.463529
R7043 n1_m1_340800_283200 n1_m1_340000_283200 0.892706
R7044 n1_m1_340800_283200 n1_m1_345600_283200 5.356235
R7045 n1_m1_345600_283200 n1_m1_350400_283200 5.356235
R7046 n1_m1_350400_283200 n1_m1_355200_283200 5.356235
R7047 n1_m1_355200_283200 n1_m1_360000_283200 5.356235
R7048 n1_m1_360000_283200 n1_m1_364800_283200 5.356235
R7049 n1_m1_364800_283200 n1_m1_368000_283200 3.570824
R7050 n1_m1_369600_283200 n1_m1_368000_283200 1.785412
R7051 n1_m1_369600_283200 n1_m1_374400_283200 5.356235
R7052 n1_m1_374400_283200 n1_m1_379200_283200 5.356235
R7053 n1_m1_379200_283200 n1_m1_384000_283200 5.356235
R7054 n1_m1_384000_283200 n1_m1_388800_283200 5.356235
R7055 n1_m1_388800_283200 n1_m1_393600_283200 5.356235
R7056 n1_m1_393600_283200 n1_m1_396000_283200 2.678118
R7057 n1_m1_398400_283200 n1_m1_396000_283200 2.678118
R7058 n1_m1_398400_283200 n1_m1_403200_283200 5.356235
R7059 n1_m1_403200_283200 n1_m1_408000_283200 5.356235
R7060 n1_m1_408000_283200 n1_m1_412800_283200 5.356235
R7061 n1_m1_412800_283200 n1_m1_417600_283200 5.356235
R7062 n1_m1_417600_283200 n1_m1_422400_283200 5.356235
R7063 n1_m1_422400_283200 n1_m1_424000_283200 1.785412
R7064 n1_m1_427200_283200 n1_m1_424000_283200 3.570824
R7065 n1_m1_427200_283200 n1_m1_432000_283200 5.356235
R7066 n1_m1_432000_283200 n1_m1_436800_283200 5.356235
R7067 n1_m1_436800_283200 n1_m1_441600_283200 5.356235
R7068 n1_m1_441600_283200 n1_m1_446400_283200 5.356235
R7069 n1_m1_446400_283200 n1_m1_451200_283200 5.356235
R7070 n1_m1_451200_283200 n1_m1_452000_283200 0.892706
R7071 n1_m1_456000_283200 n1_m1_452000_283200 4.463529
R7072 n1_m1_456000_283200 n1_m1_460800_283200 5.356235
R7073 n1_m1_460800_283200 n1_m1_465600_283200 5.356235
R7074 n1_m1_465600_283200 n1_m1_470400_283200 5.356235
R7075 n1_m1_470400_283200 n1_m1_475200_283200 5.356235
R7076 n1_m1_475200_283200 n1_m1_480000_283200 5.356235
R7077 n1_m1_480000_283200 n1_m1_484800_283200 5.356235
R7078 n1_m1_484800_283200 n1_m1_489600_283200 5.356235
R7079 n1_m1_489600_283200 n1_m1_494400_283200 5.356235
R7080 n1_m1_0_288000 n1_m1_4000_288000 4.463529
R7081 n1_m1_4800_288000 n1_m1_4000_288000 0.892706
R7082 n1_m1_4800_288000 n1_m1_9600_288000 5.356235
R7083 n1_m1_9600_288000 n1_m1_14400_288000 5.356235
R7084 n1_m1_14400_288000 n1_m1_19200_288000 5.356235
R7085 n1_m1_19200_288000 n1_m1_24000_288000 5.356235
R7086 n1_m1_24000_288000 n1_m1_28800_288000 5.356235
R7087 n1_m1_28800_288000 n1_m1_32000_288000 3.570824
R7088 n1_m1_33600_288000 n1_m1_32000_288000 1.785412
R7089 n1_m1_33600_288000 n1_m1_38400_288000 5.356235
R7090 n1_m1_38400_288000 n1_m1_43200_288000 5.356235
R7091 n1_m1_43200_288000 n1_m1_48000_288000 5.356235
R7092 n1_m1_48000_288000 n1_m1_52800_288000 5.356235
R7093 n1_m1_52800_288000 n1_m1_57600_288000 5.356235
R7094 n1_m1_57600_288000 n1_m1_60000_288000 2.678118
R7095 n1_m1_62400_288000 n1_m1_60000_288000 2.678118
R7096 n1_m1_62400_288000 n1_m1_67200_288000 5.356235
R7097 n1_m1_67200_288000 n1_m1_72000_288000 5.356235
R7098 n1_m1_72000_288000 n1_m1_76800_288000 5.356235
R7099 n1_m1_76800_288000 n1_m1_81600_288000 5.356235
R7100 n1_m1_81600_288000 n1_m1_86400_288000 5.356235
R7101 n1_m1_86400_288000 n1_m1_88000_288000 1.785412
R7102 n1_m1_91200_288000 n1_m1_88000_288000 3.570824
R7103 n1_m1_91200_288000 n1_m1_96000_288000 5.356235
R7104 n1_m1_96000_288000 n1_m1_100800_288000 5.356235
R7105 n1_m1_100800_288000 n1_m1_105600_288000 5.356235
R7106 n1_m1_105600_288000 n1_m1_110400_288000 5.356235
R7107 n1_m1_110400_288000 n1_m1_115200_288000 5.356235
R7108 n1_m1_115200_288000 n1_m1_116000_288000 0.892706
R7109 n1_m1_120000_288000 n1_m1_116000_288000 4.463529
R7110 n1_m1_120000_288000 n1_m1_124800_288000 5.356235
R7111 n1_m1_124800_288000 n1_m1_129600_288000 5.356235
R7112 n1_m1_129600_288000 n1_m1_134400_288000 5.356235
R7113 n1_m1_134400_288000 n1_m1_139200_288000 5.356235
R7114 n1_m1_139200_288000 n1_m1_144000_288000 5.356235
R7115 n1_m1_144000_288000 n1_m1_148800_288000 5.356235
R7116 n1_m1_148800_288000 n1_m1_153600_288000 5.356235
R7117 n1_m1_153600_288000 n1_m1_158400_288000 5.356235
R7118 n1_m1_158400_288000 n1_m1_163200_288000 5.356235
R7119 n1_m1_163200_288000 n1_m1_168000_288000 5.356235
R7120 n1_m1_168000_288000 n1_m1_172000_288000 4.463529
R7121 n1_m1_172800_288000 n1_m1_172000_288000 0.892706
R7122 n1_m1_172800_288000 n1_m1_177600_288000 5.356235
R7123 n1_m1_177600_288000 n1_m1_182400_288000 5.356235
R7124 n1_m1_182400_288000 n1_m1_187200_288000 5.356235
R7125 n1_m1_187200_288000 n1_m1_192000_288000 5.356235
R7126 n1_m1_192000_288000 n1_m1_196800_288000 5.356235
R7127 n1_m1_196800_288000 n1_m1_200000_288000 3.570824
R7128 n1_m1_201600_288000 n1_m1_200000_288000 1.785412
R7129 n1_m1_201600_288000 n1_m1_206400_288000 5.356235
R7130 n1_m1_206400_288000 n1_m1_211200_288000 5.356235
R7131 n1_m1_211200_288000 n1_m1_216000_288000 5.356235
R7132 n1_m1_216000_288000 n1_m1_220800_288000 5.356235
R7133 n1_m1_220800_288000 n1_m1_225600_288000 5.356235
R7134 n1_m1_225600_288000 n1_m1_228000_288000 2.678118
R7135 n1_m1_230400_288000 n1_m1_228000_288000 2.678118
R7136 n1_m1_230400_288000 n1_m1_235200_288000 5.356235
R7137 n1_m1_235200_288000 n1_m1_240000_288000 5.356235
R7138 n1_m1_240000_288000 n1_m1_244800_288000 5.356235
R7139 n1_m1_244800_288000 n1_m1_249600_288000 5.356235
R7140 n1_m1_249600_288000 n1_m1_254400_288000 5.356235
R7141 n1_m1_254400_288000 n1_m1_256000_288000 1.785412
R7142 n1_m1_259200_288000 n1_m1_256000_288000 3.570824
R7143 n1_m1_259200_288000 n1_m1_264000_288000 5.356235
R7144 n1_m1_264000_288000 n1_m1_268800_288000 5.356235
R7145 n1_m1_268800_288000 n1_m1_273600_288000 5.356235
R7146 n1_m1_273600_288000 n1_m1_278400_288000 5.356235
R7147 n1_m1_278400_288000 n1_m1_283200_288000 5.356235
R7148 n1_m1_283200_288000 n1_m1_284000_288000 0.892706
R7149 n1_m1_288000_288000 n1_m1_284000_288000 4.463529
R7150 n1_m1_288000_288000 n1_m1_292800_288000 5.356235
R7151 n1_m1_292800_288000 n1_m1_297600_288000 5.356235
R7152 n1_m1_297600_288000 n1_m1_302400_288000 5.356235
R7153 n1_m1_302400_288000 n1_m1_307200_288000 5.356235
R7154 n1_m1_307200_288000 n1_m1_312000_288000 5.356235
R7155 n1_m1_312000_288000 n1_m1_316800_288000 5.356235
R7156 n1_m1_316800_288000 n1_m1_321600_288000 5.356235
R7157 n1_m1_321600_288000 n1_m1_326400_288000 5.356235
R7158 n1_m1_326400_288000 n1_m1_331200_288000 5.356235
R7159 n1_m1_331200_288000 n1_m1_336000_288000 5.356235
R7160 n1_m1_336000_288000 n1_m1_340000_288000 4.463529
R7161 n1_m1_340800_288000 n1_m1_340000_288000 0.892706
R7162 n1_m1_340800_288000 n1_m1_345600_288000 5.356235
R7163 n1_m1_345600_288000 n1_m1_350400_288000 5.356235
R7164 n1_m1_350400_288000 n1_m1_355200_288000 5.356235
R7165 n1_m1_355200_288000 n1_m1_360000_288000 5.356235
R7166 n1_m1_360000_288000 n1_m1_364800_288000 5.356235
R7167 n1_m1_364800_288000 n1_m1_368000_288000 3.570824
R7168 n1_m1_369600_288000 n1_m1_368000_288000 1.785412
R7169 n1_m1_369600_288000 n1_m1_374400_288000 5.356235
R7170 n1_m1_374400_288000 n1_m1_379200_288000 5.356235
R7171 n1_m1_379200_288000 n1_m1_384000_288000 5.356235
R7172 n1_m1_384000_288000 n1_m1_388800_288000 5.356235
R7173 n1_m1_388800_288000 n1_m1_393600_288000 5.356235
R7174 n1_m1_393600_288000 n1_m1_396000_288000 2.678118
R7175 n1_m1_398400_288000 n1_m1_396000_288000 2.678118
R7176 n1_m1_398400_288000 n1_m1_403200_288000 5.356235
R7177 n1_m1_403200_288000 n1_m1_408000_288000 5.356235
R7178 n1_m1_408000_288000 n1_m1_412800_288000 5.356235
R7179 n1_m1_412800_288000 n1_m1_417600_288000 5.356235
R7180 n1_m1_417600_288000 n1_m1_422400_288000 5.356235
R7181 n1_m1_422400_288000 n1_m1_424000_288000 1.785412
R7182 n1_m1_427200_288000 n1_m1_424000_288000 3.570824
R7183 n1_m1_427200_288000 n1_m1_432000_288000 5.356235
R7184 n1_m1_432000_288000 n1_m1_436800_288000 5.356235
R7185 n1_m1_436800_288000 n1_m1_441600_288000 5.356235
R7186 n1_m1_441600_288000 n1_m1_446400_288000 5.356235
R7187 n1_m1_446400_288000 n1_m1_451200_288000 5.356235
R7188 n1_m1_451200_288000 n1_m1_452000_288000 0.892706
R7189 n1_m1_456000_288000 n1_m1_452000_288000 4.463529
R7190 n1_m1_456000_288000 n1_m1_460800_288000 5.356235
R7191 n1_m1_460800_288000 n1_m1_465600_288000 5.356235
R7192 n1_m1_465600_288000 n1_m1_470400_288000 5.356235
R7193 n1_m1_470400_288000 n1_m1_475200_288000 5.356235
R7194 n1_m1_475200_288000 n1_m1_480000_288000 5.356235
R7195 n1_m1_480000_288000 n1_m1_484800_288000 5.356235
R7196 n1_m1_484800_288000 n1_m1_489600_288000 5.356235
R7197 n1_m1_489600_288000 n1_m1_494400_288000 5.356235
R7198 n1_m1_0_292800 n1_m1_4000_292800 4.463529
R7199 n1_m1_4800_292800 n1_m1_4000_292800 0.892706
R7200 n1_m1_4800_292800 n1_m1_9600_292800 5.356235
R7201 n1_m1_9600_292800 n1_m1_14400_292800 5.356235
R7202 n1_m1_14400_292800 n1_m1_19200_292800 5.356235
R7203 n1_m1_19200_292800 n1_m1_24000_292800 5.356235
R7204 n1_m1_24000_292800 n1_m1_28800_292800 5.356235
R7205 n1_m1_28800_292800 n1_m1_32000_292800 3.570824
R7206 n1_m1_33600_292800 n1_m1_32000_292800 1.785412
R7207 n1_m1_33600_292800 n1_m1_38400_292800 5.356235
R7208 n1_m1_38400_292800 n1_m1_43200_292800 5.356235
R7209 n1_m1_43200_292800 n1_m1_48000_292800 5.356235
R7210 n1_m1_48000_292800 n1_m1_52800_292800 5.356235
R7211 n1_m1_52800_292800 n1_m1_57600_292800 5.356235
R7212 n1_m1_57600_292800 n1_m1_60000_292800 2.678118
R7213 n1_m1_62400_292800 n1_m1_60000_292800 2.678118
R7214 n1_m1_62400_292800 n1_m1_67200_292800 5.356235
R7215 n1_m1_67200_292800 n1_m1_72000_292800 5.356235
R7216 n1_m1_72000_292800 n1_m1_76800_292800 5.356235
R7217 n1_m1_76800_292800 n1_m1_81600_292800 5.356235
R7218 n1_m1_81600_292800 n1_m1_86400_292800 5.356235
R7219 n1_m1_86400_292800 n1_m1_88000_292800 1.785412
R7220 n1_m1_91200_292800 n1_m1_88000_292800 3.570824
R7221 n1_m1_91200_292800 n1_m1_96000_292800 5.356235
R7222 n1_m1_96000_292800 n1_m1_100800_292800 5.356235
R7223 n1_m1_100800_292800 n1_m1_105600_292800 5.356235
R7224 n1_m1_105600_292800 n1_m1_110400_292800 5.356235
R7225 n1_m1_110400_292800 n1_m1_115200_292800 5.356235
R7226 n1_m1_115200_292800 n1_m1_116000_292800 0.892706
R7227 n1_m1_120000_292800 n1_m1_116000_292800 4.463529
R7228 n1_m1_120000_292800 n1_m1_124800_292800 5.356235
R7229 n1_m1_124800_292800 n1_m1_129600_292800 5.356235
R7230 n1_m1_129600_292800 n1_m1_134400_292800 5.356235
R7231 n1_m1_134400_292800 n1_m1_139200_292800 5.356235
R7232 n1_m1_139200_292800 n1_m1_144000_292800 5.356235
R7233 n1_m1_144000_292800 n1_m1_148800_292800 5.356235
R7234 n1_m1_148800_292800 n1_m1_153600_292800 5.356235
R7235 n1_m1_153600_292800 n1_m1_158400_292800 5.356235
R7236 n1_m1_158400_292800 n1_m1_163200_292800 5.356235
R7237 n1_m1_163200_292800 n1_m1_168000_292800 5.356235
R7238 n1_m1_168000_292800 n1_m1_172000_292800 4.463529
R7239 n1_m1_172800_292800 n1_m1_172000_292800 0.892706
R7240 n1_m1_172800_292800 n1_m1_177600_292800 5.356235
R7241 n1_m1_177600_292800 n1_m1_182400_292800 5.356235
R7242 n1_m1_182400_292800 n1_m1_187200_292800 5.356235
R7243 n1_m1_187200_292800 n1_m1_192000_292800 5.356235
R7244 n1_m1_192000_292800 n1_m1_196800_292800 5.356235
R7245 n1_m1_196800_292800 n1_m1_200000_292800 3.570824
R7246 n1_m1_201600_292800 n1_m1_200000_292800 1.785412
R7247 n1_m1_201600_292800 n1_m1_206400_292800 5.356235
R7248 n1_m1_206400_292800 n1_m1_211200_292800 5.356235
R7249 n1_m1_211200_292800 n1_m1_216000_292800 5.356235
R7250 n1_m1_216000_292800 n1_m1_220800_292800 5.356235
R7251 n1_m1_220800_292800 n1_m1_225600_292800 5.356235
R7252 n1_m1_225600_292800 n1_m1_228000_292800 2.678118
R7253 n1_m1_230400_292800 n1_m1_228000_292800 2.678118
R7254 n1_m1_230400_292800 n1_m1_235200_292800 5.356235
R7255 n1_m1_235200_292800 n1_m1_240000_292800 5.356235
R7256 n1_m1_240000_292800 n1_m1_244800_292800 5.356235
R7257 n1_m1_244800_292800 n1_m1_249600_292800 5.356235
R7258 n1_m1_249600_292800 n1_m1_254400_292800 5.356235
R7259 n1_m1_254400_292800 n1_m1_256000_292800 1.785412
R7260 n1_m1_259200_292800 n1_m1_256000_292800 3.570824
R7261 n1_m1_259200_292800 n1_m1_264000_292800 5.356235
R7262 n1_m1_264000_292800 n1_m1_268800_292800 5.356235
R7263 n1_m1_268800_292800 n1_m1_273600_292800 5.356235
R7264 n1_m1_273600_292800 n1_m1_278400_292800 5.356235
R7265 n1_m1_278400_292800 n1_m1_283200_292800 5.356235
R7266 n1_m1_283200_292800 n1_m1_284000_292800 0.892706
R7267 n1_m1_288000_292800 n1_m1_284000_292800 4.463529
R7268 n1_m1_288000_292800 n1_m1_292800_292800 5.356235
R7269 n1_m1_292800_292800 n1_m1_297600_292800 5.356235
R7270 n1_m1_297600_292800 n1_m1_302400_292800 5.356235
R7271 n1_m1_302400_292800 n1_m1_307200_292800 5.356235
R7272 n1_m1_307200_292800 n1_m1_312000_292800 5.356235
R7273 n1_m1_312000_292800 n1_m1_316800_292800 5.356235
R7274 n1_m1_316800_292800 n1_m1_321600_292800 5.356235
R7275 n1_m1_321600_292800 n1_m1_326400_292800 5.356235
R7276 n1_m1_326400_292800 n1_m1_331200_292800 5.356235
R7277 n1_m1_331200_292800 n1_m1_336000_292800 5.356235
R7278 n1_m1_336000_292800 n1_m1_340000_292800 4.463529
R7279 n1_m1_340800_292800 n1_m1_340000_292800 0.892706
R7280 n1_m1_340800_292800 n1_m1_345600_292800 5.356235
R7281 n1_m1_345600_292800 n1_m1_350400_292800 5.356235
R7282 n1_m1_350400_292800 n1_m1_355200_292800 5.356235
R7283 n1_m1_355200_292800 n1_m1_360000_292800 5.356235
R7284 n1_m1_360000_292800 n1_m1_364800_292800 5.356235
R7285 n1_m1_364800_292800 n1_m1_368000_292800 3.570824
R7286 n1_m1_369600_292800 n1_m1_368000_292800 1.785412
R7287 n1_m1_369600_292800 n1_m1_374400_292800 5.356235
R7288 n1_m1_374400_292800 n1_m1_379200_292800 5.356235
R7289 n1_m1_379200_292800 n1_m1_384000_292800 5.356235
R7290 n1_m1_384000_292800 n1_m1_388800_292800 5.356235
R7291 n1_m1_388800_292800 n1_m1_393600_292800 5.356235
R7292 n1_m1_393600_292800 n1_m1_396000_292800 2.678118
R7293 n1_m1_398400_292800 n1_m1_396000_292800 2.678118
R7294 n1_m1_398400_292800 n1_m1_403200_292800 5.356235
R7295 n1_m1_403200_292800 n1_m1_408000_292800 5.356235
R7296 n1_m1_408000_292800 n1_m1_412800_292800 5.356235
R7297 n1_m1_412800_292800 n1_m1_417600_292800 5.356235
R7298 n1_m1_417600_292800 n1_m1_422400_292800 5.356235
R7299 n1_m1_422400_292800 n1_m1_424000_292800 1.785412
R7300 n1_m1_427200_292800 n1_m1_424000_292800 3.570824
R7301 n1_m1_427200_292800 n1_m1_432000_292800 5.356235
R7302 n1_m1_432000_292800 n1_m1_436800_292800 5.356235
R7303 n1_m1_436800_292800 n1_m1_441600_292800 5.356235
R7304 n1_m1_441600_292800 n1_m1_446400_292800 5.356235
R7305 n1_m1_446400_292800 n1_m1_451200_292800 5.356235
R7306 n1_m1_451200_292800 n1_m1_452000_292800 0.892706
R7307 n1_m1_456000_292800 n1_m1_452000_292800 4.463529
R7308 n1_m1_456000_292800 n1_m1_460800_292800 5.356235
R7309 n1_m1_460800_292800 n1_m1_465600_292800 5.356235
R7310 n1_m1_465600_292800 n1_m1_470400_292800 5.356235
R7311 n1_m1_470400_292800 n1_m1_475200_292800 5.356235
R7312 n1_m1_475200_292800 n1_m1_480000_292800 5.356235
R7313 n1_m1_480000_292800 n1_m1_484800_292800 5.356235
R7314 n1_m1_484800_292800 n1_m1_489600_292800 5.356235
R7315 n1_m1_489600_292800 n1_m1_494400_292800 5.356235
R7316 n1_m1_0_297600 n1_m1_4000_297600 4.463529
R7317 n1_m1_4800_297600 n1_m1_4000_297600 0.892706
R7318 n1_m1_4800_297600 n1_m1_9600_297600 5.356235
R7319 n1_m1_9600_297600 n1_m1_14400_297600 5.356235
R7320 n1_m1_14400_297600 n1_m1_19200_297600 5.356235
R7321 n1_m1_19200_297600 n1_m1_24000_297600 5.356235
R7322 n1_m1_24000_297600 n1_m1_28800_297600 5.356235
R7323 n1_m1_28800_297600 n1_m1_32000_297600 3.570824
R7324 n1_m1_33600_297600 n1_m1_32000_297600 1.785412
R7325 n1_m1_33600_297600 n1_m1_38400_297600 5.356235
R7326 n1_m1_38400_297600 n1_m1_43200_297600 5.356235
R7327 n1_m1_43200_297600 n1_m1_48000_297600 5.356235
R7328 n1_m1_48000_297600 n1_m1_52800_297600 5.356235
R7329 n1_m1_52800_297600 n1_m1_57600_297600 5.356235
R7330 n1_m1_57600_297600 n1_m1_60000_297600 2.678118
R7331 n1_m1_62400_297600 n1_m1_60000_297600 2.678118
R7332 n1_m1_62400_297600 n1_m1_67200_297600 5.356235
R7333 n1_m1_67200_297600 n1_m1_72000_297600 5.356235
R7334 n1_m1_72000_297600 n1_m1_76800_297600 5.356235
R7335 n1_m1_76800_297600 n1_m1_81600_297600 5.356235
R7336 n1_m1_81600_297600 n1_m1_86400_297600 5.356235
R7337 n1_m1_86400_297600 n1_m1_88000_297600 1.785412
R7338 n1_m1_91200_297600 n1_m1_88000_297600 3.570824
R7339 n1_m1_91200_297600 n1_m1_96000_297600 5.356235
R7340 n1_m1_96000_297600 n1_m1_100800_297600 5.356235
R7341 n1_m1_100800_297600 n1_m1_105600_297600 5.356235
R7342 n1_m1_105600_297600 n1_m1_110400_297600 5.356235
R7343 n1_m1_110400_297600 n1_m1_115200_297600 5.356235
R7344 n1_m1_115200_297600 n1_m1_116000_297600 0.892706
R7345 n1_m1_120000_297600 n1_m1_116000_297600 4.463529
R7346 n1_m1_120000_297600 n1_m1_124800_297600 5.356235
R7347 n1_m1_124800_297600 n1_m1_129600_297600 5.356235
R7348 n1_m1_129600_297600 n1_m1_134400_297600 5.356235
R7349 n1_m1_134400_297600 n1_m1_139200_297600 5.356235
R7350 n1_m1_139200_297600 n1_m1_144000_297600 5.356235
R7351 n1_m1_144000_297600 n1_m1_148800_297600 5.356235
R7352 n1_m1_148800_297600 n1_m1_153600_297600 5.356235
R7353 n1_m1_153600_297600 n1_m1_158400_297600 5.356235
R7354 n1_m1_158400_297600 n1_m1_163200_297600 5.356235
R7355 n1_m1_163200_297600 n1_m1_168000_297600 5.356235
R7356 n1_m1_168000_297600 n1_m1_172000_297600 4.463529
R7357 n1_m1_172800_297600 n1_m1_172000_297600 0.892706
R7358 n1_m1_172800_297600 n1_m1_177600_297600 5.356235
R7359 n1_m1_177600_297600 n1_m1_182400_297600 5.356235
R7360 n1_m1_182400_297600 n1_m1_187200_297600 5.356235
R7361 n1_m1_187200_297600 n1_m1_192000_297600 5.356235
R7362 n1_m1_192000_297600 n1_m1_196800_297600 5.356235
R7363 n1_m1_196800_297600 n1_m1_200000_297600 3.570824
R7364 n1_m1_201600_297600 n1_m1_200000_297600 1.785412
R7365 n1_m1_201600_297600 n1_m1_206400_297600 5.356235
R7366 n1_m1_206400_297600 n1_m1_211200_297600 5.356235
R7367 n1_m1_211200_297600 n1_m1_216000_297600 5.356235
R7368 n1_m1_216000_297600 n1_m1_220800_297600 5.356235
R7369 n1_m1_220800_297600 n1_m1_225600_297600 5.356235
R7370 n1_m1_225600_297600 n1_m1_228000_297600 2.678118
R7371 n1_m1_230400_297600 n1_m1_228000_297600 2.678118
R7372 n1_m1_230400_297600 n1_m1_235200_297600 5.356235
R7373 n1_m1_235200_297600 n1_m1_240000_297600 5.356235
R7374 n1_m1_240000_297600 n1_m1_244800_297600 5.356235
R7375 n1_m1_244800_297600 n1_m1_249600_297600 5.356235
R7376 n1_m1_249600_297600 n1_m1_254400_297600 5.356235
R7377 n1_m1_254400_297600 n1_m1_256000_297600 1.785412
R7378 n1_m1_259200_297600 n1_m1_256000_297600 3.570824
R7379 n1_m1_259200_297600 n1_m1_264000_297600 5.356235
R7380 n1_m1_264000_297600 n1_m1_268800_297600 5.356235
R7381 n1_m1_268800_297600 n1_m1_273600_297600 5.356235
R7382 n1_m1_273600_297600 n1_m1_278400_297600 5.356235
R7383 n1_m1_278400_297600 n1_m1_283200_297600 5.356235
R7384 n1_m1_283200_297600 n1_m1_284000_297600 0.892706
R7385 n1_m1_288000_297600 n1_m1_284000_297600 4.463529
R7386 n1_m1_288000_297600 n1_m1_292800_297600 5.356235
R7387 n1_m1_292800_297600 n1_m1_297600_297600 5.356235
R7388 n1_m1_297600_297600 n1_m1_302400_297600 5.356235
R7389 n1_m1_302400_297600 n1_m1_307200_297600 5.356235
R7390 n1_m1_307200_297600 n1_m1_312000_297600 5.356235
R7391 n1_m1_312000_297600 n1_m1_316800_297600 5.356235
R7392 n1_m1_316800_297600 n1_m1_321600_297600 5.356235
R7393 n1_m1_321600_297600 n1_m1_326400_297600 5.356235
R7394 n1_m1_326400_297600 n1_m1_331200_297600 5.356235
R7395 n1_m1_331200_297600 n1_m1_336000_297600 5.356235
R7396 n1_m1_336000_297600 n1_m1_340000_297600 4.463529
R7397 n1_m1_340800_297600 n1_m1_340000_297600 0.892706
R7398 n1_m1_340800_297600 n1_m1_345600_297600 5.356235
R7399 n1_m1_345600_297600 n1_m1_350400_297600 5.356235
R7400 n1_m1_350400_297600 n1_m1_355200_297600 5.356235
R7401 n1_m1_355200_297600 n1_m1_360000_297600 5.356235
R7402 n1_m1_360000_297600 n1_m1_364800_297600 5.356235
R7403 n1_m1_364800_297600 n1_m1_368000_297600 3.570824
R7404 n1_m1_369600_297600 n1_m1_368000_297600 1.785412
R7405 n1_m1_369600_297600 n1_m1_374400_297600 5.356235
R7406 n1_m1_374400_297600 n1_m1_379200_297600 5.356235
R7407 n1_m1_379200_297600 n1_m1_384000_297600 5.356235
R7408 n1_m1_384000_297600 n1_m1_388800_297600 5.356235
R7409 n1_m1_388800_297600 n1_m1_393600_297600 5.356235
R7410 n1_m1_393600_297600 n1_m1_396000_297600 2.678118
R7411 n1_m1_398400_297600 n1_m1_396000_297600 2.678118
R7412 n1_m1_398400_297600 n1_m1_403200_297600 5.356235
R7413 n1_m1_403200_297600 n1_m1_408000_297600 5.356235
R7414 n1_m1_408000_297600 n1_m1_412800_297600 5.356235
R7415 n1_m1_412800_297600 n1_m1_417600_297600 5.356235
R7416 n1_m1_417600_297600 n1_m1_422400_297600 5.356235
R7417 n1_m1_422400_297600 n1_m1_424000_297600 1.785412
R7418 n1_m1_427200_297600 n1_m1_424000_297600 3.570824
R7419 n1_m1_427200_297600 n1_m1_432000_297600 5.356235
R7420 n1_m1_432000_297600 n1_m1_436800_297600 5.356235
R7421 n1_m1_436800_297600 n1_m1_441600_297600 5.356235
R7422 n1_m1_441600_297600 n1_m1_446400_297600 5.356235
R7423 n1_m1_446400_297600 n1_m1_451200_297600 5.356235
R7424 n1_m1_451200_297600 n1_m1_452000_297600 0.892706
R7425 n1_m1_456000_297600 n1_m1_452000_297600 4.463529
R7426 n1_m1_456000_297600 n1_m1_460800_297600 5.356235
R7427 n1_m1_460800_297600 n1_m1_465600_297600 5.356235
R7428 n1_m1_465600_297600 n1_m1_470400_297600 5.356235
R7429 n1_m1_470400_297600 n1_m1_475200_297600 5.356235
R7430 n1_m1_475200_297600 n1_m1_480000_297600 5.356235
R7431 n1_m1_480000_297600 n1_m1_484800_297600 5.356235
R7432 n1_m1_484800_297600 n1_m1_489600_297600 5.356235
R7433 n1_m1_489600_297600 n1_m1_494400_297600 5.356235
R7434 n1_m1_0_302400 n1_m1_4000_302400 4.463529
R7435 n1_m1_4800_302400 n1_m1_4000_302400 0.892706
R7436 n1_m1_4800_302400 n1_m1_9600_302400 5.356235
R7437 n1_m1_9600_302400 n1_m1_14400_302400 5.356235
R7438 n1_m1_14400_302400 n1_m1_19200_302400 5.356235
R7439 n1_m1_19200_302400 n1_m1_24000_302400 5.356235
R7440 n1_m1_24000_302400 n1_m1_28800_302400 5.356235
R7441 n1_m1_28800_302400 n1_m1_32000_302400 3.570824
R7442 n1_m1_33600_302400 n1_m1_32000_302400 1.785412
R7443 n1_m1_33600_302400 n1_m1_38400_302400 5.356235
R7444 n1_m1_38400_302400 n1_m1_43200_302400 5.356235
R7445 n1_m1_43200_302400 n1_m1_48000_302400 5.356235
R7446 n1_m1_48000_302400 n1_m1_52800_302400 5.356235
R7447 n1_m1_52800_302400 n1_m1_57600_302400 5.356235
R7448 n1_m1_57600_302400 n1_m1_60000_302400 2.678118
R7449 n1_m1_62400_302400 n1_m1_60000_302400 2.678118
R7450 n1_m1_62400_302400 n1_m1_67200_302400 5.356235
R7451 n1_m1_67200_302400 n1_m1_72000_302400 5.356235
R7452 n1_m1_72000_302400 n1_m1_76800_302400 5.356235
R7453 n1_m1_76800_302400 n1_m1_81600_302400 5.356235
R7454 n1_m1_81600_302400 n1_m1_86400_302400 5.356235
R7455 n1_m1_86400_302400 n1_m1_88000_302400 1.785412
R7456 n1_m1_91200_302400 n1_m1_88000_302400 3.570824
R7457 n1_m1_91200_302400 n1_m1_96000_302400 5.356235
R7458 n1_m1_96000_302400 n1_m1_100800_302400 5.356235
R7459 n1_m1_100800_302400 n1_m1_105600_302400 5.356235
R7460 n1_m1_105600_302400 n1_m1_110400_302400 5.356235
R7461 n1_m1_110400_302400 n1_m1_115200_302400 5.356235
R7462 n1_m1_115200_302400 n1_m1_116000_302400 0.892706
R7463 n1_m1_120000_302400 n1_m1_116000_302400 4.463529
R7464 n1_m1_120000_302400 n1_m1_124800_302400 5.356235
R7465 n1_m1_124800_302400 n1_m1_129600_302400 5.356235
R7466 n1_m1_129600_302400 n1_m1_134400_302400 5.356235
R7467 n1_m1_134400_302400 n1_m1_139200_302400 5.356235
R7468 n1_m1_139200_302400 n1_m1_144000_302400 5.356235
R7469 n1_m1_144000_302400 n1_m1_148800_302400 5.356235
R7470 n1_m1_148800_302400 n1_m1_153600_302400 5.356235
R7471 n1_m1_153600_302400 n1_m1_158400_302400 5.356235
R7472 n1_m1_158400_302400 n1_m1_163200_302400 5.356235
R7473 n1_m1_163200_302400 n1_m1_168000_302400 5.356235
R7474 n1_m1_168000_302400 n1_m1_172000_302400 4.463529
R7475 n1_m1_172800_302400 n1_m1_172000_302400 0.892706
R7476 n1_m1_172800_302400 n1_m1_177600_302400 5.356235
R7477 n1_m1_177600_302400 n1_m1_182400_302400 5.356235
R7478 n1_m1_182400_302400 n1_m1_187200_302400 5.356235
R7479 n1_m1_187200_302400 n1_m1_192000_302400 5.356235
R7480 n1_m1_192000_302400 n1_m1_196800_302400 5.356235
R7481 n1_m1_196800_302400 n1_m1_200000_302400 3.570824
R7482 n1_m1_201600_302400 n1_m1_200000_302400 1.785412
R7483 n1_m1_201600_302400 n1_m1_206400_302400 5.356235
R7484 n1_m1_206400_302400 n1_m1_211200_302400 5.356235
R7485 n1_m1_211200_302400 n1_m1_216000_302400 5.356235
R7486 n1_m1_216000_302400 n1_m1_220800_302400 5.356235
R7487 n1_m1_220800_302400 n1_m1_225600_302400 5.356235
R7488 n1_m1_225600_302400 n1_m1_228000_302400 2.678118
R7489 n1_m1_230400_302400 n1_m1_228000_302400 2.678118
R7490 n1_m1_230400_302400 n1_m1_235200_302400 5.356235
R7491 n1_m1_235200_302400 n1_m1_240000_302400 5.356235
R7492 n1_m1_240000_302400 n1_m1_244800_302400 5.356235
R7493 n1_m1_244800_302400 n1_m1_249600_302400 5.356235
R7494 n1_m1_249600_302400 n1_m1_254400_302400 5.356235
R7495 n1_m1_254400_302400 n1_m1_256000_302400 1.785412
R7496 n1_m1_259200_302400 n1_m1_256000_302400 3.570824
R7497 n1_m1_259200_302400 n1_m1_264000_302400 5.356235
R7498 n1_m1_264000_302400 n1_m1_268800_302400 5.356235
R7499 n1_m1_268800_302400 n1_m1_273600_302400 5.356235
R7500 n1_m1_273600_302400 n1_m1_278400_302400 5.356235
R7501 n1_m1_278400_302400 n1_m1_283200_302400 5.356235
R7502 n1_m1_283200_302400 n1_m1_284000_302400 0.892706
R7503 n1_m1_288000_302400 n1_m1_284000_302400 4.463529
R7504 n1_m1_288000_302400 n1_m1_292800_302400 5.356235
R7505 n1_m1_292800_302400 n1_m1_297600_302400 5.356235
R7506 n1_m1_297600_302400 n1_m1_302400_302400 5.356235
R7507 n1_m1_302400_302400 n1_m1_307200_302400 5.356235
R7508 n1_m1_307200_302400 n1_m1_312000_302400 5.356235
R7509 n1_m1_312000_302400 n1_m1_316800_302400 5.356235
R7510 n1_m1_316800_302400 n1_m1_321600_302400 5.356235
R7511 n1_m1_321600_302400 n1_m1_326400_302400 5.356235
R7512 n1_m1_326400_302400 n1_m1_331200_302400 5.356235
R7513 n1_m1_331200_302400 n1_m1_336000_302400 5.356235
R7514 n1_m1_336000_302400 n1_m1_340000_302400 4.463529
R7515 n1_m1_340800_302400 n1_m1_340000_302400 0.892706
R7516 n1_m1_340800_302400 n1_m1_345600_302400 5.356235
R7517 n1_m1_345600_302400 n1_m1_350400_302400 5.356235
R7518 n1_m1_350400_302400 n1_m1_355200_302400 5.356235
R7519 n1_m1_355200_302400 n1_m1_360000_302400 5.356235
R7520 n1_m1_360000_302400 n1_m1_364800_302400 5.356235
R7521 n1_m1_364800_302400 n1_m1_368000_302400 3.570824
R7522 n1_m1_369600_302400 n1_m1_368000_302400 1.785412
R7523 n1_m1_369600_302400 n1_m1_374400_302400 5.356235
R7524 n1_m1_374400_302400 n1_m1_379200_302400 5.356235
R7525 n1_m1_379200_302400 n1_m1_384000_302400 5.356235
R7526 n1_m1_384000_302400 n1_m1_388800_302400 5.356235
R7527 n1_m1_388800_302400 n1_m1_393600_302400 5.356235
R7528 n1_m1_393600_302400 n1_m1_396000_302400 2.678118
R7529 n1_m1_398400_302400 n1_m1_396000_302400 2.678118
R7530 n1_m1_398400_302400 n1_m1_403200_302400 5.356235
R7531 n1_m1_403200_302400 n1_m1_408000_302400 5.356235
R7532 n1_m1_408000_302400 n1_m1_412800_302400 5.356235
R7533 n1_m1_412800_302400 n1_m1_417600_302400 5.356235
R7534 n1_m1_417600_302400 n1_m1_422400_302400 5.356235
R7535 n1_m1_422400_302400 n1_m1_424000_302400 1.785412
R7536 n1_m1_427200_302400 n1_m1_424000_302400 3.570824
R7537 n1_m1_427200_302400 n1_m1_432000_302400 5.356235
R7538 n1_m1_432000_302400 n1_m1_436800_302400 5.356235
R7539 n1_m1_436800_302400 n1_m1_441600_302400 5.356235
R7540 n1_m1_441600_302400 n1_m1_446400_302400 5.356235
R7541 n1_m1_446400_302400 n1_m1_451200_302400 5.356235
R7542 n1_m1_451200_302400 n1_m1_452000_302400 0.892706
R7543 n1_m1_456000_302400 n1_m1_452000_302400 4.463529
R7544 n1_m1_456000_302400 n1_m1_460800_302400 5.356235
R7545 n1_m1_460800_302400 n1_m1_465600_302400 5.356235
R7546 n1_m1_465600_302400 n1_m1_470400_302400 5.356235
R7547 n1_m1_470400_302400 n1_m1_475200_302400 5.356235
R7548 n1_m1_475200_302400 n1_m1_480000_302400 5.356235
R7549 n1_m1_480000_302400 n1_m1_484800_302400 5.356235
R7550 n1_m1_484800_302400 n1_m1_489600_302400 5.356235
R7551 n1_m1_489600_302400 n1_m1_494400_302400 5.356235
R7552 n1_m1_0_307200 n1_m1_4000_307200 4.463529
R7553 n1_m1_4800_307200 n1_m1_4000_307200 0.892706
R7554 n1_m1_4800_307200 n1_m1_9600_307200 5.356235
R7555 n1_m1_9600_307200 n1_m1_14400_307200 5.356235
R7556 n1_m1_14400_307200 n1_m1_19200_307200 5.356235
R7557 n1_m1_19200_307200 n1_m1_24000_307200 5.356235
R7558 n1_m1_24000_307200 n1_m1_28800_307200 5.356235
R7559 n1_m1_28800_307200 n1_m1_32000_307200 3.570824
R7560 n1_m1_33600_307200 n1_m1_32000_307200 1.785412
R7561 n1_m1_33600_307200 n1_m1_38400_307200 5.356235
R7562 n1_m1_38400_307200 n1_m1_43200_307200 5.356235
R7563 n1_m1_43200_307200 n1_m1_48000_307200 5.356235
R7564 n1_m1_48000_307200 n1_m1_52800_307200 5.356235
R7565 n1_m1_52800_307200 n1_m1_57600_307200 5.356235
R7566 n1_m1_57600_307200 n1_m1_60000_307200 2.678118
R7567 n1_m1_62400_307200 n1_m1_60000_307200 2.678118
R7568 n1_m1_62400_307200 n1_m1_67200_307200 5.356235
R7569 n1_m1_67200_307200 n1_m1_72000_307200 5.356235
R7570 n1_m1_72000_307200 n1_m1_76800_307200 5.356235
R7571 n1_m1_76800_307200 n1_m1_81600_307200 5.356235
R7572 n1_m1_81600_307200 n1_m1_86400_307200 5.356235
R7573 n1_m1_86400_307200 n1_m1_88000_307200 1.785412
R7574 n1_m1_91200_307200 n1_m1_88000_307200 3.570824
R7575 n1_m1_91200_307200 n1_m1_96000_307200 5.356235
R7576 n1_m1_96000_307200 n1_m1_100800_307200 5.356235
R7577 n1_m1_100800_307200 n1_m1_105600_307200 5.356235
R7578 n1_m1_105600_307200 n1_m1_110400_307200 5.356235
R7579 n1_m1_110400_307200 n1_m1_115200_307200 5.356235
R7580 n1_m1_115200_307200 n1_m1_116000_307200 0.892706
R7581 n1_m1_120000_307200 n1_m1_116000_307200 4.463529
R7582 n1_m1_120000_307200 n1_m1_124800_307200 5.356235
R7583 n1_m1_124800_307200 n1_m1_129600_307200 5.356235
R7584 n1_m1_129600_307200 n1_m1_134400_307200 5.356235
R7585 n1_m1_134400_307200 n1_m1_139200_307200 5.356235
R7586 n1_m1_139200_307200 n1_m1_144000_307200 5.356235
R7587 n1_m1_144000_307200 n1_m1_148800_307200 5.356235
R7588 n1_m1_148800_307200 n1_m1_153600_307200 5.356235
R7589 n1_m1_153600_307200 n1_m1_158400_307200 5.356235
R7590 n1_m1_158400_307200 n1_m1_163200_307200 5.356235
R7591 n1_m1_163200_307200 n1_m1_168000_307200 5.356235
R7592 n1_m1_168000_307200 n1_m1_172000_307200 4.463529
R7593 n1_m1_172800_307200 n1_m1_172000_307200 0.892706
R7594 n1_m1_172800_307200 n1_m1_177600_307200 5.356235
R7595 n1_m1_177600_307200 n1_m1_182400_307200 5.356235
R7596 n1_m1_182400_307200 n1_m1_187200_307200 5.356235
R7597 n1_m1_187200_307200 n1_m1_192000_307200 5.356235
R7598 n1_m1_192000_307200 n1_m1_196800_307200 5.356235
R7599 n1_m1_196800_307200 n1_m1_200000_307200 3.570824
R7600 n1_m1_201600_307200 n1_m1_200000_307200 1.785412
R7601 n1_m1_201600_307200 n1_m1_206400_307200 5.356235
R7602 n1_m1_206400_307200 n1_m1_211200_307200 5.356235
R7603 n1_m1_211200_307200 n1_m1_216000_307200 5.356235
R7604 n1_m1_216000_307200 n1_m1_220800_307200 5.356235
R7605 n1_m1_220800_307200 n1_m1_225600_307200 5.356235
R7606 n1_m1_225600_307200 n1_m1_228000_307200 2.678118
R7607 n1_m1_230400_307200 n1_m1_228000_307200 2.678118
R7608 n1_m1_230400_307200 n1_m1_235200_307200 5.356235
R7609 n1_m1_235200_307200 n1_m1_240000_307200 5.356235
R7610 n1_m1_240000_307200 n1_m1_244800_307200 5.356235
R7611 n1_m1_244800_307200 n1_m1_249600_307200 5.356235
R7612 n1_m1_249600_307200 n1_m1_254400_307200 5.356235
R7613 n1_m1_254400_307200 n1_m1_256000_307200 1.785412
R7614 n1_m1_259200_307200 n1_m1_256000_307200 3.570824
R7615 n1_m1_259200_307200 n1_m1_264000_307200 5.356235
R7616 n1_m1_264000_307200 n1_m1_268800_307200 5.356235
R7617 n1_m1_268800_307200 n1_m1_273600_307200 5.356235
R7618 n1_m1_273600_307200 n1_m1_278400_307200 5.356235
R7619 n1_m1_278400_307200 n1_m1_283200_307200 5.356235
R7620 n1_m1_283200_307200 n1_m1_284000_307200 0.892706
R7621 n1_m1_288000_307200 n1_m1_284000_307200 4.463529
R7622 n1_m1_288000_307200 n1_m1_292800_307200 5.356235
R7623 n1_m1_292800_307200 n1_m1_297600_307200 5.356235
R7624 n1_m1_297600_307200 n1_m1_302400_307200 5.356235
R7625 n1_m1_302400_307200 n1_m1_307200_307200 5.356235
R7626 n1_m1_307200_307200 n1_m1_312000_307200 5.356235
R7627 n1_m1_312000_307200 n1_m1_316800_307200 5.356235
R7628 n1_m1_316800_307200 n1_m1_321600_307200 5.356235
R7629 n1_m1_321600_307200 n1_m1_326400_307200 5.356235
R7630 n1_m1_326400_307200 n1_m1_331200_307200 5.356235
R7631 n1_m1_331200_307200 n1_m1_336000_307200 5.356235
R7632 n1_m1_336000_307200 n1_m1_340000_307200 4.463529
R7633 n1_m1_340800_307200 n1_m1_340000_307200 0.892706
R7634 n1_m1_340800_307200 n1_m1_345600_307200 5.356235
R7635 n1_m1_345600_307200 n1_m1_350400_307200 5.356235
R7636 n1_m1_350400_307200 n1_m1_355200_307200 5.356235
R7637 n1_m1_355200_307200 n1_m1_360000_307200 5.356235
R7638 n1_m1_360000_307200 n1_m1_364800_307200 5.356235
R7639 n1_m1_364800_307200 n1_m1_368000_307200 3.570824
R7640 n1_m1_369600_307200 n1_m1_368000_307200 1.785412
R7641 n1_m1_369600_307200 n1_m1_374400_307200 5.356235
R7642 n1_m1_374400_307200 n1_m1_379200_307200 5.356235
R7643 n1_m1_379200_307200 n1_m1_384000_307200 5.356235
R7644 n1_m1_384000_307200 n1_m1_388800_307200 5.356235
R7645 n1_m1_388800_307200 n1_m1_393600_307200 5.356235
R7646 n1_m1_393600_307200 n1_m1_396000_307200 2.678118
R7647 n1_m1_398400_307200 n1_m1_396000_307200 2.678118
R7648 n1_m1_398400_307200 n1_m1_403200_307200 5.356235
R7649 n1_m1_403200_307200 n1_m1_408000_307200 5.356235
R7650 n1_m1_408000_307200 n1_m1_412800_307200 5.356235
R7651 n1_m1_412800_307200 n1_m1_417600_307200 5.356235
R7652 n1_m1_417600_307200 n1_m1_422400_307200 5.356235
R7653 n1_m1_422400_307200 n1_m1_424000_307200 1.785412
R7654 n1_m1_427200_307200 n1_m1_424000_307200 3.570824
R7655 n1_m1_427200_307200 n1_m1_432000_307200 5.356235
R7656 n1_m1_432000_307200 n1_m1_436800_307200 5.356235
R7657 n1_m1_436800_307200 n1_m1_441600_307200 5.356235
R7658 n1_m1_441600_307200 n1_m1_446400_307200 5.356235
R7659 n1_m1_446400_307200 n1_m1_451200_307200 5.356235
R7660 n1_m1_451200_307200 n1_m1_452000_307200 0.892706
R7661 n1_m1_456000_307200 n1_m1_452000_307200 4.463529
R7662 n1_m1_456000_307200 n1_m1_460800_307200 5.356235
R7663 n1_m1_460800_307200 n1_m1_465600_307200 5.356235
R7664 n1_m1_465600_307200 n1_m1_470400_307200 5.356235
R7665 n1_m1_470400_307200 n1_m1_475200_307200 5.356235
R7666 n1_m1_475200_307200 n1_m1_480000_307200 5.356235
R7667 n1_m1_480000_307200 n1_m1_484800_307200 5.356235
R7668 n1_m1_484800_307200 n1_m1_489600_307200 5.356235
R7669 n1_m1_489600_307200 n1_m1_494400_307200 5.356235
R7670 n1_m1_0_312000 n1_m1_4000_312000 4.463529
R7671 n1_m1_4800_312000 n1_m1_4000_312000 0.892706
R7672 n1_m1_4800_312000 n1_m1_9600_312000 5.356235
R7673 n1_m1_9600_312000 n1_m1_14400_312000 5.356235
R7674 n1_m1_14400_312000 n1_m1_19200_312000 5.356235
R7675 n1_m1_19200_312000 n1_m1_24000_312000 5.356235
R7676 n1_m1_24000_312000 n1_m1_28800_312000 5.356235
R7677 n1_m1_28800_312000 n1_m1_32000_312000 3.570824
R7678 n1_m1_33600_312000 n1_m1_32000_312000 1.785412
R7679 n1_m1_33600_312000 n1_m1_38400_312000 5.356235
R7680 n1_m1_38400_312000 n1_m1_43200_312000 5.356235
R7681 n1_m1_43200_312000 n1_m1_48000_312000 5.356235
R7682 n1_m1_48000_312000 n1_m1_52800_312000 5.356235
R7683 n1_m1_52800_312000 n1_m1_57600_312000 5.356235
R7684 n1_m1_57600_312000 n1_m1_60000_312000 2.678118
R7685 n1_m1_62400_312000 n1_m1_60000_312000 2.678118
R7686 n1_m1_62400_312000 n1_m1_67200_312000 5.356235
R7687 n1_m1_67200_312000 n1_m1_72000_312000 5.356235
R7688 n1_m1_72000_312000 n1_m1_76800_312000 5.356235
R7689 n1_m1_76800_312000 n1_m1_81600_312000 5.356235
R7690 n1_m1_81600_312000 n1_m1_86400_312000 5.356235
R7691 n1_m1_86400_312000 n1_m1_88000_312000 1.785412
R7692 n1_m1_91200_312000 n1_m1_88000_312000 3.570824
R7693 n1_m1_91200_312000 n1_m1_96000_312000 5.356235
R7694 n1_m1_96000_312000 n1_m1_100800_312000 5.356235
R7695 n1_m1_100800_312000 n1_m1_105600_312000 5.356235
R7696 n1_m1_105600_312000 n1_m1_110400_312000 5.356235
R7697 n1_m1_110400_312000 n1_m1_115200_312000 5.356235
R7698 n1_m1_115200_312000 n1_m1_116000_312000 0.892706
R7699 n1_m1_120000_312000 n1_m1_116000_312000 4.463529
R7700 n1_m1_120000_312000 n1_m1_124800_312000 5.356235
R7701 n1_m1_124800_312000 n1_m1_129600_312000 5.356235
R7702 n1_m1_129600_312000 n1_m1_134400_312000 5.356235
R7703 n1_m1_134400_312000 n1_m1_139200_312000 5.356235
R7704 n1_m1_139200_312000 n1_m1_144000_312000 5.356235
R7705 n1_m1_144000_312000 n1_m1_148800_312000 5.356235
R7706 n1_m1_148800_312000 n1_m1_153600_312000 5.356235
R7707 n1_m1_153600_312000 n1_m1_158400_312000 5.356235
R7708 n1_m1_158400_312000 n1_m1_163200_312000 5.356235
R7709 n1_m1_163200_312000 n1_m1_168000_312000 5.356235
R7710 n1_m1_168000_312000 n1_m1_172000_312000 4.463529
R7711 n1_m1_172800_312000 n1_m1_172000_312000 0.892706
R7712 n1_m1_172800_312000 n1_m1_177600_312000 5.356235
R7713 n1_m1_177600_312000 n1_m1_182400_312000 5.356235
R7714 n1_m1_182400_312000 n1_m1_187200_312000 5.356235
R7715 n1_m1_187200_312000 n1_m1_192000_312000 5.356235
R7716 n1_m1_192000_312000 n1_m1_196800_312000 5.356235
R7717 n1_m1_196800_312000 n1_m1_200000_312000 3.570824
R7718 n1_m1_201600_312000 n1_m1_200000_312000 1.785412
R7719 n1_m1_201600_312000 n1_m1_206400_312000 5.356235
R7720 n1_m1_206400_312000 n1_m1_211200_312000 5.356235
R7721 n1_m1_211200_312000 n1_m1_216000_312000 5.356235
R7722 n1_m1_216000_312000 n1_m1_220800_312000 5.356235
R7723 n1_m1_220800_312000 n1_m1_225600_312000 5.356235
R7724 n1_m1_225600_312000 n1_m1_228000_312000 2.678118
R7725 n1_m1_230400_312000 n1_m1_228000_312000 2.678118
R7726 n1_m1_230400_312000 n1_m1_235200_312000 5.356235
R7727 n1_m1_235200_312000 n1_m1_240000_312000 5.356235
R7728 n1_m1_240000_312000 n1_m1_244800_312000 5.356235
R7729 n1_m1_244800_312000 n1_m1_249600_312000 5.356235
R7730 n1_m1_249600_312000 n1_m1_254400_312000 5.356235
R7731 n1_m1_254400_312000 n1_m1_256000_312000 1.785412
R7732 n1_m1_259200_312000 n1_m1_256000_312000 3.570824
R7733 n1_m1_259200_312000 n1_m1_264000_312000 5.356235
R7734 n1_m1_264000_312000 n1_m1_268800_312000 5.356235
R7735 n1_m1_268800_312000 n1_m1_273600_312000 5.356235
R7736 n1_m1_273600_312000 n1_m1_278400_312000 5.356235
R7737 n1_m1_278400_312000 n1_m1_283200_312000 5.356235
R7738 n1_m1_283200_312000 n1_m1_284000_312000 0.892706
R7739 n1_m1_288000_312000 n1_m1_284000_312000 4.463529
R7740 n1_m1_288000_312000 n1_m1_292800_312000 5.356235
R7741 n1_m1_292800_312000 n1_m1_297600_312000 5.356235
R7742 n1_m1_297600_312000 n1_m1_302400_312000 5.356235
R7743 n1_m1_302400_312000 n1_m1_307200_312000 5.356235
R7744 n1_m1_307200_312000 n1_m1_312000_312000 5.356235
R7745 n1_m1_312000_312000 n1_m1_316800_312000 5.356235
R7746 n1_m1_316800_312000 n1_m1_321600_312000 5.356235
R7747 n1_m1_321600_312000 n1_m1_326400_312000 5.356235
R7748 n1_m1_326400_312000 n1_m1_331200_312000 5.356235
R7749 n1_m1_331200_312000 n1_m1_336000_312000 5.356235
R7750 n1_m1_336000_312000 n1_m1_340000_312000 4.463529
R7751 n1_m1_340800_312000 n1_m1_340000_312000 0.892706
R7752 n1_m1_340800_312000 n1_m1_345600_312000 5.356235
R7753 n1_m1_345600_312000 n1_m1_350400_312000 5.356235
R7754 n1_m1_350400_312000 n1_m1_355200_312000 5.356235
R7755 n1_m1_355200_312000 n1_m1_360000_312000 5.356235
R7756 n1_m1_360000_312000 n1_m1_364800_312000 5.356235
R7757 n1_m1_364800_312000 n1_m1_368000_312000 3.570824
R7758 n1_m1_369600_312000 n1_m1_368000_312000 1.785412
R7759 n1_m1_369600_312000 n1_m1_374400_312000 5.356235
R7760 n1_m1_374400_312000 n1_m1_379200_312000 5.356235
R7761 n1_m1_379200_312000 n1_m1_384000_312000 5.356235
R7762 n1_m1_384000_312000 n1_m1_388800_312000 5.356235
R7763 n1_m1_388800_312000 n1_m1_393600_312000 5.356235
R7764 n1_m1_393600_312000 n1_m1_396000_312000 2.678118
R7765 n1_m1_398400_312000 n1_m1_396000_312000 2.678118
R7766 n1_m1_398400_312000 n1_m1_403200_312000 5.356235
R7767 n1_m1_403200_312000 n1_m1_408000_312000 5.356235
R7768 n1_m1_408000_312000 n1_m1_412800_312000 5.356235
R7769 n1_m1_412800_312000 n1_m1_417600_312000 5.356235
R7770 n1_m1_417600_312000 n1_m1_422400_312000 5.356235
R7771 n1_m1_422400_312000 n1_m1_424000_312000 1.785412
R7772 n1_m1_427200_312000 n1_m1_424000_312000 3.570824
R7773 n1_m1_427200_312000 n1_m1_432000_312000 5.356235
R7774 n1_m1_432000_312000 n1_m1_436800_312000 5.356235
R7775 n1_m1_436800_312000 n1_m1_441600_312000 5.356235
R7776 n1_m1_441600_312000 n1_m1_446400_312000 5.356235
R7777 n1_m1_446400_312000 n1_m1_451200_312000 5.356235
R7778 n1_m1_451200_312000 n1_m1_452000_312000 0.892706
R7779 n1_m1_456000_312000 n1_m1_452000_312000 4.463529
R7780 n1_m1_456000_312000 n1_m1_460800_312000 5.356235
R7781 n1_m1_460800_312000 n1_m1_465600_312000 5.356235
R7782 n1_m1_465600_312000 n1_m1_470400_312000 5.356235
R7783 n1_m1_470400_312000 n1_m1_475200_312000 5.356235
R7784 n1_m1_475200_312000 n1_m1_480000_312000 5.356235
R7785 n1_m1_480000_312000 n1_m1_484800_312000 5.356235
R7786 n1_m1_484800_312000 n1_m1_489600_312000 5.356235
R7787 n1_m1_489600_312000 n1_m1_494400_312000 5.356235
R7788 n1_m1_0_316800 n1_m1_4000_316800 4.463529
R7789 n1_m1_4800_316800 n1_m1_4000_316800 0.892706
R7790 n1_m1_4800_316800 n1_m1_9600_316800 5.356235
R7791 n1_m1_9600_316800 n1_m1_14400_316800 5.356235
R7792 n1_m1_14400_316800 n1_m1_19200_316800 5.356235
R7793 n1_m1_19200_316800 n1_m1_24000_316800 5.356235
R7794 n1_m1_24000_316800 n1_m1_28800_316800 5.356235
R7795 n1_m1_28800_316800 n1_m1_32000_316800 3.570824
R7796 n1_m1_33600_316800 n1_m1_32000_316800 1.785412
R7797 n1_m1_33600_316800 n1_m1_38400_316800 5.356235
R7798 n1_m1_38400_316800 n1_m1_43200_316800 5.356235
R7799 n1_m1_43200_316800 n1_m1_48000_316800 5.356235
R7800 n1_m1_48000_316800 n1_m1_52800_316800 5.356235
R7801 n1_m1_52800_316800 n1_m1_57600_316800 5.356235
R7802 n1_m1_57600_316800 n1_m1_60000_316800 2.678118
R7803 n1_m1_62400_316800 n1_m1_60000_316800 2.678118
R7804 n1_m1_62400_316800 n1_m1_67200_316800 5.356235
R7805 n1_m1_67200_316800 n1_m1_72000_316800 5.356235
R7806 n1_m1_72000_316800 n1_m1_76800_316800 5.356235
R7807 n1_m1_76800_316800 n1_m1_81600_316800 5.356235
R7808 n1_m1_81600_316800 n1_m1_86400_316800 5.356235
R7809 n1_m1_86400_316800 n1_m1_88000_316800 1.785412
R7810 n1_m1_91200_316800 n1_m1_88000_316800 3.570824
R7811 n1_m1_91200_316800 n1_m1_96000_316800 5.356235
R7812 n1_m1_96000_316800 n1_m1_100800_316800 5.356235
R7813 n1_m1_100800_316800 n1_m1_105600_316800 5.356235
R7814 n1_m1_105600_316800 n1_m1_110400_316800 5.356235
R7815 n1_m1_110400_316800 n1_m1_115200_316800 5.356235
R7816 n1_m1_115200_316800 n1_m1_116000_316800 0.892706
R7817 n1_m1_120000_316800 n1_m1_116000_316800 4.463529
R7818 n1_m1_120000_316800 n1_m1_124800_316800 5.356235
R7819 n1_m1_124800_316800 n1_m1_129600_316800 5.356235
R7820 n1_m1_129600_316800 n1_m1_134400_316800 5.356235
R7821 n1_m1_134400_316800 n1_m1_139200_316800 5.356235
R7822 n1_m1_139200_316800 n1_m1_144000_316800 5.356235
R7823 n1_m1_144000_316800 n1_m1_148800_316800 5.356235
R7824 n1_m1_148800_316800 n1_m1_153600_316800 5.356235
R7825 n1_m1_153600_316800 n1_m1_158400_316800 5.356235
R7826 n1_m1_158400_316800 n1_m1_163200_316800 5.356235
R7827 n1_m1_163200_316800 n1_m1_168000_316800 5.356235
R7828 n1_m1_168000_316800 n1_m1_172000_316800 4.463529
R7829 n1_m1_172800_316800 n1_m1_172000_316800 0.892706
R7830 n1_m1_172800_316800 n1_m1_177600_316800 5.356235
R7831 n1_m1_177600_316800 n1_m1_182400_316800 5.356235
R7832 n1_m1_182400_316800 n1_m1_187200_316800 5.356235
R7833 n1_m1_187200_316800 n1_m1_192000_316800 5.356235
R7834 n1_m1_192000_316800 n1_m1_196800_316800 5.356235
R7835 n1_m1_196800_316800 n1_m1_200000_316800 3.570824
R7836 n1_m1_201600_316800 n1_m1_200000_316800 1.785412
R7837 n1_m1_201600_316800 n1_m1_206400_316800 5.356235
R7838 n1_m1_206400_316800 n1_m1_211200_316800 5.356235
R7839 n1_m1_211200_316800 n1_m1_216000_316800 5.356235
R7840 n1_m1_216000_316800 n1_m1_220800_316800 5.356235
R7841 n1_m1_220800_316800 n1_m1_225600_316800 5.356235
R7842 n1_m1_225600_316800 n1_m1_228000_316800 2.678118
R7843 n1_m1_230400_316800 n1_m1_228000_316800 2.678118
R7844 n1_m1_230400_316800 n1_m1_235200_316800 5.356235
R7845 n1_m1_235200_316800 n1_m1_240000_316800 5.356235
R7846 n1_m1_240000_316800 n1_m1_244800_316800 5.356235
R7847 n1_m1_244800_316800 n1_m1_249600_316800 5.356235
R7848 n1_m1_249600_316800 n1_m1_254400_316800 5.356235
R7849 n1_m1_254400_316800 n1_m1_256000_316800 1.785412
R7850 n1_m1_259200_316800 n1_m1_256000_316800 3.570824
R7851 n1_m1_259200_316800 n1_m1_264000_316800 5.356235
R7852 n1_m1_264000_316800 n1_m1_268800_316800 5.356235
R7853 n1_m1_268800_316800 n1_m1_273600_316800 5.356235
R7854 n1_m1_273600_316800 n1_m1_278400_316800 5.356235
R7855 n1_m1_278400_316800 n1_m1_283200_316800 5.356235
R7856 n1_m1_283200_316800 n1_m1_284000_316800 0.892706
R7857 n1_m1_288000_316800 n1_m1_284000_316800 4.463529
R7858 n1_m1_288000_316800 n1_m1_292800_316800 5.356235
R7859 n1_m1_292800_316800 n1_m1_297600_316800 5.356235
R7860 n1_m1_297600_316800 n1_m1_302400_316800 5.356235
R7861 n1_m1_302400_316800 n1_m1_307200_316800 5.356235
R7862 n1_m1_307200_316800 n1_m1_312000_316800 5.356235
R7863 n1_m1_312000_316800 n1_m1_316800_316800 5.356235
R7864 n1_m1_316800_316800 n1_m1_321600_316800 5.356235
R7865 n1_m1_321600_316800 n1_m1_326400_316800 5.356235
R7866 n1_m1_326400_316800 n1_m1_331200_316800 5.356235
R7867 n1_m1_331200_316800 n1_m1_336000_316800 5.356235
R7868 n1_m1_336000_316800 n1_m1_340000_316800 4.463529
R7869 n1_m1_340800_316800 n1_m1_340000_316800 0.892706
R7870 n1_m1_340800_316800 n1_m1_345600_316800 5.356235
R7871 n1_m1_345600_316800 n1_m1_350400_316800 5.356235
R7872 n1_m1_350400_316800 n1_m1_355200_316800 5.356235
R7873 n1_m1_355200_316800 n1_m1_360000_316800 5.356235
R7874 n1_m1_360000_316800 n1_m1_364800_316800 5.356235
R7875 n1_m1_364800_316800 n1_m1_368000_316800 3.570824
R7876 n1_m1_369600_316800 n1_m1_368000_316800 1.785412
R7877 n1_m1_369600_316800 n1_m1_374400_316800 5.356235
R7878 n1_m1_374400_316800 n1_m1_379200_316800 5.356235
R7879 n1_m1_379200_316800 n1_m1_384000_316800 5.356235
R7880 n1_m1_384000_316800 n1_m1_388800_316800 5.356235
R7881 n1_m1_388800_316800 n1_m1_393600_316800 5.356235
R7882 n1_m1_393600_316800 n1_m1_396000_316800 2.678118
R7883 n1_m1_398400_316800 n1_m1_396000_316800 2.678118
R7884 n1_m1_398400_316800 n1_m1_403200_316800 5.356235
R7885 n1_m1_403200_316800 n1_m1_408000_316800 5.356235
R7886 n1_m1_408000_316800 n1_m1_412800_316800 5.356235
R7887 n1_m1_412800_316800 n1_m1_417600_316800 5.356235
R7888 n1_m1_417600_316800 n1_m1_422400_316800 5.356235
R7889 n1_m1_422400_316800 n1_m1_424000_316800 1.785412
R7890 n1_m1_427200_316800 n1_m1_424000_316800 3.570824
R7891 n1_m1_427200_316800 n1_m1_432000_316800 5.356235
R7892 n1_m1_432000_316800 n1_m1_436800_316800 5.356235
R7893 n1_m1_436800_316800 n1_m1_441600_316800 5.356235
R7894 n1_m1_441600_316800 n1_m1_446400_316800 5.356235
R7895 n1_m1_446400_316800 n1_m1_451200_316800 5.356235
R7896 n1_m1_451200_316800 n1_m1_452000_316800 0.892706
R7897 n1_m1_456000_316800 n1_m1_452000_316800 4.463529
R7898 n1_m1_456000_316800 n1_m1_460800_316800 5.356235
R7899 n1_m1_460800_316800 n1_m1_465600_316800 5.356235
R7900 n1_m1_465600_316800 n1_m1_470400_316800 5.356235
R7901 n1_m1_470400_316800 n1_m1_475200_316800 5.356235
R7902 n1_m1_475200_316800 n1_m1_480000_316800 5.356235
R7903 n1_m1_480000_316800 n1_m1_484800_316800 5.356235
R7904 n1_m1_484800_316800 n1_m1_489600_316800 5.356235
R7905 n1_m1_489600_316800 n1_m1_494400_316800 5.356235
R7906 n1_m1_0_321600 n1_m1_4000_321600 4.463529
R7907 n1_m1_4800_321600 n1_m1_4000_321600 0.892706
R7908 n1_m1_4800_321600 n1_m1_9600_321600 5.356235
R7909 n1_m1_9600_321600 n1_m1_14400_321600 5.356235
R7910 n1_m1_14400_321600 n1_m1_19200_321600 5.356235
R7911 n1_m1_19200_321600 n1_m1_24000_321600 5.356235
R7912 n1_m1_24000_321600 n1_m1_28800_321600 5.356235
R7913 n1_m1_28800_321600 n1_m1_32000_321600 3.570824
R7914 n1_m1_33600_321600 n1_m1_32000_321600 1.785412
R7915 n1_m1_33600_321600 n1_m1_38400_321600 5.356235
R7916 n1_m1_38400_321600 n1_m1_43200_321600 5.356235
R7917 n1_m1_43200_321600 n1_m1_48000_321600 5.356235
R7918 n1_m1_48000_321600 n1_m1_52800_321600 5.356235
R7919 n1_m1_52800_321600 n1_m1_57600_321600 5.356235
R7920 n1_m1_57600_321600 n1_m1_60000_321600 2.678118
R7921 n1_m1_62400_321600 n1_m1_60000_321600 2.678118
R7922 n1_m1_62400_321600 n1_m1_67200_321600 5.356235
R7923 n1_m1_67200_321600 n1_m1_72000_321600 5.356235
R7924 n1_m1_72000_321600 n1_m1_76800_321600 5.356235
R7925 n1_m1_76800_321600 n1_m1_81600_321600 5.356235
R7926 n1_m1_81600_321600 n1_m1_86400_321600 5.356235
R7927 n1_m1_86400_321600 n1_m1_88000_321600 1.785412
R7928 n1_m1_91200_321600 n1_m1_88000_321600 3.570824
R7929 n1_m1_91200_321600 n1_m1_96000_321600 5.356235
R7930 n1_m1_96000_321600 n1_m1_100800_321600 5.356235
R7931 n1_m1_100800_321600 n1_m1_105600_321600 5.356235
R7932 n1_m1_105600_321600 n1_m1_110400_321600 5.356235
R7933 n1_m1_110400_321600 n1_m1_115200_321600 5.356235
R7934 n1_m1_115200_321600 n1_m1_116000_321600 0.892706
R7935 n1_m1_120000_321600 n1_m1_116000_321600 4.463529
R7936 n1_m1_120000_321600 n1_m1_124800_321600 5.356235
R7937 n1_m1_124800_321600 n1_m1_129600_321600 5.356235
R7938 n1_m1_129600_321600 n1_m1_134400_321600 5.356235
R7939 n1_m1_134400_321600 n1_m1_139200_321600 5.356235
R7940 n1_m1_139200_321600 n1_m1_144000_321600 5.356235
R7941 n1_m1_144000_321600 n1_m1_148800_321600 5.356235
R7942 n1_m1_148800_321600 n1_m1_153600_321600 5.356235
R7943 n1_m1_153600_321600 n1_m1_158400_321600 5.356235
R7944 n1_m1_158400_321600 n1_m1_163200_321600 5.356235
R7945 n1_m1_163200_321600 n1_m1_168000_321600 5.356235
R7946 n1_m1_168000_321600 n1_m1_172000_321600 4.463529
R7947 n1_m1_172800_321600 n1_m1_172000_321600 0.892706
R7948 n1_m1_172800_321600 n1_m1_177600_321600 5.356235
R7949 n1_m1_177600_321600 n1_m1_182400_321600 5.356235
R7950 n1_m1_182400_321600 n1_m1_187200_321600 5.356235
R7951 n1_m1_187200_321600 n1_m1_192000_321600 5.356235
R7952 n1_m1_192000_321600 n1_m1_196800_321600 5.356235
R7953 n1_m1_196800_321600 n1_m1_200000_321600 3.570824
R7954 n1_m1_201600_321600 n1_m1_200000_321600 1.785412
R7955 n1_m1_201600_321600 n1_m1_206400_321600 5.356235
R7956 n1_m1_206400_321600 n1_m1_211200_321600 5.356235
R7957 n1_m1_211200_321600 n1_m1_216000_321600 5.356235
R7958 n1_m1_216000_321600 n1_m1_220800_321600 5.356235
R7959 n1_m1_220800_321600 n1_m1_225600_321600 5.356235
R7960 n1_m1_225600_321600 n1_m1_228000_321600 2.678118
R7961 n1_m1_230400_321600 n1_m1_228000_321600 2.678118
R7962 n1_m1_230400_321600 n1_m1_235200_321600 5.356235
R7963 n1_m1_235200_321600 n1_m1_240000_321600 5.356235
R7964 n1_m1_240000_321600 n1_m1_244800_321600 5.356235
R7965 n1_m1_244800_321600 n1_m1_249600_321600 5.356235
R7966 n1_m1_249600_321600 n1_m1_254400_321600 5.356235
R7967 n1_m1_254400_321600 n1_m1_256000_321600 1.785412
R7968 n1_m1_259200_321600 n1_m1_256000_321600 3.570824
R7969 n1_m1_259200_321600 n1_m1_264000_321600 5.356235
R7970 n1_m1_264000_321600 n1_m1_268800_321600 5.356235
R7971 n1_m1_268800_321600 n1_m1_273600_321600 5.356235
R7972 n1_m1_273600_321600 n1_m1_278400_321600 5.356235
R7973 n1_m1_278400_321600 n1_m1_283200_321600 5.356235
R7974 n1_m1_283200_321600 n1_m1_284000_321600 0.892706
R7975 n1_m1_288000_321600 n1_m1_284000_321600 4.463529
R7976 n1_m1_288000_321600 n1_m1_292800_321600 5.356235
R7977 n1_m1_292800_321600 n1_m1_297600_321600 5.356235
R7978 n1_m1_297600_321600 n1_m1_302400_321600 5.356235
R7979 n1_m1_302400_321600 n1_m1_307200_321600 5.356235
R7980 n1_m1_307200_321600 n1_m1_312000_321600 5.356235
R7981 n1_m1_312000_321600 n1_m1_316800_321600 5.356235
R7982 n1_m1_316800_321600 n1_m1_321600_321600 5.356235
R7983 n1_m1_321600_321600 n1_m1_326400_321600 5.356235
R7984 n1_m1_326400_321600 n1_m1_331200_321600 5.356235
R7985 n1_m1_331200_321600 n1_m1_336000_321600 5.356235
R7986 n1_m1_336000_321600 n1_m1_340000_321600 4.463529
R7987 n1_m1_340800_321600 n1_m1_340000_321600 0.892706
R7988 n1_m1_340800_321600 n1_m1_345600_321600 5.356235
R7989 n1_m1_345600_321600 n1_m1_350400_321600 5.356235
R7990 n1_m1_350400_321600 n1_m1_355200_321600 5.356235
R7991 n1_m1_355200_321600 n1_m1_360000_321600 5.356235
R7992 n1_m1_360000_321600 n1_m1_364800_321600 5.356235
R7993 n1_m1_364800_321600 n1_m1_368000_321600 3.570824
R7994 n1_m1_369600_321600 n1_m1_368000_321600 1.785412
R7995 n1_m1_369600_321600 n1_m1_374400_321600 5.356235
R7996 n1_m1_374400_321600 n1_m1_379200_321600 5.356235
R7997 n1_m1_379200_321600 n1_m1_384000_321600 5.356235
R7998 n1_m1_384000_321600 n1_m1_388800_321600 5.356235
R7999 n1_m1_388800_321600 n1_m1_393600_321600 5.356235
R8000 n1_m1_393600_321600 n1_m1_396000_321600 2.678118
R8001 n1_m1_398400_321600 n1_m1_396000_321600 2.678118
R8002 n1_m1_398400_321600 n1_m1_403200_321600 5.356235
R8003 n1_m1_403200_321600 n1_m1_408000_321600 5.356235
R8004 n1_m1_408000_321600 n1_m1_412800_321600 5.356235
R8005 n1_m1_412800_321600 n1_m1_417600_321600 5.356235
R8006 n1_m1_417600_321600 n1_m1_422400_321600 5.356235
R8007 n1_m1_422400_321600 n1_m1_424000_321600 1.785412
R8008 n1_m1_427200_321600 n1_m1_424000_321600 3.570824
R8009 n1_m1_427200_321600 n1_m1_432000_321600 5.356235
R8010 n1_m1_432000_321600 n1_m1_436800_321600 5.356235
R8011 n1_m1_436800_321600 n1_m1_441600_321600 5.356235
R8012 n1_m1_441600_321600 n1_m1_446400_321600 5.356235
R8013 n1_m1_446400_321600 n1_m1_451200_321600 5.356235
R8014 n1_m1_451200_321600 n1_m1_452000_321600 0.892706
R8015 n1_m1_456000_321600 n1_m1_452000_321600 4.463529
R8016 n1_m1_456000_321600 n1_m1_460800_321600 5.356235
R8017 n1_m1_460800_321600 n1_m1_465600_321600 5.356235
R8018 n1_m1_465600_321600 n1_m1_470400_321600 5.356235
R8019 n1_m1_470400_321600 n1_m1_475200_321600 5.356235
R8020 n1_m1_475200_321600 n1_m1_480000_321600 5.356235
R8021 n1_m1_480000_321600 n1_m1_484800_321600 5.356235
R8022 n1_m1_484800_321600 n1_m1_489600_321600 5.356235
R8023 n1_m1_489600_321600 n1_m1_494400_321600 5.356235
R8024 n1_m1_0_326400 n1_m1_4000_326400 4.463529
R8025 n1_m1_4800_326400 n1_m1_4000_326400 0.892706
R8026 n1_m1_4800_326400 n1_m1_9600_326400 5.356235
R8027 n1_m1_9600_326400 n1_m1_14400_326400 5.356235
R8028 n1_m1_14400_326400 n1_m1_19200_326400 5.356235
R8029 n1_m1_19200_326400 n1_m1_24000_326400 5.356235
R8030 n1_m1_24000_326400 n1_m1_28800_326400 5.356235
R8031 n1_m1_28800_326400 n1_m1_32000_326400 3.570824
R8032 n1_m1_33600_326400 n1_m1_32000_326400 1.785412
R8033 n1_m1_33600_326400 n1_m1_38400_326400 5.356235
R8034 n1_m1_38400_326400 n1_m1_43200_326400 5.356235
R8035 n1_m1_43200_326400 n1_m1_48000_326400 5.356235
R8036 n1_m1_48000_326400 n1_m1_52800_326400 5.356235
R8037 n1_m1_52800_326400 n1_m1_57600_326400 5.356235
R8038 n1_m1_57600_326400 n1_m1_60000_326400 2.678118
R8039 n1_m1_62400_326400 n1_m1_60000_326400 2.678118
R8040 n1_m1_62400_326400 n1_m1_67200_326400 5.356235
R8041 n1_m1_67200_326400 n1_m1_72000_326400 5.356235
R8042 n1_m1_72000_326400 n1_m1_76800_326400 5.356235
R8043 n1_m1_76800_326400 n1_m1_81600_326400 5.356235
R8044 n1_m1_81600_326400 n1_m1_86400_326400 5.356235
R8045 n1_m1_86400_326400 n1_m1_88000_326400 1.785412
R8046 n1_m1_91200_326400 n1_m1_88000_326400 3.570824
R8047 n1_m1_91200_326400 n1_m1_96000_326400 5.356235
R8048 n1_m1_96000_326400 n1_m1_100800_326400 5.356235
R8049 n1_m1_100800_326400 n1_m1_105600_326400 5.356235
R8050 n1_m1_105600_326400 n1_m1_110400_326400 5.356235
R8051 n1_m1_110400_326400 n1_m1_115200_326400 5.356235
R8052 n1_m1_115200_326400 n1_m1_116000_326400 0.892706
R8053 n1_m1_120000_326400 n1_m1_116000_326400 4.463529
R8054 n1_m1_120000_326400 n1_m1_124800_326400 5.356235
R8055 n1_m1_124800_326400 n1_m1_129600_326400 5.356235
R8056 n1_m1_129600_326400 n1_m1_134400_326400 5.356235
R8057 n1_m1_134400_326400 n1_m1_139200_326400 5.356235
R8058 n1_m1_139200_326400 n1_m1_144000_326400 5.356235
R8059 n1_m1_144000_326400 n1_m1_148800_326400 5.356235
R8060 n1_m1_148800_326400 n1_m1_153600_326400 5.356235
R8061 n1_m1_153600_326400 n1_m1_158400_326400 5.356235
R8062 n1_m1_158400_326400 n1_m1_163200_326400 5.356235
R8063 n1_m1_163200_326400 n1_m1_168000_326400 5.356235
R8064 n1_m1_168000_326400 n1_m1_172000_326400 4.463529
R8065 n1_m1_172800_326400 n1_m1_172000_326400 0.892706
R8066 n1_m1_172800_326400 n1_m1_177600_326400 5.356235
R8067 n1_m1_177600_326400 n1_m1_182400_326400 5.356235
R8068 n1_m1_182400_326400 n1_m1_187200_326400 5.356235
R8069 n1_m1_187200_326400 n1_m1_192000_326400 5.356235
R8070 n1_m1_192000_326400 n1_m1_196800_326400 5.356235
R8071 n1_m1_196800_326400 n1_m1_200000_326400 3.570824
R8072 n1_m1_201600_326400 n1_m1_200000_326400 1.785412
R8073 n1_m1_201600_326400 n1_m1_206400_326400 5.356235
R8074 n1_m1_206400_326400 n1_m1_211200_326400 5.356235
R8075 n1_m1_211200_326400 n1_m1_216000_326400 5.356235
R8076 n1_m1_216000_326400 n1_m1_220800_326400 5.356235
R8077 n1_m1_220800_326400 n1_m1_225600_326400 5.356235
R8078 n1_m1_225600_326400 n1_m1_228000_326400 2.678118
R8079 n1_m1_230400_326400 n1_m1_228000_326400 2.678118
R8080 n1_m1_230400_326400 n1_m1_235200_326400 5.356235
R8081 n1_m1_235200_326400 n1_m1_240000_326400 5.356235
R8082 n1_m1_240000_326400 n1_m1_244800_326400 5.356235
R8083 n1_m1_244800_326400 n1_m1_249600_326400 5.356235
R8084 n1_m1_249600_326400 n1_m1_254400_326400 5.356235
R8085 n1_m1_254400_326400 n1_m1_256000_326400 1.785412
R8086 n1_m1_259200_326400 n1_m1_256000_326400 3.570824
R8087 n1_m1_259200_326400 n1_m1_264000_326400 5.356235
R8088 n1_m1_264000_326400 n1_m1_268800_326400 5.356235
R8089 n1_m1_268800_326400 n1_m1_273600_326400 5.356235
R8090 n1_m1_273600_326400 n1_m1_278400_326400 5.356235
R8091 n1_m1_278400_326400 n1_m1_283200_326400 5.356235
R8092 n1_m1_283200_326400 n1_m1_284000_326400 0.892706
R8093 n1_m1_288000_326400 n1_m1_284000_326400 4.463529
R8094 n1_m1_288000_326400 n1_m1_292800_326400 5.356235
R8095 n1_m1_292800_326400 n1_m1_297600_326400 5.356235
R8096 n1_m1_297600_326400 n1_m1_302400_326400 5.356235
R8097 n1_m1_302400_326400 n1_m1_307200_326400 5.356235
R8098 n1_m1_307200_326400 n1_m1_312000_326400 5.356235
R8099 n1_m1_312000_326400 n1_m1_316800_326400 5.356235
R8100 n1_m1_316800_326400 n1_m1_321600_326400 5.356235
R8101 n1_m1_321600_326400 n1_m1_326400_326400 5.356235
R8102 n1_m1_326400_326400 n1_m1_331200_326400 5.356235
R8103 n1_m1_331200_326400 n1_m1_336000_326400 5.356235
R8104 n1_m1_336000_326400 n1_m1_340000_326400 4.463529
R8105 n1_m1_340800_326400 n1_m1_340000_326400 0.892706
R8106 n1_m1_340800_326400 n1_m1_345600_326400 5.356235
R8107 n1_m1_345600_326400 n1_m1_350400_326400 5.356235
R8108 n1_m1_350400_326400 n1_m1_355200_326400 5.356235
R8109 n1_m1_355200_326400 n1_m1_360000_326400 5.356235
R8110 n1_m1_360000_326400 n1_m1_364800_326400 5.356235
R8111 n1_m1_364800_326400 n1_m1_368000_326400 3.570824
R8112 n1_m1_369600_326400 n1_m1_368000_326400 1.785412
R8113 n1_m1_369600_326400 n1_m1_374400_326400 5.356235
R8114 n1_m1_374400_326400 n1_m1_379200_326400 5.356235
R8115 n1_m1_379200_326400 n1_m1_384000_326400 5.356235
R8116 n1_m1_384000_326400 n1_m1_388800_326400 5.356235
R8117 n1_m1_388800_326400 n1_m1_393600_326400 5.356235
R8118 n1_m1_393600_326400 n1_m1_396000_326400 2.678118
R8119 n1_m1_398400_326400 n1_m1_396000_326400 2.678118
R8120 n1_m1_398400_326400 n1_m1_403200_326400 5.356235
R8121 n1_m1_403200_326400 n1_m1_408000_326400 5.356235
R8122 n1_m1_408000_326400 n1_m1_412800_326400 5.356235
R8123 n1_m1_412800_326400 n1_m1_417600_326400 5.356235
R8124 n1_m1_417600_326400 n1_m1_422400_326400 5.356235
R8125 n1_m1_422400_326400 n1_m1_424000_326400 1.785412
R8126 n1_m1_427200_326400 n1_m1_424000_326400 3.570824
R8127 n1_m1_427200_326400 n1_m1_432000_326400 5.356235
R8128 n1_m1_432000_326400 n1_m1_436800_326400 5.356235
R8129 n1_m1_436800_326400 n1_m1_441600_326400 5.356235
R8130 n1_m1_441600_326400 n1_m1_446400_326400 5.356235
R8131 n1_m1_446400_326400 n1_m1_451200_326400 5.356235
R8132 n1_m1_451200_326400 n1_m1_452000_326400 0.892706
R8133 n1_m1_456000_326400 n1_m1_452000_326400 4.463529
R8134 n1_m1_456000_326400 n1_m1_460800_326400 5.356235
R8135 n1_m1_460800_326400 n1_m1_465600_326400 5.356235
R8136 n1_m1_465600_326400 n1_m1_470400_326400 5.356235
R8137 n1_m1_470400_326400 n1_m1_475200_326400 5.356235
R8138 n1_m1_475200_326400 n1_m1_480000_326400 5.356235
R8139 n1_m1_480000_326400 n1_m1_484800_326400 5.356235
R8140 n1_m1_484800_326400 n1_m1_489600_326400 5.356235
R8141 n1_m1_489600_326400 n1_m1_494400_326400 5.356235
R8142 n1_m1_0_331200 n1_m1_4000_331200 4.463529
R8143 n1_m1_4800_331200 n1_m1_4000_331200 0.892706
R8144 n1_m1_4800_331200 n1_m1_9600_331200 5.356235
R8145 n1_m1_9600_331200 n1_m1_14400_331200 5.356235
R8146 n1_m1_14400_331200 n1_m1_19200_331200 5.356235
R8147 n1_m1_19200_331200 n1_m1_24000_331200 5.356235
R8148 n1_m1_24000_331200 n1_m1_28800_331200 5.356235
R8149 n1_m1_28800_331200 n1_m1_32000_331200 3.570824
R8150 n1_m1_33600_331200 n1_m1_32000_331200 1.785412
R8151 n1_m1_33600_331200 n1_m1_38400_331200 5.356235
R8152 n1_m1_38400_331200 n1_m1_43200_331200 5.356235
R8153 n1_m1_43200_331200 n1_m1_48000_331200 5.356235
R8154 n1_m1_48000_331200 n1_m1_52800_331200 5.356235
R8155 n1_m1_52800_331200 n1_m1_57600_331200 5.356235
R8156 n1_m1_57600_331200 n1_m1_60000_331200 2.678118
R8157 n1_m1_62400_331200 n1_m1_60000_331200 2.678118
R8158 n1_m1_62400_331200 n1_m1_67200_331200 5.356235
R8159 n1_m1_67200_331200 n1_m1_72000_331200 5.356235
R8160 n1_m1_72000_331200 n1_m1_76800_331200 5.356235
R8161 n1_m1_76800_331200 n1_m1_81600_331200 5.356235
R8162 n1_m1_81600_331200 n1_m1_86400_331200 5.356235
R8163 n1_m1_86400_331200 n1_m1_88000_331200 1.785412
R8164 n1_m1_91200_331200 n1_m1_88000_331200 3.570824
R8165 n1_m1_91200_331200 n1_m1_96000_331200 5.356235
R8166 n1_m1_96000_331200 n1_m1_100800_331200 5.356235
R8167 n1_m1_100800_331200 n1_m1_105600_331200 5.356235
R8168 n1_m1_105600_331200 n1_m1_110400_331200 5.356235
R8169 n1_m1_110400_331200 n1_m1_115200_331200 5.356235
R8170 n1_m1_115200_331200 n1_m1_116000_331200 0.892706
R8171 n1_m1_120000_331200 n1_m1_116000_331200 4.463529
R8172 n1_m1_120000_331200 n1_m1_124800_331200 5.356235
R8173 n1_m1_124800_331200 n1_m1_129600_331200 5.356235
R8174 n1_m1_129600_331200 n1_m1_134400_331200 5.356235
R8175 n1_m1_134400_331200 n1_m1_139200_331200 5.356235
R8176 n1_m1_139200_331200 n1_m1_144000_331200 5.356235
R8177 n1_m1_144000_331200 n1_m1_148800_331200 5.356235
R8178 n1_m1_148800_331200 n1_m1_153600_331200 5.356235
R8179 n1_m1_153600_331200 n1_m1_158400_331200 5.356235
R8180 n1_m1_158400_331200 n1_m1_163200_331200 5.356235
R8181 n1_m1_163200_331200 n1_m1_168000_331200 5.356235
R8182 n1_m1_168000_331200 n1_m1_172000_331200 4.463529
R8183 n1_m1_172800_331200 n1_m1_172000_331200 0.892706
R8184 n1_m1_172800_331200 n1_m1_177600_331200 5.356235
R8185 n1_m1_177600_331200 n1_m1_182400_331200 5.356235
R8186 n1_m1_182400_331200 n1_m1_187200_331200 5.356235
R8187 n1_m1_187200_331200 n1_m1_192000_331200 5.356235
R8188 n1_m1_192000_331200 n1_m1_196800_331200 5.356235
R8189 n1_m1_196800_331200 n1_m1_200000_331200 3.570824
R8190 n1_m1_201600_331200 n1_m1_200000_331200 1.785412
R8191 n1_m1_201600_331200 n1_m1_206400_331200 5.356235
R8192 n1_m1_206400_331200 n1_m1_211200_331200 5.356235
R8193 n1_m1_211200_331200 n1_m1_216000_331200 5.356235
R8194 n1_m1_216000_331200 n1_m1_220800_331200 5.356235
R8195 n1_m1_220800_331200 n1_m1_225600_331200 5.356235
R8196 n1_m1_225600_331200 n1_m1_228000_331200 2.678118
R8197 n1_m1_230400_331200 n1_m1_228000_331200 2.678118
R8198 n1_m1_230400_331200 n1_m1_235200_331200 5.356235
R8199 n1_m1_235200_331200 n1_m1_240000_331200 5.356235
R8200 n1_m1_240000_331200 n1_m1_244800_331200 5.356235
R8201 n1_m1_244800_331200 n1_m1_249600_331200 5.356235
R8202 n1_m1_249600_331200 n1_m1_254400_331200 5.356235
R8203 n1_m1_254400_331200 n1_m1_256000_331200 1.785412
R8204 n1_m1_259200_331200 n1_m1_256000_331200 3.570824
R8205 n1_m1_259200_331200 n1_m1_264000_331200 5.356235
R8206 n1_m1_264000_331200 n1_m1_268800_331200 5.356235
R8207 n1_m1_268800_331200 n1_m1_273600_331200 5.356235
R8208 n1_m1_273600_331200 n1_m1_278400_331200 5.356235
R8209 n1_m1_278400_331200 n1_m1_283200_331200 5.356235
R8210 n1_m1_283200_331200 n1_m1_284000_331200 0.892706
R8211 n1_m1_288000_331200 n1_m1_284000_331200 4.463529
R8212 n1_m1_288000_331200 n1_m1_292800_331200 5.356235
R8213 n1_m1_292800_331200 n1_m1_297600_331200 5.356235
R8214 n1_m1_297600_331200 n1_m1_302400_331200 5.356235
R8215 n1_m1_302400_331200 n1_m1_307200_331200 5.356235
R8216 n1_m1_307200_331200 n1_m1_312000_331200 5.356235
R8217 n1_m1_312000_331200 n1_m1_316800_331200 5.356235
R8218 n1_m1_316800_331200 n1_m1_321600_331200 5.356235
R8219 n1_m1_321600_331200 n1_m1_326400_331200 5.356235
R8220 n1_m1_326400_331200 n1_m1_331200_331200 5.356235
R8221 n1_m1_331200_331200 n1_m1_336000_331200 5.356235
R8222 n1_m1_336000_331200 n1_m1_340000_331200 4.463529
R8223 n1_m1_340800_331200 n1_m1_340000_331200 0.892706
R8224 n1_m1_340800_331200 n1_m1_345600_331200 5.356235
R8225 n1_m1_345600_331200 n1_m1_350400_331200 5.356235
R8226 n1_m1_350400_331200 n1_m1_355200_331200 5.356235
R8227 n1_m1_355200_331200 n1_m1_360000_331200 5.356235
R8228 n1_m1_360000_331200 n1_m1_364800_331200 5.356235
R8229 n1_m1_364800_331200 n1_m1_368000_331200 3.570824
R8230 n1_m1_369600_331200 n1_m1_368000_331200 1.785412
R8231 n1_m1_369600_331200 n1_m1_374400_331200 5.356235
R8232 n1_m1_374400_331200 n1_m1_379200_331200 5.356235
R8233 n1_m1_379200_331200 n1_m1_384000_331200 5.356235
R8234 n1_m1_384000_331200 n1_m1_388800_331200 5.356235
R8235 n1_m1_388800_331200 n1_m1_393600_331200 5.356235
R8236 n1_m1_393600_331200 n1_m1_396000_331200 2.678118
R8237 n1_m1_398400_331200 n1_m1_396000_331200 2.678118
R8238 n1_m1_398400_331200 n1_m1_403200_331200 5.356235
R8239 n1_m1_403200_331200 n1_m1_408000_331200 5.356235
R8240 n1_m1_408000_331200 n1_m1_412800_331200 5.356235
R8241 n1_m1_412800_331200 n1_m1_417600_331200 5.356235
R8242 n1_m1_417600_331200 n1_m1_422400_331200 5.356235
R8243 n1_m1_422400_331200 n1_m1_424000_331200 1.785412
R8244 n1_m1_427200_331200 n1_m1_424000_331200 3.570824
R8245 n1_m1_427200_331200 n1_m1_432000_331200 5.356235
R8246 n1_m1_432000_331200 n1_m1_436800_331200 5.356235
R8247 n1_m1_436800_331200 n1_m1_441600_331200 5.356235
R8248 n1_m1_441600_331200 n1_m1_446400_331200 5.356235
R8249 n1_m1_446400_331200 n1_m1_451200_331200 5.356235
R8250 n1_m1_451200_331200 n1_m1_452000_331200 0.892706
R8251 n1_m1_456000_331200 n1_m1_452000_331200 4.463529
R8252 n1_m1_456000_331200 n1_m1_460800_331200 5.356235
R8253 n1_m1_460800_331200 n1_m1_465600_331200 5.356235
R8254 n1_m1_465600_331200 n1_m1_470400_331200 5.356235
R8255 n1_m1_470400_331200 n1_m1_475200_331200 5.356235
R8256 n1_m1_475200_331200 n1_m1_480000_331200 5.356235
R8257 n1_m1_480000_331200 n1_m1_484800_331200 5.356235
R8258 n1_m1_484800_331200 n1_m1_489600_331200 5.356235
R8259 n1_m1_489600_331200 n1_m1_494400_331200 5.356235
R8260 n1_m1_0_336000 n1_m1_4000_336000 4.463529
R8261 n1_m1_4800_336000 n1_m1_4000_336000 0.892706
R8262 n1_m1_4800_336000 n1_m1_9600_336000 5.356235
R8263 n1_m1_9600_336000 n1_m1_14400_336000 5.356235
R8264 n1_m1_14400_336000 n1_m1_19200_336000 5.356235
R8265 n1_m1_19200_336000 n1_m1_24000_336000 5.356235
R8266 n1_m1_24000_336000 n1_m1_28800_336000 5.356235
R8267 n1_m1_28800_336000 n1_m1_32000_336000 3.570824
R8268 n1_m1_33600_336000 n1_m1_32000_336000 1.785412
R8269 n1_m1_33600_336000 n1_m1_38400_336000 5.356235
R8270 n1_m1_38400_336000 n1_m1_43200_336000 5.356235
R8271 n1_m1_43200_336000 n1_m1_48000_336000 5.356235
R8272 n1_m1_48000_336000 n1_m1_52800_336000 5.356235
R8273 n1_m1_52800_336000 n1_m1_57600_336000 5.356235
R8274 n1_m1_57600_336000 n1_m1_60000_336000 2.678118
R8275 n1_m1_62400_336000 n1_m1_60000_336000 2.678118
R8276 n1_m1_62400_336000 n1_m1_67200_336000 5.356235
R8277 n1_m1_67200_336000 n1_m1_72000_336000 5.356235
R8278 n1_m1_72000_336000 n1_m1_76800_336000 5.356235
R8279 n1_m1_76800_336000 n1_m1_81600_336000 5.356235
R8280 n1_m1_81600_336000 n1_m1_86400_336000 5.356235
R8281 n1_m1_86400_336000 n1_m1_88000_336000 1.785412
R8282 n1_m1_91200_336000 n1_m1_88000_336000 3.570824
R8283 n1_m1_91200_336000 n1_m1_96000_336000 5.356235
R8284 n1_m1_96000_336000 n1_m1_100800_336000 5.356235
R8285 n1_m1_100800_336000 n1_m1_105600_336000 5.356235
R8286 n1_m1_105600_336000 n1_m1_110400_336000 5.356235
R8287 n1_m1_110400_336000 n1_m1_115200_336000 5.356235
R8288 n1_m1_115200_336000 n1_m1_116000_336000 0.892706
R8289 n1_m1_120000_336000 n1_m1_116000_336000 4.463529
R8290 n1_m1_120000_336000 n1_m1_124800_336000 5.356235
R8291 n1_m1_124800_336000 n1_m1_129600_336000 5.356235
R8292 n1_m1_129600_336000 n1_m1_134400_336000 5.356235
R8293 n1_m1_134400_336000 n1_m1_139200_336000 5.356235
R8294 n1_m1_139200_336000 n1_m1_144000_336000 5.356235
R8295 n1_m1_144000_336000 n1_m1_148800_336000 5.356235
R8296 n1_m1_148800_336000 n1_m1_153600_336000 5.356235
R8297 n1_m1_153600_336000 n1_m1_158400_336000 5.356235
R8298 n1_m1_158400_336000 n1_m1_163200_336000 5.356235
R8299 n1_m1_163200_336000 n1_m1_168000_336000 5.356235
R8300 n1_m1_168000_336000 n1_m1_172000_336000 4.463529
R8301 n1_m1_172800_336000 n1_m1_172000_336000 0.892706
R8302 n1_m1_172800_336000 n1_m1_177600_336000 5.356235
R8303 n1_m1_177600_336000 n1_m1_182400_336000 5.356235
R8304 n1_m1_182400_336000 n1_m1_187200_336000 5.356235
R8305 n1_m1_187200_336000 n1_m1_192000_336000 5.356235
R8306 n1_m1_192000_336000 n1_m1_196800_336000 5.356235
R8307 n1_m1_196800_336000 n1_m1_200000_336000 3.570824
R8308 n1_m1_201600_336000 n1_m1_200000_336000 1.785412
R8309 n1_m1_201600_336000 n1_m1_206400_336000 5.356235
R8310 n1_m1_206400_336000 n1_m1_211200_336000 5.356235
R8311 n1_m1_211200_336000 n1_m1_216000_336000 5.356235
R8312 n1_m1_216000_336000 n1_m1_220800_336000 5.356235
R8313 n1_m1_220800_336000 n1_m1_225600_336000 5.356235
R8314 n1_m1_225600_336000 n1_m1_228000_336000 2.678118
R8315 n1_m1_230400_336000 n1_m1_228000_336000 2.678118
R8316 n1_m1_230400_336000 n1_m1_235200_336000 5.356235
R8317 n1_m1_235200_336000 n1_m1_240000_336000 5.356235
R8318 n1_m1_240000_336000 n1_m1_244800_336000 5.356235
R8319 n1_m1_244800_336000 n1_m1_249600_336000 5.356235
R8320 n1_m1_249600_336000 n1_m1_254400_336000 5.356235
R8321 n1_m1_254400_336000 n1_m1_256000_336000 1.785412
R8322 n1_m1_259200_336000 n1_m1_256000_336000 3.570824
R8323 n1_m1_259200_336000 n1_m1_264000_336000 5.356235
R8324 n1_m1_264000_336000 n1_m1_268800_336000 5.356235
R8325 n1_m1_268800_336000 n1_m1_273600_336000 5.356235
R8326 n1_m1_273600_336000 n1_m1_278400_336000 5.356235
R8327 n1_m1_278400_336000 n1_m1_283200_336000 5.356235
R8328 n1_m1_283200_336000 n1_m1_284000_336000 0.892706
R8329 n1_m1_288000_336000 n1_m1_284000_336000 4.463529
R8330 n1_m1_288000_336000 n1_m1_292800_336000 5.356235
R8331 n1_m1_292800_336000 n1_m1_297600_336000 5.356235
R8332 n1_m1_297600_336000 n1_m1_302400_336000 5.356235
R8333 n1_m1_302400_336000 n1_m1_307200_336000 5.356235
R8334 n1_m1_307200_336000 n1_m1_312000_336000 5.356235
R8335 n1_m1_312000_336000 n1_m1_316800_336000 5.356235
R8336 n1_m1_316800_336000 n1_m1_321600_336000 5.356235
R8337 n1_m1_321600_336000 n1_m1_326400_336000 5.356235
R8338 n1_m1_326400_336000 n1_m1_331200_336000 5.356235
R8339 n1_m1_331200_336000 n1_m1_336000_336000 5.356235
R8340 n1_m1_336000_336000 n1_m1_340000_336000 4.463529
R8341 n1_m1_340800_336000 n1_m1_340000_336000 0.892706
R8342 n1_m1_340800_336000 n1_m1_345600_336000 5.356235
R8343 n1_m1_345600_336000 n1_m1_350400_336000 5.356235
R8344 n1_m1_350400_336000 n1_m1_355200_336000 5.356235
R8345 n1_m1_355200_336000 n1_m1_360000_336000 5.356235
R8346 n1_m1_360000_336000 n1_m1_364800_336000 5.356235
R8347 n1_m1_364800_336000 n1_m1_368000_336000 3.570824
R8348 n1_m1_369600_336000 n1_m1_368000_336000 1.785412
R8349 n1_m1_369600_336000 n1_m1_374400_336000 5.356235
R8350 n1_m1_374400_336000 n1_m1_379200_336000 5.356235
R8351 n1_m1_379200_336000 n1_m1_384000_336000 5.356235
R8352 n1_m1_384000_336000 n1_m1_388800_336000 5.356235
R8353 n1_m1_388800_336000 n1_m1_393600_336000 5.356235
R8354 n1_m1_393600_336000 n1_m1_396000_336000 2.678118
R8355 n1_m1_398400_336000 n1_m1_396000_336000 2.678118
R8356 n1_m1_398400_336000 n1_m1_403200_336000 5.356235
R8357 n1_m1_403200_336000 n1_m1_408000_336000 5.356235
R8358 n1_m1_408000_336000 n1_m1_412800_336000 5.356235
R8359 n1_m1_412800_336000 n1_m1_417600_336000 5.356235
R8360 n1_m1_417600_336000 n1_m1_422400_336000 5.356235
R8361 n1_m1_422400_336000 n1_m1_424000_336000 1.785412
R8362 n1_m1_427200_336000 n1_m1_424000_336000 3.570824
R8363 n1_m1_427200_336000 n1_m1_432000_336000 5.356235
R8364 n1_m1_432000_336000 n1_m1_436800_336000 5.356235
R8365 n1_m1_436800_336000 n1_m1_441600_336000 5.356235
R8366 n1_m1_441600_336000 n1_m1_446400_336000 5.356235
R8367 n1_m1_446400_336000 n1_m1_451200_336000 5.356235
R8368 n1_m1_451200_336000 n1_m1_452000_336000 0.892706
R8369 n1_m1_456000_336000 n1_m1_452000_336000 4.463529
R8370 n1_m1_456000_336000 n1_m1_460800_336000 5.356235
R8371 n1_m1_460800_336000 n1_m1_465600_336000 5.356235
R8372 n1_m1_465600_336000 n1_m1_470400_336000 5.356235
R8373 n1_m1_470400_336000 n1_m1_475200_336000 5.356235
R8374 n1_m1_475200_336000 n1_m1_480000_336000 5.356235
R8375 n1_m1_480000_336000 n1_m1_484800_336000 5.356235
R8376 n1_m1_484800_336000 n1_m1_489600_336000 5.356235
R8377 n1_m1_489600_336000 n1_m1_494400_336000 5.356235
R8378 n1_m1_0_340800 n1_m1_4000_340800 4.463529
R8379 n1_m1_4800_340800 n1_m1_4000_340800 0.892706
R8380 n1_m1_4800_340800 n1_m1_9600_340800 5.356235
R8381 n1_m1_9600_340800 n1_m1_14400_340800 5.356235
R8382 n1_m1_14400_340800 n1_m1_19200_340800 5.356235
R8383 n1_m1_19200_340800 n1_m1_24000_340800 5.356235
R8384 n1_m1_24000_340800 n1_m1_28800_340800 5.356235
R8385 n1_m1_28800_340800 n1_m1_32000_340800 3.570824
R8386 n1_m1_33600_340800 n1_m1_32000_340800 1.785412
R8387 n1_m1_33600_340800 n1_m1_38400_340800 5.356235
R8388 n1_m1_38400_340800 n1_m1_43200_340800 5.356235
R8389 n1_m1_43200_340800 n1_m1_48000_340800 5.356235
R8390 n1_m1_48000_340800 n1_m1_52800_340800 5.356235
R8391 n1_m1_52800_340800 n1_m1_57600_340800 5.356235
R8392 n1_m1_57600_340800 n1_m1_60000_340800 2.678118
R8393 n1_m1_62400_340800 n1_m1_60000_340800 2.678118
R8394 n1_m1_62400_340800 n1_m1_67200_340800 5.356235
R8395 n1_m1_67200_340800 n1_m1_72000_340800 5.356235
R8396 n1_m1_72000_340800 n1_m1_76800_340800 5.356235
R8397 n1_m1_76800_340800 n1_m1_81600_340800 5.356235
R8398 n1_m1_81600_340800 n1_m1_86400_340800 5.356235
R8399 n1_m1_86400_340800 n1_m1_88000_340800 1.785412
R8400 n1_m1_91200_340800 n1_m1_88000_340800 3.570824
R8401 n1_m1_91200_340800 n1_m1_96000_340800 5.356235
R8402 n1_m1_96000_340800 n1_m1_100800_340800 5.356235
R8403 n1_m1_100800_340800 n1_m1_105600_340800 5.356235
R8404 n1_m1_105600_340800 n1_m1_110400_340800 5.356235
R8405 n1_m1_110400_340800 n1_m1_115200_340800 5.356235
R8406 n1_m1_115200_340800 n1_m1_116000_340800 0.892706
R8407 n1_m1_120000_340800 n1_m1_116000_340800 4.463529
R8408 n1_m1_120000_340800 n1_m1_124800_340800 5.356235
R8409 n1_m1_124800_340800 n1_m1_129600_340800 5.356235
R8410 n1_m1_129600_340800 n1_m1_134400_340800 5.356235
R8411 n1_m1_134400_340800 n1_m1_139200_340800 5.356235
R8412 n1_m1_139200_340800 n1_m1_144000_340800 5.356235
R8413 n1_m1_144000_340800 n1_m1_148800_340800 5.356235
R8414 n1_m1_148800_340800 n1_m1_153600_340800 5.356235
R8415 n1_m1_153600_340800 n1_m1_158400_340800 5.356235
R8416 n1_m1_158400_340800 n1_m1_163200_340800 5.356235
R8417 n1_m1_163200_340800 n1_m1_168000_340800 5.356235
R8418 n1_m1_168000_340800 n1_m1_172000_340800 4.463529
R8419 n1_m1_172800_340800 n1_m1_172000_340800 0.892706
R8420 n1_m1_172800_340800 n1_m1_177600_340800 5.356235
R8421 n1_m1_177600_340800 n1_m1_182400_340800 5.356235
R8422 n1_m1_182400_340800 n1_m1_187200_340800 5.356235
R8423 n1_m1_187200_340800 n1_m1_192000_340800 5.356235
R8424 n1_m1_192000_340800 n1_m1_196800_340800 5.356235
R8425 n1_m1_196800_340800 n1_m1_200000_340800 3.570824
R8426 n1_m1_201600_340800 n1_m1_200000_340800 1.785412
R8427 n1_m1_201600_340800 n1_m1_206400_340800 5.356235
R8428 n1_m1_206400_340800 n1_m1_211200_340800 5.356235
R8429 n1_m1_211200_340800 n1_m1_216000_340800 5.356235
R8430 n1_m1_216000_340800 n1_m1_220800_340800 5.356235
R8431 n1_m1_220800_340800 n1_m1_225600_340800 5.356235
R8432 n1_m1_225600_340800 n1_m1_228000_340800 2.678118
R8433 n1_m1_230400_340800 n1_m1_228000_340800 2.678118
R8434 n1_m1_230400_340800 n1_m1_235200_340800 5.356235
R8435 n1_m1_235200_340800 n1_m1_240000_340800 5.356235
R8436 n1_m1_240000_340800 n1_m1_244800_340800 5.356235
R8437 n1_m1_244800_340800 n1_m1_249600_340800 5.356235
R8438 n1_m1_249600_340800 n1_m1_254400_340800 5.356235
R8439 n1_m1_254400_340800 n1_m1_256000_340800 1.785412
R8440 n1_m1_259200_340800 n1_m1_256000_340800 3.570824
R8441 n1_m1_259200_340800 n1_m1_264000_340800 5.356235
R8442 n1_m1_264000_340800 n1_m1_268800_340800 5.356235
R8443 n1_m1_268800_340800 n1_m1_273600_340800 5.356235
R8444 n1_m1_273600_340800 n1_m1_278400_340800 5.356235
R8445 n1_m1_278400_340800 n1_m1_283200_340800 5.356235
R8446 n1_m1_283200_340800 n1_m1_284000_340800 0.892706
R8447 n1_m1_288000_340800 n1_m1_284000_340800 4.463529
R8448 n1_m1_288000_340800 n1_m1_292800_340800 5.356235
R8449 n1_m1_292800_340800 n1_m1_297600_340800 5.356235
R8450 n1_m1_297600_340800 n1_m1_302400_340800 5.356235
R8451 n1_m1_302400_340800 n1_m1_307200_340800 5.356235
R8452 n1_m1_307200_340800 n1_m1_312000_340800 5.356235
R8453 n1_m1_312000_340800 n1_m1_316800_340800 5.356235
R8454 n1_m1_316800_340800 n1_m1_321600_340800 5.356235
R8455 n1_m1_321600_340800 n1_m1_326400_340800 5.356235
R8456 n1_m1_326400_340800 n1_m1_331200_340800 5.356235
R8457 n1_m1_331200_340800 n1_m1_336000_340800 5.356235
R8458 n1_m1_336000_340800 n1_m1_340000_340800 4.463529
R8459 n1_m1_340800_340800 n1_m1_340000_340800 0.892706
R8460 n1_m1_340800_340800 n1_m1_345600_340800 5.356235
R8461 n1_m1_345600_340800 n1_m1_350400_340800 5.356235
R8462 n1_m1_350400_340800 n1_m1_355200_340800 5.356235
R8463 n1_m1_355200_340800 n1_m1_360000_340800 5.356235
R8464 n1_m1_360000_340800 n1_m1_364800_340800 5.356235
R8465 n1_m1_364800_340800 n1_m1_368000_340800 3.570824
R8466 n1_m1_369600_340800 n1_m1_368000_340800 1.785412
R8467 n1_m1_369600_340800 n1_m1_374400_340800 5.356235
R8468 n1_m1_374400_340800 n1_m1_379200_340800 5.356235
R8469 n1_m1_379200_340800 n1_m1_384000_340800 5.356235
R8470 n1_m1_384000_340800 n1_m1_388800_340800 5.356235
R8471 n1_m1_388800_340800 n1_m1_393600_340800 5.356235
R8472 n1_m1_393600_340800 n1_m1_396000_340800 2.678118
R8473 n1_m1_398400_340800 n1_m1_396000_340800 2.678118
R8474 n1_m1_398400_340800 n1_m1_403200_340800 5.356235
R8475 n1_m1_403200_340800 n1_m1_408000_340800 5.356235
R8476 n1_m1_408000_340800 n1_m1_412800_340800 5.356235
R8477 n1_m1_412800_340800 n1_m1_417600_340800 5.356235
R8478 n1_m1_417600_340800 n1_m1_422400_340800 5.356235
R8479 n1_m1_422400_340800 n1_m1_424000_340800 1.785412
R8480 n1_m1_427200_340800 n1_m1_424000_340800 3.570824
R8481 n1_m1_427200_340800 n1_m1_432000_340800 5.356235
R8482 n1_m1_432000_340800 n1_m1_436800_340800 5.356235
R8483 n1_m1_436800_340800 n1_m1_441600_340800 5.356235
R8484 n1_m1_441600_340800 n1_m1_446400_340800 5.356235
R8485 n1_m1_446400_340800 n1_m1_451200_340800 5.356235
R8486 n1_m1_451200_340800 n1_m1_452000_340800 0.892706
R8487 n1_m1_456000_340800 n1_m1_452000_340800 4.463529
R8488 n1_m1_456000_340800 n1_m1_460800_340800 5.356235
R8489 n1_m1_460800_340800 n1_m1_465600_340800 5.356235
R8490 n1_m1_465600_340800 n1_m1_470400_340800 5.356235
R8491 n1_m1_470400_340800 n1_m1_475200_340800 5.356235
R8492 n1_m1_475200_340800 n1_m1_480000_340800 5.356235
R8493 n1_m1_480000_340800 n1_m1_484800_340800 5.356235
R8494 n1_m1_484800_340800 n1_m1_489600_340800 5.356235
R8495 n1_m1_489600_340800 n1_m1_494400_340800 5.356235
R8496 n1_m1_0_345600 n1_m1_4000_345600 4.463529
R8497 n1_m1_4800_345600 n1_m1_4000_345600 0.892706
R8498 n1_m1_4800_345600 n1_m1_9600_345600 5.356235
R8499 n1_m1_9600_345600 n1_m1_14400_345600 5.356235
R8500 n1_m1_14400_345600 n1_m1_19200_345600 5.356235
R8501 n1_m1_19200_345600 n1_m1_24000_345600 5.356235
R8502 n1_m1_24000_345600 n1_m1_28800_345600 5.356235
R8503 n1_m1_28800_345600 n1_m1_32000_345600 3.570824
R8504 n1_m1_33600_345600 n1_m1_32000_345600 1.785412
R8505 n1_m1_33600_345600 n1_m1_38400_345600 5.356235
R8506 n1_m1_38400_345600 n1_m1_43200_345600 5.356235
R8507 n1_m1_43200_345600 n1_m1_48000_345600 5.356235
R8508 n1_m1_48000_345600 n1_m1_52800_345600 5.356235
R8509 n1_m1_52800_345600 n1_m1_57600_345600 5.356235
R8510 n1_m1_57600_345600 n1_m1_60000_345600 2.678118
R8511 n1_m1_62400_345600 n1_m1_60000_345600 2.678118
R8512 n1_m1_62400_345600 n1_m1_67200_345600 5.356235
R8513 n1_m1_67200_345600 n1_m1_72000_345600 5.356235
R8514 n1_m1_72000_345600 n1_m1_76800_345600 5.356235
R8515 n1_m1_76800_345600 n1_m1_81600_345600 5.356235
R8516 n1_m1_81600_345600 n1_m1_86400_345600 5.356235
R8517 n1_m1_86400_345600 n1_m1_88000_345600 1.785412
R8518 n1_m1_91200_345600 n1_m1_88000_345600 3.570824
R8519 n1_m1_91200_345600 n1_m1_96000_345600 5.356235
R8520 n1_m1_96000_345600 n1_m1_100800_345600 5.356235
R8521 n1_m1_100800_345600 n1_m1_105600_345600 5.356235
R8522 n1_m1_105600_345600 n1_m1_110400_345600 5.356235
R8523 n1_m1_110400_345600 n1_m1_115200_345600 5.356235
R8524 n1_m1_115200_345600 n1_m1_116000_345600 0.892706
R8525 n1_m1_120000_345600 n1_m1_116000_345600 4.463529
R8526 n1_m1_120000_345600 n1_m1_124800_345600 5.356235
R8527 n1_m1_124800_345600 n1_m1_129600_345600 5.356235
R8528 n1_m1_129600_345600 n1_m1_134400_345600 5.356235
R8529 n1_m1_134400_345600 n1_m1_139200_345600 5.356235
R8530 n1_m1_139200_345600 n1_m1_144000_345600 5.356235
R8531 n1_m1_144000_345600 n1_m1_148800_345600 5.356235
R8532 n1_m1_148800_345600 n1_m1_153600_345600 5.356235
R8533 n1_m1_153600_345600 n1_m1_158400_345600 5.356235
R8534 n1_m1_158400_345600 n1_m1_163200_345600 5.356235
R8535 n1_m1_163200_345600 n1_m1_168000_345600 5.356235
R8536 n1_m1_168000_345600 n1_m1_172000_345600 4.463529
R8537 n1_m1_172800_345600 n1_m1_172000_345600 0.892706
R8538 n1_m1_172800_345600 n1_m1_177600_345600 5.356235
R8539 n1_m1_177600_345600 n1_m1_182400_345600 5.356235
R8540 n1_m1_182400_345600 n1_m1_187200_345600 5.356235
R8541 n1_m1_187200_345600 n1_m1_192000_345600 5.356235
R8542 n1_m1_192000_345600 n1_m1_196800_345600 5.356235
R8543 n1_m1_196800_345600 n1_m1_200000_345600 3.570824
R8544 n1_m1_201600_345600 n1_m1_200000_345600 1.785412
R8545 n1_m1_201600_345600 n1_m1_206400_345600 5.356235
R8546 n1_m1_206400_345600 n1_m1_211200_345600 5.356235
R8547 n1_m1_211200_345600 n1_m1_216000_345600 5.356235
R8548 n1_m1_216000_345600 n1_m1_220800_345600 5.356235
R8549 n1_m1_220800_345600 n1_m1_225600_345600 5.356235
R8550 n1_m1_225600_345600 n1_m1_228000_345600 2.678118
R8551 n1_m1_230400_345600 n1_m1_228000_345600 2.678118
R8552 n1_m1_230400_345600 n1_m1_235200_345600 5.356235
R8553 n1_m1_235200_345600 n1_m1_240000_345600 5.356235
R8554 n1_m1_240000_345600 n1_m1_244800_345600 5.356235
R8555 n1_m1_244800_345600 n1_m1_249600_345600 5.356235
R8556 n1_m1_249600_345600 n1_m1_254400_345600 5.356235
R8557 n1_m1_254400_345600 n1_m1_256000_345600 1.785412
R8558 n1_m1_259200_345600 n1_m1_256000_345600 3.570824
R8559 n1_m1_259200_345600 n1_m1_264000_345600 5.356235
R8560 n1_m1_264000_345600 n1_m1_268800_345600 5.356235
R8561 n1_m1_268800_345600 n1_m1_273600_345600 5.356235
R8562 n1_m1_273600_345600 n1_m1_278400_345600 5.356235
R8563 n1_m1_278400_345600 n1_m1_283200_345600 5.356235
R8564 n1_m1_283200_345600 n1_m1_284000_345600 0.892706
R8565 n1_m1_288000_345600 n1_m1_284000_345600 4.463529
R8566 n1_m1_288000_345600 n1_m1_292800_345600 5.356235
R8567 n1_m1_292800_345600 n1_m1_297600_345600 5.356235
R8568 n1_m1_297600_345600 n1_m1_302400_345600 5.356235
R8569 n1_m1_302400_345600 n1_m1_307200_345600 5.356235
R8570 n1_m1_307200_345600 n1_m1_312000_345600 5.356235
R8571 n1_m1_312000_345600 n1_m1_316800_345600 5.356235
R8572 n1_m1_316800_345600 n1_m1_321600_345600 5.356235
R8573 n1_m1_321600_345600 n1_m1_326400_345600 5.356235
R8574 n1_m1_326400_345600 n1_m1_331200_345600 5.356235
R8575 n1_m1_331200_345600 n1_m1_336000_345600 5.356235
R8576 n1_m1_336000_345600 n1_m1_340000_345600 4.463529
R8577 n1_m1_340800_345600 n1_m1_340000_345600 0.892706
R8578 n1_m1_340800_345600 n1_m1_345600_345600 5.356235
R8579 n1_m1_345600_345600 n1_m1_350400_345600 5.356235
R8580 n1_m1_350400_345600 n1_m1_355200_345600 5.356235
R8581 n1_m1_355200_345600 n1_m1_360000_345600 5.356235
R8582 n1_m1_360000_345600 n1_m1_364800_345600 5.356235
R8583 n1_m1_364800_345600 n1_m1_368000_345600 3.570824
R8584 n1_m1_369600_345600 n1_m1_368000_345600 1.785412
R8585 n1_m1_369600_345600 n1_m1_374400_345600 5.356235
R8586 n1_m1_374400_345600 n1_m1_379200_345600 5.356235
R8587 n1_m1_379200_345600 n1_m1_384000_345600 5.356235
R8588 n1_m1_384000_345600 n1_m1_388800_345600 5.356235
R8589 n1_m1_388800_345600 n1_m1_393600_345600 5.356235
R8590 n1_m1_393600_345600 n1_m1_396000_345600 2.678118
R8591 n1_m1_398400_345600 n1_m1_396000_345600 2.678118
R8592 n1_m1_398400_345600 n1_m1_403200_345600 5.356235
R8593 n1_m1_403200_345600 n1_m1_408000_345600 5.356235
R8594 n1_m1_408000_345600 n1_m1_412800_345600 5.356235
R8595 n1_m1_412800_345600 n1_m1_417600_345600 5.356235
R8596 n1_m1_417600_345600 n1_m1_422400_345600 5.356235
R8597 n1_m1_422400_345600 n1_m1_424000_345600 1.785412
R8598 n1_m1_427200_345600 n1_m1_424000_345600 3.570824
R8599 n1_m1_427200_345600 n1_m1_432000_345600 5.356235
R8600 n1_m1_432000_345600 n1_m1_436800_345600 5.356235
R8601 n1_m1_436800_345600 n1_m1_441600_345600 5.356235
R8602 n1_m1_441600_345600 n1_m1_446400_345600 5.356235
R8603 n1_m1_446400_345600 n1_m1_451200_345600 5.356235
R8604 n1_m1_451200_345600 n1_m1_452000_345600 0.892706
R8605 n1_m1_456000_345600 n1_m1_452000_345600 4.463529
R8606 n1_m1_456000_345600 n1_m1_460800_345600 5.356235
R8607 n1_m1_460800_345600 n1_m1_465600_345600 5.356235
R8608 n1_m1_465600_345600 n1_m1_470400_345600 5.356235
R8609 n1_m1_470400_345600 n1_m1_475200_345600 5.356235
R8610 n1_m1_475200_345600 n1_m1_480000_345600 5.356235
R8611 n1_m1_480000_345600 n1_m1_484800_345600 5.356235
R8612 n1_m1_484800_345600 n1_m1_489600_345600 5.356235
R8613 n1_m1_489600_345600 n1_m1_494400_345600 5.356235
R8614 n1_m1_0_350400 n1_m1_4000_350400 4.463529
R8615 n1_m1_4800_350400 n1_m1_4000_350400 0.892706
R8616 n1_m1_4800_350400 n1_m1_9600_350400 5.356235
R8617 n1_m1_9600_350400 n1_m1_14400_350400 5.356235
R8618 n1_m1_14400_350400 n1_m1_19200_350400 5.356235
R8619 n1_m1_19200_350400 n1_m1_24000_350400 5.356235
R8620 n1_m1_24000_350400 n1_m1_28800_350400 5.356235
R8621 n1_m1_28800_350400 n1_m1_32000_350400 3.570824
R8622 n1_m1_33600_350400 n1_m1_32000_350400 1.785412
R8623 n1_m1_33600_350400 n1_m1_38400_350400 5.356235
R8624 n1_m1_38400_350400 n1_m1_43200_350400 5.356235
R8625 n1_m1_43200_350400 n1_m1_48000_350400 5.356235
R8626 n1_m1_48000_350400 n1_m1_52800_350400 5.356235
R8627 n1_m1_52800_350400 n1_m1_57600_350400 5.356235
R8628 n1_m1_57600_350400 n1_m1_60000_350400 2.678118
R8629 n1_m1_62400_350400 n1_m1_60000_350400 2.678118
R8630 n1_m1_62400_350400 n1_m1_67200_350400 5.356235
R8631 n1_m1_67200_350400 n1_m1_72000_350400 5.356235
R8632 n1_m1_72000_350400 n1_m1_76800_350400 5.356235
R8633 n1_m1_76800_350400 n1_m1_81600_350400 5.356235
R8634 n1_m1_81600_350400 n1_m1_86400_350400 5.356235
R8635 n1_m1_86400_350400 n1_m1_88000_350400 1.785412
R8636 n1_m1_91200_350400 n1_m1_88000_350400 3.570824
R8637 n1_m1_91200_350400 n1_m1_96000_350400 5.356235
R8638 n1_m1_96000_350400 n1_m1_100800_350400 5.356235
R8639 n1_m1_100800_350400 n1_m1_105600_350400 5.356235
R8640 n1_m1_105600_350400 n1_m1_110400_350400 5.356235
R8641 n1_m1_110400_350400 n1_m1_115200_350400 5.356235
R8642 n1_m1_115200_350400 n1_m1_116000_350400 0.892706
R8643 n1_m1_120000_350400 n1_m1_116000_350400 4.463529
R8644 n1_m1_120000_350400 n1_m1_124800_350400 5.356235
R8645 n1_m1_124800_350400 n1_m1_129600_350400 5.356235
R8646 n1_m1_129600_350400 n1_m1_134400_350400 5.356235
R8647 n1_m1_134400_350400 n1_m1_139200_350400 5.356235
R8648 n1_m1_139200_350400 n1_m1_144000_350400 5.356235
R8649 n1_m1_144000_350400 n1_m1_148800_350400 5.356235
R8650 n1_m1_148800_350400 n1_m1_153600_350400 5.356235
R8651 n1_m1_153600_350400 n1_m1_158400_350400 5.356235
R8652 n1_m1_158400_350400 n1_m1_163200_350400 5.356235
R8653 n1_m1_163200_350400 n1_m1_168000_350400 5.356235
R8654 n1_m1_168000_350400 n1_m1_172000_350400 4.463529
R8655 n1_m1_172800_350400 n1_m1_172000_350400 0.892706
R8656 n1_m1_172800_350400 n1_m1_177600_350400 5.356235
R8657 n1_m1_177600_350400 n1_m1_182400_350400 5.356235
R8658 n1_m1_182400_350400 n1_m1_187200_350400 5.356235
R8659 n1_m1_187200_350400 n1_m1_192000_350400 5.356235
R8660 n1_m1_192000_350400 n1_m1_196800_350400 5.356235
R8661 n1_m1_196800_350400 n1_m1_200000_350400 3.570824
R8662 n1_m1_201600_350400 n1_m1_200000_350400 1.785412
R8663 n1_m1_201600_350400 n1_m1_206400_350400 5.356235
R8664 n1_m1_206400_350400 n1_m1_211200_350400 5.356235
R8665 n1_m1_211200_350400 n1_m1_216000_350400 5.356235
R8666 n1_m1_216000_350400 n1_m1_220800_350400 5.356235
R8667 n1_m1_220800_350400 n1_m1_225600_350400 5.356235
R8668 n1_m1_225600_350400 n1_m1_228000_350400 2.678118
R8669 n1_m1_230400_350400 n1_m1_228000_350400 2.678118
R8670 n1_m1_230400_350400 n1_m1_235200_350400 5.356235
R8671 n1_m1_235200_350400 n1_m1_240000_350400 5.356235
R8672 n1_m1_240000_350400 n1_m1_244800_350400 5.356235
R8673 n1_m1_244800_350400 n1_m1_249600_350400 5.356235
R8674 n1_m1_249600_350400 n1_m1_254400_350400 5.356235
R8675 n1_m1_254400_350400 n1_m1_256000_350400 1.785412
R8676 n1_m1_259200_350400 n1_m1_256000_350400 3.570824
R8677 n1_m1_259200_350400 n1_m1_264000_350400 5.356235
R8678 n1_m1_264000_350400 n1_m1_268800_350400 5.356235
R8679 n1_m1_268800_350400 n1_m1_273600_350400 5.356235
R8680 n1_m1_273600_350400 n1_m1_278400_350400 5.356235
R8681 n1_m1_278400_350400 n1_m1_283200_350400 5.356235
R8682 n1_m1_283200_350400 n1_m1_284000_350400 0.892706
R8683 n1_m1_288000_350400 n1_m1_284000_350400 4.463529
R8684 n1_m1_288000_350400 n1_m1_292800_350400 5.356235
R8685 n1_m1_292800_350400 n1_m1_297600_350400 5.356235
R8686 n1_m1_297600_350400 n1_m1_302400_350400 5.356235
R8687 n1_m1_302400_350400 n1_m1_307200_350400 5.356235
R8688 n1_m1_307200_350400 n1_m1_312000_350400 5.356235
R8689 n1_m1_312000_350400 n1_m1_316800_350400 5.356235
R8690 n1_m1_316800_350400 n1_m1_321600_350400 5.356235
R8691 n1_m1_321600_350400 n1_m1_326400_350400 5.356235
R8692 n1_m1_326400_350400 n1_m1_331200_350400 5.356235
R8693 n1_m1_331200_350400 n1_m1_336000_350400 5.356235
R8694 n1_m1_336000_350400 n1_m1_340000_350400 4.463529
R8695 n1_m1_340800_350400 n1_m1_340000_350400 0.892706
R8696 n1_m1_340800_350400 n1_m1_345600_350400 5.356235
R8697 n1_m1_345600_350400 n1_m1_350400_350400 5.356235
R8698 n1_m1_350400_350400 n1_m1_355200_350400 5.356235
R8699 n1_m1_355200_350400 n1_m1_360000_350400 5.356235
R8700 n1_m1_360000_350400 n1_m1_364800_350400 5.356235
R8701 n1_m1_364800_350400 n1_m1_368000_350400 3.570824
R8702 n1_m1_369600_350400 n1_m1_368000_350400 1.785412
R8703 n1_m1_369600_350400 n1_m1_374400_350400 5.356235
R8704 n1_m1_374400_350400 n1_m1_379200_350400 5.356235
R8705 n1_m1_379200_350400 n1_m1_384000_350400 5.356235
R8706 n1_m1_384000_350400 n1_m1_388800_350400 5.356235
R8707 n1_m1_388800_350400 n1_m1_393600_350400 5.356235
R8708 n1_m1_393600_350400 n1_m1_396000_350400 2.678118
R8709 n1_m1_398400_350400 n1_m1_396000_350400 2.678118
R8710 n1_m1_398400_350400 n1_m1_403200_350400 5.356235
R8711 n1_m1_403200_350400 n1_m1_408000_350400 5.356235
R8712 n1_m1_408000_350400 n1_m1_412800_350400 5.356235
R8713 n1_m1_412800_350400 n1_m1_417600_350400 5.356235
R8714 n1_m1_417600_350400 n1_m1_422400_350400 5.356235
R8715 n1_m1_422400_350400 n1_m1_424000_350400 1.785412
R8716 n1_m1_427200_350400 n1_m1_424000_350400 3.570824
R8717 n1_m1_427200_350400 n1_m1_432000_350400 5.356235
R8718 n1_m1_432000_350400 n1_m1_436800_350400 5.356235
R8719 n1_m1_436800_350400 n1_m1_441600_350400 5.356235
R8720 n1_m1_441600_350400 n1_m1_446400_350400 5.356235
R8721 n1_m1_446400_350400 n1_m1_451200_350400 5.356235
R8722 n1_m1_451200_350400 n1_m1_452000_350400 0.892706
R8723 n1_m1_456000_350400 n1_m1_452000_350400 4.463529
R8724 n1_m1_456000_350400 n1_m1_460800_350400 5.356235
R8725 n1_m1_460800_350400 n1_m1_465600_350400 5.356235
R8726 n1_m1_465600_350400 n1_m1_470400_350400 5.356235
R8727 n1_m1_470400_350400 n1_m1_475200_350400 5.356235
R8728 n1_m1_475200_350400 n1_m1_480000_350400 5.356235
R8729 n1_m1_480000_350400 n1_m1_484800_350400 5.356235
R8730 n1_m1_484800_350400 n1_m1_489600_350400 5.356235
R8731 n1_m1_489600_350400 n1_m1_494400_350400 5.356235
R8732 n1_m1_0_355200 n1_m1_4000_355200 4.463529
R8733 n1_m1_4800_355200 n1_m1_4000_355200 0.892706
R8734 n1_m1_4800_355200 n1_m1_9600_355200 5.356235
R8735 n1_m1_9600_355200 n1_m1_14400_355200 5.356235
R8736 n1_m1_14400_355200 n1_m1_19200_355200 5.356235
R8737 n1_m1_19200_355200 n1_m1_24000_355200 5.356235
R8738 n1_m1_24000_355200 n1_m1_28800_355200 5.356235
R8739 n1_m1_28800_355200 n1_m1_32000_355200 3.570824
R8740 n1_m1_33600_355200 n1_m1_32000_355200 1.785412
R8741 n1_m1_33600_355200 n1_m1_38400_355200 5.356235
R8742 n1_m1_38400_355200 n1_m1_43200_355200 5.356235
R8743 n1_m1_43200_355200 n1_m1_48000_355200 5.356235
R8744 n1_m1_48000_355200 n1_m1_52800_355200 5.356235
R8745 n1_m1_52800_355200 n1_m1_57600_355200 5.356235
R8746 n1_m1_57600_355200 n1_m1_60000_355200 2.678118
R8747 n1_m1_62400_355200 n1_m1_60000_355200 2.678118
R8748 n1_m1_62400_355200 n1_m1_67200_355200 5.356235
R8749 n1_m1_67200_355200 n1_m1_72000_355200 5.356235
R8750 n1_m1_72000_355200 n1_m1_76800_355200 5.356235
R8751 n1_m1_76800_355200 n1_m1_81600_355200 5.356235
R8752 n1_m1_81600_355200 n1_m1_86400_355200 5.356235
R8753 n1_m1_86400_355200 n1_m1_88000_355200 1.785412
R8754 n1_m1_91200_355200 n1_m1_88000_355200 3.570824
R8755 n1_m1_91200_355200 n1_m1_96000_355200 5.356235
R8756 n1_m1_96000_355200 n1_m1_100800_355200 5.356235
R8757 n1_m1_100800_355200 n1_m1_105600_355200 5.356235
R8758 n1_m1_105600_355200 n1_m1_110400_355200 5.356235
R8759 n1_m1_110400_355200 n1_m1_115200_355200 5.356235
R8760 n1_m1_115200_355200 n1_m1_116000_355200 0.892706
R8761 n1_m1_120000_355200 n1_m1_116000_355200 4.463529
R8762 n1_m1_120000_355200 n1_m1_124800_355200 5.356235
R8763 n1_m1_124800_355200 n1_m1_129600_355200 5.356235
R8764 n1_m1_129600_355200 n1_m1_134400_355200 5.356235
R8765 n1_m1_134400_355200 n1_m1_139200_355200 5.356235
R8766 n1_m1_139200_355200 n1_m1_144000_355200 5.356235
R8767 n1_m1_144000_355200 n1_m1_148800_355200 5.356235
R8768 n1_m1_148800_355200 n1_m1_153600_355200 5.356235
R8769 n1_m1_153600_355200 n1_m1_158400_355200 5.356235
R8770 n1_m1_158400_355200 n1_m1_163200_355200 5.356235
R8771 n1_m1_163200_355200 n1_m1_168000_355200 5.356235
R8772 n1_m1_168000_355200 n1_m1_172000_355200 4.463529
R8773 n1_m1_172800_355200 n1_m1_172000_355200 0.892706
R8774 n1_m1_172800_355200 n1_m1_177600_355200 5.356235
R8775 n1_m1_177600_355200 n1_m1_182400_355200 5.356235
R8776 n1_m1_182400_355200 n1_m1_187200_355200 5.356235
R8777 n1_m1_187200_355200 n1_m1_192000_355200 5.356235
R8778 n1_m1_192000_355200 n1_m1_196800_355200 5.356235
R8779 n1_m1_196800_355200 n1_m1_200000_355200 3.570824
R8780 n1_m1_201600_355200 n1_m1_200000_355200 1.785412
R8781 n1_m1_201600_355200 n1_m1_206400_355200 5.356235
R8782 n1_m1_206400_355200 n1_m1_211200_355200 5.356235
R8783 n1_m1_211200_355200 n1_m1_216000_355200 5.356235
R8784 n1_m1_216000_355200 n1_m1_220800_355200 5.356235
R8785 n1_m1_220800_355200 n1_m1_225600_355200 5.356235
R8786 n1_m1_225600_355200 n1_m1_228000_355200 2.678118
R8787 n1_m1_230400_355200 n1_m1_228000_355200 2.678118
R8788 n1_m1_230400_355200 n1_m1_235200_355200 5.356235
R8789 n1_m1_235200_355200 n1_m1_240000_355200 5.356235
R8790 n1_m1_240000_355200 n1_m1_244800_355200 5.356235
R8791 n1_m1_244800_355200 n1_m1_249600_355200 5.356235
R8792 n1_m1_249600_355200 n1_m1_254400_355200 5.356235
R8793 n1_m1_254400_355200 n1_m1_256000_355200 1.785412
R8794 n1_m1_259200_355200 n1_m1_256000_355200 3.570824
R8795 n1_m1_259200_355200 n1_m1_264000_355200 5.356235
R8796 n1_m1_264000_355200 n1_m1_268800_355200 5.356235
R8797 n1_m1_268800_355200 n1_m1_273600_355200 5.356235
R8798 n1_m1_273600_355200 n1_m1_278400_355200 5.356235
R8799 n1_m1_278400_355200 n1_m1_283200_355200 5.356235
R8800 n1_m1_283200_355200 n1_m1_284000_355200 0.892706
R8801 n1_m1_288000_355200 n1_m1_284000_355200 4.463529
R8802 n1_m1_288000_355200 n1_m1_292800_355200 5.356235
R8803 n1_m1_292800_355200 n1_m1_297600_355200 5.356235
R8804 n1_m1_297600_355200 n1_m1_302400_355200 5.356235
R8805 n1_m1_302400_355200 n1_m1_307200_355200 5.356235
R8806 n1_m1_307200_355200 n1_m1_312000_355200 5.356235
R8807 n1_m1_312000_355200 n1_m1_316800_355200 5.356235
R8808 n1_m1_316800_355200 n1_m1_321600_355200 5.356235
R8809 n1_m1_321600_355200 n1_m1_326400_355200 5.356235
R8810 n1_m1_326400_355200 n1_m1_331200_355200 5.356235
R8811 n1_m1_331200_355200 n1_m1_336000_355200 5.356235
R8812 n1_m1_336000_355200 n1_m1_340000_355200 4.463529
R8813 n1_m1_340800_355200 n1_m1_340000_355200 0.892706
R8814 n1_m1_340800_355200 n1_m1_345600_355200 5.356235
R8815 n1_m1_345600_355200 n1_m1_350400_355200 5.356235
R8816 n1_m1_350400_355200 n1_m1_355200_355200 5.356235
R8817 n1_m1_355200_355200 n1_m1_360000_355200 5.356235
R8818 n1_m1_360000_355200 n1_m1_364800_355200 5.356235
R8819 n1_m1_364800_355200 n1_m1_368000_355200 3.570824
R8820 n1_m1_369600_355200 n1_m1_368000_355200 1.785412
R8821 n1_m1_369600_355200 n1_m1_374400_355200 5.356235
R8822 n1_m1_374400_355200 n1_m1_379200_355200 5.356235
R8823 n1_m1_379200_355200 n1_m1_384000_355200 5.356235
R8824 n1_m1_384000_355200 n1_m1_388800_355200 5.356235
R8825 n1_m1_388800_355200 n1_m1_393600_355200 5.356235
R8826 n1_m1_393600_355200 n1_m1_396000_355200 2.678118
R8827 n1_m1_398400_355200 n1_m1_396000_355200 2.678118
R8828 n1_m1_398400_355200 n1_m1_403200_355200 5.356235
R8829 n1_m1_403200_355200 n1_m1_408000_355200 5.356235
R8830 n1_m1_408000_355200 n1_m1_412800_355200 5.356235
R8831 n1_m1_412800_355200 n1_m1_417600_355200 5.356235
R8832 n1_m1_417600_355200 n1_m1_422400_355200 5.356235
R8833 n1_m1_422400_355200 n1_m1_424000_355200 1.785412
R8834 n1_m1_427200_355200 n1_m1_424000_355200 3.570824
R8835 n1_m1_427200_355200 n1_m1_432000_355200 5.356235
R8836 n1_m1_432000_355200 n1_m1_436800_355200 5.356235
R8837 n1_m1_436800_355200 n1_m1_441600_355200 5.356235
R8838 n1_m1_441600_355200 n1_m1_446400_355200 5.356235
R8839 n1_m1_446400_355200 n1_m1_451200_355200 5.356235
R8840 n1_m1_451200_355200 n1_m1_452000_355200 0.892706
R8841 n1_m1_456000_355200 n1_m1_452000_355200 4.463529
R8842 n1_m1_456000_355200 n1_m1_460800_355200 5.356235
R8843 n1_m1_460800_355200 n1_m1_465600_355200 5.356235
R8844 n1_m1_465600_355200 n1_m1_470400_355200 5.356235
R8845 n1_m1_470400_355200 n1_m1_475200_355200 5.356235
R8846 n1_m1_475200_355200 n1_m1_480000_355200 5.356235
R8847 n1_m1_480000_355200 n1_m1_484800_355200 5.356235
R8848 n1_m1_484800_355200 n1_m1_489600_355200 5.356235
R8849 n1_m1_489600_355200 n1_m1_494400_355200 5.356235
R8850 n1_m1_0_360000 n1_m1_4000_360000 4.463529
R8851 n1_m1_4800_360000 n1_m1_4000_360000 0.892706
R8852 n1_m1_4800_360000 n1_m1_9600_360000 5.356235
R8853 n1_m1_9600_360000 n1_m1_14400_360000 5.356235
R8854 n1_m1_14400_360000 n1_m1_19200_360000 5.356235
R8855 n1_m1_19200_360000 n1_m1_24000_360000 5.356235
R8856 n1_m1_24000_360000 n1_m1_28800_360000 5.356235
R8857 n1_m1_28800_360000 n1_m1_32000_360000 3.570824
R8858 n1_m1_33600_360000 n1_m1_32000_360000 1.785412
R8859 n1_m1_33600_360000 n1_m1_38400_360000 5.356235
R8860 n1_m1_38400_360000 n1_m1_43200_360000 5.356235
R8861 n1_m1_43200_360000 n1_m1_48000_360000 5.356235
R8862 n1_m1_48000_360000 n1_m1_52800_360000 5.356235
R8863 n1_m1_52800_360000 n1_m1_57600_360000 5.356235
R8864 n1_m1_57600_360000 n1_m1_60000_360000 2.678118
R8865 n1_m1_62400_360000 n1_m1_60000_360000 2.678118
R8866 n1_m1_62400_360000 n1_m1_67200_360000 5.356235
R8867 n1_m1_67200_360000 n1_m1_72000_360000 5.356235
R8868 n1_m1_72000_360000 n1_m1_76800_360000 5.356235
R8869 n1_m1_76800_360000 n1_m1_81600_360000 5.356235
R8870 n1_m1_81600_360000 n1_m1_86400_360000 5.356235
R8871 n1_m1_86400_360000 n1_m1_88000_360000 1.785412
R8872 n1_m1_91200_360000 n1_m1_88000_360000 3.570824
R8873 n1_m1_91200_360000 n1_m1_96000_360000 5.356235
R8874 n1_m1_96000_360000 n1_m1_100800_360000 5.356235
R8875 n1_m1_100800_360000 n1_m1_105600_360000 5.356235
R8876 n1_m1_105600_360000 n1_m1_110400_360000 5.356235
R8877 n1_m1_110400_360000 n1_m1_115200_360000 5.356235
R8878 n1_m1_115200_360000 n1_m1_116000_360000 0.892706
R8879 n1_m1_120000_360000 n1_m1_116000_360000 4.463529
R8880 n1_m1_120000_360000 n1_m1_124800_360000 5.356235
R8881 n1_m1_124800_360000 n1_m1_129600_360000 5.356235
R8882 n1_m1_129600_360000 n1_m1_134400_360000 5.356235
R8883 n1_m1_134400_360000 n1_m1_139200_360000 5.356235
R8884 n1_m1_139200_360000 n1_m1_144000_360000 5.356235
R8885 n1_m1_144000_360000 n1_m1_148800_360000 5.356235
R8886 n1_m1_148800_360000 n1_m1_153600_360000 5.356235
R8887 n1_m1_153600_360000 n1_m1_158400_360000 5.356235
R8888 n1_m1_158400_360000 n1_m1_163200_360000 5.356235
R8889 n1_m1_163200_360000 n1_m1_168000_360000 5.356235
R8890 n1_m1_168000_360000 n1_m1_172000_360000 4.463529
R8891 n1_m1_172800_360000 n1_m1_172000_360000 0.892706
R8892 n1_m1_172800_360000 n1_m1_177600_360000 5.356235
R8893 n1_m1_177600_360000 n1_m1_182400_360000 5.356235
R8894 n1_m1_182400_360000 n1_m1_187200_360000 5.356235
R8895 n1_m1_187200_360000 n1_m1_192000_360000 5.356235
R8896 n1_m1_192000_360000 n1_m1_196800_360000 5.356235
R8897 n1_m1_196800_360000 n1_m1_200000_360000 3.570824
R8898 n1_m1_201600_360000 n1_m1_200000_360000 1.785412
R8899 n1_m1_201600_360000 n1_m1_206400_360000 5.356235
R8900 n1_m1_206400_360000 n1_m1_211200_360000 5.356235
R8901 n1_m1_211200_360000 n1_m1_216000_360000 5.356235
R8902 n1_m1_216000_360000 n1_m1_220800_360000 5.356235
R8903 n1_m1_220800_360000 n1_m1_225600_360000 5.356235
R8904 n1_m1_225600_360000 n1_m1_228000_360000 2.678118
R8905 n1_m1_230400_360000 n1_m1_228000_360000 2.678118
R8906 n1_m1_230400_360000 n1_m1_235200_360000 5.356235
R8907 n1_m1_235200_360000 n1_m1_240000_360000 5.356235
R8908 n1_m1_240000_360000 n1_m1_244800_360000 5.356235
R8909 n1_m1_244800_360000 n1_m1_249600_360000 5.356235
R8910 n1_m1_249600_360000 n1_m1_254400_360000 5.356235
R8911 n1_m1_254400_360000 n1_m1_256000_360000 1.785412
R8912 n1_m1_259200_360000 n1_m1_256000_360000 3.570824
R8913 n1_m1_259200_360000 n1_m1_264000_360000 5.356235
R8914 n1_m1_264000_360000 n1_m1_268800_360000 5.356235
R8915 n1_m1_268800_360000 n1_m1_273600_360000 5.356235
R8916 n1_m1_273600_360000 n1_m1_278400_360000 5.356235
R8917 n1_m1_278400_360000 n1_m1_283200_360000 5.356235
R8918 n1_m1_283200_360000 n1_m1_284000_360000 0.892706
R8919 n1_m1_288000_360000 n1_m1_284000_360000 4.463529
R8920 n1_m1_288000_360000 n1_m1_292800_360000 5.356235
R8921 n1_m1_292800_360000 n1_m1_297600_360000 5.356235
R8922 n1_m1_297600_360000 n1_m1_302400_360000 5.356235
R8923 n1_m1_302400_360000 n1_m1_307200_360000 5.356235
R8924 n1_m1_307200_360000 n1_m1_312000_360000 5.356235
R8925 n1_m1_312000_360000 n1_m1_316800_360000 5.356235
R8926 n1_m1_316800_360000 n1_m1_321600_360000 5.356235
R8927 n1_m1_321600_360000 n1_m1_326400_360000 5.356235
R8928 n1_m1_326400_360000 n1_m1_331200_360000 5.356235
R8929 n1_m1_331200_360000 n1_m1_336000_360000 5.356235
R8930 n1_m1_336000_360000 n1_m1_340000_360000 4.463529
R8931 n1_m1_340800_360000 n1_m1_340000_360000 0.892706
R8932 n1_m1_340800_360000 n1_m1_345600_360000 5.356235
R8933 n1_m1_345600_360000 n1_m1_350400_360000 5.356235
R8934 n1_m1_350400_360000 n1_m1_355200_360000 5.356235
R8935 n1_m1_355200_360000 n1_m1_360000_360000 5.356235
R8936 n1_m1_360000_360000 n1_m1_364800_360000 5.356235
R8937 n1_m1_364800_360000 n1_m1_368000_360000 3.570824
R8938 n1_m1_369600_360000 n1_m1_368000_360000 1.785412
R8939 n1_m1_369600_360000 n1_m1_374400_360000 5.356235
R8940 n1_m1_374400_360000 n1_m1_379200_360000 5.356235
R8941 n1_m1_379200_360000 n1_m1_384000_360000 5.356235
R8942 n1_m1_384000_360000 n1_m1_388800_360000 5.356235
R8943 n1_m1_388800_360000 n1_m1_393600_360000 5.356235
R8944 n1_m1_393600_360000 n1_m1_396000_360000 2.678118
R8945 n1_m1_398400_360000 n1_m1_396000_360000 2.678118
R8946 n1_m1_398400_360000 n1_m1_403200_360000 5.356235
R8947 n1_m1_403200_360000 n1_m1_408000_360000 5.356235
R8948 n1_m1_408000_360000 n1_m1_412800_360000 5.356235
R8949 n1_m1_412800_360000 n1_m1_417600_360000 5.356235
R8950 n1_m1_417600_360000 n1_m1_422400_360000 5.356235
R8951 n1_m1_422400_360000 n1_m1_424000_360000 1.785412
R8952 n1_m1_427200_360000 n1_m1_424000_360000 3.570824
R8953 n1_m1_427200_360000 n1_m1_432000_360000 5.356235
R8954 n1_m1_432000_360000 n1_m1_436800_360000 5.356235
R8955 n1_m1_436800_360000 n1_m1_441600_360000 5.356235
R8956 n1_m1_441600_360000 n1_m1_446400_360000 5.356235
R8957 n1_m1_446400_360000 n1_m1_451200_360000 5.356235
R8958 n1_m1_451200_360000 n1_m1_452000_360000 0.892706
R8959 n1_m1_456000_360000 n1_m1_452000_360000 4.463529
R8960 n1_m1_456000_360000 n1_m1_460800_360000 5.356235
R8961 n1_m1_460800_360000 n1_m1_465600_360000 5.356235
R8962 n1_m1_465600_360000 n1_m1_470400_360000 5.356235
R8963 n1_m1_470400_360000 n1_m1_475200_360000 5.356235
R8964 n1_m1_475200_360000 n1_m1_480000_360000 5.356235
R8965 n1_m1_480000_360000 n1_m1_484800_360000 5.356235
R8966 n1_m1_484800_360000 n1_m1_489600_360000 5.356235
R8967 n1_m1_489600_360000 n1_m1_494400_360000 5.356235
R8968 n1_m1_0_364800 n1_m1_4000_364800 4.463529
R8969 n1_m1_4800_364800 n1_m1_4000_364800 0.892706
R8970 n1_m1_4800_364800 n1_m1_9600_364800 5.356235
R8971 n1_m1_9600_364800 n1_m1_14400_364800 5.356235
R8972 n1_m1_14400_364800 n1_m1_19200_364800 5.356235
R8973 n1_m1_19200_364800 n1_m1_24000_364800 5.356235
R8974 n1_m1_24000_364800 n1_m1_28800_364800 5.356235
R8975 n1_m1_28800_364800 n1_m1_32000_364800 3.570824
R8976 n1_m1_33600_364800 n1_m1_32000_364800 1.785412
R8977 n1_m1_33600_364800 n1_m1_38400_364800 5.356235
R8978 n1_m1_38400_364800 n1_m1_43200_364800 5.356235
R8979 n1_m1_43200_364800 n1_m1_48000_364800 5.356235
R8980 n1_m1_48000_364800 n1_m1_52800_364800 5.356235
R8981 n1_m1_52800_364800 n1_m1_57600_364800 5.356235
R8982 n1_m1_57600_364800 n1_m1_60000_364800 2.678118
R8983 n1_m1_62400_364800 n1_m1_60000_364800 2.678118
R8984 n1_m1_62400_364800 n1_m1_67200_364800 5.356235
R8985 n1_m1_67200_364800 n1_m1_72000_364800 5.356235
R8986 n1_m1_72000_364800 n1_m1_76800_364800 5.356235
R8987 n1_m1_76800_364800 n1_m1_81600_364800 5.356235
R8988 n1_m1_81600_364800 n1_m1_86400_364800 5.356235
R8989 n1_m1_86400_364800 n1_m1_88000_364800 1.785412
R8990 n1_m1_91200_364800 n1_m1_88000_364800 3.570824
R8991 n1_m1_91200_364800 n1_m1_96000_364800 5.356235
R8992 n1_m1_96000_364800 n1_m1_100800_364800 5.356235
R8993 n1_m1_100800_364800 n1_m1_105600_364800 5.356235
R8994 n1_m1_105600_364800 n1_m1_110400_364800 5.356235
R8995 n1_m1_110400_364800 n1_m1_115200_364800 5.356235
R8996 n1_m1_115200_364800 n1_m1_116000_364800 0.892706
R8997 n1_m1_120000_364800 n1_m1_116000_364800 4.463529
R8998 n1_m1_120000_364800 n1_m1_124800_364800 5.356235
R8999 n1_m1_124800_364800 n1_m1_129600_364800 5.356235
R9000 n1_m1_129600_364800 n1_m1_134400_364800 5.356235
R9001 n1_m1_134400_364800 n1_m1_139200_364800 5.356235
R9002 n1_m1_139200_364800 n1_m1_144000_364800 5.356235
R9003 n1_m1_144000_364800 n1_m1_148800_364800 5.356235
R9004 n1_m1_148800_364800 n1_m1_153600_364800 5.356235
R9005 n1_m1_153600_364800 n1_m1_158400_364800 5.356235
R9006 n1_m1_158400_364800 n1_m1_163200_364800 5.356235
R9007 n1_m1_163200_364800 n1_m1_168000_364800 5.356235
R9008 n1_m1_168000_364800 n1_m1_172000_364800 4.463529
R9009 n1_m1_172800_364800 n1_m1_172000_364800 0.892706
R9010 n1_m1_172800_364800 n1_m1_177600_364800 5.356235
R9011 n1_m1_177600_364800 n1_m1_182400_364800 5.356235
R9012 n1_m1_182400_364800 n1_m1_187200_364800 5.356235
R9013 n1_m1_187200_364800 n1_m1_192000_364800 5.356235
R9014 n1_m1_192000_364800 n1_m1_196800_364800 5.356235
R9015 n1_m1_196800_364800 n1_m1_200000_364800 3.570824
R9016 n1_m1_201600_364800 n1_m1_200000_364800 1.785412
R9017 n1_m1_201600_364800 n1_m1_206400_364800 5.356235
R9018 n1_m1_206400_364800 n1_m1_211200_364800 5.356235
R9019 n1_m1_211200_364800 n1_m1_216000_364800 5.356235
R9020 n1_m1_216000_364800 n1_m1_220800_364800 5.356235
R9021 n1_m1_220800_364800 n1_m1_225600_364800 5.356235
R9022 n1_m1_225600_364800 n1_m1_228000_364800 2.678118
R9023 n1_m1_230400_364800 n1_m1_228000_364800 2.678118
R9024 n1_m1_230400_364800 n1_m1_235200_364800 5.356235
R9025 n1_m1_235200_364800 n1_m1_240000_364800 5.356235
R9026 n1_m1_240000_364800 n1_m1_244800_364800 5.356235
R9027 n1_m1_244800_364800 n1_m1_249600_364800 5.356235
R9028 n1_m1_249600_364800 n1_m1_254400_364800 5.356235
R9029 n1_m1_254400_364800 n1_m1_256000_364800 1.785412
R9030 n1_m1_259200_364800 n1_m1_256000_364800 3.570824
R9031 n1_m1_259200_364800 n1_m1_264000_364800 5.356235
R9032 n1_m1_264000_364800 n1_m1_268800_364800 5.356235
R9033 n1_m1_268800_364800 n1_m1_273600_364800 5.356235
R9034 n1_m1_273600_364800 n1_m1_278400_364800 5.356235
R9035 n1_m1_278400_364800 n1_m1_283200_364800 5.356235
R9036 n1_m1_283200_364800 n1_m1_284000_364800 0.892706
R9037 n1_m1_288000_364800 n1_m1_284000_364800 4.463529
R9038 n1_m1_288000_364800 n1_m1_292800_364800 5.356235
R9039 n1_m1_292800_364800 n1_m1_297600_364800 5.356235
R9040 n1_m1_297600_364800 n1_m1_302400_364800 5.356235
R9041 n1_m1_302400_364800 n1_m1_307200_364800 5.356235
R9042 n1_m1_307200_364800 n1_m1_312000_364800 5.356235
R9043 n1_m1_312000_364800 n1_m1_316800_364800 5.356235
R9044 n1_m1_316800_364800 n1_m1_321600_364800 5.356235
R9045 n1_m1_321600_364800 n1_m1_326400_364800 5.356235
R9046 n1_m1_326400_364800 n1_m1_331200_364800 5.356235
R9047 n1_m1_331200_364800 n1_m1_336000_364800 5.356235
R9048 n1_m1_336000_364800 n1_m1_340000_364800 4.463529
R9049 n1_m1_340800_364800 n1_m1_340000_364800 0.892706
R9050 n1_m1_340800_364800 n1_m1_345600_364800 5.356235
R9051 n1_m1_345600_364800 n1_m1_350400_364800 5.356235
R9052 n1_m1_350400_364800 n1_m1_355200_364800 5.356235
R9053 n1_m1_355200_364800 n1_m1_360000_364800 5.356235
R9054 n1_m1_360000_364800 n1_m1_364800_364800 5.356235
R9055 n1_m1_364800_364800 n1_m1_368000_364800 3.570824
R9056 n1_m1_369600_364800 n1_m1_368000_364800 1.785412
R9057 n1_m1_369600_364800 n1_m1_374400_364800 5.356235
R9058 n1_m1_374400_364800 n1_m1_379200_364800 5.356235
R9059 n1_m1_379200_364800 n1_m1_384000_364800 5.356235
R9060 n1_m1_384000_364800 n1_m1_388800_364800 5.356235
R9061 n1_m1_388800_364800 n1_m1_393600_364800 5.356235
R9062 n1_m1_393600_364800 n1_m1_396000_364800 2.678118
R9063 n1_m1_398400_364800 n1_m1_396000_364800 2.678118
R9064 n1_m1_398400_364800 n1_m1_403200_364800 5.356235
R9065 n1_m1_403200_364800 n1_m1_408000_364800 5.356235
R9066 n1_m1_408000_364800 n1_m1_412800_364800 5.356235
R9067 n1_m1_412800_364800 n1_m1_417600_364800 5.356235
R9068 n1_m1_417600_364800 n1_m1_422400_364800 5.356235
R9069 n1_m1_422400_364800 n1_m1_424000_364800 1.785412
R9070 n1_m1_427200_364800 n1_m1_424000_364800 3.570824
R9071 n1_m1_427200_364800 n1_m1_432000_364800 5.356235
R9072 n1_m1_432000_364800 n1_m1_436800_364800 5.356235
R9073 n1_m1_436800_364800 n1_m1_441600_364800 5.356235
R9074 n1_m1_441600_364800 n1_m1_446400_364800 5.356235
R9075 n1_m1_446400_364800 n1_m1_451200_364800 5.356235
R9076 n1_m1_451200_364800 n1_m1_452000_364800 0.892706
R9077 n1_m1_456000_364800 n1_m1_452000_364800 4.463529
R9078 n1_m1_456000_364800 n1_m1_460800_364800 5.356235
R9079 n1_m1_460800_364800 n1_m1_465600_364800 5.356235
R9080 n1_m1_465600_364800 n1_m1_470400_364800 5.356235
R9081 n1_m1_470400_364800 n1_m1_475200_364800 5.356235
R9082 n1_m1_475200_364800 n1_m1_480000_364800 5.356235
R9083 n1_m1_480000_364800 n1_m1_484800_364800 5.356235
R9084 n1_m1_484800_364800 n1_m1_489600_364800 5.356235
R9085 n1_m1_489600_364800 n1_m1_494400_364800 5.356235
R9086 n1_m1_0_369600 n1_m1_4000_369600 4.463529
R9087 n1_m1_4800_369600 n1_m1_4000_369600 0.892706
R9088 n1_m1_4800_369600 n1_m1_9600_369600 5.356235
R9089 n1_m1_9600_369600 n1_m1_14400_369600 5.356235
R9090 n1_m1_14400_369600 n1_m1_19200_369600 5.356235
R9091 n1_m1_19200_369600 n1_m1_24000_369600 5.356235
R9092 n1_m1_24000_369600 n1_m1_28800_369600 5.356235
R9093 n1_m1_28800_369600 n1_m1_32000_369600 3.570824
R9094 n1_m1_33600_369600 n1_m1_32000_369600 1.785412
R9095 n1_m1_33600_369600 n1_m1_38400_369600 5.356235
R9096 n1_m1_38400_369600 n1_m1_43200_369600 5.356235
R9097 n1_m1_43200_369600 n1_m1_48000_369600 5.356235
R9098 n1_m1_48000_369600 n1_m1_52800_369600 5.356235
R9099 n1_m1_52800_369600 n1_m1_57600_369600 5.356235
R9100 n1_m1_57600_369600 n1_m1_60000_369600 2.678118
R9101 n1_m1_62400_369600 n1_m1_60000_369600 2.678118
R9102 n1_m1_62400_369600 n1_m1_67200_369600 5.356235
R9103 n1_m1_67200_369600 n1_m1_72000_369600 5.356235
R9104 n1_m1_72000_369600 n1_m1_76800_369600 5.356235
R9105 n1_m1_76800_369600 n1_m1_81600_369600 5.356235
R9106 n1_m1_81600_369600 n1_m1_86400_369600 5.356235
R9107 n1_m1_86400_369600 n1_m1_88000_369600 1.785412
R9108 n1_m1_91200_369600 n1_m1_88000_369600 3.570824
R9109 n1_m1_91200_369600 n1_m1_96000_369600 5.356235
R9110 n1_m1_96000_369600 n1_m1_100800_369600 5.356235
R9111 n1_m1_100800_369600 n1_m1_105600_369600 5.356235
R9112 n1_m1_105600_369600 n1_m1_110400_369600 5.356235
R9113 n1_m1_110400_369600 n1_m1_115200_369600 5.356235
R9114 n1_m1_115200_369600 n1_m1_116000_369600 0.892706
R9115 n1_m1_120000_369600 n1_m1_116000_369600 4.463529
R9116 n1_m1_120000_369600 n1_m1_124800_369600 5.356235
R9117 n1_m1_124800_369600 n1_m1_129600_369600 5.356235
R9118 n1_m1_129600_369600 n1_m1_134400_369600 5.356235
R9119 n1_m1_134400_369600 n1_m1_139200_369600 5.356235
R9120 n1_m1_139200_369600 n1_m1_144000_369600 5.356235
R9121 n1_m1_144000_369600 n1_m1_148800_369600 5.356235
R9122 n1_m1_148800_369600 n1_m1_153600_369600 5.356235
R9123 n1_m1_153600_369600 n1_m1_158400_369600 5.356235
R9124 n1_m1_158400_369600 n1_m1_163200_369600 5.356235
R9125 n1_m1_163200_369600 n1_m1_168000_369600 5.356235
R9126 n1_m1_168000_369600 n1_m1_172000_369600 4.463529
R9127 n1_m1_172800_369600 n1_m1_172000_369600 0.892706
R9128 n1_m1_172800_369600 n1_m1_177600_369600 5.356235
R9129 n1_m1_177600_369600 n1_m1_182400_369600 5.356235
R9130 n1_m1_182400_369600 n1_m1_187200_369600 5.356235
R9131 n1_m1_187200_369600 n1_m1_192000_369600 5.356235
R9132 n1_m1_192000_369600 n1_m1_196800_369600 5.356235
R9133 n1_m1_196800_369600 n1_m1_200000_369600 3.570824
R9134 n1_m1_201600_369600 n1_m1_200000_369600 1.785412
R9135 n1_m1_201600_369600 n1_m1_206400_369600 5.356235
R9136 n1_m1_206400_369600 n1_m1_211200_369600 5.356235
R9137 n1_m1_211200_369600 n1_m1_216000_369600 5.356235
R9138 n1_m1_216000_369600 n1_m1_220800_369600 5.356235
R9139 n1_m1_220800_369600 n1_m1_225600_369600 5.356235
R9140 n1_m1_225600_369600 n1_m1_228000_369600 2.678118
R9141 n1_m1_230400_369600 n1_m1_228000_369600 2.678118
R9142 n1_m1_230400_369600 n1_m1_235200_369600 5.356235
R9143 n1_m1_235200_369600 n1_m1_240000_369600 5.356235
R9144 n1_m1_240000_369600 n1_m1_244800_369600 5.356235
R9145 n1_m1_244800_369600 n1_m1_249600_369600 5.356235
R9146 n1_m1_249600_369600 n1_m1_254400_369600 5.356235
R9147 n1_m1_254400_369600 n1_m1_256000_369600 1.785412
R9148 n1_m1_259200_369600 n1_m1_256000_369600 3.570824
R9149 n1_m1_259200_369600 n1_m1_264000_369600 5.356235
R9150 n1_m1_264000_369600 n1_m1_268800_369600 5.356235
R9151 n1_m1_268800_369600 n1_m1_273600_369600 5.356235
R9152 n1_m1_273600_369600 n1_m1_278400_369600 5.356235
R9153 n1_m1_278400_369600 n1_m1_283200_369600 5.356235
R9154 n1_m1_283200_369600 n1_m1_284000_369600 0.892706
R9155 n1_m1_288000_369600 n1_m1_284000_369600 4.463529
R9156 n1_m1_288000_369600 n1_m1_292800_369600 5.356235
R9157 n1_m1_292800_369600 n1_m1_297600_369600 5.356235
R9158 n1_m1_297600_369600 n1_m1_302400_369600 5.356235
R9159 n1_m1_302400_369600 n1_m1_307200_369600 5.356235
R9160 n1_m1_307200_369600 n1_m1_312000_369600 5.356235
R9161 n1_m1_312000_369600 n1_m1_316800_369600 5.356235
R9162 n1_m1_316800_369600 n1_m1_321600_369600 5.356235
R9163 n1_m1_321600_369600 n1_m1_326400_369600 5.356235
R9164 n1_m1_326400_369600 n1_m1_331200_369600 5.356235
R9165 n1_m1_331200_369600 n1_m1_336000_369600 5.356235
R9166 n1_m1_336000_369600 n1_m1_340000_369600 4.463529
R9167 n1_m1_340800_369600 n1_m1_340000_369600 0.892706
R9168 n1_m1_340800_369600 n1_m1_345600_369600 5.356235
R9169 n1_m1_345600_369600 n1_m1_350400_369600 5.356235
R9170 n1_m1_350400_369600 n1_m1_355200_369600 5.356235
R9171 n1_m1_355200_369600 n1_m1_360000_369600 5.356235
R9172 n1_m1_360000_369600 n1_m1_364800_369600 5.356235
R9173 n1_m1_364800_369600 n1_m1_368000_369600 3.570824
R9174 n1_m1_369600_369600 n1_m1_368000_369600 1.785412
R9175 n1_m1_369600_369600 n1_m1_374400_369600 5.356235
R9176 n1_m1_374400_369600 n1_m1_379200_369600 5.356235
R9177 n1_m1_379200_369600 n1_m1_384000_369600 5.356235
R9178 n1_m1_384000_369600 n1_m1_388800_369600 5.356235
R9179 n1_m1_388800_369600 n1_m1_393600_369600 5.356235
R9180 n1_m1_393600_369600 n1_m1_396000_369600 2.678118
R9181 n1_m1_398400_369600 n1_m1_396000_369600 2.678118
R9182 n1_m1_398400_369600 n1_m1_403200_369600 5.356235
R9183 n1_m1_403200_369600 n1_m1_408000_369600 5.356235
R9184 n1_m1_408000_369600 n1_m1_412800_369600 5.356235
R9185 n1_m1_412800_369600 n1_m1_417600_369600 5.356235
R9186 n1_m1_417600_369600 n1_m1_422400_369600 5.356235
R9187 n1_m1_422400_369600 n1_m1_424000_369600 1.785412
R9188 n1_m1_427200_369600 n1_m1_424000_369600 3.570824
R9189 n1_m1_427200_369600 n1_m1_432000_369600 5.356235
R9190 n1_m1_432000_369600 n1_m1_436800_369600 5.356235
R9191 n1_m1_436800_369600 n1_m1_441600_369600 5.356235
R9192 n1_m1_441600_369600 n1_m1_446400_369600 5.356235
R9193 n1_m1_446400_369600 n1_m1_451200_369600 5.356235
R9194 n1_m1_451200_369600 n1_m1_452000_369600 0.892706
R9195 n1_m1_456000_369600 n1_m1_452000_369600 4.463529
R9196 n1_m1_456000_369600 n1_m1_460800_369600 5.356235
R9197 n1_m1_460800_369600 n1_m1_465600_369600 5.356235
R9198 n1_m1_465600_369600 n1_m1_470400_369600 5.356235
R9199 n1_m1_470400_369600 n1_m1_475200_369600 5.356235
R9200 n1_m1_475200_369600 n1_m1_480000_369600 5.356235
R9201 n1_m1_480000_369600 n1_m1_484800_369600 5.356235
R9202 n1_m1_484800_369600 n1_m1_489600_369600 5.356235
R9203 n1_m1_489600_369600 n1_m1_494400_369600 5.356235
R9204 n1_m1_0_374400 n1_m1_4000_374400 4.463529
R9205 n1_m1_4800_374400 n1_m1_4000_374400 0.892706
R9206 n1_m1_4800_374400 n1_m1_9600_374400 5.356235
R9207 n1_m1_9600_374400 n1_m1_14400_374400 5.356235
R9208 n1_m1_14400_374400 n1_m1_19200_374400 5.356235
R9209 n1_m1_19200_374400 n1_m1_24000_374400 5.356235
R9210 n1_m1_24000_374400 n1_m1_28800_374400 5.356235
R9211 n1_m1_28800_374400 n1_m1_32000_374400 3.570824
R9212 n1_m1_33600_374400 n1_m1_32000_374400 1.785412
R9213 n1_m1_33600_374400 n1_m1_38400_374400 5.356235
R9214 n1_m1_38400_374400 n1_m1_43200_374400 5.356235
R9215 n1_m1_43200_374400 n1_m1_48000_374400 5.356235
R9216 n1_m1_48000_374400 n1_m1_52800_374400 5.356235
R9217 n1_m1_52800_374400 n1_m1_57600_374400 5.356235
R9218 n1_m1_57600_374400 n1_m1_60000_374400 2.678118
R9219 n1_m1_62400_374400 n1_m1_60000_374400 2.678118
R9220 n1_m1_62400_374400 n1_m1_67200_374400 5.356235
R9221 n1_m1_67200_374400 n1_m1_72000_374400 5.356235
R9222 n1_m1_72000_374400 n1_m1_76800_374400 5.356235
R9223 n1_m1_76800_374400 n1_m1_81600_374400 5.356235
R9224 n1_m1_81600_374400 n1_m1_86400_374400 5.356235
R9225 n1_m1_86400_374400 n1_m1_88000_374400 1.785412
R9226 n1_m1_91200_374400 n1_m1_88000_374400 3.570824
R9227 n1_m1_91200_374400 n1_m1_96000_374400 5.356235
R9228 n1_m1_96000_374400 n1_m1_100800_374400 5.356235
R9229 n1_m1_100800_374400 n1_m1_105600_374400 5.356235
R9230 n1_m1_105600_374400 n1_m1_110400_374400 5.356235
R9231 n1_m1_110400_374400 n1_m1_115200_374400 5.356235
R9232 n1_m1_115200_374400 n1_m1_116000_374400 0.892706
R9233 n1_m1_120000_374400 n1_m1_116000_374400 4.463529
R9234 n1_m1_120000_374400 n1_m1_124800_374400 5.356235
R9235 n1_m1_124800_374400 n1_m1_129600_374400 5.356235
R9236 n1_m1_129600_374400 n1_m1_134400_374400 5.356235
R9237 n1_m1_134400_374400 n1_m1_139200_374400 5.356235
R9238 n1_m1_139200_374400 n1_m1_144000_374400 5.356235
R9239 n1_m1_144000_374400 n1_m1_148800_374400 5.356235
R9240 n1_m1_148800_374400 n1_m1_153600_374400 5.356235
R9241 n1_m1_153600_374400 n1_m1_158400_374400 5.356235
R9242 n1_m1_158400_374400 n1_m1_163200_374400 5.356235
R9243 n1_m1_163200_374400 n1_m1_168000_374400 5.356235
R9244 n1_m1_168000_374400 n1_m1_172000_374400 4.463529
R9245 n1_m1_172800_374400 n1_m1_172000_374400 0.892706
R9246 n1_m1_172800_374400 n1_m1_177600_374400 5.356235
R9247 n1_m1_177600_374400 n1_m1_182400_374400 5.356235
R9248 n1_m1_182400_374400 n1_m1_187200_374400 5.356235
R9249 n1_m1_187200_374400 n1_m1_192000_374400 5.356235
R9250 n1_m1_192000_374400 n1_m1_196800_374400 5.356235
R9251 n1_m1_196800_374400 n1_m1_200000_374400 3.570824
R9252 n1_m1_201600_374400 n1_m1_200000_374400 1.785412
R9253 n1_m1_201600_374400 n1_m1_206400_374400 5.356235
R9254 n1_m1_206400_374400 n1_m1_211200_374400 5.356235
R9255 n1_m1_211200_374400 n1_m1_216000_374400 5.356235
R9256 n1_m1_216000_374400 n1_m1_220800_374400 5.356235
R9257 n1_m1_220800_374400 n1_m1_225600_374400 5.356235
R9258 n1_m1_225600_374400 n1_m1_228000_374400 2.678118
R9259 n1_m1_230400_374400 n1_m1_228000_374400 2.678118
R9260 n1_m1_230400_374400 n1_m1_235200_374400 5.356235
R9261 n1_m1_235200_374400 n1_m1_240000_374400 5.356235
R9262 n1_m1_240000_374400 n1_m1_244800_374400 5.356235
R9263 n1_m1_244800_374400 n1_m1_249600_374400 5.356235
R9264 n1_m1_249600_374400 n1_m1_254400_374400 5.356235
R9265 n1_m1_254400_374400 n1_m1_256000_374400 1.785412
R9266 n1_m1_259200_374400 n1_m1_256000_374400 3.570824
R9267 n1_m1_259200_374400 n1_m1_264000_374400 5.356235
R9268 n1_m1_264000_374400 n1_m1_268800_374400 5.356235
R9269 n1_m1_268800_374400 n1_m1_273600_374400 5.356235
R9270 n1_m1_273600_374400 n1_m1_278400_374400 5.356235
R9271 n1_m1_278400_374400 n1_m1_283200_374400 5.356235
R9272 n1_m1_283200_374400 n1_m1_284000_374400 0.892706
R9273 n1_m1_288000_374400 n1_m1_284000_374400 4.463529
R9274 n1_m1_288000_374400 n1_m1_292800_374400 5.356235
R9275 n1_m1_292800_374400 n1_m1_297600_374400 5.356235
R9276 n1_m1_297600_374400 n1_m1_302400_374400 5.356235
R9277 n1_m1_302400_374400 n1_m1_307200_374400 5.356235
R9278 n1_m1_307200_374400 n1_m1_312000_374400 5.356235
R9279 n1_m1_312000_374400 n1_m1_316800_374400 5.356235
R9280 n1_m1_316800_374400 n1_m1_321600_374400 5.356235
R9281 n1_m1_321600_374400 n1_m1_326400_374400 5.356235
R9282 n1_m1_326400_374400 n1_m1_331200_374400 5.356235
R9283 n1_m1_331200_374400 n1_m1_336000_374400 5.356235
R9284 n1_m1_336000_374400 n1_m1_340000_374400 4.463529
R9285 n1_m1_340800_374400 n1_m1_340000_374400 0.892706
R9286 n1_m1_340800_374400 n1_m1_345600_374400 5.356235
R9287 n1_m1_345600_374400 n1_m1_350400_374400 5.356235
R9288 n1_m1_350400_374400 n1_m1_355200_374400 5.356235
R9289 n1_m1_355200_374400 n1_m1_360000_374400 5.356235
R9290 n1_m1_360000_374400 n1_m1_364800_374400 5.356235
R9291 n1_m1_364800_374400 n1_m1_368000_374400 3.570824
R9292 n1_m1_369600_374400 n1_m1_368000_374400 1.785412
R9293 n1_m1_369600_374400 n1_m1_374400_374400 5.356235
R9294 n1_m1_374400_374400 n1_m1_379200_374400 5.356235
R9295 n1_m1_379200_374400 n1_m1_384000_374400 5.356235
R9296 n1_m1_384000_374400 n1_m1_388800_374400 5.356235
R9297 n1_m1_388800_374400 n1_m1_393600_374400 5.356235
R9298 n1_m1_393600_374400 n1_m1_396000_374400 2.678118
R9299 n1_m1_398400_374400 n1_m1_396000_374400 2.678118
R9300 n1_m1_398400_374400 n1_m1_403200_374400 5.356235
R9301 n1_m1_403200_374400 n1_m1_408000_374400 5.356235
R9302 n1_m1_408000_374400 n1_m1_412800_374400 5.356235
R9303 n1_m1_412800_374400 n1_m1_417600_374400 5.356235
R9304 n1_m1_417600_374400 n1_m1_422400_374400 5.356235
R9305 n1_m1_422400_374400 n1_m1_424000_374400 1.785412
R9306 n1_m1_427200_374400 n1_m1_424000_374400 3.570824
R9307 n1_m1_427200_374400 n1_m1_432000_374400 5.356235
R9308 n1_m1_432000_374400 n1_m1_436800_374400 5.356235
R9309 n1_m1_436800_374400 n1_m1_441600_374400 5.356235
R9310 n1_m1_441600_374400 n1_m1_446400_374400 5.356235
R9311 n1_m1_446400_374400 n1_m1_451200_374400 5.356235
R9312 n1_m1_451200_374400 n1_m1_452000_374400 0.892706
R9313 n1_m1_456000_374400 n1_m1_452000_374400 4.463529
R9314 n1_m1_456000_374400 n1_m1_460800_374400 5.356235
R9315 n1_m1_460800_374400 n1_m1_465600_374400 5.356235
R9316 n1_m1_465600_374400 n1_m1_470400_374400 5.356235
R9317 n1_m1_470400_374400 n1_m1_475200_374400 5.356235
R9318 n1_m1_475200_374400 n1_m1_480000_374400 5.356235
R9319 n1_m1_480000_374400 n1_m1_484800_374400 5.356235
R9320 n1_m1_484800_374400 n1_m1_489600_374400 5.356235
R9321 n1_m1_489600_374400 n1_m1_494400_374400 5.356235
R9322 n1_m1_0_379200 n1_m1_4000_379200 4.463529
R9323 n1_m1_4800_379200 n1_m1_4000_379200 0.892706
R9324 n1_m1_4800_379200 n1_m1_9600_379200 5.356235
R9325 n1_m1_9600_379200 n1_m1_14400_379200 5.356235
R9326 n1_m1_14400_379200 n1_m1_19200_379200 5.356235
R9327 n1_m1_19200_379200 n1_m1_24000_379200 5.356235
R9328 n1_m1_24000_379200 n1_m1_28800_379200 5.356235
R9329 n1_m1_28800_379200 n1_m1_32000_379200 3.570824
R9330 n1_m1_33600_379200 n1_m1_32000_379200 1.785412
R9331 n1_m1_33600_379200 n1_m1_38400_379200 5.356235
R9332 n1_m1_38400_379200 n1_m1_43200_379200 5.356235
R9333 n1_m1_43200_379200 n1_m1_48000_379200 5.356235
R9334 n1_m1_48000_379200 n1_m1_52800_379200 5.356235
R9335 n1_m1_52800_379200 n1_m1_57600_379200 5.356235
R9336 n1_m1_57600_379200 n1_m1_60000_379200 2.678118
R9337 n1_m1_62400_379200 n1_m1_60000_379200 2.678118
R9338 n1_m1_62400_379200 n1_m1_67200_379200 5.356235
R9339 n1_m1_67200_379200 n1_m1_72000_379200 5.356235
R9340 n1_m1_72000_379200 n1_m1_76800_379200 5.356235
R9341 n1_m1_76800_379200 n1_m1_81600_379200 5.356235
R9342 n1_m1_81600_379200 n1_m1_86400_379200 5.356235
R9343 n1_m1_86400_379200 n1_m1_88000_379200 1.785412
R9344 n1_m1_91200_379200 n1_m1_88000_379200 3.570824
R9345 n1_m1_91200_379200 n1_m1_96000_379200 5.356235
R9346 n1_m1_96000_379200 n1_m1_100800_379200 5.356235
R9347 n1_m1_100800_379200 n1_m1_105600_379200 5.356235
R9348 n1_m1_105600_379200 n1_m1_110400_379200 5.356235
R9349 n1_m1_110400_379200 n1_m1_115200_379200 5.356235
R9350 n1_m1_115200_379200 n1_m1_116000_379200 0.892706
R9351 n1_m1_120000_379200 n1_m1_116000_379200 4.463529
R9352 n1_m1_120000_379200 n1_m1_124800_379200 5.356235
R9353 n1_m1_124800_379200 n1_m1_129600_379200 5.356235
R9354 n1_m1_129600_379200 n1_m1_134400_379200 5.356235
R9355 n1_m1_134400_379200 n1_m1_139200_379200 5.356235
R9356 n1_m1_139200_379200 n1_m1_144000_379200 5.356235
R9357 n1_m1_144000_379200 n1_m1_148800_379200 5.356235
R9358 n1_m1_148800_379200 n1_m1_153600_379200 5.356235
R9359 n1_m1_153600_379200 n1_m1_158400_379200 5.356235
R9360 n1_m1_158400_379200 n1_m1_163200_379200 5.356235
R9361 n1_m1_163200_379200 n1_m1_168000_379200 5.356235
R9362 n1_m1_168000_379200 n1_m1_172000_379200 4.463529
R9363 n1_m1_172800_379200 n1_m1_172000_379200 0.892706
R9364 n1_m1_172800_379200 n1_m1_177600_379200 5.356235
R9365 n1_m1_177600_379200 n1_m1_182400_379200 5.356235
R9366 n1_m1_182400_379200 n1_m1_187200_379200 5.356235
R9367 n1_m1_187200_379200 n1_m1_192000_379200 5.356235
R9368 n1_m1_192000_379200 n1_m1_196800_379200 5.356235
R9369 n1_m1_196800_379200 n1_m1_200000_379200 3.570824
R9370 n1_m1_201600_379200 n1_m1_200000_379200 1.785412
R9371 n1_m1_201600_379200 n1_m1_206400_379200 5.356235
R9372 n1_m1_206400_379200 n1_m1_211200_379200 5.356235
R9373 n1_m1_211200_379200 n1_m1_216000_379200 5.356235
R9374 n1_m1_216000_379200 n1_m1_220800_379200 5.356235
R9375 n1_m1_220800_379200 n1_m1_225600_379200 5.356235
R9376 n1_m1_225600_379200 n1_m1_228000_379200 2.678118
R9377 n1_m1_230400_379200 n1_m1_228000_379200 2.678118
R9378 n1_m1_230400_379200 n1_m1_235200_379200 5.356235
R9379 n1_m1_235200_379200 n1_m1_240000_379200 5.356235
R9380 n1_m1_240000_379200 n1_m1_244800_379200 5.356235
R9381 n1_m1_244800_379200 n1_m1_249600_379200 5.356235
R9382 n1_m1_249600_379200 n1_m1_254400_379200 5.356235
R9383 n1_m1_254400_379200 n1_m1_256000_379200 1.785412
R9384 n1_m1_259200_379200 n1_m1_256000_379200 3.570824
R9385 n1_m1_259200_379200 n1_m1_264000_379200 5.356235
R9386 n1_m1_264000_379200 n1_m1_268800_379200 5.356235
R9387 n1_m1_268800_379200 n1_m1_273600_379200 5.356235
R9388 n1_m1_273600_379200 n1_m1_278400_379200 5.356235
R9389 n1_m1_278400_379200 n1_m1_283200_379200 5.356235
R9390 n1_m1_283200_379200 n1_m1_284000_379200 0.892706
R9391 n1_m1_288000_379200 n1_m1_284000_379200 4.463529
R9392 n1_m1_288000_379200 n1_m1_292800_379200 5.356235
R9393 n1_m1_292800_379200 n1_m1_297600_379200 5.356235
R9394 n1_m1_297600_379200 n1_m1_302400_379200 5.356235
R9395 n1_m1_302400_379200 n1_m1_307200_379200 5.356235
R9396 n1_m1_307200_379200 n1_m1_312000_379200 5.356235
R9397 n1_m1_312000_379200 n1_m1_316800_379200 5.356235
R9398 n1_m1_316800_379200 n1_m1_321600_379200 5.356235
R9399 n1_m1_321600_379200 n1_m1_326400_379200 5.356235
R9400 n1_m1_326400_379200 n1_m1_331200_379200 5.356235
R9401 n1_m1_331200_379200 n1_m1_336000_379200 5.356235
R9402 n1_m1_336000_379200 n1_m1_340000_379200 4.463529
R9403 n1_m1_340800_379200 n1_m1_340000_379200 0.892706
R9404 n1_m1_340800_379200 n1_m1_345600_379200 5.356235
R9405 n1_m1_345600_379200 n1_m1_350400_379200 5.356235
R9406 n1_m1_350400_379200 n1_m1_355200_379200 5.356235
R9407 n1_m1_355200_379200 n1_m1_360000_379200 5.356235
R9408 n1_m1_360000_379200 n1_m1_364800_379200 5.356235
R9409 n1_m1_364800_379200 n1_m1_368000_379200 3.570824
R9410 n1_m1_369600_379200 n1_m1_368000_379200 1.785412
R9411 n1_m1_369600_379200 n1_m1_374400_379200 5.356235
R9412 n1_m1_374400_379200 n1_m1_379200_379200 5.356235
R9413 n1_m1_379200_379200 n1_m1_384000_379200 5.356235
R9414 n1_m1_384000_379200 n1_m1_388800_379200 5.356235
R9415 n1_m1_388800_379200 n1_m1_393600_379200 5.356235
R9416 n1_m1_393600_379200 n1_m1_396000_379200 2.678118
R9417 n1_m1_398400_379200 n1_m1_396000_379200 2.678118
R9418 n1_m1_398400_379200 n1_m1_403200_379200 5.356235
R9419 n1_m1_403200_379200 n1_m1_408000_379200 5.356235
R9420 n1_m1_408000_379200 n1_m1_412800_379200 5.356235
R9421 n1_m1_412800_379200 n1_m1_417600_379200 5.356235
R9422 n1_m1_417600_379200 n1_m1_422400_379200 5.356235
R9423 n1_m1_422400_379200 n1_m1_424000_379200 1.785412
R9424 n1_m1_427200_379200 n1_m1_424000_379200 3.570824
R9425 n1_m1_427200_379200 n1_m1_432000_379200 5.356235
R9426 n1_m1_432000_379200 n1_m1_436800_379200 5.356235
R9427 n1_m1_436800_379200 n1_m1_441600_379200 5.356235
R9428 n1_m1_441600_379200 n1_m1_446400_379200 5.356235
R9429 n1_m1_446400_379200 n1_m1_451200_379200 5.356235
R9430 n1_m1_451200_379200 n1_m1_452000_379200 0.892706
R9431 n1_m1_456000_379200 n1_m1_452000_379200 4.463529
R9432 n1_m1_456000_379200 n1_m1_460800_379200 5.356235
R9433 n1_m1_460800_379200 n1_m1_465600_379200 5.356235
R9434 n1_m1_465600_379200 n1_m1_470400_379200 5.356235
R9435 n1_m1_470400_379200 n1_m1_475200_379200 5.356235
R9436 n1_m1_475200_379200 n1_m1_480000_379200 5.356235
R9437 n1_m1_480000_379200 n1_m1_484800_379200 5.356235
R9438 n1_m1_484800_379200 n1_m1_489600_379200 5.356235
R9439 n1_m1_489600_379200 n1_m1_494400_379200 5.356235
R9440 n1_m1_0_384000 n1_m1_4000_384000 4.463529
R9441 n1_m1_4800_384000 n1_m1_4000_384000 0.892706
R9442 n1_m1_4800_384000 n1_m1_9600_384000 5.356235
R9443 n1_m1_9600_384000 n1_m1_14400_384000 5.356235
R9444 n1_m1_14400_384000 n1_m1_19200_384000 5.356235
R9445 n1_m1_19200_384000 n1_m1_24000_384000 5.356235
R9446 n1_m1_24000_384000 n1_m1_28800_384000 5.356235
R9447 n1_m1_28800_384000 n1_m1_32000_384000 3.570824
R9448 n1_m1_33600_384000 n1_m1_32000_384000 1.785412
R9449 n1_m1_33600_384000 n1_m1_38400_384000 5.356235
R9450 n1_m1_38400_384000 n1_m1_43200_384000 5.356235
R9451 n1_m1_43200_384000 n1_m1_48000_384000 5.356235
R9452 n1_m1_48000_384000 n1_m1_52800_384000 5.356235
R9453 n1_m1_52800_384000 n1_m1_57600_384000 5.356235
R9454 n1_m1_57600_384000 n1_m1_60000_384000 2.678118
R9455 n1_m1_62400_384000 n1_m1_60000_384000 2.678118
R9456 n1_m1_62400_384000 n1_m1_67200_384000 5.356235
R9457 n1_m1_67200_384000 n1_m1_72000_384000 5.356235
R9458 n1_m1_72000_384000 n1_m1_76800_384000 5.356235
R9459 n1_m1_76800_384000 n1_m1_81600_384000 5.356235
R9460 n1_m1_81600_384000 n1_m1_86400_384000 5.356235
R9461 n1_m1_86400_384000 n1_m1_88000_384000 1.785412
R9462 n1_m1_91200_384000 n1_m1_88000_384000 3.570824
R9463 n1_m1_91200_384000 n1_m1_96000_384000 5.356235
R9464 n1_m1_96000_384000 n1_m1_100800_384000 5.356235
R9465 n1_m1_100800_384000 n1_m1_105600_384000 5.356235
R9466 n1_m1_105600_384000 n1_m1_110400_384000 5.356235
R9467 n1_m1_110400_384000 n1_m1_115200_384000 5.356235
R9468 n1_m1_115200_384000 n1_m1_116000_384000 0.892706
R9469 n1_m1_120000_384000 n1_m1_116000_384000 4.463529
R9470 n1_m1_120000_384000 n1_m1_124800_384000 5.356235
R9471 n1_m1_124800_384000 n1_m1_129600_384000 5.356235
R9472 n1_m1_129600_384000 n1_m1_134400_384000 5.356235
R9473 n1_m1_134400_384000 n1_m1_139200_384000 5.356235
R9474 n1_m1_139200_384000 n1_m1_144000_384000 5.356235
R9475 n1_m1_144000_384000 n1_m1_148800_384000 5.356235
R9476 n1_m1_148800_384000 n1_m1_153600_384000 5.356235
R9477 n1_m1_153600_384000 n1_m1_158400_384000 5.356235
R9478 n1_m1_158400_384000 n1_m1_163200_384000 5.356235
R9479 n1_m1_163200_384000 n1_m1_168000_384000 5.356235
R9480 n1_m1_168000_384000 n1_m1_172000_384000 4.463529
R9481 n1_m1_172800_384000 n1_m1_172000_384000 0.892706
R9482 n1_m1_172800_384000 n1_m1_177600_384000 5.356235
R9483 n1_m1_177600_384000 n1_m1_182400_384000 5.356235
R9484 n1_m1_182400_384000 n1_m1_187200_384000 5.356235
R9485 n1_m1_187200_384000 n1_m1_192000_384000 5.356235
R9486 n1_m1_192000_384000 n1_m1_196800_384000 5.356235
R9487 n1_m1_196800_384000 n1_m1_200000_384000 3.570824
R9488 n1_m1_201600_384000 n1_m1_200000_384000 1.785412
R9489 n1_m1_201600_384000 n1_m1_206400_384000 5.356235
R9490 n1_m1_206400_384000 n1_m1_211200_384000 5.356235
R9491 n1_m1_211200_384000 n1_m1_216000_384000 5.356235
R9492 n1_m1_216000_384000 n1_m1_220800_384000 5.356235
R9493 n1_m1_220800_384000 n1_m1_225600_384000 5.356235
R9494 n1_m1_225600_384000 n1_m1_228000_384000 2.678118
R9495 n1_m1_230400_384000 n1_m1_228000_384000 2.678118
R9496 n1_m1_230400_384000 n1_m1_235200_384000 5.356235
R9497 n1_m1_235200_384000 n1_m1_240000_384000 5.356235
R9498 n1_m1_240000_384000 n1_m1_244800_384000 5.356235
R9499 n1_m1_244800_384000 n1_m1_249600_384000 5.356235
R9500 n1_m1_249600_384000 n1_m1_254400_384000 5.356235
R9501 n1_m1_254400_384000 n1_m1_256000_384000 1.785412
R9502 n1_m1_259200_384000 n1_m1_256000_384000 3.570824
R9503 n1_m1_259200_384000 n1_m1_264000_384000 5.356235
R9504 n1_m1_264000_384000 n1_m1_268800_384000 5.356235
R9505 n1_m1_268800_384000 n1_m1_273600_384000 5.356235
R9506 n1_m1_273600_384000 n1_m1_278400_384000 5.356235
R9507 n1_m1_278400_384000 n1_m1_283200_384000 5.356235
R9508 n1_m1_283200_384000 n1_m1_284000_384000 0.892706
R9509 n1_m1_288000_384000 n1_m1_284000_384000 4.463529
R9510 n1_m1_288000_384000 n1_m1_292800_384000 5.356235
R9511 n1_m1_292800_384000 n1_m1_297600_384000 5.356235
R9512 n1_m1_297600_384000 n1_m1_302400_384000 5.356235
R9513 n1_m1_302400_384000 n1_m1_307200_384000 5.356235
R9514 n1_m1_307200_384000 n1_m1_312000_384000 5.356235
R9515 n1_m1_312000_384000 n1_m1_316800_384000 5.356235
R9516 n1_m1_316800_384000 n1_m1_321600_384000 5.356235
R9517 n1_m1_321600_384000 n1_m1_326400_384000 5.356235
R9518 n1_m1_326400_384000 n1_m1_331200_384000 5.356235
R9519 n1_m1_331200_384000 n1_m1_336000_384000 5.356235
R9520 n1_m1_336000_384000 n1_m1_340000_384000 4.463529
R9521 n1_m1_340800_384000 n1_m1_340000_384000 0.892706
R9522 n1_m1_340800_384000 n1_m1_345600_384000 5.356235
R9523 n1_m1_345600_384000 n1_m1_350400_384000 5.356235
R9524 n1_m1_350400_384000 n1_m1_355200_384000 5.356235
R9525 n1_m1_355200_384000 n1_m1_360000_384000 5.356235
R9526 n1_m1_360000_384000 n1_m1_364800_384000 5.356235
R9527 n1_m1_364800_384000 n1_m1_368000_384000 3.570824
R9528 n1_m1_369600_384000 n1_m1_368000_384000 1.785412
R9529 n1_m1_369600_384000 n1_m1_374400_384000 5.356235
R9530 n1_m1_374400_384000 n1_m1_379200_384000 5.356235
R9531 n1_m1_379200_384000 n1_m1_384000_384000 5.356235
R9532 n1_m1_384000_384000 n1_m1_388800_384000 5.356235
R9533 n1_m1_388800_384000 n1_m1_393600_384000 5.356235
R9534 n1_m1_393600_384000 n1_m1_396000_384000 2.678118
R9535 n1_m1_398400_384000 n1_m1_396000_384000 2.678118
R9536 n1_m1_398400_384000 n1_m1_403200_384000 5.356235
R9537 n1_m1_403200_384000 n1_m1_408000_384000 5.356235
R9538 n1_m1_408000_384000 n1_m1_412800_384000 5.356235
R9539 n1_m1_412800_384000 n1_m1_417600_384000 5.356235
R9540 n1_m1_417600_384000 n1_m1_422400_384000 5.356235
R9541 n1_m1_422400_384000 n1_m1_424000_384000 1.785412
R9542 n1_m1_427200_384000 n1_m1_424000_384000 3.570824
R9543 n1_m1_427200_384000 n1_m1_432000_384000 5.356235
R9544 n1_m1_432000_384000 n1_m1_436800_384000 5.356235
R9545 n1_m1_436800_384000 n1_m1_441600_384000 5.356235
R9546 n1_m1_441600_384000 n1_m1_446400_384000 5.356235
R9547 n1_m1_446400_384000 n1_m1_451200_384000 5.356235
R9548 n1_m1_451200_384000 n1_m1_452000_384000 0.892706
R9549 n1_m1_456000_384000 n1_m1_452000_384000 4.463529
R9550 n1_m1_456000_384000 n1_m1_460800_384000 5.356235
R9551 n1_m1_460800_384000 n1_m1_465600_384000 5.356235
R9552 n1_m1_465600_384000 n1_m1_470400_384000 5.356235
R9553 n1_m1_470400_384000 n1_m1_475200_384000 5.356235
R9554 n1_m1_475200_384000 n1_m1_480000_384000 5.356235
R9555 n1_m1_480000_384000 n1_m1_484800_384000 5.356235
R9556 n1_m1_484800_384000 n1_m1_489600_384000 5.356235
R9557 n1_m1_489600_384000 n1_m1_494400_384000 5.356235
R9558 n1_m1_0_388800 n1_m1_4000_388800 4.463529
R9559 n1_m1_4800_388800 n1_m1_4000_388800 0.892706
R9560 n1_m1_4800_388800 n1_m1_9600_388800 5.356235
R9561 n1_m1_9600_388800 n1_m1_14400_388800 5.356235
R9562 n1_m1_14400_388800 n1_m1_19200_388800 5.356235
R9563 n1_m1_19200_388800 n1_m1_24000_388800 5.356235
R9564 n1_m1_24000_388800 n1_m1_28800_388800 5.356235
R9565 n1_m1_28800_388800 n1_m1_32000_388800 3.570824
R9566 n1_m1_33600_388800 n1_m1_32000_388800 1.785412
R9567 n1_m1_33600_388800 n1_m1_38400_388800 5.356235
R9568 n1_m1_38400_388800 n1_m1_43200_388800 5.356235
R9569 n1_m1_43200_388800 n1_m1_48000_388800 5.356235
R9570 n1_m1_48000_388800 n1_m1_52800_388800 5.356235
R9571 n1_m1_52800_388800 n1_m1_57600_388800 5.356235
R9572 n1_m1_57600_388800 n1_m1_60000_388800 2.678118
R9573 n1_m1_62400_388800 n1_m1_60000_388800 2.678118
R9574 n1_m1_62400_388800 n1_m1_67200_388800 5.356235
R9575 n1_m1_67200_388800 n1_m1_72000_388800 5.356235
R9576 n1_m1_72000_388800 n1_m1_76800_388800 5.356235
R9577 n1_m1_76800_388800 n1_m1_81600_388800 5.356235
R9578 n1_m1_81600_388800 n1_m1_86400_388800 5.356235
R9579 n1_m1_86400_388800 n1_m1_88000_388800 1.785412
R9580 n1_m1_91200_388800 n1_m1_88000_388800 3.570824
R9581 n1_m1_91200_388800 n1_m1_96000_388800 5.356235
R9582 n1_m1_96000_388800 n1_m1_100800_388800 5.356235
R9583 n1_m1_100800_388800 n1_m1_105600_388800 5.356235
R9584 n1_m1_105600_388800 n1_m1_110400_388800 5.356235
R9585 n1_m1_110400_388800 n1_m1_115200_388800 5.356235
R9586 n1_m1_115200_388800 n1_m1_116000_388800 0.892706
R9587 n1_m1_120000_388800 n1_m1_116000_388800 4.463529
R9588 n1_m1_120000_388800 n1_m1_124800_388800 5.356235
R9589 n1_m1_124800_388800 n1_m1_129600_388800 5.356235
R9590 n1_m1_129600_388800 n1_m1_134400_388800 5.356235
R9591 n1_m1_134400_388800 n1_m1_139200_388800 5.356235
R9592 n1_m1_139200_388800 n1_m1_144000_388800 5.356235
R9593 n1_m1_144000_388800 n1_m1_148800_388800 5.356235
R9594 n1_m1_148800_388800 n1_m1_153600_388800 5.356235
R9595 n1_m1_153600_388800 n1_m1_158400_388800 5.356235
R9596 n1_m1_158400_388800 n1_m1_163200_388800 5.356235
R9597 n1_m1_163200_388800 n1_m1_168000_388800 5.356235
R9598 n1_m1_168000_388800 n1_m1_172000_388800 4.463529
R9599 n1_m1_172800_388800 n1_m1_172000_388800 0.892706
R9600 n1_m1_172800_388800 n1_m1_177600_388800 5.356235
R9601 n1_m1_177600_388800 n1_m1_182400_388800 5.356235
R9602 n1_m1_182400_388800 n1_m1_187200_388800 5.356235
R9603 n1_m1_187200_388800 n1_m1_192000_388800 5.356235
R9604 n1_m1_192000_388800 n1_m1_196800_388800 5.356235
R9605 n1_m1_196800_388800 n1_m1_200000_388800 3.570824
R9606 n1_m1_201600_388800 n1_m1_200000_388800 1.785412
R9607 n1_m1_201600_388800 n1_m1_206400_388800 5.356235
R9608 n1_m1_206400_388800 n1_m1_211200_388800 5.356235
R9609 n1_m1_211200_388800 n1_m1_216000_388800 5.356235
R9610 n1_m1_216000_388800 n1_m1_220800_388800 5.356235
R9611 n1_m1_220800_388800 n1_m1_225600_388800 5.356235
R9612 n1_m1_225600_388800 n1_m1_228000_388800 2.678118
R9613 n1_m1_230400_388800 n1_m1_228000_388800 2.678118
R9614 n1_m1_230400_388800 n1_m1_235200_388800 5.356235
R9615 n1_m1_235200_388800 n1_m1_240000_388800 5.356235
R9616 n1_m1_240000_388800 n1_m1_244800_388800 5.356235
R9617 n1_m1_244800_388800 n1_m1_249600_388800 5.356235
R9618 n1_m1_249600_388800 n1_m1_254400_388800 5.356235
R9619 n1_m1_254400_388800 n1_m1_256000_388800 1.785412
R9620 n1_m1_259200_388800 n1_m1_256000_388800 3.570824
R9621 n1_m1_259200_388800 n1_m1_264000_388800 5.356235
R9622 n1_m1_264000_388800 n1_m1_268800_388800 5.356235
R9623 n1_m1_268800_388800 n1_m1_273600_388800 5.356235
R9624 n1_m1_273600_388800 n1_m1_278400_388800 5.356235
R9625 n1_m1_278400_388800 n1_m1_283200_388800 5.356235
R9626 n1_m1_283200_388800 n1_m1_284000_388800 0.892706
R9627 n1_m1_288000_388800 n1_m1_284000_388800 4.463529
R9628 n1_m1_288000_388800 n1_m1_292800_388800 5.356235
R9629 n1_m1_292800_388800 n1_m1_297600_388800 5.356235
R9630 n1_m1_297600_388800 n1_m1_302400_388800 5.356235
R9631 n1_m1_302400_388800 n1_m1_307200_388800 5.356235
R9632 n1_m1_307200_388800 n1_m1_312000_388800 5.356235
R9633 n1_m1_312000_388800 n1_m1_316800_388800 5.356235
R9634 n1_m1_316800_388800 n1_m1_321600_388800 5.356235
R9635 n1_m1_321600_388800 n1_m1_326400_388800 5.356235
R9636 n1_m1_326400_388800 n1_m1_331200_388800 5.356235
R9637 n1_m1_331200_388800 n1_m1_336000_388800 5.356235
R9638 n1_m1_336000_388800 n1_m1_340000_388800 4.463529
R9639 n1_m1_340800_388800 n1_m1_340000_388800 0.892706
R9640 n1_m1_340800_388800 n1_m1_345600_388800 5.356235
R9641 n1_m1_345600_388800 n1_m1_350400_388800 5.356235
R9642 n1_m1_350400_388800 n1_m1_355200_388800 5.356235
R9643 n1_m1_355200_388800 n1_m1_360000_388800 5.356235
R9644 n1_m1_360000_388800 n1_m1_364800_388800 5.356235
R9645 n1_m1_364800_388800 n1_m1_368000_388800 3.570824
R9646 n1_m1_369600_388800 n1_m1_368000_388800 1.785412
R9647 n1_m1_369600_388800 n1_m1_374400_388800 5.356235
R9648 n1_m1_374400_388800 n1_m1_379200_388800 5.356235
R9649 n1_m1_379200_388800 n1_m1_384000_388800 5.356235
R9650 n1_m1_384000_388800 n1_m1_388800_388800 5.356235
R9651 n1_m1_388800_388800 n1_m1_393600_388800 5.356235
R9652 n1_m1_393600_388800 n1_m1_396000_388800 2.678118
R9653 n1_m1_398400_388800 n1_m1_396000_388800 2.678118
R9654 n1_m1_398400_388800 n1_m1_403200_388800 5.356235
R9655 n1_m1_403200_388800 n1_m1_408000_388800 5.356235
R9656 n1_m1_408000_388800 n1_m1_412800_388800 5.356235
R9657 n1_m1_412800_388800 n1_m1_417600_388800 5.356235
R9658 n1_m1_417600_388800 n1_m1_422400_388800 5.356235
R9659 n1_m1_422400_388800 n1_m1_424000_388800 1.785412
R9660 n1_m1_427200_388800 n1_m1_424000_388800 3.570824
R9661 n1_m1_427200_388800 n1_m1_432000_388800 5.356235
R9662 n1_m1_432000_388800 n1_m1_436800_388800 5.356235
R9663 n1_m1_436800_388800 n1_m1_441600_388800 5.356235
R9664 n1_m1_441600_388800 n1_m1_446400_388800 5.356235
R9665 n1_m1_446400_388800 n1_m1_451200_388800 5.356235
R9666 n1_m1_451200_388800 n1_m1_452000_388800 0.892706
R9667 n1_m1_456000_388800 n1_m1_452000_388800 4.463529
R9668 n1_m1_456000_388800 n1_m1_460800_388800 5.356235
R9669 n1_m1_460800_388800 n1_m1_465600_388800 5.356235
R9670 n1_m1_465600_388800 n1_m1_470400_388800 5.356235
R9671 n1_m1_470400_388800 n1_m1_475200_388800 5.356235
R9672 n1_m1_475200_388800 n1_m1_480000_388800 5.356235
R9673 n1_m1_480000_388800 n1_m1_484800_388800 5.356235
R9674 n1_m1_484800_388800 n1_m1_489600_388800 5.356235
R9675 n1_m1_489600_388800 n1_m1_494400_388800 5.356235
R9676 n1_m1_0_393600 n1_m1_4000_393600 4.463529
R9677 n1_m1_4800_393600 n1_m1_4000_393600 0.892706
R9678 n1_m1_4800_393600 n1_m1_9600_393600 5.356235
R9679 n1_m1_9600_393600 n1_m1_14400_393600 5.356235
R9680 n1_m1_14400_393600 n1_m1_19200_393600 5.356235
R9681 n1_m1_19200_393600 n1_m1_24000_393600 5.356235
R9682 n1_m1_24000_393600 n1_m1_28800_393600 5.356235
R9683 n1_m1_28800_393600 n1_m1_32000_393600 3.570824
R9684 n1_m1_33600_393600 n1_m1_32000_393600 1.785412
R9685 n1_m1_33600_393600 n1_m1_38400_393600 5.356235
R9686 n1_m1_38400_393600 n1_m1_43200_393600 5.356235
R9687 n1_m1_43200_393600 n1_m1_48000_393600 5.356235
R9688 n1_m1_48000_393600 n1_m1_52800_393600 5.356235
R9689 n1_m1_52800_393600 n1_m1_57600_393600 5.356235
R9690 n1_m1_57600_393600 n1_m1_60000_393600 2.678118
R9691 n1_m1_62400_393600 n1_m1_60000_393600 2.678118
R9692 n1_m1_62400_393600 n1_m1_67200_393600 5.356235
R9693 n1_m1_67200_393600 n1_m1_72000_393600 5.356235
R9694 n1_m1_72000_393600 n1_m1_76800_393600 5.356235
R9695 n1_m1_76800_393600 n1_m1_81600_393600 5.356235
R9696 n1_m1_81600_393600 n1_m1_86400_393600 5.356235
R9697 n1_m1_86400_393600 n1_m1_88000_393600 1.785412
R9698 n1_m1_91200_393600 n1_m1_88000_393600 3.570824
R9699 n1_m1_91200_393600 n1_m1_96000_393600 5.356235
R9700 n1_m1_96000_393600 n1_m1_100800_393600 5.356235
R9701 n1_m1_100800_393600 n1_m1_105600_393600 5.356235
R9702 n1_m1_105600_393600 n1_m1_110400_393600 5.356235
R9703 n1_m1_110400_393600 n1_m1_115200_393600 5.356235
R9704 n1_m1_115200_393600 n1_m1_116000_393600 0.892706
R9705 n1_m1_120000_393600 n1_m1_116000_393600 4.463529
R9706 n1_m1_120000_393600 n1_m1_124800_393600 5.356235
R9707 n1_m1_124800_393600 n1_m1_129600_393600 5.356235
R9708 n1_m1_129600_393600 n1_m1_134400_393600 5.356235
R9709 n1_m1_134400_393600 n1_m1_139200_393600 5.356235
R9710 n1_m1_139200_393600 n1_m1_144000_393600 5.356235
R9711 n1_m1_144000_393600 n1_m1_148800_393600 5.356235
R9712 n1_m1_148800_393600 n1_m1_153600_393600 5.356235
R9713 n1_m1_153600_393600 n1_m1_158400_393600 5.356235
R9714 n1_m1_158400_393600 n1_m1_163200_393600 5.356235
R9715 n1_m1_163200_393600 n1_m1_168000_393600 5.356235
R9716 n1_m1_168000_393600 n1_m1_172000_393600 4.463529
R9717 n1_m1_172800_393600 n1_m1_172000_393600 0.892706
R9718 n1_m1_172800_393600 n1_m1_177600_393600 5.356235
R9719 n1_m1_177600_393600 n1_m1_182400_393600 5.356235
R9720 n1_m1_182400_393600 n1_m1_187200_393600 5.356235
R9721 n1_m1_187200_393600 n1_m1_192000_393600 5.356235
R9722 n1_m1_192000_393600 n1_m1_196800_393600 5.356235
R9723 n1_m1_196800_393600 n1_m1_200000_393600 3.570824
R9724 n1_m1_201600_393600 n1_m1_200000_393600 1.785412
R9725 n1_m1_201600_393600 n1_m1_206400_393600 5.356235
R9726 n1_m1_206400_393600 n1_m1_211200_393600 5.356235
R9727 n1_m1_211200_393600 n1_m1_216000_393600 5.356235
R9728 n1_m1_216000_393600 n1_m1_220800_393600 5.356235
R9729 n1_m1_220800_393600 n1_m1_225600_393600 5.356235
R9730 n1_m1_225600_393600 n1_m1_228000_393600 2.678118
R9731 n1_m1_230400_393600 n1_m1_228000_393600 2.678118
R9732 n1_m1_230400_393600 n1_m1_235200_393600 5.356235
R9733 n1_m1_235200_393600 n1_m1_240000_393600 5.356235
R9734 n1_m1_240000_393600 n1_m1_244800_393600 5.356235
R9735 n1_m1_244800_393600 n1_m1_249600_393600 5.356235
R9736 n1_m1_249600_393600 n1_m1_254400_393600 5.356235
R9737 n1_m1_254400_393600 n1_m1_256000_393600 1.785412
R9738 n1_m1_259200_393600 n1_m1_256000_393600 3.570824
R9739 n1_m1_259200_393600 n1_m1_264000_393600 5.356235
R9740 n1_m1_264000_393600 n1_m1_268800_393600 5.356235
R9741 n1_m1_268800_393600 n1_m1_273600_393600 5.356235
R9742 n1_m1_273600_393600 n1_m1_278400_393600 5.356235
R9743 n1_m1_278400_393600 n1_m1_283200_393600 5.356235
R9744 n1_m1_283200_393600 n1_m1_284000_393600 0.892706
R9745 n1_m1_288000_393600 n1_m1_284000_393600 4.463529
R9746 n1_m1_288000_393600 n1_m1_292800_393600 5.356235
R9747 n1_m1_292800_393600 n1_m1_297600_393600 5.356235
R9748 n1_m1_297600_393600 n1_m1_302400_393600 5.356235
R9749 n1_m1_302400_393600 n1_m1_307200_393600 5.356235
R9750 n1_m1_307200_393600 n1_m1_312000_393600 5.356235
R9751 n1_m1_312000_393600 n1_m1_316800_393600 5.356235
R9752 n1_m1_316800_393600 n1_m1_321600_393600 5.356235
R9753 n1_m1_321600_393600 n1_m1_326400_393600 5.356235
R9754 n1_m1_326400_393600 n1_m1_331200_393600 5.356235
R9755 n1_m1_331200_393600 n1_m1_336000_393600 5.356235
R9756 n1_m1_336000_393600 n1_m1_340000_393600 4.463529
R9757 n1_m1_340800_393600 n1_m1_340000_393600 0.892706
R9758 n1_m1_340800_393600 n1_m1_345600_393600 5.356235
R9759 n1_m1_345600_393600 n1_m1_350400_393600 5.356235
R9760 n1_m1_350400_393600 n1_m1_355200_393600 5.356235
R9761 n1_m1_355200_393600 n1_m1_360000_393600 5.356235
R9762 n1_m1_360000_393600 n1_m1_364800_393600 5.356235
R9763 n1_m1_364800_393600 n1_m1_368000_393600 3.570824
R9764 n1_m1_369600_393600 n1_m1_368000_393600 1.785412
R9765 n1_m1_369600_393600 n1_m1_374400_393600 5.356235
R9766 n1_m1_374400_393600 n1_m1_379200_393600 5.356235
R9767 n1_m1_379200_393600 n1_m1_384000_393600 5.356235
R9768 n1_m1_384000_393600 n1_m1_388800_393600 5.356235
R9769 n1_m1_388800_393600 n1_m1_393600_393600 5.356235
R9770 n1_m1_393600_393600 n1_m1_396000_393600 2.678118
R9771 n1_m1_398400_393600 n1_m1_396000_393600 2.678118
R9772 n1_m1_398400_393600 n1_m1_403200_393600 5.356235
R9773 n1_m1_403200_393600 n1_m1_408000_393600 5.356235
R9774 n1_m1_408000_393600 n1_m1_412800_393600 5.356235
R9775 n1_m1_412800_393600 n1_m1_417600_393600 5.356235
R9776 n1_m1_417600_393600 n1_m1_422400_393600 5.356235
R9777 n1_m1_422400_393600 n1_m1_424000_393600 1.785412
R9778 n1_m1_427200_393600 n1_m1_424000_393600 3.570824
R9779 n1_m1_427200_393600 n1_m1_432000_393600 5.356235
R9780 n1_m1_432000_393600 n1_m1_436800_393600 5.356235
R9781 n1_m1_436800_393600 n1_m1_441600_393600 5.356235
R9782 n1_m1_441600_393600 n1_m1_446400_393600 5.356235
R9783 n1_m1_446400_393600 n1_m1_451200_393600 5.356235
R9784 n1_m1_451200_393600 n1_m1_452000_393600 0.892706
R9785 n1_m1_456000_393600 n1_m1_452000_393600 4.463529
R9786 n1_m1_456000_393600 n1_m1_460800_393600 5.356235
R9787 n1_m1_460800_393600 n1_m1_465600_393600 5.356235
R9788 n1_m1_465600_393600 n1_m1_470400_393600 5.356235
R9789 n1_m1_470400_393600 n1_m1_475200_393600 5.356235
R9790 n1_m1_475200_393600 n1_m1_480000_393600 5.356235
R9791 n1_m1_480000_393600 n1_m1_484800_393600 5.356235
R9792 n1_m1_484800_393600 n1_m1_489600_393600 5.356235
R9793 n1_m1_489600_393600 n1_m1_494400_393600 5.356235
R9794 n1_m1_0_398400 n1_m1_4000_398400 4.463529
R9795 n1_m1_4800_398400 n1_m1_4000_398400 0.892706
R9796 n1_m1_4800_398400 n1_m1_9600_398400 5.356235
R9797 n1_m1_9600_398400 n1_m1_14400_398400 5.356235
R9798 n1_m1_14400_398400 n1_m1_19200_398400 5.356235
R9799 n1_m1_19200_398400 n1_m1_24000_398400 5.356235
R9800 n1_m1_24000_398400 n1_m1_28800_398400 5.356235
R9801 n1_m1_28800_398400 n1_m1_32000_398400 3.570824
R9802 n1_m1_33600_398400 n1_m1_32000_398400 1.785412
R9803 n1_m1_33600_398400 n1_m1_38400_398400 5.356235
R9804 n1_m1_38400_398400 n1_m1_43200_398400 5.356235
R9805 n1_m1_43200_398400 n1_m1_48000_398400 5.356235
R9806 n1_m1_48000_398400 n1_m1_52800_398400 5.356235
R9807 n1_m1_52800_398400 n1_m1_57600_398400 5.356235
R9808 n1_m1_57600_398400 n1_m1_60000_398400 2.678118
R9809 n1_m1_62400_398400 n1_m1_60000_398400 2.678118
R9810 n1_m1_62400_398400 n1_m1_67200_398400 5.356235
R9811 n1_m1_67200_398400 n1_m1_72000_398400 5.356235
R9812 n1_m1_72000_398400 n1_m1_76800_398400 5.356235
R9813 n1_m1_76800_398400 n1_m1_81600_398400 5.356235
R9814 n1_m1_81600_398400 n1_m1_86400_398400 5.356235
R9815 n1_m1_86400_398400 n1_m1_88000_398400 1.785412
R9816 n1_m1_91200_398400 n1_m1_88000_398400 3.570824
R9817 n1_m1_91200_398400 n1_m1_96000_398400 5.356235
R9818 n1_m1_96000_398400 n1_m1_100800_398400 5.356235
R9819 n1_m1_100800_398400 n1_m1_105600_398400 5.356235
R9820 n1_m1_105600_398400 n1_m1_110400_398400 5.356235
R9821 n1_m1_110400_398400 n1_m1_115200_398400 5.356235
R9822 n1_m1_115200_398400 n1_m1_116000_398400 0.892706
R9823 n1_m1_120000_398400 n1_m1_116000_398400 4.463529
R9824 n1_m1_120000_398400 n1_m1_124800_398400 5.356235
R9825 n1_m1_124800_398400 n1_m1_129600_398400 5.356235
R9826 n1_m1_129600_398400 n1_m1_134400_398400 5.356235
R9827 n1_m1_134400_398400 n1_m1_139200_398400 5.356235
R9828 n1_m1_139200_398400 n1_m1_144000_398400 5.356235
R9829 n1_m1_144000_398400 n1_m1_148800_398400 5.356235
R9830 n1_m1_148800_398400 n1_m1_153600_398400 5.356235
R9831 n1_m1_153600_398400 n1_m1_158400_398400 5.356235
R9832 n1_m1_158400_398400 n1_m1_163200_398400 5.356235
R9833 n1_m1_163200_398400 n1_m1_168000_398400 5.356235
R9834 n1_m1_168000_398400 n1_m1_172000_398400 4.463529
R9835 n1_m1_172800_398400 n1_m1_172000_398400 0.892706
R9836 n1_m1_172800_398400 n1_m1_177600_398400 5.356235
R9837 n1_m1_177600_398400 n1_m1_182400_398400 5.356235
R9838 n1_m1_182400_398400 n1_m1_187200_398400 5.356235
R9839 n1_m1_187200_398400 n1_m1_192000_398400 5.356235
R9840 n1_m1_192000_398400 n1_m1_196800_398400 5.356235
R9841 n1_m1_196800_398400 n1_m1_200000_398400 3.570824
R9842 n1_m1_201600_398400 n1_m1_200000_398400 1.785412
R9843 n1_m1_201600_398400 n1_m1_206400_398400 5.356235
R9844 n1_m1_206400_398400 n1_m1_211200_398400 5.356235
R9845 n1_m1_211200_398400 n1_m1_216000_398400 5.356235
R9846 n1_m1_216000_398400 n1_m1_220800_398400 5.356235
R9847 n1_m1_220800_398400 n1_m1_225600_398400 5.356235
R9848 n1_m1_225600_398400 n1_m1_228000_398400 2.678118
R9849 n1_m1_230400_398400 n1_m1_228000_398400 2.678118
R9850 n1_m1_230400_398400 n1_m1_235200_398400 5.356235
R9851 n1_m1_235200_398400 n1_m1_240000_398400 5.356235
R9852 n1_m1_240000_398400 n1_m1_244800_398400 5.356235
R9853 n1_m1_244800_398400 n1_m1_249600_398400 5.356235
R9854 n1_m1_249600_398400 n1_m1_254400_398400 5.356235
R9855 n1_m1_254400_398400 n1_m1_256000_398400 1.785412
R9856 n1_m1_259200_398400 n1_m1_256000_398400 3.570824
R9857 n1_m1_259200_398400 n1_m1_264000_398400 5.356235
R9858 n1_m1_264000_398400 n1_m1_268800_398400 5.356235
R9859 n1_m1_268800_398400 n1_m1_273600_398400 5.356235
R9860 n1_m1_273600_398400 n1_m1_278400_398400 5.356235
R9861 n1_m1_278400_398400 n1_m1_283200_398400 5.356235
R9862 n1_m1_283200_398400 n1_m1_284000_398400 0.892706
R9863 n1_m1_288000_398400 n1_m1_284000_398400 4.463529
R9864 n1_m1_288000_398400 n1_m1_292800_398400 5.356235
R9865 n1_m1_292800_398400 n1_m1_297600_398400 5.356235
R9866 n1_m1_297600_398400 n1_m1_302400_398400 5.356235
R9867 n1_m1_302400_398400 n1_m1_307200_398400 5.356235
R9868 n1_m1_307200_398400 n1_m1_312000_398400 5.356235
R9869 n1_m1_312000_398400 n1_m1_316800_398400 5.356235
R9870 n1_m1_316800_398400 n1_m1_321600_398400 5.356235
R9871 n1_m1_321600_398400 n1_m1_326400_398400 5.356235
R9872 n1_m1_326400_398400 n1_m1_331200_398400 5.356235
R9873 n1_m1_331200_398400 n1_m1_336000_398400 5.356235
R9874 n1_m1_336000_398400 n1_m1_340000_398400 4.463529
R9875 n1_m1_340800_398400 n1_m1_340000_398400 0.892706
R9876 n1_m1_340800_398400 n1_m1_345600_398400 5.356235
R9877 n1_m1_345600_398400 n1_m1_350400_398400 5.356235
R9878 n1_m1_350400_398400 n1_m1_355200_398400 5.356235
R9879 n1_m1_355200_398400 n1_m1_360000_398400 5.356235
R9880 n1_m1_360000_398400 n1_m1_364800_398400 5.356235
R9881 n1_m1_364800_398400 n1_m1_368000_398400 3.570824
R9882 n1_m1_369600_398400 n1_m1_368000_398400 1.785412
R9883 n1_m1_369600_398400 n1_m1_374400_398400 5.356235
R9884 n1_m1_374400_398400 n1_m1_379200_398400 5.356235
R9885 n1_m1_379200_398400 n1_m1_384000_398400 5.356235
R9886 n1_m1_384000_398400 n1_m1_388800_398400 5.356235
R9887 n1_m1_388800_398400 n1_m1_393600_398400 5.356235
R9888 n1_m1_393600_398400 n1_m1_396000_398400 2.678118
R9889 n1_m1_398400_398400 n1_m1_396000_398400 2.678118
R9890 n1_m1_398400_398400 n1_m1_403200_398400 5.356235
R9891 n1_m1_403200_398400 n1_m1_408000_398400 5.356235
R9892 n1_m1_408000_398400 n1_m1_412800_398400 5.356235
R9893 n1_m1_412800_398400 n1_m1_417600_398400 5.356235
R9894 n1_m1_417600_398400 n1_m1_422400_398400 5.356235
R9895 n1_m1_422400_398400 n1_m1_424000_398400 1.785412
R9896 n1_m1_427200_398400 n1_m1_424000_398400 3.570824
R9897 n1_m1_427200_398400 n1_m1_432000_398400 5.356235
R9898 n1_m1_432000_398400 n1_m1_436800_398400 5.356235
R9899 n1_m1_436800_398400 n1_m1_441600_398400 5.356235
R9900 n1_m1_441600_398400 n1_m1_446400_398400 5.356235
R9901 n1_m1_446400_398400 n1_m1_451200_398400 5.356235
R9902 n1_m1_451200_398400 n1_m1_452000_398400 0.892706
R9903 n1_m1_456000_398400 n1_m1_452000_398400 4.463529
R9904 n1_m1_456000_398400 n1_m1_460800_398400 5.356235
R9905 n1_m1_460800_398400 n1_m1_465600_398400 5.356235
R9906 n1_m1_465600_398400 n1_m1_470400_398400 5.356235
R9907 n1_m1_470400_398400 n1_m1_475200_398400 5.356235
R9908 n1_m1_475200_398400 n1_m1_480000_398400 5.356235
R9909 n1_m1_480000_398400 n1_m1_484800_398400 5.356235
R9910 n1_m1_484800_398400 n1_m1_489600_398400 5.356235
R9911 n1_m1_489600_398400 n1_m1_494400_398400 5.356235
R9912 n1_m1_0_403200 n1_m1_4000_403200 4.463529
R9913 n1_m1_4800_403200 n1_m1_4000_403200 0.892706
R9914 n1_m1_4800_403200 n1_m1_9600_403200 5.356235
R9915 n1_m1_9600_403200 n1_m1_14400_403200 5.356235
R9916 n1_m1_14400_403200 n1_m1_19200_403200 5.356235
R9917 n1_m1_19200_403200 n1_m1_24000_403200 5.356235
R9918 n1_m1_24000_403200 n1_m1_28800_403200 5.356235
R9919 n1_m1_28800_403200 n1_m1_32000_403200 3.570824
R9920 n1_m1_33600_403200 n1_m1_32000_403200 1.785412
R9921 n1_m1_33600_403200 n1_m1_38400_403200 5.356235
R9922 n1_m1_38400_403200 n1_m1_43200_403200 5.356235
R9923 n1_m1_43200_403200 n1_m1_48000_403200 5.356235
R9924 n1_m1_48000_403200 n1_m1_52800_403200 5.356235
R9925 n1_m1_52800_403200 n1_m1_57600_403200 5.356235
R9926 n1_m1_57600_403200 n1_m1_60000_403200 2.678118
R9927 n1_m1_62400_403200 n1_m1_60000_403200 2.678118
R9928 n1_m1_62400_403200 n1_m1_67200_403200 5.356235
R9929 n1_m1_67200_403200 n1_m1_72000_403200 5.356235
R9930 n1_m1_72000_403200 n1_m1_76800_403200 5.356235
R9931 n1_m1_76800_403200 n1_m1_81600_403200 5.356235
R9932 n1_m1_81600_403200 n1_m1_86400_403200 5.356235
R9933 n1_m1_86400_403200 n1_m1_88000_403200 1.785412
R9934 n1_m1_91200_403200 n1_m1_88000_403200 3.570824
R9935 n1_m1_91200_403200 n1_m1_96000_403200 5.356235
R9936 n1_m1_96000_403200 n1_m1_100800_403200 5.356235
R9937 n1_m1_100800_403200 n1_m1_105600_403200 5.356235
R9938 n1_m1_105600_403200 n1_m1_110400_403200 5.356235
R9939 n1_m1_110400_403200 n1_m1_115200_403200 5.356235
R9940 n1_m1_115200_403200 n1_m1_116000_403200 0.892706
R9941 n1_m1_120000_403200 n1_m1_116000_403200 4.463529
R9942 n1_m1_120000_403200 n1_m1_124800_403200 5.356235
R9943 n1_m1_124800_403200 n1_m1_129600_403200 5.356235
R9944 n1_m1_129600_403200 n1_m1_134400_403200 5.356235
R9945 n1_m1_134400_403200 n1_m1_139200_403200 5.356235
R9946 n1_m1_139200_403200 n1_m1_144000_403200 5.356235
R9947 n1_m1_144000_403200 n1_m1_148800_403200 5.356235
R9948 n1_m1_148800_403200 n1_m1_153600_403200 5.356235
R9949 n1_m1_153600_403200 n1_m1_158400_403200 5.356235
R9950 n1_m1_158400_403200 n1_m1_163200_403200 5.356235
R9951 n1_m1_163200_403200 n1_m1_168000_403200 5.356235
R9952 n1_m1_168000_403200 n1_m1_172000_403200 4.463529
R9953 n1_m1_172800_403200 n1_m1_172000_403200 0.892706
R9954 n1_m1_172800_403200 n1_m1_177600_403200 5.356235
R9955 n1_m1_177600_403200 n1_m1_182400_403200 5.356235
R9956 n1_m1_182400_403200 n1_m1_187200_403200 5.356235
R9957 n1_m1_187200_403200 n1_m1_192000_403200 5.356235
R9958 n1_m1_192000_403200 n1_m1_196800_403200 5.356235
R9959 n1_m1_196800_403200 n1_m1_200000_403200 3.570824
R9960 n1_m1_201600_403200 n1_m1_200000_403200 1.785412
R9961 n1_m1_201600_403200 n1_m1_206400_403200 5.356235
R9962 n1_m1_206400_403200 n1_m1_211200_403200 5.356235
R9963 n1_m1_211200_403200 n1_m1_216000_403200 5.356235
R9964 n1_m1_216000_403200 n1_m1_220800_403200 5.356235
R9965 n1_m1_220800_403200 n1_m1_225600_403200 5.356235
R9966 n1_m1_225600_403200 n1_m1_228000_403200 2.678118
R9967 n1_m1_230400_403200 n1_m1_228000_403200 2.678118
R9968 n1_m1_230400_403200 n1_m1_235200_403200 5.356235
R9969 n1_m1_235200_403200 n1_m1_240000_403200 5.356235
R9970 n1_m1_240000_403200 n1_m1_244800_403200 5.356235
R9971 n1_m1_244800_403200 n1_m1_249600_403200 5.356235
R9972 n1_m1_249600_403200 n1_m1_254400_403200 5.356235
R9973 n1_m1_254400_403200 n1_m1_256000_403200 1.785412
R9974 n1_m1_259200_403200 n1_m1_256000_403200 3.570824
R9975 n1_m1_259200_403200 n1_m1_264000_403200 5.356235
R9976 n1_m1_264000_403200 n1_m1_268800_403200 5.356235
R9977 n1_m1_268800_403200 n1_m1_273600_403200 5.356235
R9978 n1_m1_273600_403200 n1_m1_278400_403200 5.356235
R9979 n1_m1_278400_403200 n1_m1_283200_403200 5.356235
R9980 n1_m1_283200_403200 n1_m1_284000_403200 0.892706
R9981 n1_m1_288000_403200 n1_m1_284000_403200 4.463529
R9982 n1_m1_288000_403200 n1_m1_292800_403200 5.356235
R9983 n1_m1_292800_403200 n1_m1_297600_403200 5.356235
R9984 n1_m1_297600_403200 n1_m1_302400_403200 5.356235
R9985 n1_m1_302400_403200 n1_m1_307200_403200 5.356235
R9986 n1_m1_307200_403200 n1_m1_312000_403200 5.356235
R9987 n1_m1_312000_403200 n1_m1_316800_403200 5.356235
R9988 n1_m1_316800_403200 n1_m1_321600_403200 5.356235
R9989 n1_m1_321600_403200 n1_m1_326400_403200 5.356235
R9990 n1_m1_326400_403200 n1_m1_331200_403200 5.356235
R9991 n1_m1_331200_403200 n1_m1_336000_403200 5.356235
R9992 n1_m1_336000_403200 n1_m1_340000_403200 4.463529
R9993 n1_m1_340800_403200 n1_m1_340000_403200 0.892706
R9994 n1_m1_340800_403200 n1_m1_345600_403200 5.356235
R9995 n1_m1_345600_403200 n1_m1_350400_403200 5.356235
R9996 n1_m1_350400_403200 n1_m1_355200_403200 5.356235
R9997 n1_m1_355200_403200 n1_m1_360000_403200 5.356235
R9998 n1_m1_360000_403200 n1_m1_364800_403200 5.356235
R9999 n1_m1_364800_403200 n1_m1_368000_403200 3.570824
R10000 n1_m1_369600_403200 n1_m1_368000_403200 1.785412
R10001 n1_m1_369600_403200 n1_m1_374400_403200 5.356235
R10002 n1_m1_374400_403200 n1_m1_379200_403200 5.356235
R10003 n1_m1_379200_403200 n1_m1_384000_403200 5.356235
R10004 n1_m1_384000_403200 n1_m1_388800_403200 5.356235
R10005 n1_m1_388800_403200 n1_m1_393600_403200 5.356235
R10006 n1_m1_393600_403200 n1_m1_396000_403200 2.678118
R10007 n1_m1_398400_403200 n1_m1_396000_403200 2.678118
R10008 n1_m1_398400_403200 n1_m1_403200_403200 5.356235
R10009 n1_m1_403200_403200 n1_m1_408000_403200 5.356235
R10010 n1_m1_408000_403200 n1_m1_412800_403200 5.356235
R10011 n1_m1_412800_403200 n1_m1_417600_403200 5.356235
R10012 n1_m1_417600_403200 n1_m1_422400_403200 5.356235
R10013 n1_m1_422400_403200 n1_m1_424000_403200 1.785412
R10014 n1_m1_427200_403200 n1_m1_424000_403200 3.570824
R10015 n1_m1_427200_403200 n1_m1_432000_403200 5.356235
R10016 n1_m1_432000_403200 n1_m1_436800_403200 5.356235
R10017 n1_m1_436800_403200 n1_m1_441600_403200 5.356235
R10018 n1_m1_441600_403200 n1_m1_446400_403200 5.356235
R10019 n1_m1_446400_403200 n1_m1_451200_403200 5.356235
R10020 n1_m1_451200_403200 n1_m1_452000_403200 0.892706
R10021 n1_m1_456000_403200 n1_m1_452000_403200 4.463529
R10022 n1_m1_456000_403200 n1_m1_460800_403200 5.356235
R10023 n1_m1_460800_403200 n1_m1_465600_403200 5.356235
R10024 n1_m1_465600_403200 n1_m1_470400_403200 5.356235
R10025 n1_m1_470400_403200 n1_m1_475200_403200 5.356235
R10026 n1_m1_475200_403200 n1_m1_480000_403200 5.356235
R10027 n1_m1_480000_403200 n1_m1_484800_403200 5.356235
R10028 n1_m1_484800_403200 n1_m1_489600_403200 5.356235
R10029 n1_m1_489600_403200 n1_m1_494400_403200 5.356235
R10030 n1_m1_0_408000 n1_m1_4000_408000 4.463529
R10031 n1_m1_4800_408000 n1_m1_4000_408000 0.892706
R10032 n1_m1_4800_408000 n1_m1_9600_408000 5.356235
R10033 n1_m1_9600_408000 n1_m1_14400_408000 5.356235
R10034 n1_m1_14400_408000 n1_m1_19200_408000 5.356235
R10035 n1_m1_19200_408000 n1_m1_24000_408000 5.356235
R10036 n1_m1_24000_408000 n1_m1_28800_408000 5.356235
R10037 n1_m1_28800_408000 n1_m1_32000_408000 3.570824
R10038 n1_m1_33600_408000 n1_m1_32000_408000 1.785412
R10039 n1_m1_33600_408000 n1_m1_38400_408000 5.356235
R10040 n1_m1_38400_408000 n1_m1_43200_408000 5.356235
R10041 n1_m1_43200_408000 n1_m1_48000_408000 5.356235
R10042 n1_m1_48000_408000 n1_m1_52800_408000 5.356235
R10043 n1_m1_52800_408000 n1_m1_57600_408000 5.356235
R10044 n1_m1_57600_408000 n1_m1_60000_408000 2.678118
R10045 n1_m1_62400_408000 n1_m1_60000_408000 2.678118
R10046 n1_m1_62400_408000 n1_m1_67200_408000 5.356235
R10047 n1_m1_67200_408000 n1_m1_72000_408000 5.356235
R10048 n1_m1_72000_408000 n1_m1_76800_408000 5.356235
R10049 n1_m1_76800_408000 n1_m1_81600_408000 5.356235
R10050 n1_m1_81600_408000 n1_m1_86400_408000 5.356235
R10051 n1_m1_86400_408000 n1_m1_88000_408000 1.785412
R10052 n1_m1_91200_408000 n1_m1_88000_408000 3.570824
R10053 n1_m1_91200_408000 n1_m1_96000_408000 5.356235
R10054 n1_m1_96000_408000 n1_m1_100800_408000 5.356235
R10055 n1_m1_100800_408000 n1_m1_105600_408000 5.356235
R10056 n1_m1_105600_408000 n1_m1_110400_408000 5.356235
R10057 n1_m1_110400_408000 n1_m1_115200_408000 5.356235
R10058 n1_m1_115200_408000 n1_m1_116000_408000 0.892706
R10059 n1_m1_120000_408000 n1_m1_116000_408000 4.463529
R10060 n1_m1_120000_408000 n1_m1_124800_408000 5.356235
R10061 n1_m1_124800_408000 n1_m1_129600_408000 5.356235
R10062 n1_m1_129600_408000 n1_m1_134400_408000 5.356235
R10063 n1_m1_134400_408000 n1_m1_139200_408000 5.356235
R10064 n1_m1_139200_408000 n1_m1_144000_408000 5.356235
R10065 n1_m1_144000_408000 n1_m1_148800_408000 5.356235
R10066 n1_m1_148800_408000 n1_m1_153600_408000 5.356235
R10067 n1_m1_153600_408000 n1_m1_158400_408000 5.356235
R10068 n1_m1_158400_408000 n1_m1_163200_408000 5.356235
R10069 n1_m1_163200_408000 n1_m1_168000_408000 5.356235
R10070 n1_m1_168000_408000 n1_m1_172000_408000 4.463529
R10071 n1_m1_172800_408000 n1_m1_172000_408000 0.892706
R10072 n1_m1_172800_408000 n1_m1_177600_408000 5.356235
R10073 n1_m1_177600_408000 n1_m1_182400_408000 5.356235
R10074 n1_m1_182400_408000 n1_m1_187200_408000 5.356235
R10075 n1_m1_187200_408000 n1_m1_192000_408000 5.356235
R10076 n1_m1_192000_408000 n1_m1_196800_408000 5.356235
R10077 n1_m1_196800_408000 n1_m1_200000_408000 3.570824
R10078 n1_m1_201600_408000 n1_m1_200000_408000 1.785412
R10079 n1_m1_201600_408000 n1_m1_206400_408000 5.356235
R10080 n1_m1_206400_408000 n1_m1_211200_408000 5.356235
R10081 n1_m1_211200_408000 n1_m1_216000_408000 5.356235
R10082 n1_m1_216000_408000 n1_m1_220800_408000 5.356235
R10083 n1_m1_220800_408000 n1_m1_225600_408000 5.356235
R10084 n1_m1_225600_408000 n1_m1_228000_408000 2.678118
R10085 n1_m1_230400_408000 n1_m1_228000_408000 2.678118
R10086 n1_m1_230400_408000 n1_m1_235200_408000 5.356235
R10087 n1_m1_235200_408000 n1_m1_240000_408000 5.356235
R10088 n1_m1_240000_408000 n1_m1_244800_408000 5.356235
R10089 n1_m1_244800_408000 n1_m1_249600_408000 5.356235
R10090 n1_m1_249600_408000 n1_m1_254400_408000 5.356235
R10091 n1_m1_254400_408000 n1_m1_256000_408000 1.785412
R10092 n1_m1_259200_408000 n1_m1_256000_408000 3.570824
R10093 n1_m1_259200_408000 n1_m1_264000_408000 5.356235
R10094 n1_m1_264000_408000 n1_m1_268800_408000 5.356235
R10095 n1_m1_268800_408000 n1_m1_273600_408000 5.356235
R10096 n1_m1_273600_408000 n1_m1_278400_408000 5.356235
R10097 n1_m1_278400_408000 n1_m1_283200_408000 5.356235
R10098 n1_m1_283200_408000 n1_m1_284000_408000 0.892706
R10099 n1_m1_288000_408000 n1_m1_284000_408000 4.463529
R10100 n1_m1_288000_408000 n1_m1_292800_408000 5.356235
R10101 n1_m1_292800_408000 n1_m1_297600_408000 5.356235
R10102 n1_m1_297600_408000 n1_m1_302400_408000 5.356235
R10103 n1_m1_302400_408000 n1_m1_307200_408000 5.356235
R10104 n1_m1_307200_408000 n1_m1_312000_408000 5.356235
R10105 n1_m1_312000_408000 n1_m1_316800_408000 5.356235
R10106 n1_m1_316800_408000 n1_m1_321600_408000 5.356235
R10107 n1_m1_321600_408000 n1_m1_326400_408000 5.356235
R10108 n1_m1_326400_408000 n1_m1_331200_408000 5.356235
R10109 n1_m1_331200_408000 n1_m1_336000_408000 5.356235
R10110 n1_m1_336000_408000 n1_m1_340000_408000 4.463529
R10111 n1_m1_340800_408000 n1_m1_340000_408000 0.892706
R10112 n1_m1_340800_408000 n1_m1_345600_408000 5.356235
R10113 n1_m1_345600_408000 n1_m1_350400_408000 5.356235
R10114 n1_m1_350400_408000 n1_m1_355200_408000 5.356235
R10115 n1_m1_355200_408000 n1_m1_360000_408000 5.356235
R10116 n1_m1_360000_408000 n1_m1_364800_408000 5.356235
R10117 n1_m1_364800_408000 n1_m1_368000_408000 3.570824
R10118 n1_m1_369600_408000 n1_m1_368000_408000 1.785412
R10119 n1_m1_369600_408000 n1_m1_374400_408000 5.356235
R10120 n1_m1_374400_408000 n1_m1_379200_408000 5.356235
R10121 n1_m1_379200_408000 n1_m1_384000_408000 5.356235
R10122 n1_m1_384000_408000 n1_m1_388800_408000 5.356235
R10123 n1_m1_388800_408000 n1_m1_393600_408000 5.356235
R10124 n1_m1_393600_408000 n1_m1_396000_408000 2.678118
R10125 n1_m1_398400_408000 n1_m1_396000_408000 2.678118
R10126 n1_m1_398400_408000 n1_m1_403200_408000 5.356235
R10127 n1_m1_403200_408000 n1_m1_408000_408000 5.356235
R10128 n1_m1_408000_408000 n1_m1_412800_408000 5.356235
R10129 n1_m1_412800_408000 n1_m1_417600_408000 5.356235
R10130 n1_m1_417600_408000 n1_m1_422400_408000 5.356235
R10131 n1_m1_422400_408000 n1_m1_424000_408000 1.785412
R10132 n1_m1_427200_408000 n1_m1_424000_408000 3.570824
R10133 n1_m1_427200_408000 n1_m1_432000_408000 5.356235
R10134 n1_m1_432000_408000 n1_m1_436800_408000 5.356235
R10135 n1_m1_436800_408000 n1_m1_441600_408000 5.356235
R10136 n1_m1_441600_408000 n1_m1_446400_408000 5.356235
R10137 n1_m1_446400_408000 n1_m1_451200_408000 5.356235
R10138 n1_m1_451200_408000 n1_m1_452000_408000 0.892706
R10139 n1_m1_456000_408000 n1_m1_452000_408000 4.463529
R10140 n1_m1_456000_408000 n1_m1_460800_408000 5.356235
R10141 n1_m1_460800_408000 n1_m1_465600_408000 5.356235
R10142 n1_m1_465600_408000 n1_m1_470400_408000 5.356235
R10143 n1_m1_470400_408000 n1_m1_475200_408000 5.356235
R10144 n1_m1_475200_408000 n1_m1_480000_408000 5.356235
R10145 n1_m1_480000_408000 n1_m1_484800_408000 5.356235
R10146 n1_m1_484800_408000 n1_m1_489600_408000 5.356235
R10147 n1_m1_489600_408000 n1_m1_494400_408000 5.356235
R10148 n1_m1_0_412800 n1_m1_4000_412800 4.463529
R10149 n1_m1_4800_412800 n1_m1_4000_412800 0.892706
R10150 n1_m1_4800_412800 n1_m1_9600_412800 5.356235
R10151 n1_m1_9600_412800 n1_m1_14400_412800 5.356235
R10152 n1_m1_14400_412800 n1_m1_19200_412800 5.356235
R10153 n1_m1_19200_412800 n1_m1_24000_412800 5.356235
R10154 n1_m1_24000_412800 n1_m1_28800_412800 5.356235
R10155 n1_m1_28800_412800 n1_m1_32000_412800 3.570824
R10156 n1_m1_33600_412800 n1_m1_32000_412800 1.785412
R10157 n1_m1_33600_412800 n1_m1_38400_412800 5.356235
R10158 n1_m1_38400_412800 n1_m1_43200_412800 5.356235
R10159 n1_m1_43200_412800 n1_m1_48000_412800 5.356235
R10160 n1_m1_48000_412800 n1_m1_52800_412800 5.356235
R10161 n1_m1_52800_412800 n1_m1_57600_412800 5.356235
R10162 n1_m1_57600_412800 n1_m1_60000_412800 2.678118
R10163 n1_m1_62400_412800 n1_m1_60000_412800 2.678118
R10164 n1_m1_62400_412800 n1_m1_67200_412800 5.356235
R10165 n1_m1_67200_412800 n1_m1_72000_412800 5.356235
R10166 n1_m1_72000_412800 n1_m1_76800_412800 5.356235
R10167 n1_m1_76800_412800 n1_m1_81600_412800 5.356235
R10168 n1_m1_81600_412800 n1_m1_86400_412800 5.356235
R10169 n1_m1_86400_412800 n1_m1_88000_412800 1.785412
R10170 n1_m1_91200_412800 n1_m1_88000_412800 3.570824
R10171 n1_m1_91200_412800 n1_m1_96000_412800 5.356235
R10172 n1_m1_96000_412800 n1_m1_100800_412800 5.356235
R10173 n1_m1_100800_412800 n1_m1_105600_412800 5.356235
R10174 n1_m1_105600_412800 n1_m1_110400_412800 5.356235
R10175 n1_m1_110400_412800 n1_m1_115200_412800 5.356235
R10176 n1_m1_115200_412800 n1_m1_116000_412800 0.892706
R10177 n1_m1_120000_412800 n1_m1_116000_412800 4.463529
R10178 n1_m1_120000_412800 n1_m1_124800_412800 5.356235
R10179 n1_m1_124800_412800 n1_m1_129600_412800 5.356235
R10180 n1_m1_129600_412800 n1_m1_134400_412800 5.356235
R10181 n1_m1_134400_412800 n1_m1_139200_412800 5.356235
R10182 n1_m1_139200_412800 n1_m1_144000_412800 5.356235
R10183 n1_m1_144000_412800 n1_m1_148800_412800 5.356235
R10184 n1_m1_148800_412800 n1_m1_153600_412800 5.356235
R10185 n1_m1_153600_412800 n1_m1_158400_412800 5.356235
R10186 n1_m1_158400_412800 n1_m1_163200_412800 5.356235
R10187 n1_m1_163200_412800 n1_m1_168000_412800 5.356235
R10188 n1_m1_168000_412800 n1_m1_172000_412800 4.463529
R10189 n1_m1_172800_412800 n1_m1_172000_412800 0.892706
R10190 n1_m1_172800_412800 n1_m1_177600_412800 5.356235
R10191 n1_m1_177600_412800 n1_m1_182400_412800 5.356235
R10192 n1_m1_182400_412800 n1_m1_187200_412800 5.356235
R10193 n1_m1_187200_412800 n1_m1_192000_412800 5.356235
R10194 n1_m1_192000_412800 n1_m1_196800_412800 5.356235
R10195 n1_m1_196800_412800 n1_m1_200000_412800 3.570824
R10196 n1_m1_201600_412800 n1_m1_200000_412800 1.785412
R10197 n1_m1_201600_412800 n1_m1_206400_412800 5.356235
R10198 n1_m1_206400_412800 n1_m1_211200_412800 5.356235
R10199 n1_m1_211200_412800 n1_m1_216000_412800 5.356235
R10200 n1_m1_216000_412800 n1_m1_220800_412800 5.356235
R10201 n1_m1_220800_412800 n1_m1_225600_412800 5.356235
R10202 n1_m1_225600_412800 n1_m1_228000_412800 2.678118
R10203 n1_m1_230400_412800 n1_m1_228000_412800 2.678118
R10204 n1_m1_230400_412800 n1_m1_235200_412800 5.356235
R10205 n1_m1_235200_412800 n1_m1_240000_412800 5.356235
R10206 n1_m1_240000_412800 n1_m1_244800_412800 5.356235
R10207 n1_m1_244800_412800 n1_m1_249600_412800 5.356235
R10208 n1_m1_249600_412800 n1_m1_254400_412800 5.356235
R10209 n1_m1_254400_412800 n1_m1_256000_412800 1.785412
R10210 n1_m1_259200_412800 n1_m1_256000_412800 3.570824
R10211 n1_m1_259200_412800 n1_m1_264000_412800 5.356235
R10212 n1_m1_264000_412800 n1_m1_268800_412800 5.356235
R10213 n1_m1_268800_412800 n1_m1_273600_412800 5.356235
R10214 n1_m1_273600_412800 n1_m1_278400_412800 5.356235
R10215 n1_m1_278400_412800 n1_m1_283200_412800 5.356235
R10216 n1_m1_283200_412800 n1_m1_284000_412800 0.892706
R10217 n1_m1_288000_412800 n1_m1_284000_412800 4.463529
R10218 n1_m1_288000_412800 n1_m1_292800_412800 5.356235
R10219 n1_m1_292800_412800 n1_m1_297600_412800 5.356235
R10220 n1_m1_297600_412800 n1_m1_302400_412800 5.356235
R10221 n1_m1_302400_412800 n1_m1_307200_412800 5.356235
R10222 n1_m1_307200_412800 n1_m1_312000_412800 5.356235
R10223 n1_m1_312000_412800 n1_m1_316800_412800 5.356235
R10224 n1_m1_316800_412800 n1_m1_321600_412800 5.356235
R10225 n1_m1_321600_412800 n1_m1_326400_412800 5.356235
R10226 n1_m1_326400_412800 n1_m1_331200_412800 5.356235
R10227 n1_m1_331200_412800 n1_m1_336000_412800 5.356235
R10228 n1_m1_336000_412800 n1_m1_340000_412800 4.463529
R10229 n1_m1_340800_412800 n1_m1_340000_412800 0.892706
R10230 n1_m1_340800_412800 n1_m1_345600_412800 5.356235
R10231 n1_m1_345600_412800 n1_m1_350400_412800 5.356235
R10232 n1_m1_350400_412800 n1_m1_355200_412800 5.356235
R10233 n1_m1_355200_412800 n1_m1_360000_412800 5.356235
R10234 n1_m1_360000_412800 n1_m1_364800_412800 5.356235
R10235 n1_m1_364800_412800 n1_m1_368000_412800 3.570824
R10236 n1_m1_369600_412800 n1_m1_368000_412800 1.785412
R10237 n1_m1_369600_412800 n1_m1_374400_412800 5.356235
R10238 n1_m1_374400_412800 n1_m1_379200_412800 5.356235
R10239 n1_m1_379200_412800 n1_m1_384000_412800 5.356235
R10240 n1_m1_384000_412800 n1_m1_388800_412800 5.356235
R10241 n1_m1_388800_412800 n1_m1_393600_412800 5.356235
R10242 n1_m1_393600_412800 n1_m1_396000_412800 2.678118
R10243 n1_m1_398400_412800 n1_m1_396000_412800 2.678118
R10244 n1_m1_398400_412800 n1_m1_403200_412800 5.356235
R10245 n1_m1_403200_412800 n1_m1_408000_412800 5.356235
R10246 n1_m1_408000_412800 n1_m1_412800_412800 5.356235
R10247 n1_m1_412800_412800 n1_m1_417600_412800 5.356235
R10248 n1_m1_417600_412800 n1_m1_422400_412800 5.356235
R10249 n1_m1_422400_412800 n1_m1_424000_412800 1.785412
R10250 n1_m1_427200_412800 n1_m1_424000_412800 3.570824
R10251 n1_m1_427200_412800 n1_m1_432000_412800 5.356235
R10252 n1_m1_432000_412800 n1_m1_436800_412800 5.356235
R10253 n1_m1_436800_412800 n1_m1_441600_412800 5.356235
R10254 n1_m1_441600_412800 n1_m1_446400_412800 5.356235
R10255 n1_m1_446400_412800 n1_m1_451200_412800 5.356235
R10256 n1_m1_451200_412800 n1_m1_452000_412800 0.892706
R10257 n1_m1_456000_412800 n1_m1_452000_412800 4.463529
R10258 n1_m1_456000_412800 n1_m1_460800_412800 5.356235
R10259 n1_m1_460800_412800 n1_m1_465600_412800 5.356235
R10260 n1_m1_465600_412800 n1_m1_470400_412800 5.356235
R10261 n1_m1_470400_412800 n1_m1_475200_412800 5.356235
R10262 n1_m1_475200_412800 n1_m1_480000_412800 5.356235
R10263 n1_m1_480000_412800 n1_m1_484800_412800 5.356235
R10264 n1_m1_484800_412800 n1_m1_489600_412800 5.356235
R10265 n1_m1_489600_412800 n1_m1_494400_412800 5.356235
R10266 n1_m1_0_417600 n1_m1_4000_417600 4.463529
R10267 n1_m1_4800_417600 n1_m1_4000_417600 0.892706
R10268 n1_m1_4800_417600 n1_m1_9600_417600 5.356235
R10269 n1_m1_9600_417600 n1_m1_14400_417600 5.356235
R10270 n1_m1_14400_417600 n1_m1_19200_417600 5.356235
R10271 n1_m1_19200_417600 n1_m1_24000_417600 5.356235
R10272 n1_m1_24000_417600 n1_m1_28800_417600 5.356235
R10273 n1_m1_28800_417600 n1_m1_32000_417600 3.570824
R10274 n1_m1_33600_417600 n1_m1_32000_417600 1.785412
R10275 n1_m1_33600_417600 n1_m1_38400_417600 5.356235
R10276 n1_m1_38400_417600 n1_m1_43200_417600 5.356235
R10277 n1_m1_43200_417600 n1_m1_48000_417600 5.356235
R10278 n1_m1_48000_417600 n1_m1_52800_417600 5.356235
R10279 n1_m1_52800_417600 n1_m1_57600_417600 5.356235
R10280 n1_m1_57600_417600 n1_m1_60000_417600 2.678118
R10281 n1_m1_62400_417600 n1_m1_60000_417600 2.678118
R10282 n1_m1_62400_417600 n1_m1_67200_417600 5.356235
R10283 n1_m1_67200_417600 n1_m1_72000_417600 5.356235
R10284 n1_m1_72000_417600 n1_m1_76800_417600 5.356235
R10285 n1_m1_76800_417600 n1_m1_81600_417600 5.356235
R10286 n1_m1_81600_417600 n1_m1_86400_417600 5.356235
R10287 n1_m1_86400_417600 n1_m1_88000_417600 1.785412
R10288 n1_m1_91200_417600 n1_m1_88000_417600 3.570824
R10289 n1_m1_91200_417600 n1_m1_96000_417600 5.356235
R10290 n1_m1_96000_417600 n1_m1_100800_417600 5.356235
R10291 n1_m1_100800_417600 n1_m1_105600_417600 5.356235
R10292 n1_m1_105600_417600 n1_m1_110400_417600 5.356235
R10293 n1_m1_110400_417600 n1_m1_115200_417600 5.356235
R10294 n1_m1_115200_417600 n1_m1_116000_417600 0.892706
R10295 n1_m1_120000_417600 n1_m1_116000_417600 4.463529
R10296 n1_m1_120000_417600 n1_m1_124800_417600 5.356235
R10297 n1_m1_124800_417600 n1_m1_129600_417600 5.356235
R10298 n1_m1_129600_417600 n1_m1_134400_417600 5.356235
R10299 n1_m1_134400_417600 n1_m1_139200_417600 5.356235
R10300 n1_m1_139200_417600 n1_m1_144000_417600 5.356235
R10301 n1_m1_144000_417600 n1_m1_148800_417600 5.356235
R10302 n1_m1_148800_417600 n1_m1_153600_417600 5.356235
R10303 n1_m1_153600_417600 n1_m1_158400_417600 5.356235
R10304 n1_m1_158400_417600 n1_m1_163200_417600 5.356235
R10305 n1_m1_163200_417600 n1_m1_168000_417600 5.356235
R10306 n1_m1_168000_417600 n1_m1_172000_417600 4.463529
R10307 n1_m1_172800_417600 n1_m1_172000_417600 0.892706
R10308 n1_m1_172800_417600 n1_m1_177600_417600 5.356235
R10309 n1_m1_177600_417600 n1_m1_182400_417600 5.356235
R10310 n1_m1_182400_417600 n1_m1_187200_417600 5.356235
R10311 n1_m1_187200_417600 n1_m1_192000_417600 5.356235
R10312 n1_m1_192000_417600 n1_m1_196800_417600 5.356235
R10313 n1_m1_196800_417600 n1_m1_200000_417600 3.570824
R10314 n1_m1_201600_417600 n1_m1_200000_417600 1.785412
R10315 n1_m1_201600_417600 n1_m1_206400_417600 5.356235
R10316 n1_m1_206400_417600 n1_m1_211200_417600 5.356235
R10317 n1_m1_211200_417600 n1_m1_216000_417600 5.356235
R10318 n1_m1_216000_417600 n1_m1_220800_417600 5.356235
R10319 n1_m1_220800_417600 n1_m1_225600_417600 5.356235
R10320 n1_m1_225600_417600 n1_m1_228000_417600 2.678118
R10321 n1_m1_230400_417600 n1_m1_228000_417600 2.678118
R10322 n1_m1_230400_417600 n1_m1_235200_417600 5.356235
R10323 n1_m1_235200_417600 n1_m1_240000_417600 5.356235
R10324 n1_m1_240000_417600 n1_m1_244800_417600 5.356235
R10325 n1_m1_244800_417600 n1_m1_249600_417600 5.356235
R10326 n1_m1_249600_417600 n1_m1_254400_417600 5.356235
R10327 n1_m1_254400_417600 n1_m1_256000_417600 1.785412
R10328 n1_m1_259200_417600 n1_m1_256000_417600 3.570824
R10329 n1_m1_259200_417600 n1_m1_264000_417600 5.356235
R10330 n1_m1_264000_417600 n1_m1_268800_417600 5.356235
R10331 n1_m1_268800_417600 n1_m1_273600_417600 5.356235
R10332 n1_m1_273600_417600 n1_m1_278400_417600 5.356235
R10333 n1_m1_278400_417600 n1_m1_283200_417600 5.356235
R10334 n1_m1_283200_417600 n1_m1_284000_417600 0.892706
R10335 n1_m1_288000_417600 n1_m1_284000_417600 4.463529
R10336 n1_m1_288000_417600 n1_m1_292800_417600 5.356235
R10337 n1_m1_292800_417600 n1_m1_297600_417600 5.356235
R10338 n1_m1_297600_417600 n1_m1_302400_417600 5.356235
R10339 n1_m1_302400_417600 n1_m1_307200_417600 5.356235
R10340 n1_m1_307200_417600 n1_m1_312000_417600 5.356235
R10341 n1_m1_312000_417600 n1_m1_316800_417600 5.356235
R10342 n1_m1_316800_417600 n1_m1_321600_417600 5.356235
R10343 n1_m1_321600_417600 n1_m1_326400_417600 5.356235
R10344 n1_m1_326400_417600 n1_m1_331200_417600 5.356235
R10345 n1_m1_331200_417600 n1_m1_336000_417600 5.356235
R10346 n1_m1_336000_417600 n1_m1_340000_417600 4.463529
R10347 n1_m1_340800_417600 n1_m1_340000_417600 0.892706
R10348 n1_m1_340800_417600 n1_m1_345600_417600 5.356235
R10349 n1_m1_345600_417600 n1_m1_350400_417600 5.356235
R10350 n1_m1_350400_417600 n1_m1_355200_417600 5.356235
R10351 n1_m1_355200_417600 n1_m1_360000_417600 5.356235
R10352 n1_m1_360000_417600 n1_m1_364800_417600 5.356235
R10353 n1_m1_364800_417600 n1_m1_368000_417600 3.570824
R10354 n1_m1_369600_417600 n1_m1_368000_417600 1.785412
R10355 n1_m1_369600_417600 n1_m1_374400_417600 5.356235
R10356 n1_m1_374400_417600 n1_m1_379200_417600 5.356235
R10357 n1_m1_379200_417600 n1_m1_384000_417600 5.356235
R10358 n1_m1_384000_417600 n1_m1_388800_417600 5.356235
R10359 n1_m1_388800_417600 n1_m1_393600_417600 5.356235
R10360 n1_m1_393600_417600 n1_m1_396000_417600 2.678118
R10361 n1_m1_398400_417600 n1_m1_396000_417600 2.678118
R10362 n1_m1_398400_417600 n1_m1_403200_417600 5.356235
R10363 n1_m1_403200_417600 n1_m1_408000_417600 5.356235
R10364 n1_m1_408000_417600 n1_m1_412800_417600 5.356235
R10365 n1_m1_412800_417600 n1_m1_417600_417600 5.356235
R10366 n1_m1_417600_417600 n1_m1_422400_417600 5.356235
R10367 n1_m1_422400_417600 n1_m1_424000_417600 1.785412
R10368 n1_m1_427200_417600 n1_m1_424000_417600 3.570824
R10369 n1_m1_427200_417600 n1_m1_432000_417600 5.356235
R10370 n1_m1_432000_417600 n1_m1_436800_417600 5.356235
R10371 n1_m1_436800_417600 n1_m1_441600_417600 5.356235
R10372 n1_m1_441600_417600 n1_m1_446400_417600 5.356235
R10373 n1_m1_446400_417600 n1_m1_451200_417600 5.356235
R10374 n1_m1_451200_417600 n1_m1_452000_417600 0.892706
R10375 n1_m1_456000_417600 n1_m1_452000_417600 4.463529
R10376 n1_m1_456000_417600 n1_m1_460800_417600 5.356235
R10377 n1_m1_460800_417600 n1_m1_465600_417600 5.356235
R10378 n1_m1_465600_417600 n1_m1_470400_417600 5.356235
R10379 n1_m1_470400_417600 n1_m1_475200_417600 5.356235
R10380 n1_m1_475200_417600 n1_m1_480000_417600 5.356235
R10381 n1_m1_480000_417600 n1_m1_484800_417600 5.356235
R10382 n1_m1_484800_417600 n1_m1_489600_417600 5.356235
R10383 n1_m1_489600_417600 n1_m1_494400_417600 5.356235
R10384 n1_m1_0_422400 n1_m1_4000_422400 4.463529
R10385 n1_m1_4800_422400 n1_m1_4000_422400 0.892706
R10386 n1_m1_4800_422400 n1_m1_9600_422400 5.356235
R10387 n1_m1_9600_422400 n1_m1_14400_422400 5.356235
R10388 n1_m1_14400_422400 n1_m1_19200_422400 5.356235
R10389 n1_m1_19200_422400 n1_m1_24000_422400 5.356235
R10390 n1_m1_24000_422400 n1_m1_28800_422400 5.356235
R10391 n1_m1_28800_422400 n1_m1_32000_422400 3.570824
R10392 n1_m1_33600_422400 n1_m1_32000_422400 1.785412
R10393 n1_m1_33600_422400 n1_m1_38400_422400 5.356235
R10394 n1_m1_38400_422400 n1_m1_43200_422400 5.356235
R10395 n1_m1_43200_422400 n1_m1_48000_422400 5.356235
R10396 n1_m1_48000_422400 n1_m1_52800_422400 5.356235
R10397 n1_m1_52800_422400 n1_m1_57600_422400 5.356235
R10398 n1_m1_57600_422400 n1_m1_60000_422400 2.678118
R10399 n1_m1_62400_422400 n1_m1_60000_422400 2.678118
R10400 n1_m1_62400_422400 n1_m1_67200_422400 5.356235
R10401 n1_m1_67200_422400 n1_m1_72000_422400 5.356235
R10402 n1_m1_72000_422400 n1_m1_76800_422400 5.356235
R10403 n1_m1_76800_422400 n1_m1_81600_422400 5.356235
R10404 n1_m1_81600_422400 n1_m1_86400_422400 5.356235
R10405 n1_m1_86400_422400 n1_m1_88000_422400 1.785412
R10406 n1_m1_91200_422400 n1_m1_88000_422400 3.570824
R10407 n1_m1_91200_422400 n1_m1_96000_422400 5.356235
R10408 n1_m1_96000_422400 n1_m1_100800_422400 5.356235
R10409 n1_m1_100800_422400 n1_m1_105600_422400 5.356235
R10410 n1_m1_105600_422400 n1_m1_110400_422400 5.356235
R10411 n1_m1_110400_422400 n1_m1_115200_422400 5.356235
R10412 n1_m1_115200_422400 n1_m1_116000_422400 0.892706
R10413 n1_m1_120000_422400 n1_m1_116000_422400 4.463529
R10414 n1_m1_120000_422400 n1_m1_124800_422400 5.356235
R10415 n1_m1_124800_422400 n1_m1_129600_422400 5.356235
R10416 n1_m1_129600_422400 n1_m1_134400_422400 5.356235
R10417 n1_m1_134400_422400 n1_m1_139200_422400 5.356235
R10418 n1_m1_139200_422400 n1_m1_144000_422400 5.356235
R10419 n1_m1_144000_422400 n1_m1_148800_422400 5.356235
R10420 n1_m1_148800_422400 n1_m1_153600_422400 5.356235
R10421 n1_m1_153600_422400 n1_m1_158400_422400 5.356235
R10422 n1_m1_158400_422400 n1_m1_163200_422400 5.356235
R10423 n1_m1_163200_422400 n1_m1_168000_422400 5.356235
R10424 n1_m1_168000_422400 n1_m1_172000_422400 4.463529
R10425 n1_m1_172800_422400 n1_m1_172000_422400 0.892706
R10426 n1_m1_172800_422400 n1_m1_177600_422400 5.356235
R10427 n1_m1_177600_422400 n1_m1_182400_422400 5.356235
R10428 n1_m1_182400_422400 n1_m1_187200_422400 5.356235
R10429 n1_m1_187200_422400 n1_m1_192000_422400 5.356235
R10430 n1_m1_192000_422400 n1_m1_196800_422400 5.356235
R10431 n1_m1_196800_422400 n1_m1_200000_422400 3.570824
R10432 n1_m1_201600_422400 n1_m1_200000_422400 1.785412
R10433 n1_m1_201600_422400 n1_m1_206400_422400 5.356235
R10434 n1_m1_206400_422400 n1_m1_211200_422400 5.356235
R10435 n1_m1_211200_422400 n1_m1_216000_422400 5.356235
R10436 n1_m1_216000_422400 n1_m1_220800_422400 5.356235
R10437 n1_m1_220800_422400 n1_m1_225600_422400 5.356235
R10438 n1_m1_225600_422400 n1_m1_228000_422400 2.678118
R10439 n1_m1_230400_422400 n1_m1_228000_422400 2.678118
R10440 n1_m1_230400_422400 n1_m1_235200_422400 5.356235
R10441 n1_m1_235200_422400 n1_m1_240000_422400 5.356235
R10442 n1_m1_240000_422400 n1_m1_244800_422400 5.356235
R10443 n1_m1_244800_422400 n1_m1_249600_422400 5.356235
R10444 n1_m1_249600_422400 n1_m1_254400_422400 5.356235
R10445 n1_m1_254400_422400 n1_m1_256000_422400 1.785412
R10446 n1_m1_259200_422400 n1_m1_256000_422400 3.570824
R10447 n1_m1_259200_422400 n1_m1_264000_422400 5.356235
R10448 n1_m1_264000_422400 n1_m1_268800_422400 5.356235
R10449 n1_m1_268800_422400 n1_m1_273600_422400 5.356235
R10450 n1_m1_273600_422400 n1_m1_278400_422400 5.356235
R10451 n1_m1_278400_422400 n1_m1_283200_422400 5.356235
R10452 n1_m1_283200_422400 n1_m1_284000_422400 0.892706
R10453 n1_m1_288000_422400 n1_m1_284000_422400 4.463529
R10454 n1_m1_288000_422400 n1_m1_292800_422400 5.356235
R10455 n1_m1_292800_422400 n1_m1_297600_422400 5.356235
R10456 n1_m1_297600_422400 n1_m1_302400_422400 5.356235
R10457 n1_m1_302400_422400 n1_m1_307200_422400 5.356235
R10458 n1_m1_307200_422400 n1_m1_312000_422400 5.356235
R10459 n1_m1_312000_422400 n1_m1_316800_422400 5.356235
R10460 n1_m1_316800_422400 n1_m1_321600_422400 5.356235
R10461 n1_m1_321600_422400 n1_m1_326400_422400 5.356235
R10462 n1_m1_326400_422400 n1_m1_331200_422400 5.356235
R10463 n1_m1_331200_422400 n1_m1_336000_422400 5.356235
R10464 n1_m1_336000_422400 n1_m1_340000_422400 4.463529
R10465 n1_m1_340800_422400 n1_m1_340000_422400 0.892706
R10466 n1_m1_340800_422400 n1_m1_345600_422400 5.356235
R10467 n1_m1_345600_422400 n1_m1_350400_422400 5.356235
R10468 n1_m1_350400_422400 n1_m1_355200_422400 5.356235
R10469 n1_m1_355200_422400 n1_m1_360000_422400 5.356235
R10470 n1_m1_360000_422400 n1_m1_364800_422400 5.356235
R10471 n1_m1_364800_422400 n1_m1_368000_422400 3.570824
R10472 n1_m1_369600_422400 n1_m1_368000_422400 1.785412
R10473 n1_m1_369600_422400 n1_m1_374400_422400 5.356235
R10474 n1_m1_374400_422400 n1_m1_379200_422400 5.356235
R10475 n1_m1_379200_422400 n1_m1_384000_422400 5.356235
R10476 n1_m1_384000_422400 n1_m1_388800_422400 5.356235
R10477 n1_m1_388800_422400 n1_m1_393600_422400 5.356235
R10478 n1_m1_393600_422400 n1_m1_396000_422400 2.678118
R10479 n1_m1_398400_422400 n1_m1_396000_422400 2.678118
R10480 n1_m1_398400_422400 n1_m1_403200_422400 5.356235
R10481 n1_m1_403200_422400 n1_m1_408000_422400 5.356235
R10482 n1_m1_408000_422400 n1_m1_412800_422400 5.356235
R10483 n1_m1_412800_422400 n1_m1_417600_422400 5.356235
R10484 n1_m1_417600_422400 n1_m1_422400_422400 5.356235
R10485 n1_m1_422400_422400 n1_m1_424000_422400 1.785412
R10486 n1_m1_427200_422400 n1_m1_424000_422400 3.570824
R10487 n1_m1_427200_422400 n1_m1_432000_422400 5.356235
R10488 n1_m1_432000_422400 n1_m1_436800_422400 5.356235
R10489 n1_m1_436800_422400 n1_m1_441600_422400 5.356235
R10490 n1_m1_441600_422400 n1_m1_446400_422400 5.356235
R10491 n1_m1_446400_422400 n1_m1_451200_422400 5.356235
R10492 n1_m1_451200_422400 n1_m1_452000_422400 0.892706
R10493 n1_m1_456000_422400 n1_m1_452000_422400 4.463529
R10494 n1_m1_456000_422400 n1_m1_460800_422400 5.356235
R10495 n1_m1_460800_422400 n1_m1_465600_422400 5.356235
R10496 n1_m1_465600_422400 n1_m1_470400_422400 5.356235
R10497 n1_m1_470400_422400 n1_m1_475200_422400 5.356235
R10498 n1_m1_475200_422400 n1_m1_480000_422400 5.356235
R10499 n1_m1_480000_422400 n1_m1_484800_422400 5.356235
R10500 n1_m1_484800_422400 n1_m1_489600_422400 5.356235
R10501 n1_m1_489600_422400 n1_m1_494400_422400 5.356235
R10502 n1_m1_0_427200 n1_m1_4000_427200 4.463529
R10503 n1_m1_4800_427200 n1_m1_4000_427200 0.892706
R10504 n1_m1_4800_427200 n1_m1_9600_427200 5.356235
R10505 n1_m1_9600_427200 n1_m1_14400_427200 5.356235
R10506 n1_m1_14400_427200 n1_m1_19200_427200 5.356235
R10507 n1_m1_19200_427200 n1_m1_24000_427200 5.356235
R10508 n1_m1_24000_427200 n1_m1_28800_427200 5.356235
R10509 n1_m1_28800_427200 n1_m1_32000_427200 3.570824
R10510 n1_m1_33600_427200 n1_m1_32000_427200 1.785412
R10511 n1_m1_33600_427200 n1_m1_38400_427200 5.356235
R10512 n1_m1_38400_427200 n1_m1_43200_427200 5.356235
R10513 n1_m1_43200_427200 n1_m1_48000_427200 5.356235
R10514 n1_m1_48000_427200 n1_m1_52800_427200 5.356235
R10515 n1_m1_52800_427200 n1_m1_57600_427200 5.356235
R10516 n1_m1_57600_427200 n1_m1_60000_427200 2.678118
R10517 n1_m1_62400_427200 n1_m1_60000_427200 2.678118
R10518 n1_m1_62400_427200 n1_m1_67200_427200 5.356235
R10519 n1_m1_67200_427200 n1_m1_72000_427200 5.356235
R10520 n1_m1_72000_427200 n1_m1_76800_427200 5.356235
R10521 n1_m1_76800_427200 n1_m1_81600_427200 5.356235
R10522 n1_m1_81600_427200 n1_m1_86400_427200 5.356235
R10523 n1_m1_86400_427200 n1_m1_88000_427200 1.785412
R10524 n1_m1_91200_427200 n1_m1_88000_427200 3.570824
R10525 n1_m1_91200_427200 n1_m1_96000_427200 5.356235
R10526 n1_m1_96000_427200 n1_m1_100800_427200 5.356235
R10527 n1_m1_100800_427200 n1_m1_105600_427200 5.356235
R10528 n1_m1_105600_427200 n1_m1_110400_427200 5.356235
R10529 n1_m1_110400_427200 n1_m1_115200_427200 5.356235
R10530 n1_m1_115200_427200 n1_m1_116000_427200 0.892706
R10531 n1_m1_120000_427200 n1_m1_116000_427200 4.463529
R10532 n1_m1_120000_427200 n1_m1_124800_427200 5.356235
R10533 n1_m1_124800_427200 n1_m1_129600_427200 5.356235
R10534 n1_m1_129600_427200 n1_m1_134400_427200 5.356235
R10535 n1_m1_134400_427200 n1_m1_139200_427200 5.356235
R10536 n1_m1_139200_427200 n1_m1_144000_427200 5.356235
R10537 n1_m1_144000_427200 n1_m1_148800_427200 5.356235
R10538 n1_m1_148800_427200 n1_m1_153600_427200 5.356235
R10539 n1_m1_153600_427200 n1_m1_158400_427200 5.356235
R10540 n1_m1_158400_427200 n1_m1_163200_427200 5.356235
R10541 n1_m1_163200_427200 n1_m1_168000_427200 5.356235
R10542 n1_m1_168000_427200 n1_m1_172000_427200 4.463529
R10543 n1_m1_172800_427200 n1_m1_172000_427200 0.892706
R10544 n1_m1_172800_427200 n1_m1_177600_427200 5.356235
R10545 n1_m1_177600_427200 n1_m1_182400_427200 5.356235
R10546 n1_m1_182400_427200 n1_m1_187200_427200 5.356235
R10547 n1_m1_187200_427200 n1_m1_192000_427200 5.356235
R10548 n1_m1_192000_427200 n1_m1_196800_427200 5.356235
R10549 n1_m1_196800_427200 n1_m1_200000_427200 3.570824
R10550 n1_m1_201600_427200 n1_m1_200000_427200 1.785412
R10551 n1_m1_201600_427200 n1_m1_206400_427200 5.356235
R10552 n1_m1_206400_427200 n1_m1_211200_427200 5.356235
R10553 n1_m1_211200_427200 n1_m1_216000_427200 5.356235
R10554 n1_m1_216000_427200 n1_m1_220800_427200 5.356235
R10555 n1_m1_220800_427200 n1_m1_225600_427200 5.356235
R10556 n1_m1_225600_427200 n1_m1_228000_427200 2.678118
R10557 n1_m1_230400_427200 n1_m1_228000_427200 2.678118
R10558 n1_m1_230400_427200 n1_m1_235200_427200 5.356235
R10559 n1_m1_235200_427200 n1_m1_240000_427200 5.356235
R10560 n1_m1_240000_427200 n1_m1_244800_427200 5.356235
R10561 n1_m1_244800_427200 n1_m1_249600_427200 5.356235
R10562 n1_m1_249600_427200 n1_m1_254400_427200 5.356235
R10563 n1_m1_254400_427200 n1_m1_256000_427200 1.785412
R10564 n1_m1_259200_427200 n1_m1_256000_427200 3.570824
R10565 n1_m1_259200_427200 n1_m1_264000_427200 5.356235
R10566 n1_m1_264000_427200 n1_m1_268800_427200 5.356235
R10567 n1_m1_268800_427200 n1_m1_273600_427200 5.356235
R10568 n1_m1_273600_427200 n1_m1_278400_427200 5.356235
R10569 n1_m1_278400_427200 n1_m1_283200_427200 5.356235
R10570 n1_m1_283200_427200 n1_m1_284000_427200 0.892706
R10571 n1_m1_288000_427200 n1_m1_284000_427200 4.463529
R10572 n1_m1_288000_427200 n1_m1_292800_427200 5.356235
R10573 n1_m1_292800_427200 n1_m1_297600_427200 5.356235
R10574 n1_m1_297600_427200 n1_m1_302400_427200 5.356235
R10575 n1_m1_302400_427200 n1_m1_307200_427200 5.356235
R10576 n1_m1_307200_427200 n1_m1_312000_427200 5.356235
R10577 n1_m1_312000_427200 n1_m1_316800_427200 5.356235
R10578 n1_m1_316800_427200 n1_m1_321600_427200 5.356235
R10579 n1_m1_321600_427200 n1_m1_326400_427200 5.356235
R10580 n1_m1_326400_427200 n1_m1_331200_427200 5.356235
R10581 n1_m1_331200_427200 n1_m1_336000_427200 5.356235
R10582 n1_m1_336000_427200 n1_m1_340000_427200 4.463529
R10583 n1_m1_340800_427200 n1_m1_340000_427200 0.892706
R10584 n1_m1_340800_427200 n1_m1_345600_427200 5.356235
R10585 n1_m1_345600_427200 n1_m1_350400_427200 5.356235
R10586 n1_m1_350400_427200 n1_m1_355200_427200 5.356235
R10587 n1_m1_355200_427200 n1_m1_360000_427200 5.356235
R10588 n1_m1_360000_427200 n1_m1_364800_427200 5.356235
R10589 n1_m1_364800_427200 n1_m1_368000_427200 3.570824
R10590 n1_m1_369600_427200 n1_m1_368000_427200 1.785412
R10591 n1_m1_369600_427200 n1_m1_374400_427200 5.356235
R10592 n1_m1_374400_427200 n1_m1_379200_427200 5.356235
R10593 n1_m1_379200_427200 n1_m1_384000_427200 5.356235
R10594 n1_m1_384000_427200 n1_m1_388800_427200 5.356235
R10595 n1_m1_388800_427200 n1_m1_393600_427200 5.356235
R10596 n1_m1_393600_427200 n1_m1_396000_427200 2.678118
R10597 n1_m1_398400_427200 n1_m1_396000_427200 2.678118
R10598 n1_m1_398400_427200 n1_m1_403200_427200 5.356235
R10599 n1_m1_403200_427200 n1_m1_408000_427200 5.356235
R10600 n1_m1_408000_427200 n1_m1_412800_427200 5.356235
R10601 n1_m1_412800_427200 n1_m1_417600_427200 5.356235
R10602 n1_m1_417600_427200 n1_m1_422400_427200 5.356235
R10603 n1_m1_422400_427200 n1_m1_424000_427200 1.785412
R10604 n1_m1_427200_427200 n1_m1_424000_427200 3.570824
R10605 n1_m1_427200_427200 n1_m1_432000_427200 5.356235
R10606 n1_m1_432000_427200 n1_m1_436800_427200 5.356235
R10607 n1_m1_436800_427200 n1_m1_441600_427200 5.356235
R10608 n1_m1_441600_427200 n1_m1_446400_427200 5.356235
R10609 n1_m1_446400_427200 n1_m1_451200_427200 5.356235
R10610 n1_m1_451200_427200 n1_m1_452000_427200 0.892706
R10611 n1_m1_456000_427200 n1_m1_452000_427200 4.463529
R10612 n1_m1_456000_427200 n1_m1_460800_427200 5.356235
R10613 n1_m1_460800_427200 n1_m1_465600_427200 5.356235
R10614 n1_m1_465600_427200 n1_m1_470400_427200 5.356235
R10615 n1_m1_470400_427200 n1_m1_475200_427200 5.356235
R10616 n1_m1_475200_427200 n1_m1_480000_427200 5.356235
R10617 n1_m1_480000_427200 n1_m1_484800_427200 5.356235
R10618 n1_m1_484800_427200 n1_m1_489600_427200 5.356235
R10619 n1_m1_489600_427200 n1_m1_494400_427200 5.356235
R10620 n1_m1_0_432000 n1_m1_4000_432000 4.463529
R10621 n1_m1_4800_432000 n1_m1_4000_432000 0.892706
R10622 n1_m1_4800_432000 n1_m1_9600_432000 5.356235
R10623 n1_m1_9600_432000 n1_m1_14400_432000 5.356235
R10624 n1_m1_14400_432000 n1_m1_19200_432000 5.356235
R10625 n1_m1_19200_432000 n1_m1_24000_432000 5.356235
R10626 n1_m1_24000_432000 n1_m1_28800_432000 5.356235
R10627 n1_m1_28800_432000 n1_m1_32000_432000 3.570824
R10628 n1_m1_33600_432000 n1_m1_32000_432000 1.785412
R10629 n1_m1_33600_432000 n1_m1_38400_432000 5.356235
R10630 n1_m1_38400_432000 n1_m1_43200_432000 5.356235
R10631 n1_m1_43200_432000 n1_m1_48000_432000 5.356235
R10632 n1_m1_48000_432000 n1_m1_52800_432000 5.356235
R10633 n1_m1_52800_432000 n1_m1_57600_432000 5.356235
R10634 n1_m1_57600_432000 n1_m1_60000_432000 2.678118
R10635 n1_m1_62400_432000 n1_m1_60000_432000 2.678118
R10636 n1_m1_62400_432000 n1_m1_67200_432000 5.356235
R10637 n1_m1_67200_432000 n1_m1_72000_432000 5.356235
R10638 n1_m1_72000_432000 n1_m1_76800_432000 5.356235
R10639 n1_m1_76800_432000 n1_m1_81600_432000 5.356235
R10640 n1_m1_81600_432000 n1_m1_86400_432000 5.356235
R10641 n1_m1_86400_432000 n1_m1_88000_432000 1.785412
R10642 n1_m1_91200_432000 n1_m1_88000_432000 3.570824
R10643 n1_m1_91200_432000 n1_m1_96000_432000 5.356235
R10644 n1_m1_96000_432000 n1_m1_100800_432000 5.356235
R10645 n1_m1_100800_432000 n1_m1_105600_432000 5.356235
R10646 n1_m1_105600_432000 n1_m1_110400_432000 5.356235
R10647 n1_m1_110400_432000 n1_m1_115200_432000 5.356235
R10648 n1_m1_115200_432000 n1_m1_116000_432000 0.892706
R10649 n1_m1_120000_432000 n1_m1_116000_432000 4.463529
R10650 n1_m1_120000_432000 n1_m1_124800_432000 5.356235
R10651 n1_m1_124800_432000 n1_m1_129600_432000 5.356235
R10652 n1_m1_129600_432000 n1_m1_134400_432000 5.356235
R10653 n1_m1_134400_432000 n1_m1_139200_432000 5.356235
R10654 n1_m1_139200_432000 n1_m1_144000_432000 5.356235
R10655 n1_m1_144000_432000 n1_m1_148800_432000 5.356235
R10656 n1_m1_148800_432000 n1_m1_153600_432000 5.356235
R10657 n1_m1_153600_432000 n1_m1_158400_432000 5.356235
R10658 n1_m1_158400_432000 n1_m1_163200_432000 5.356235
R10659 n1_m1_163200_432000 n1_m1_168000_432000 5.356235
R10660 n1_m1_168000_432000 n1_m1_172000_432000 4.463529
R10661 n1_m1_172800_432000 n1_m1_172000_432000 0.892706
R10662 n1_m1_172800_432000 n1_m1_177600_432000 5.356235
R10663 n1_m1_177600_432000 n1_m1_182400_432000 5.356235
R10664 n1_m1_182400_432000 n1_m1_187200_432000 5.356235
R10665 n1_m1_187200_432000 n1_m1_192000_432000 5.356235
R10666 n1_m1_192000_432000 n1_m1_196800_432000 5.356235
R10667 n1_m1_196800_432000 n1_m1_200000_432000 3.570824
R10668 n1_m1_201600_432000 n1_m1_200000_432000 1.785412
R10669 n1_m1_201600_432000 n1_m1_206400_432000 5.356235
R10670 n1_m1_206400_432000 n1_m1_211200_432000 5.356235
R10671 n1_m1_211200_432000 n1_m1_216000_432000 5.356235
R10672 n1_m1_216000_432000 n1_m1_220800_432000 5.356235
R10673 n1_m1_220800_432000 n1_m1_225600_432000 5.356235
R10674 n1_m1_225600_432000 n1_m1_228000_432000 2.678118
R10675 n1_m1_230400_432000 n1_m1_228000_432000 2.678118
R10676 n1_m1_230400_432000 n1_m1_235200_432000 5.356235
R10677 n1_m1_235200_432000 n1_m1_240000_432000 5.356235
R10678 n1_m1_240000_432000 n1_m1_244800_432000 5.356235
R10679 n1_m1_244800_432000 n1_m1_249600_432000 5.356235
R10680 n1_m1_249600_432000 n1_m1_254400_432000 5.356235
R10681 n1_m1_254400_432000 n1_m1_256000_432000 1.785412
R10682 n1_m1_259200_432000 n1_m1_256000_432000 3.570824
R10683 n1_m1_259200_432000 n1_m1_264000_432000 5.356235
R10684 n1_m1_264000_432000 n1_m1_268800_432000 5.356235
R10685 n1_m1_268800_432000 n1_m1_273600_432000 5.356235
R10686 n1_m1_273600_432000 n1_m1_278400_432000 5.356235
R10687 n1_m1_278400_432000 n1_m1_283200_432000 5.356235
R10688 n1_m1_283200_432000 n1_m1_284000_432000 0.892706
R10689 n1_m1_288000_432000 n1_m1_284000_432000 4.463529
R10690 n1_m1_288000_432000 n1_m1_292800_432000 5.356235
R10691 n1_m1_292800_432000 n1_m1_297600_432000 5.356235
R10692 n1_m1_297600_432000 n1_m1_302400_432000 5.356235
R10693 n1_m1_302400_432000 n1_m1_307200_432000 5.356235
R10694 n1_m1_307200_432000 n1_m1_312000_432000 5.356235
R10695 n1_m1_312000_432000 n1_m1_316800_432000 5.356235
R10696 n1_m1_316800_432000 n1_m1_321600_432000 5.356235
R10697 n1_m1_321600_432000 n1_m1_326400_432000 5.356235
R10698 n1_m1_326400_432000 n1_m1_331200_432000 5.356235
R10699 n1_m1_331200_432000 n1_m1_336000_432000 5.356235
R10700 n1_m1_336000_432000 n1_m1_340000_432000 4.463529
R10701 n1_m1_340800_432000 n1_m1_340000_432000 0.892706
R10702 n1_m1_340800_432000 n1_m1_345600_432000 5.356235
R10703 n1_m1_345600_432000 n1_m1_350400_432000 5.356235
R10704 n1_m1_350400_432000 n1_m1_355200_432000 5.356235
R10705 n1_m1_355200_432000 n1_m1_360000_432000 5.356235
R10706 n1_m1_360000_432000 n1_m1_364800_432000 5.356235
R10707 n1_m1_364800_432000 n1_m1_368000_432000 3.570824
R10708 n1_m1_369600_432000 n1_m1_368000_432000 1.785412
R10709 n1_m1_369600_432000 n1_m1_374400_432000 5.356235
R10710 n1_m1_374400_432000 n1_m1_379200_432000 5.356235
R10711 n1_m1_379200_432000 n1_m1_384000_432000 5.356235
R10712 n1_m1_384000_432000 n1_m1_388800_432000 5.356235
R10713 n1_m1_388800_432000 n1_m1_393600_432000 5.356235
R10714 n1_m1_393600_432000 n1_m1_396000_432000 2.678118
R10715 n1_m1_398400_432000 n1_m1_396000_432000 2.678118
R10716 n1_m1_398400_432000 n1_m1_403200_432000 5.356235
R10717 n1_m1_403200_432000 n1_m1_408000_432000 5.356235
R10718 n1_m1_408000_432000 n1_m1_412800_432000 5.356235
R10719 n1_m1_412800_432000 n1_m1_417600_432000 5.356235
R10720 n1_m1_417600_432000 n1_m1_422400_432000 5.356235
R10721 n1_m1_422400_432000 n1_m1_424000_432000 1.785412
R10722 n1_m1_427200_432000 n1_m1_424000_432000 3.570824
R10723 n1_m1_427200_432000 n1_m1_432000_432000 5.356235
R10724 n1_m1_432000_432000 n1_m1_436800_432000 5.356235
R10725 n1_m1_436800_432000 n1_m1_441600_432000 5.356235
R10726 n1_m1_441600_432000 n1_m1_446400_432000 5.356235
R10727 n1_m1_446400_432000 n1_m1_451200_432000 5.356235
R10728 n1_m1_451200_432000 n1_m1_452000_432000 0.892706
R10729 n1_m1_456000_432000 n1_m1_452000_432000 4.463529
R10730 n1_m1_456000_432000 n1_m1_460800_432000 5.356235
R10731 n1_m1_460800_432000 n1_m1_465600_432000 5.356235
R10732 n1_m1_465600_432000 n1_m1_470400_432000 5.356235
R10733 n1_m1_470400_432000 n1_m1_475200_432000 5.356235
R10734 n1_m1_475200_432000 n1_m1_480000_432000 5.356235
R10735 n1_m1_480000_432000 n1_m1_484800_432000 5.356235
R10736 n1_m1_484800_432000 n1_m1_489600_432000 5.356235
R10737 n1_m1_489600_432000 n1_m1_494400_432000 5.356235
R10738 n1_m1_0_436800 n1_m1_4000_436800 4.463529
R10739 n1_m1_4800_436800 n1_m1_4000_436800 0.892706
R10740 n1_m1_4800_436800 n1_m1_9600_436800 5.356235
R10741 n1_m1_9600_436800 n1_m1_14400_436800 5.356235
R10742 n1_m1_14400_436800 n1_m1_19200_436800 5.356235
R10743 n1_m1_19200_436800 n1_m1_24000_436800 5.356235
R10744 n1_m1_24000_436800 n1_m1_28800_436800 5.356235
R10745 n1_m1_28800_436800 n1_m1_32000_436800 3.570824
R10746 n1_m1_33600_436800 n1_m1_32000_436800 1.785412
R10747 n1_m1_33600_436800 n1_m1_38400_436800 5.356235
R10748 n1_m1_38400_436800 n1_m1_43200_436800 5.356235
R10749 n1_m1_43200_436800 n1_m1_48000_436800 5.356235
R10750 n1_m1_48000_436800 n1_m1_52800_436800 5.356235
R10751 n1_m1_52800_436800 n1_m1_57600_436800 5.356235
R10752 n1_m1_57600_436800 n1_m1_60000_436800 2.678118
R10753 n1_m1_62400_436800 n1_m1_60000_436800 2.678118
R10754 n1_m1_62400_436800 n1_m1_67200_436800 5.356235
R10755 n1_m1_67200_436800 n1_m1_72000_436800 5.356235
R10756 n1_m1_72000_436800 n1_m1_76800_436800 5.356235
R10757 n1_m1_76800_436800 n1_m1_81600_436800 5.356235
R10758 n1_m1_81600_436800 n1_m1_86400_436800 5.356235
R10759 n1_m1_86400_436800 n1_m1_88000_436800 1.785412
R10760 n1_m1_91200_436800 n1_m1_88000_436800 3.570824
R10761 n1_m1_91200_436800 n1_m1_96000_436800 5.356235
R10762 n1_m1_96000_436800 n1_m1_100800_436800 5.356235
R10763 n1_m1_100800_436800 n1_m1_105600_436800 5.356235
R10764 n1_m1_105600_436800 n1_m1_110400_436800 5.356235
R10765 n1_m1_110400_436800 n1_m1_115200_436800 5.356235
R10766 n1_m1_115200_436800 n1_m1_116000_436800 0.892706
R10767 n1_m1_120000_436800 n1_m1_116000_436800 4.463529
R10768 n1_m1_120000_436800 n1_m1_124800_436800 5.356235
R10769 n1_m1_124800_436800 n1_m1_129600_436800 5.356235
R10770 n1_m1_129600_436800 n1_m1_134400_436800 5.356235
R10771 n1_m1_134400_436800 n1_m1_139200_436800 5.356235
R10772 n1_m1_139200_436800 n1_m1_144000_436800 5.356235
R10773 n1_m1_144000_436800 n1_m1_148800_436800 5.356235
R10774 n1_m1_148800_436800 n1_m1_153600_436800 5.356235
R10775 n1_m1_153600_436800 n1_m1_158400_436800 5.356235
R10776 n1_m1_158400_436800 n1_m1_163200_436800 5.356235
R10777 n1_m1_163200_436800 n1_m1_168000_436800 5.356235
R10778 n1_m1_168000_436800 n1_m1_172000_436800 4.463529
R10779 n1_m1_172800_436800 n1_m1_172000_436800 0.892706
R10780 n1_m1_172800_436800 n1_m1_177600_436800 5.356235
R10781 n1_m1_177600_436800 n1_m1_182400_436800 5.356235
R10782 n1_m1_182400_436800 n1_m1_187200_436800 5.356235
R10783 n1_m1_187200_436800 n1_m1_192000_436800 5.356235
R10784 n1_m1_192000_436800 n1_m1_196800_436800 5.356235
R10785 n1_m1_196800_436800 n1_m1_200000_436800 3.570824
R10786 n1_m1_201600_436800 n1_m1_200000_436800 1.785412
R10787 n1_m1_201600_436800 n1_m1_206400_436800 5.356235
R10788 n1_m1_206400_436800 n1_m1_211200_436800 5.356235
R10789 n1_m1_211200_436800 n1_m1_216000_436800 5.356235
R10790 n1_m1_216000_436800 n1_m1_220800_436800 5.356235
R10791 n1_m1_220800_436800 n1_m1_225600_436800 5.356235
R10792 n1_m1_225600_436800 n1_m1_228000_436800 2.678118
R10793 n1_m1_230400_436800 n1_m1_228000_436800 2.678118
R10794 n1_m1_230400_436800 n1_m1_235200_436800 5.356235
R10795 n1_m1_235200_436800 n1_m1_240000_436800 5.356235
R10796 n1_m1_240000_436800 n1_m1_244800_436800 5.356235
R10797 n1_m1_244800_436800 n1_m1_249600_436800 5.356235
R10798 n1_m1_249600_436800 n1_m1_254400_436800 5.356235
R10799 n1_m1_254400_436800 n1_m1_256000_436800 1.785412
R10800 n1_m1_259200_436800 n1_m1_256000_436800 3.570824
R10801 n1_m1_259200_436800 n1_m1_264000_436800 5.356235
R10802 n1_m1_264000_436800 n1_m1_268800_436800 5.356235
R10803 n1_m1_268800_436800 n1_m1_273600_436800 5.356235
R10804 n1_m1_273600_436800 n1_m1_278400_436800 5.356235
R10805 n1_m1_278400_436800 n1_m1_283200_436800 5.356235
R10806 n1_m1_283200_436800 n1_m1_284000_436800 0.892706
R10807 n1_m1_288000_436800 n1_m1_284000_436800 4.463529
R10808 n1_m1_288000_436800 n1_m1_292800_436800 5.356235
R10809 n1_m1_292800_436800 n1_m1_297600_436800 5.356235
R10810 n1_m1_297600_436800 n1_m1_302400_436800 5.356235
R10811 n1_m1_302400_436800 n1_m1_307200_436800 5.356235
R10812 n1_m1_307200_436800 n1_m1_312000_436800 5.356235
R10813 n1_m1_312000_436800 n1_m1_316800_436800 5.356235
R10814 n1_m1_316800_436800 n1_m1_321600_436800 5.356235
R10815 n1_m1_321600_436800 n1_m1_326400_436800 5.356235
R10816 n1_m1_326400_436800 n1_m1_331200_436800 5.356235
R10817 n1_m1_331200_436800 n1_m1_336000_436800 5.356235
R10818 n1_m1_336000_436800 n1_m1_340000_436800 4.463529
R10819 n1_m1_340800_436800 n1_m1_340000_436800 0.892706
R10820 n1_m1_340800_436800 n1_m1_345600_436800 5.356235
R10821 n1_m1_345600_436800 n1_m1_350400_436800 5.356235
R10822 n1_m1_350400_436800 n1_m1_355200_436800 5.356235
R10823 n1_m1_355200_436800 n1_m1_360000_436800 5.356235
R10824 n1_m1_360000_436800 n1_m1_364800_436800 5.356235
R10825 n1_m1_364800_436800 n1_m1_368000_436800 3.570824
R10826 n1_m1_369600_436800 n1_m1_368000_436800 1.785412
R10827 n1_m1_369600_436800 n1_m1_374400_436800 5.356235
R10828 n1_m1_374400_436800 n1_m1_379200_436800 5.356235
R10829 n1_m1_379200_436800 n1_m1_384000_436800 5.356235
R10830 n1_m1_384000_436800 n1_m1_388800_436800 5.356235
R10831 n1_m1_388800_436800 n1_m1_393600_436800 5.356235
R10832 n1_m1_393600_436800 n1_m1_396000_436800 2.678118
R10833 n1_m1_398400_436800 n1_m1_396000_436800 2.678118
R10834 n1_m1_398400_436800 n1_m1_403200_436800 5.356235
R10835 n1_m1_403200_436800 n1_m1_408000_436800 5.356235
R10836 n1_m1_408000_436800 n1_m1_412800_436800 5.356235
R10837 n1_m1_412800_436800 n1_m1_417600_436800 5.356235
R10838 n1_m1_417600_436800 n1_m1_422400_436800 5.356235
R10839 n1_m1_422400_436800 n1_m1_424000_436800 1.785412
R10840 n1_m1_427200_436800 n1_m1_424000_436800 3.570824
R10841 n1_m1_427200_436800 n1_m1_432000_436800 5.356235
R10842 n1_m1_432000_436800 n1_m1_436800_436800 5.356235
R10843 n1_m1_436800_436800 n1_m1_441600_436800 5.356235
R10844 n1_m1_441600_436800 n1_m1_446400_436800 5.356235
R10845 n1_m1_446400_436800 n1_m1_451200_436800 5.356235
R10846 n1_m1_451200_436800 n1_m1_452000_436800 0.892706
R10847 n1_m1_456000_436800 n1_m1_452000_436800 4.463529
R10848 n1_m1_456000_436800 n1_m1_460800_436800 5.356235
R10849 n1_m1_460800_436800 n1_m1_465600_436800 5.356235
R10850 n1_m1_465600_436800 n1_m1_470400_436800 5.356235
R10851 n1_m1_470400_436800 n1_m1_475200_436800 5.356235
R10852 n1_m1_475200_436800 n1_m1_480000_436800 5.356235
R10853 n1_m1_480000_436800 n1_m1_484800_436800 5.356235
R10854 n1_m1_484800_436800 n1_m1_489600_436800 5.356235
R10855 n1_m1_489600_436800 n1_m1_494400_436800 5.356235
R10856 n1_m1_0_441600 n1_m1_4000_441600 4.463529
R10857 n1_m1_4800_441600 n1_m1_4000_441600 0.892706
R10858 n1_m1_4800_441600 n1_m1_9600_441600 5.356235
R10859 n1_m1_9600_441600 n1_m1_14400_441600 5.356235
R10860 n1_m1_14400_441600 n1_m1_19200_441600 5.356235
R10861 n1_m1_19200_441600 n1_m1_24000_441600 5.356235
R10862 n1_m1_24000_441600 n1_m1_28800_441600 5.356235
R10863 n1_m1_28800_441600 n1_m1_32000_441600 3.570824
R10864 n1_m1_33600_441600 n1_m1_32000_441600 1.785412
R10865 n1_m1_33600_441600 n1_m1_38400_441600 5.356235
R10866 n1_m1_38400_441600 n1_m1_43200_441600 5.356235
R10867 n1_m1_43200_441600 n1_m1_48000_441600 5.356235
R10868 n1_m1_48000_441600 n1_m1_52800_441600 5.356235
R10869 n1_m1_52800_441600 n1_m1_57600_441600 5.356235
R10870 n1_m1_57600_441600 n1_m1_60000_441600 2.678118
R10871 n1_m1_62400_441600 n1_m1_60000_441600 2.678118
R10872 n1_m1_62400_441600 n1_m1_67200_441600 5.356235
R10873 n1_m1_67200_441600 n1_m1_72000_441600 5.356235
R10874 n1_m1_72000_441600 n1_m1_76800_441600 5.356235
R10875 n1_m1_76800_441600 n1_m1_81600_441600 5.356235
R10876 n1_m1_81600_441600 n1_m1_86400_441600 5.356235
R10877 n1_m1_86400_441600 n1_m1_88000_441600 1.785412
R10878 n1_m1_91200_441600 n1_m1_88000_441600 3.570824
R10879 n1_m1_91200_441600 n1_m1_96000_441600 5.356235
R10880 n1_m1_96000_441600 n1_m1_100800_441600 5.356235
R10881 n1_m1_100800_441600 n1_m1_105600_441600 5.356235
R10882 n1_m1_105600_441600 n1_m1_110400_441600 5.356235
R10883 n1_m1_110400_441600 n1_m1_115200_441600 5.356235
R10884 n1_m1_115200_441600 n1_m1_116000_441600 0.892706
R10885 n1_m1_120000_441600 n1_m1_116000_441600 4.463529
R10886 n1_m1_120000_441600 n1_m1_124800_441600 5.356235
R10887 n1_m1_124800_441600 n1_m1_129600_441600 5.356235
R10888 n1_m1_129600_441600 n1_m1_134400_441600 5.356235
R10889 n1_m1_134400_441600 n1_m1_139200_441600 5.356235
R10890 n1_m1_139200_441600 n1_m1_144000_441600 5.356235
R10891 n1_m1_144000_441600 n1_m1_148800_441600 5.356235
R10892 n1_m1_148800_441600 n1_m1_153600_441600 5.356235
R10893 n1_m1_153600_441600 n1_m1_158400_441600 5.356235
R10894 n1_m1_158400_441600 n1_m1_163200_441600 5.356235
R10895 n1_m1_163200_441600 n1_m1_168000_441600 5.356235
R10896 n1_m1_168000_441600 n1_m1_172000_441600 4.463529
R10897 n1_m1_172800_441600 n1_m1_172000_441600 0.892706
R10898 n1_m1_172800_441600 n1_m1_177600_441600 5.356235
R10899 n1_m1_177600_441600 n1_m1_182400_441600 5.356235
R10900 n1_m1_182400_441600 n1_m1_187200_441600 5.356235
R10901 n1_m1_187200_441600 n1_m1_192000_441600 5.356235
R10902 n1_m1_192000_441600 n1_m1_196800_441600 5.356235
R10903 n1_m1_196800_441600 n1_m1_200000_441600 3.570824
R10904 n1_m1_201600_441600 n1_m1_200000_441600 1.785412
R10905 n1_m1_201600_441600 n1_m1_206400_441600 5.356235
R10906 n1_m1_206400_441600 n1_m1_211200_441600 5.356235
R10907 n1_m1_211200_441600 n1_m1_216000_441600 5.356235
R10908 n1_m1_216000_441600 n1_m1_220800_441600 5.356235
R10909 n1_m1_220800_441600 n1_m1_225600_441600 5.356235
R10910 n1_m1_225600_441600 n1_m1_228000_441600 2.678118
R10911 n1_m1_230400_441600 n1_m1_228000_441600 2.678118
R10912 n1_m1_230400_441600 n1_m1_235200_441600 5.356235
R10913 n1_m1_235200_441600 n1_m1_240000_441600 5.356235
R10914 n1_m1_240000_441600 n1_m1_244800_441600 5.356235
R10915 n1_m1_244800_441600 n1_m1_249600_441600 5.356235
R10916 n1_m1_249600_441600 n1_m1_254400_441600 5.356235
R10917 n1_m1_254400_441600 n1_m1_256000_441600 1.785412
R10918 n1_m1_259200_441600 n1_m1_256000_441600 3.570824
R10919 n1_m1_259200_441600 n1_m1_264000_441600 5.356235
R10920 n1_m1_264000_441600 n1_m1_268800_441600 5.356235
R10921 n1_m1_268800_441600 n1_m1_273600_441600 5.356235
R10922 n1_m1_273600_441600 n1_m1_278400_441600 5.356235
R10923 n1_m1_278400_441600 n1_m1_283200_441600 5.356235
R10924 n1_m1_283200_441600 n1_m1_284000_441600 0.892706
R10925 n1_m1_288000_441600 n1_m1_284000_441600 4.463529
R10926 n1_m1_288000_441600 n1_m1_292800_441600 5.356235
R10927 n1_m1_292800_441600 n1_m1_297600_441600 5.356235
R10928 n1_m1_297600_441600 n1_m1_302400_441600 5.356235
R10929 n1_m1_302400_441600 n1_m1_307200_441600 5.356235
R10930 n1_m1_307200_441600 n1_m1_312000_441600 5.356235
R10931 n1_m1_312000_441600 n1_m1_316800_441600 5.356235
R10932 n1_m1_316800_441600 n1_m1_321600_441600 5.356235
R10933 n1_m1_321600_441600 n1_m1_326400_441600 5.356235
R10934 n1_m1_326400_441600 n1_m1_331200_441600 5.356235
R10935 n1_m1_331200_441600 n1_m1_336000_441600 5.356235
R10936 n1_m1_336000_441600 n1_m1_340000_441600 4.463529
R10937 n1_m1_340800_441600 n1_m1_340000_441600 0.892706
R10938 n1_m1_340800_441600 n1_m1_345600_441600 5.356235
R10939 n1_m1_345600_441600 n1_m1_350400_441600 5.356235
R10940 n1_m1_350400_441600 n1_m1_355200_441600 5.356235
R10941 n1_m1_355200_441600 n1_m1_360000_441600 5.356235
R10942 n1_m1_360000_441600 n1_m1_364800_441600 5.356235
R10943 n1_m1_364800_441600 n1_m1_368000_441600 3.570824
R10944 n1_m1_369600_441600 n1_m1_368000_441600 1.785412
R10945 n1_m1_369600_441600 n1_m1_374400_441600 5.356235
R10946 n1_m1_374400_441600 n1_m1_379200_441600 5.356235
R10947 n1_m1_379200_441600 n1_m1_384000_441600 5.356235
R10948 n1_m1_384000_441600 n1_m1_388800_441600 5.356235
R10949 n1_m1_388800_441600 n1_m1_393600_441600 5.356235
R10950 n1_m1_393600_441600 n1_m1_396000_441600 2.678118
R10951 n1_m1_398400_441600 n1_m1_396000_441600 2.678118
R10952 n1_m1_398400_441600 n1_m1_403200_441600 5.356235
R10953 n1_m1_403200_441600 n1_m1_408000_441600 5.356235
R10954 n1_m1_408000_441600 n1_m1_412800_441600 5.356235
R10955 n1_m1_412800_441600 n1_m1_417600_441600 5.356235
R10956 n1_m1_417600_441600 n1_m1_422400_441600 5.356235
R10957 n1_m1_422400_441600 n1_m1_424000_441600 1.785412
R10958 n1_m1_427200_441600 n1_m1_424000_441600 3.570824
R10959 n1_m1_427200_441600 n1_m1_432000_441600 5.356235
R10960 n1_m1_432000_441600 n1_m1_436800_441600 5.356235
R10961 n1_m1_436800_441600 n1_m1_441600_441600 5.356235
R10962 n1_m1_441600_441600 n1_m1_446400_441600 5.356235
R10963 n1_m1_446400_441600 n1_m1_451200_441600 5.356235
R10964 n1_m1_451200_441600 n1_m1_452000_441600 0.892706
R10965 n1_m1_456000_441600 n1_m1_452000_441600 4.463529
R10966 n1_m1_456000_441600 n1_m1_460800_441600 5.356235
R10967 n1_m1_460800_441600 n1_m1_465600_441600 5.356235
R10968 n1_m1_465600_441600 n1_m1_470400_441600 5.356235
R10969 n1_m1_470400_441600 n1_m1_475200_441600 5.356235
R10970 n1_m1_475200_441600 n1_m1_480000_441600 5.356235
R10971 n1_m1_480000_441600 n1_m1_484800_441600 5.356235
R10972 n1_m1_484800_441600 n1_m1_489600_441600 5.356235
R10973 n1_m1_489600_441600 n1_m1_494400_441600 5.356235
R10974 n1_m1_0_446400 n1_m1_4000_446400 4.463529
R10975 n1_m1_4800_446400 n1_m1_4000_446400 0.892706
R10976 n1_m1_4800_446400 n1_m1_9600_446400 5.356235
R10977 n1_m1_9600_446400 n1_m1_14400_446400 5.356235
R10978 n1_m1_14400_446400 n1_m1_19200_446400 5.356235
R10979 n1_m1_19200_446400 n1_m1_24000_446400 5.356235
R10980 n1_m1_24000_446400 n1_m1_28800_446400 5.356235
R10981 n1_m1_28800_446400 n1_m1_32000_446400 3.570824
R10982 n1_m1_33600_446400 n1_m1_32000_446400 1.785412
R10983 n1_m1_33600_446400 n1_m1_38400_446400 5.356235
R10984 n1_m1_38400_446400 n1_m1_43200_446400 5.356235
R10985 n1_m1_43200_446400 n1_m1_48000_446400 5.356235
R10986 n1_m1_48000_446400 n1_m1_52800_446400 5.356235
R10987 n1_m1_52800_446400 n1_m1_57600_446400 5.356235
R10988 n1_m1_57600_446400 n1_m1_60000_446400 2.678118
R10989 n1_m1_62400_446400 n1_m1_60000_446400 2.678118
R10990 n1_m1_62400_446400 n1_m1_67200_446400 5.356235
R10991 n1_m1_67200_446400 n1_m1_72000_446400 5.356235
R10992 n1_m1_72000_446400 n1_m1_76800_446400 5.356235
R10993 n1_m1_76800_446400 n1_m1_81600_446400 5.356235
R10994 n1_m1_81600_446400 n1_m1_86400_446400 5.356235
R10995 n1_m1_86400_446400 n1_m1_88000_446400 1.785412
R10996 n1_m1_91200_446400 n1_m1_88000_446400 3.570824
R10997 n1_m1_91200_446400 n1_m1_96000_446400 5.356235
R10998 n1_m1_96000_446400 n1_m1_100800_446400 5.356235
R10999 n1_m1_100800_446400 n1_m1_105600_446400 5.356235
R11000 n1_m1_105600_446400 n1_m1_110400_446400 5.356235
R11001 n1_m1_110400_446400 n1_m1_115200_446400 5.356235
R11002 n1_m1_115200_446400 n1_m1_116000_446400 0.892706
R11003 n1_m1_120000_446400 n1_m1_116000_446400 4.463529
R11004 n1_m1_120000_446400 n1_m1_124800_446400 5.356235
R11005 n1_m1_124800_446400 n1_m1_129600_446400 5.356235
R11006 n1_m1_129600_446400 n1_m1_134400_446400 5.356235
R11007 n1_m1_134400_446400 n1_m1_139200_446400 5.356235
R11008 n1_m1_139200_446400 n1_m1_144000_446400 5.356235
R11009 n1_m1_144000_446400 n1_m1_148800_446400 5.356235
R11010 n1_m1_148800_446400 n1_m1_153600_446400 5.356235
R11011 n1_m1_153600_446400 n1_m1_158400_446400 5.356235
R11012 n1_m1_158400_446400 n1_m1_163200_446400 5.356235
R11013 n1_m1_163200_446400 n1_m1_168000_446400 5.356235
R11014 n1_m1_168000_446400 n1_m1_172000_446400 4.463529
R11015 n1_m1_172800_446400 n1_m1_172000_446400 0.892706
R11016 n1_m1_172800_446400 n1_m1_177600_446400 5.356235
R11017 n1_m1_177600_446400 n1_m1_182400_446400 5.356235
R11018 n1_m1_182400_446400 n1_m1_187200_446400 5.356235
R11019 n1_m1_187200_446400 n1_m1_192000_446400 5.356235
R11020 n1_m1_192000_446400 n1_m1_196800_446400 5.356235
R11021 n1_m1_196800_446400 n1_m1_200000_446400 3.570824
R11022 n1_m1_201600_446400 n1_m1_200000_446400 1.785412
R11023 n1_m1_201600_446400 n1_m1_206400_446400 5.356235
R11024 n1_m1_206400_446400 n1_m1_211200_446400 5.356235
R11025 n1_m1_211200_446400 n1_m1_216000_446400 5.356235
R11026 n1_m1_216000_446400 n1_m1_220800_446400 5.356235
R11027 n1_m1_220800_446400 n1_m1_225600_446400 5.356235
R11028 n1_m1_225600_446400 n1_m1_228000_446400 2.678118
R11029 n1_m1_230400_446400 n1_m1_228000_446400 2.678118
R11030 n1_m1_230400_446400 n1_m1_235200_446400 5.356235
R11031 n1_m1_235200_446400 n1_m1_240000_446400 5.356235
R11032 n1_m1_240000_446400 n1_m1_244800_446400 5.356235
R11033 n1_m1_244800_446400 n1_m1_249600_446400 5.356235
R11034 n1_m1_249600_446400 n1_m1_254400_446400 5.356235
R11035 n1_m1_254400_446400 n1_m1_256000_446400 1.785412
R11036 n1_m1_259200_446400 n1_m1_256000_446400 3.570824
R11037 n1_m1_259200_446400 n1_m1_264000_446400 5.356235
R11038 n1_m1_264000_446400 n1_m1_268800_446400 5.356235
R11039 n1_m1_268800_446400 n1_m1_273600_446400 5.356235
R11040 n1_m1_273600_446400 n1_m1_278400_446400 5.356235
R11041 n1_m1_278400_446400 n1_m1_283200_446400 5.356235
R11042 n1_m1_283200_446400 n1_m1_284000_446400 0.892706
R11043 n1_m1_288000_446400 n1_m1_284000_446400 4.463529
R11044 n1_m1_288000_446400 n1_m1_292800_446400 5.356235
R11045 n1_m1_292800_446400 n1_m1_297600_446400 5.356235
R11046 n1_m1_297600_446400 n1_m1_302400_446400 5.356235
R11047 n1_m1_302400_446400 n1_m1_307200_446400 5.356235
R11048 n1_m1_307200_446400 n1_m1_312000_446400 5.356235
R11049 n1_m1_312000_446400 n1_m1_316800_446400 5.356235
R11050 n1_m1_316800_446400 n1_m1_321600_446400 5.356235
R11051 n1_m1_321600_446400 n1_m1_326400_446400 5.356235
R11052 n1_m1_326400_446400 n1_m1_331200_446400 5.356235
R11053 n1_m1_331200_446400 n1_m1_336000_446400 5.356235
R11054 n1_m1_336000_446400 n1_m1_340000_446400 4.463529
R11055 n1_m1_340800_446400 n1_m1_340000_446400 0.892706
R11056 n1_m1_340800_446400 n1_m1_345600_446400 5.356235
R11057 n1_m1_345600_446400 n1_m1_350400_446400 5.356235
R11058 n1_m1_350400_446400 n1_m1_355200_446400 5.356235
R11059 n1_m1_355200_446400 n1_m1_360000_446400 5.356235
R11060 n1_m1_360000_446400 n1_m1_364800_446400 5.356235
R11061 n1_m1_364800_446400 n1_m1_368000_446400 3.570824
R11062 n1_m1_369600_446400 n1_m1_368000_446400 1.785412
R11063 n1_m1_369600_446400 n1_m1_374400_446400 5.356235
R11064 n1_m1_374400_446400 n1_m1_379200_446400 5.356235
R11065 n1_m1_379200_446400 n1_m1_384000_446400 5.356235
R11066 n1_m1_384000_446400 n1_m1_388800_446400 5.356235
R11067 n1_m1_388800_446400 n1_m1_393600_446400 5.356235
R11068 n1_m1_393600_446400 n1_m1_396000_446400 2.678118
R11069 n1_m1_398400_446400 n1_m1_396000_446400 2.678118
R11070 n1_m1_398400_446400 n1_m1_403200_446400 5.356235
R11071 n1_m1_403200_446400 n1_m1_408000_446400 5.356235
R11072 n1_m1_408000_446400 n1_m1_412800_446400 5.356235
R11073 n1_m1_412800_446400 n1_m1_417600_446400 5.356235
R11074 n1_m1_417600_446400 n1_m1_422400_446400 5.356235
R11075 n1_m1_422400_446400 n1_m1_424000_446400 1.785412
R11076 n1_m1_427200_446400 n1_m1_424000_446400 3.570824
R11077 n1_m1_427200_446400 n1_m1_432000_446400 5.356235
R11078 n1_m1_432000_446400 n1_m1_436800_446400 5.356235
R11079 n1_m1_436800_446400 n1_m1_441600_446400 5.356235
R11080 n1_m1_441600_446400 n1_m1_446400_446400 5.356235
R11081 n1_m1_446400_446400 n1_m1_451200_446400 5.356235
R11082 n1_m1_451200_446400 n1_m1_452000_446400 0.892706
R11083 n1_m1_456000_446400 n1_m1_452000_446400 4.463529
R11084 n1_m1_456000_446400 n1_m1_460800_446400 5.356235
R11085 n1_m1_460800_446400 n1_m1_465600_446400 5.356235
R11086 n1_m1_465600_446400 n1_m1_470400_446400 5.356235
R11087 n1_m1_470400_446400 n1_m1_475200_446400 5.356235
R11088 n1_m1_475200_446400 n1_m1_480000_446400 5.356235
R11089 n1_m1_480000_446400 n1_m1_484800_446400 5.356235
R11090 n1_m1_484800_446400 n1_m1_489600_446400 5.356235
R11091 n1_m1_489600_446400 n1_m1_494400_446400 5.356235
R11092 n1_m1_0_451200 n1_m1_4000_451200 4.463529
R11093 n1_m1_4800_451200 n1_m1_4000_451200 0.892706
R11094 n1_m1_4800_451200 n1_m1_9600_451200 5.356235
R11095 n1_m1_9600_451200 n1_m1_14400_451200 5.356235
R11096 n1_m1_14400_451200 n1_m1_19200_451200 5.356235
R11097 n1_m1_19200_451200 n1_m1_24000_451200 5.356235
R11098 n1_m1_24000_451200 n1_m1_28800_451200 5.356235
R11099 n1_m1_28800_451200 n1_m1_32000_451200 3.570824
R11100 n1_m1_33600_451200 n1_m1_32000_451200 1.785412
R11101 n1_m1_33600_451200 n1_m1_38400_451200 5.356235
R11102 n1_m1_38400_451200 n1_m1_43200_451200 5.356235
R11103 n1_m1_43200_451200 n1_m1_48000_451200 5.356235
R11104 n1_m1_48000_451200 n1_m1_52800_451200 5.356235
R11105 n1_m1_52800_451200 n1_m1_57600_451200 5.356235
R11106 n1_m1_57600_451200 n1_m1_60000_451200 2.678118
R11107 n1_m1_62400_451200 n1_m1_60000_451200 2.678118
R11108 n1_m1_62400_451200 n1_m1_67200_451200 5.356235
R11109 n1_m1_67200_451200 n1_m1_72000_451200 5.356235
R11110 n1_m1_72000_451200 n1_m1_76800_451200 5.356235
R11111 n1_m1_76800_451200 n1_m1_81600_451200 5.356235
R11112 n1_m1_81600_451200 n1_m1_86400_451200 5.356235
R11113 n1_m1_86400_451200 n1_m1_88000_451200 1.785412
R11114 n1_m1_91200_451200 n1_m1_88000_451200 3.570824
R11115 n1_m1_91200_451200 n1_m1_96000_451200 5.356235
R11116 n1_m1_96000_451200 n1_m1_100800_451200 5.356235
R11117 n1_m1_100800_451200 n1_m1_105600_451200 5.356235
R11118 n1_m1_105600_451200 n1_m1_110400_451200 5.356235
R11119 n1_m1_110400_451200 n1_m1_115200_451200 5.356235
R11120 n1_m1_115200_451200 n1_m1_116000_451200 0.892706
R11121 n1_m1_120000_451200 n1_m1_116000_451200 4.463529
R11122 n1_m1_120000_451200 n1_m1_124800_451200 5.356235
R11123 n1_m1_124800_451200 n1_m1_129600_451200 5.356235
R11124 n1_m1_129600_451200 n1_m1_134400_451200 5.356235
R11125 n1_m1_134400_451200 n1_m1_139200_451200 5.356235
R11126 n1_m1_139200_451200 n1_m1_144000_451200 5.356235
R11127 n1_m1_144000_451200 n1_m1_148800_451200 5.356235
R11128 n1_m1_148800_451200 n1_m1_153600_451200 5.356235
R11129 n1_m1_153600_451200 n1_m1_158400_451200 5.356235
R11130 n1_m1_158400_451200 n1_m1_163200_451200 5.356235
R11131 n1_m1_163200_451200 n1_m1_168000_451200 5.356235
R11132 n1_m1_168000_451200 n1_m1_172000_451200 4.463529
R11133 n1_m1_172800_451200 n1_m1_172000_451200 0.892706
R11134 n1_m1_172800_451200 n1_m1_177600_451200 5.356235
R11135 n1_m1_177600_451200 n1_m1_182400_451200 5.356235
R11136 n1_m1_182400_451200 n1_m1_187200_451200 5.356235
R11137 n1_m1_187200_451200 n1_m1_192000_451200 5.356235
R11138 n1_m1_192000_451200 n1_m1_196800_451200 5.356235
R11139 n1_m1_196800_451200 n1_m1_200000_451200 3.570824
R11140 n1_m1_201600_451200 n1_m1_200000_451200 1.785412
R11141 n1_m1_201600_451200 n1_m1_206400_451200 5.356235
R11142 n1_m1_206400_451200 n1_m1_211200_451200 5.356235
R11143 n1_m1_211200_451200 n1_m1_216000_451200 5.356235
R11144 n1_m1_216000_451200 n1_m1_220800_451200 5.356235
R11145 n1_m1_220800_451200 n1_m1_225600_451200 5.356235
R11146 n1_m1_225600_451200 n1_m1_228000_451200 2.678118
R11147 n1_m1_230400_451200 n1_m1_228000_451200 2.678118
R11148 n1_m1_230400_451200 n1_m1_235200_451200 5.356235
R11149 n1_m1_235200_451200 n1_m1_240000_451200 5.356235
R11150 n1_m1_240000_451200 n1_m1_244800_451200 5.356235
R11151 n1_m1_244800_451200 n1_m1_249600_451200 5.356235
R11152 n1_m1_249600_451200 n1_m1_254400_451200 5.356235
R11153 n1_m1_254400_451200 n1_m1_256000_451200 1.785412
R11154 n1_m1_259200_451200 n1_m1_256000_451200 3.570824
R11155 n1_m1_259200_451200 n1_m1_264000_451200 5.356235
R11156 n1_m1_264000_451200 n1_m1_268800_451200 5.356235
R11157 n1_m1_268800_451200 n1_m1_273600_451200 5.356235
R11158 n1_m1_273600_451200 n1_m1_278400_451200 5.356235
R11159 n1_m1_278400_451200 n1_m1_283200_451200 5.356235
R11160 n1_m1_283200_451200 n1_m1_284000_451200 0.892706
R11161 n1_m1_288000_451200 n1_m1_284000_451200 4.463529
R11162 n1_m1_288000_451200 n1_m1_292800_451200 5.356235
R11163 n1_m1_292800_451200 n1_m1_297600_451200 5.356235
R11164 n1_m1_297600_451200 n1_m1_302400_451200 5.356235
R11165 n1_m1_302400_451200 n1_m1_307200_451200 5.356235
R11166 n1_m1_307200_451200 n1_m1_312000_451200 5.356235
R11167 n1_m1_312000_451200 n1_m1_316800_451200 5.356235
R11168 n1_m1_316800_451200 n1_m1_321600_451200 5.356235
R11169 n1_m1_321600_451200 n1_m1_326400_451200 5.356235
R11170 n1_m1_326400_451200 n1_m1_331200_451200 5.356235
R11171 n1_m1_331200_451200 n1_m1_336000_451200 5.356235
R11172 n1_m1_336000_451200 n1_m1_340000_451200 4.463529
R11173 n1_m1_340800_451200 n1_m1_340000_451200 0.892706
R11174 n1_m1_340800_451200 n1_m1_345600_451200 5.356235
R11175 n1_m1_345600_451200 n1_m1_350400_451200 5.356235
R11176 n1_m1_350400_451200 n1_m1_355200_451200 5.356235
R11177 n1_m1_355200_451200 n1_m1_360000_451200 5.356235
R11178 n1_m1_360000_451200 n1_m1_364800_451200 5.356235
R11179 n1_m1_364800_451200 n1_m1_368000_451200 3.570824
R11180 n1_m1_369600_451200 n1_m1_368000_451200 1.785412
R11181 n1_m1_369600_451200 n1_m1_374400_451200 5.356235
R11182 n1_m1_374400_451200 n1_m1_379200_451200 5.356235
R11183 n1_m1_379200_451200 n1_m1_384000_451200 5.356235
R11184 n1_m1_384000_451200 n1_m1_388800_451200 5.356235
R11185 n1_m1_388800_451200 n1_m1_393600_451200 5.356235
R11186 n1_m1_393600_451200 n1_m1_396000_451200 2.678118
R11187 n1_m1_398400_451200 n1_m1_396000_451200 2.678118
R11188 n1_m1_398400_451200 n1_m1_403200_451200 5.356235
R11189 n1_m1_403200_451200 n1_m1_408000_451200 5.356235
R11190 n1_m1_408000_451200 n1_m1_412800_451200 5.356235
R11191 n1_m1_412800_451200 n1_m1_417600_451200 5.356235
R11192 n1_m1_417600_451200 n1_m1_422400_451200 5.356235
R11193 n1_m1_422400_451200 n1_m1_424000_451200 1.785412
R11194 n1_m1_427200_451200 n1_m1_424000_451200 3.570824
R11195 n1_m1_427200_451200 n1_m1_432000_451200 5.356235
R11196 n1_m1_432000_451200 n1_m1_436800_451200 5.356235
R11197 n1_m1_436800_451200 n1_m1_441600_451200 5.356235
R11198 n1_m1_441600_451200 n1_m1_446400_451200 5.356235
R11199 n1_m1_446400_451200 n1_m1_451200_451200 5.356235
R11200 n1_m1_451200_451200 n1_m1_452000_451200 0.892706
R11201 n1_m1_456000_451200 n1_m1_452000_451200 4.463529
R11202 n1_m1_456000_451200 n1_m1_460800_451200 5.356235
R11203 n1_m1_460800_451200 n1_m1_465600_451200 5.356235
R11204 n1_m1_465600_451200 n1_m1_470400_451200 5.356235
R11205 n1_m1_470400_451200 n1_m1_475200_451200 5.356235
R11206 n1_m1_475200_451200 n1_m1_480000_451200 5.356235
R11207 n1_m1_480000_451200 n1_m1_484800_451200 5.356235
R11208 n1_m1_484800_451200 n1_m1_489600_451200 5.356235
R11209 n1_m1_489600_451200 n1_m1_494400_451200 5.356235
R11210 n1_m1_0_456000 n1_m1_4000_456000 4.463529
R11211 n1_m1_4800_456000 n1_m1_4000_456000 0.892706
R11212 n1_m1_4800_456000 n1_m1_9600_456000 5.356235
R11213 n1_m1_9600_456000 n1_m1_14400_456000 5.356235
R11214 n1_m1_14400_456000 n1_m1_19200_456000 5.356235
R11215 n1_m1_19200_456000 n1_m1_24000_456000 5.356235
R11216 n1_m1_24000_456000 n1_m1_28800_456000 5.356235
R11217 n1_m1_28800_456000 n1_m1_32000_456000 3.570824
R11218 n1_m1_33600_456000 n1_m1_32000_456000 1.785412
R11219 n1_m1_33600_456000 n1_m1_38400_456000 5.356235
R11220 n1_m1_38400_456000 n1_m1_43200_456000 5.356235
R11221 n1_m1_43200_456000 n1_m1_48000_456000 5.356235
R11222 n1_m1_48000_456000 n1_m1_52800_456000 5.356235
R11223 n1_m1_52800_456000 n1_m1_57600_456000 5.356235
R11224 n1_m1_57600_456000 n1_m1_60000_456000 2.678118
R11225 n1_m1_62400_456000 n1_m1_60000_456000 2.678118
R11226 n1_m1_62400_456000 n1_m1_67200_456000 5.356235
R11227 n1_m1_67200_456000 n1_m1_72000_456000 5.356235
R11228 n1_m1_72000_456000 n1_m1_76800_456000 5.356235
R11229 n1_m1_76800_456000 n1_m1_81600_456000 5.356235
R11230 n1_m1_81600_456000 n1_m1_86400_456000 5.356235
R11231 n1_m1_86400_456000 n1_m1_88000_456000 1.785412
R11232 n1_m1_91200_456000 n1_m1_88000_456000 3.570824
R11233 n1_m1_91200_456000 n1_m1_96000_456000 5.356235
R11234 n1_m1_96000_456000 n1_m1_100800_456000 5.356235
R11235 n1_m1_100800_456000 n1_m1_105600_456000 5.356235
R11236 n1_m1_105600_456000 n1_m1_110400_456000 5.356235
R11237 n1_m1_110400_456000 n1_m1_115200_456000 5.356235
R11238 n1_m1_115200_456000 n1_m1_116000_456000 0.892706
R11239 n1_m1_120000_456000 n1_m1_116000_456000 4.463529
R11240 n1_m1_120000_456000 n1_m1_124800_456000 5.356235
R11241 n1_m1_124800_456000 n1_m1_129600_456000 5.356235
R11242 n1_m1_129600_456000 n1_m1_134400_456000 5.356235
R11243 n1_m1_134400_456000 n1_m1_139200_456000 5.356235
R11244 n1_m1_139200_456000 n1_m1_144000_456000 5.356235
R11245 n1_m1_144000_456000 n1_m1_148800_456000 5.356235
R11246 n1_m1_148800_456000 n1_m1_153600_456000 5.356235
R11247 n1_m1_153600_456000 n1_m1_158400_456000 5.356235
R11248 n1_m1_158400_456000 n1_m1_163200_456000 5.356235
R11249 n1_m1_163200_456000 n1_m1_168000_456000 5.356235
R11250 n1_m1_168000_456000 n1_m1_172000_456000 4.463529
R11251 n1_m1_172800_456000 n1_m1_172000_456000 0.892706
R11252 n1_m1_172800_456000 n1_m1_177600_456000 5.356235
R11253 n1_m1_177600_456000 n1_m1_182400_456000 5.356235
R11254 n1_m1_182400_456000 n1_m1_187200_456000 5.356235
R11255 n1_m1_187200_456000 n1_m1_192000_456000 5.356235
R11256 n1_m1_192000_456000 n1_m1_196800_456000 5.356235
R11257 n1_m1_196800_456000 n1_m1_200000_456000 3.570824
R11258 n1_m1_201600_456000 n1_m1_200000_456000 1.785412
R11259 n1_m1_201600_456000 n1_m1_206400_456000 5.356235
R11260 n1_m1_206400_456000 n1_m1_211200_456000 5.356235
R11261 n1_m1_211200_456000 n1_m1_216000_456000 5.356235
R11262 n1_m1_216000_456000 n1_m1_220800_456000 5.356235
R11263 n1_m1_220800_456000 n1_m1_225600_456000 5.356235
R11264 n1_m1_225600_456000 n1_m1_228000_456000 2.678118
R11265 n1_m1_230400_456000 n1_m1_228000_456000 2.678118
R11266 n1_m1_230400_456000 n1_m1_235200_456000 5.356235
R11267 n1_m1_235200_456000 n1_m1_240000_456000 5.356235
R11268 n1_m1_240000_456000 n1_m1_244800_456000 5.356235
R11269 n1_m1_244800_456000 n1_m1_249600_456000 5.356235
R11270 n1_m1_249600_456000 n1_m1_254400_456000 5.356235
R11271 n1_m1_254400_456000 n1_m1_256000_456000 1.785412
R11272 n1_m1_259200_456000 n1_m1_256000_456000 3.570824
R11273 n1_m1_259200_456000 n1_m1_264000_456000 5.356235
R11274 n1_m1_264000_456000 n1_m1_268800_456000 5.356235
R11275 n1_m1_268800_456000 n1_m1_273600_456000 5.356235
R11276 n1_m1_273600_456000 n1_m1_278400_456000 5.356235
R11277 n1_m1_278400_456000 n1_m1_283200_456000 5.356235
R11278 n1_m1_283200_456000 n1_m1_284000_456000 0.892706
R11279 n1_m1_288000_456000 n1_m1_284000_456000 4.463529
R11280 n1_m1_288000_456000 n1_m1_292800_456000 5.356235
R11281 n1_m1_292800_456000 n1_m1_297600_456000 5.356235
R11282 n1_m1_297600_456000 n1_m1_302400_456000 5.356235
R11283 n1_m1_302400_456000 n1_m1_307200_456000 5.356235
R11284 n1_m1_307200_456000 n1_m1_312000_456000 5.356235
R11285 n1_m1_312000_456000 n1_m1_316800_456000 5.356235
R11286 n1_m1_316800_456000 n1_m1_321600_456000 5.356235
R11287 n1_m1_321600_456000 n1_m1_326400_456000 5.356235
R11288 n1_m1_326400_456000 n1_m1_331200_456000 5.356235
R11289 n1_m1_331200_456000 n1_m1_336000_456000 5.356235
R11290 n1_m1_336000_456000 n1_m1_340000_456000 4.463529
R11291 n1_m1_340800_456000 n1_m1_340000_456000 0.892706
R11292 n1_m1_340800_456000 n1_m1_345600_456000 5.356235
R11293 n1_m1_345600_456000 n1_m1_350400_456000 5.356235
R11294 n1_m1_350400_456000 n1_m1_355200_456000 5.356235
R11295 n1_m1_355200_456000 n1_m1_360000_456000 5.356235
R11296 n1_m1_360000_456000 n1_m1_364800_456000 5.356235
R11297 n1_m1_364800_456000 n1_m1_368000_456000 3.570824
R11298 n1_m1_369600_456000 n1_m1_368000_456000 1.785412
R11299 n1_m1_369600_456000 n1_m1_374400_456000 5.356235
R11300 n1_m1_374400_456000 n1_m1_379200_456000 5.356235
R11301 n1_m1_379200_456000 n1_m1_384000_456000 5.356235
R11302 n1_m1_384000_456000 n1_m1_388800_456000 5.356235
R11303 n1_m1_388800_456000 n1_m1_393600_456000 5.356235
R11304 n1_m1_393600_456000 n1_m1_396000_456000 2.678118
R11305 n1_m1_398400_456000 n1_m1_396000_456000 2.678118
R11306 n1_m1_398400_456000 n1_m1_403200_456000 5.356235
R11307 n1_m1_403200_456000 n1_m1_408000_456000 5.356235
R11308 n1_m1_408000_456000 n1_m1_412800_456000 5.356235
R11309 n1_m1_412800_456000 n1_m1_417600_456000 5.356235
R11310 n1_m1_417600_456000 n1_m1_422400_456000 5.356235
R11311 n1_m1_422400_456000 n1_m1_424000_456000 1.785412
R11312 n1_m1_427200_456000 n1_m1_424000_456000 3.570824
R11313 n1_m1_427200_456000 n1_m1_432000_456000 5.356235
R11314 n1_m1_432000_456000 n1_m1_436800_456000 5.356235
R11315 n1_m1_436800_456000 n1_m1_441600_456000 5.356235
R11316 n1_m1_441600_456000 n1_m1_446400_456000 5.356235
R11317 n1_m1_446400_456000 n1_m1_451200_456000 5.356235
R11318 n1_m1_451200_456000 n1_m1_452000_456000 0.892706
R11319 n1_m1_456000_456000 n1_m1_452000_456000 4.463529
R11320 n1_m1_456000_456000 n1_m1_460800_456000 5.356235
R11321 n1_m1_460800_456000 n1_m1_465600_456000 5.356235
R11322 n1_m1_465600_456000 n1_m1_470400_456000 5.356235
R11323 n1_m1_470400_456000 n1_m1_475200_456000 5.356235
R11324 n1_m1_475200_456000 n1_m1_480000_456000 5.356235
R11325 n1_m1_480000_456000 n1_m1_484800_456000 5.356235
R11326 n1_m1_484800_456000 n1_m1_489600_456000 5.356235
R11327 n1_m1_489600_456000 n1_m1_494400_456000 5.356235
R11328 n1_m1_0_460800 n1_m1_4000_460800 4.463529
R11329 n1_m1_4800_460800 n1_m1_4000_460800 0.892706
R11330 n1_m1_4800_460800 n1_m1_9600_460800 5.356235
R11331 n1_m1_9600_460800 n1_m1_14400_460800 5.356235
R11332 n1_m1_14400_460800 n1_m1_19200_460800 5.356235
R11333 n1_m1_19200_460800 n1_m1_24000_460800 5.356235
R11334 n1_m1_24000_460800 n1_m1_28800_460800 5.356235
R11335 n1_m1_28800_460800 n1_m1_32000_460800 3.570824
R11336 n1_m1_33600_460800 n1_m1_32000_460800 1.785412
R11337 n1_m1_33600_460800 n1_m1_38400_460800 5.356235
R11338 n1_m1_38400_460800 n1_m1_43200_460800 5.356235
R11339 n1_m1_43200_460800 n1_m1_48000_460800 5.356235
R11340 n1_m1_48000_460800 n1_m1_52800_460800 5.356235
R11341 n1_m1_52800_460800 n1_m1_57600_460800 5.356235
R11342 n1_m1_57600_460800 n1_m1_60000_460800 2.678118
R11343 n1_m1_62400_460800 n1_m1_60000_460800 2.678118
R11344 n1_m1_62400_460800 n1_m1_67200_460800 5.356235
R11345 n1_m1_67200_460800 n1_m1_72000_460800 5.356235
R11346 n1_m1_72000_460800 n1_m1_76800_460800 5.356235
R11347 n1_m1_76800_460800 n1_m1_81600_460800 5.356235
R11348 n1_m1_81600_460800 n1_m1_86400_460800 5.356235
R11349 n1_m1_86400_460800 n1_m1_88000_460800 1.785412
R11350 n1_m1_91200_460800 n1_m1_88000_460800 3.570824
R11351 n1_m1_91200_460800 n1_m1_96000_460800 5.356235
R11352 n1_m1_96000_460800 n1_m1_100800_460800 5.356235
R11353 n1_m1_100800_460800 n1_m1_105600_460800 5.356235
R11354 n1_m1_105600_460800 n1_m1_110400_460800 5.356235
R11355 n1_m1_110400_460800 n1_m1_115200_460800 5.356235
R11356 n1_m1_115200_460800 n1_m1_116000_460800 0.892706
R11357 n1_m1_120000_460800 n1_m1_116000_460800 4.463529
R11358 n1_m1_120000_460800 n1_m1_124800_460800 5.356235
R11359 n1_m1_124800_460800 n1_m1_129600_460800 5.356235
R11360 n1_m1_129600_460800 n1_m1_134400_460800 5.356235
R11361 n1_m1_134400_460800 n1_m1_139200_460800 5.356235
R11362 n1_m1_139200_460800 n1_m1_144000_460800 5.356235
R11363 n1_m1_144000_460800 n1_m1_148800_460800 5.356235
R11364 n1_m1_148800_460800 n1_m1_153600_460800 5.356235
R11365 n1_m1_153600_460800 n1_m1_158400_460800 5.356235
R11366 n1_m1_158400_460800 n1_m1_163200_460800 5.356235
R11367 n1_m1_163200_460800 n1_m1_168000_460800 5.356235
R11368 n1_m1_168000_460800 n1_m1_172000_460800 4.463529
R11369 n1_m1_172800_460800 n1_m1_172000_460800 0.892706
R11370 n1_m1_172800_460800 n1_m1_177600_460800 5.356235
R11371 n1_m1_177600_460800 n1_m1_182400_460800 5.356235
R11372 n1_m1_182400_460800 n1_m1_187200_460800 5.356235
R11373 n1_m1_187200_460800 n1_m1_192000_460800 5.356235
R11374 n1_m1_192000_460800 n1_m1_196800_460800 5.356235
R11375 n1_m1_196800_460800 n1_m1_200000_460800 3.570824
R11376 n1_m1_201600_460800 n1_m1_200000_460800 1.785412
R11377 n1_m1_201600_460800 n1_m1_206400_460800 5.356235
R11378 n1_m1_206400_460800 n1_m1_211200_460800 5.356235
R11379 n1_m1_211200_460800 n1_m1_216000_460800 5.356235
R11380 n1_m1_216000_460800 n1_m1_220800_460800 5.356235
R11381 n1_m1_220800_460800 n1_m1_225600_460800 5.356235
R11382 n1_m1_225600_460800 n1_m1_228000_460800 2.678118
R11383 n1_m1_230400_460800 n1_m1_228000_460800 2.678118
R11384 n1_m1_230400_460800 n1_m1_235200_460800 5.356235
R11385 n1_m1_235200_460800 n1_m1_240000_460800 5.356235
R11386 n1_m1_240000_460800 n1_m1_244800_460800 5.356235
R11387 n1_m1_244800_460800 n1_m1_249600_460800 5.356235
R11388 n1_m1_249600_460800 n1_m1_254400_460800 5.356235
R11389 n1_m1_254400_460800 n1_m1_256000_460800 1.785412
R11390 n1_m1_259200_460800 n1_m1_256000_460800 3.570824
R11391 n1_m1_259200_460800 n1_m1_264000_460800 5.356235
R11392 n1_m1_264000_460800 n1_m1_268800_460800 5.356235
R11393 n1_m1_268800_460800 n1_m1_273600_460800 5.356235
R11394 n1_m1_273600_460800 n1_m1_278400_460800 5.356235
R11395 n1_m1_278400_460800 n1_m1_283200_460800 5.356235
R11396 n1_m1_283200_460800 n1_m1_284000_460800 0.892706
R11397 n1_m1_288000_460800 n1_m1_284000_460800 4.463529
R11398 n1_m1_288000_460800 n1_m1_292800_460800 5.356235
R11399 n1_m1_292800_460800 n1_m1_297600_460800 5.356235
R11400 n1_m1_297600_460800 n1_m1_302400_460800 5.356235
R11401 n1_m1_302400_460800 n1_m1_307200_460800 5.356235
R11402 n1_m1_307200_460800 n1_m1_312000_460800 5.356235
R11403 n1_m1_312000_460800 n1_m1_316800_460800 5.356235
R11404 n1_m1_316800_460800 n1_m1_321600_460800 5.356235
R11405 n1_m1_321600_460800 n1_m1_326400_460800 5.356235
R11406 n1_m1_326400_460800 n1_m1_331200_460800 5.356235
R11407 n1_m1_331200_460800 n1_m1_336000_460800 5.356235
R11408 n1_m1_336000_460800 n1_m1_340000_460800 4.463529
R11409 n1_m1_340800_460800 n1_m1_340000_460800 0.892706
R11410 n1_m1_340800_460800 n1_m1_345600_460800 5.356235
R11411 n1_m1_345600_460800 n1_m1_350400_460800 5.356235
R11412 n1_m1_350400_460800 n1_m1_355200_460800 5.356235
R11413 n1_m1_355200_460800 n1_m1_360000_460800 5.356235
R11414 n1_m1_360000_460800 n1_m1_364800_460800 5.356235
R11415 n1_m1_364800_460800 n1_m1_368000_460800 3.570824
R11416 n1_m1_369600_460800 n1_m1_368000_460800 1.785412
R11417 n1_m1_369600_460800 n1_m1_374400_460800 5.356235
R11418 n1_m1_374400_460800 n1_m1_379200_460800 5.356235
R11419 n1_m1_379200_460800 n1_m1_384000_460800 5.356235
R11420 n1_m1_384000_460800 n1_m1_388800_460800 5.356235
R11421 n1_m1_388800_460800 n1_m1_393600_460800 5.356235
R11422 n1_m1_393600_460800 n1_m1_396000_460800 2.678118
R11423 n1_m1_398400_460800 n1_m1_396000_460800 2.678118
R11424 n1_m1_398400_460800 n1_m1_403200_460800 5.356235
R11425 n1_m1_403200_460800 n1_m1_408000_460800 5.356235
R11426 n1_m1_408000_460800 n1_m1_412800_460800 5.356235
R11427 n1_m1_412800_460800 n1_m1_417600_460800 5.356235
R11428 n1_m1_417600_460800 n1_m1_422400_460800 5.356235
R11429 n1_m1_422400_460800 n1_m1_424000_460800 1.785412
R11430 n1_m1_427200_460800 n1_m1_424000_460800 3.570824
R11431 n1_m1_427200_460800 n1_m1_432000_460800 5.356235
R11432 n1_m1_432000_460800 n1_m1_436800_460800 5.356235
R11433 n1_m1_436800_460800 n1_m1_441600_460800 5.356235
R11434 n1_m1_441600_460800 n1_m1_446400_460800 5.356235
R11435 n1_m1_446400_460800 n1_m1_451200_460800 5.356235
R11436 n1_m1_451200_460800 n1_m1_452000_460800 0.892706
R11437 n1_m1_456000_460800 n1_m1_452000_460800 4.463529
R11438 n1_m1_456000_460800 n1_m1_460800_460800 5.356235
R11439 n1_m1_460800_460800 n1_m1_465600_460800 5.356235
R11440 n1_m1_465600_460800 n1_m1_470400_460800 5.356235
R11441 n1_m1_470400_460800 n1_m1_475200_460800 5.356235
R11442 n1_m1_475200_460800 n1_m1_480000_460800 5.356235
R11443 n1_m1_480000_460800 n1_m1_484800_460800 5.356235
R11444 n1_m1_484800_460800 n1_m1_489600_460800 5.356235
R11445 n1_m1_489600_460800 n1_m1_494400_460800 5.356235
R11446 n1_m1_0_465600 n1_m1_4000_465600 4.463529
R11447 n1_m1_4800_465600 n1_m1_4000_465600 0.892706
R11448 n1_m1_4800_465600 n1_m1_9600_465600 5.356235
R11449 n1_m1_9600_465600 n1_m1_14400_465600 5.356235
R11450 n1_m1_14400_465600 n1_m1_19200_465600 5.356235
R11451 n1_m1_19200_465600 n1_m1_24000_465600 5.356235
R11452 n1_m1_24000_465600 n1_m1_28800_465600 5.356235
R11453 n1_m1_28800_465600 n1_m1_32000_465600 3.570824
R11454 n1_m1_33600_465600 n1_m1_32000_465600 1.785412
R11455 n1_m1_33600_465600 n1_m1_38400_465600 5.356235
R11456 n1_m1_38400_465600 n1_m1_43200_465600 5.356235
R11457 n1_m1_43200_465600 n1_m1_48000_465600 5.356235
R11458 n1_m1_48000_465600 n1_m1_52800_465600 5.356235
R11459 n1_m1_52800_465600 n1_m1_57600_465600 5.356235
R11460 n1_m1_57600_465600 n1_m1_60000_465600 2.678118
R11461 n1_m1_62400_465600 n1_m1_60000_465600 2.678118
R11462 n1_m1_62400_465600 n1_m1_67200_465600 5.356235
R11463 n1_m1_67200_465600 n1_m1_72000_465600 5.356235
R11464 n1_m1_72000_465600 n1_m1_76800_465600 5.356235
R11465 n1_m1_76800_465600 n1_m1_81600_465600 5.356235
R11466 n1_m1_81600_465600 n1_m1_86400_465600 5.356235
R11467 n1_m1_86400_465600 n1_m1_88000_465600 1.785412
R11468 n1_m1_91200_465600 n1_m1_88000_465600 3.570824
R11469 n1_m1_91200_465600 n1_m1_96000_465600 5.356235
R11470 n1_m1_96000_465600 n1_m1_100800_465600 5.356235
R11471 n1_m1_100800_465600 n1_m1_105600_465600 5.356235
R11472 n1_m1_105600_465600 n1_m1_110400_465600 5.356235
R11473 n1_m1_110400_465600 n1_m1_115200_465600 5.356235
R11474 n1_m1_115200_465600 n1_m1_116000_465600 0.892706
R11475 n1_m1_120000_465600 n1_m1_116000_465600 4.463529
R11476 n1_m1_120000_465600 n1_m1_124800_465600 5.356235
R11477 n1_m1_124800_465600 n1_m1_129600_465600 5.356235
R11478 n1_m1_129600_465600 n1_m1_134400_465600 5.356235
R11479 n1_m1_134400_465600 n1_m1_139200_465600 5.356235
R11480 n1_m1_139200_465600 n1_m1_144000_465600 5.356235
R11481 n1_m1_144000_465600 n1_m1_148800_465600 5.356235
R11482 n1_m1_148800_465600 n1_m1_153600_465600 5.356235
R11483 n1_m1_153600_465600 n1_m1_158400_465600 5.356235
R11484 n1_m1_158400_465600 n1_m1_163200_465600 5.356235
R11485 n1_m1_163200_465600 n1_m1_168000_465600 5.356235
R11486 n1_m1_168000_465600 n1_m1_172000_465600 4.463529
R11487 n1_m1_172800_465600 n1_m1_172000_465600 0.892706
R11488 n1_m1_172800_465600 n1_m1_177600_465600 5.356235
R11489 n1_m1_177600_465600 n1_m1_182400_465600 5.356235
R11490 n1_m1_182400_465600 n1_m1_187200_465600 5.356235
R11491 n1_m1_187200_465600 n1_m1_192000_465600 5.356235
R11492 n1_m1_192000_465600 n1_m1_196800_465600 5.356235
R11493 n1_m1_196800_465600 n1_m1_200000_465600 3.570824
R11494 n1_m1_201600_465600 n1_m1_200000_465600 1.785412
R11495 n1_m1_201600_465600 n1_m1_206400_465600 5.356235
R11496 n1_m1_206400_465600 n1_m1_211200_465600 5.356235
R11497 n1_m1_211200_465600 n1_m1_216000_465600 5.356235
R11498 n1_m1_216000_465600 n1_m1_220800_465600 5.356235
R11499 n1_m1_220800_465600 n1_m1_225600_465600 5.356235
R11500 n1_m1_225600_465600 n1_m1_228000_465600 2.678118
R11501 n1_m1_230400_465600 n1_m1_228000_465600 2.678118
R11502 n1_m1_230400_465600 n1_m1_235200_465600 5.356235
R11503 n1_m1_235200_465600 n1_m1_240000_465600 5.356235
R11504 n1_m1_240000_465600 n1_m1_244800_465600 5.356235
R11505 n1_m1_244800_465600 n1_m1_249600_465600 5.356235
R11506 n1_m1_249600_465600 n1_m1_254400_465600 5.356235
R11507 n1_m1_254400_465600 n1_m1_256000_465600 1.785412
R11508 n1_m1_259200_465600 n1_m1_256000_465600 3.570824
R11509 n1_m1_259200_465600 n1_m1_264000_465600 5.356235
R11510 n1_m1_264000_465600 n1_m1_268800_465600 5.356235
R11511 n1_m1_268800_465600 n1_m1_273600_465600 5.356235
R11512 n1_m1_273600_465600 n1_m1_278400_465600 5.356235
R11513 n1_m1_278400_465600 n1_m1_283200_465600 5.356235
R11514 n1_m1_283200_465600 n1_m1_284000_465600 0.892706
R11515 n1_m1_288000_465600 n1_m1_284000_465600 4.463529
R11516 n1_m1_288000_465600 n1_m1_292800_465600 5.356235
R11517 n1_m1_292800_465600 n1_m1_297600_465600 5.356235
R11518 n1_m1_297600_465600 n1_m1_302400_465600 5.356235
R11519 n1_m1_302400_465600 n1_m1_307200_465600 5.356235
R11520 n1_m1_307200_465600 n1_m1_312000_465600 5.356235
R11521 n1_m1_312000_465600 n1_m1_316800_465600 5.356235
R11522 n1_m1_316800_465600 n1_m1_321600_465600 5.356235
R11523 n1_m1_321600_465600 n1_m1_326400_465600 5.356235
R11524 n1_m1_326400_465600 n1_m1_331200_465600 5.356235
R11525 n1_m1_331200_465600 n1_m1_336000_465600 5.356235
R11526 n1_m1_336000_465600 n1_m1_340000_465600 4.463529
R11527 n1_m1_340800_465600 n1_m1_340000_465600 0.892706
R11528 n1_m1_340800_465600 n1_m1_345600_465600 5.356235
R11529 n1_m1_345600_465600 n1_m1_350400_465600 5.356235
R11530 n1_m1_350400_465600 n1_m1_355200_465600 5.356235
R11531 n1_m1_355200_465600 n1_m1_360000_465600 5.356235
R11532 n1_m1_360000_465600 n1_m1_364800_465600 5.356235
R11533 n1_m1_364800_465600 n1_m1_368000_465600 3.570824
R11534 n1_m1_369600_465600 n1_m1_368000_465600 1.785412
R11535 n1_m1_369600_465600 n1_m1_374400_465600 5.356235
R11536 n1_m1_374400_465600 n1_m1_379200_465600 5.356235
R11537 n1_m1_379200_465600 n1_m1_384000_465600 5.356235
R11538 n1_m1_384000_465600 n1_m1_388800_465600 5.356235
R11539 n1_m1_388800_465600 n1_m1_393600_465600 5.356235
R11540 n1_m1_393600_465600 n1_m1_396000_465600 2.678118
R11541 n1_m1_398400_465600 n1_m1_396000_465600 2.678118
R11542 n1_m1_398400_465600 n1_m1_403200_465600 5.356235
R11543 n1_m1_403200_465600 n1_m1_408000_465600 5.356235
R11544 n1_m1_408000_465600 n1_m1_412800_465600 5.356235
R11545 n1_m1_412800_465600 n1_m1_417600_465600 5.356235
R11546 n1_m1_417600_465600 n1_m1_422400_465600 5.356235
R11547 n1_m1_422400_465600 n1_m1_424000_465600 1.785412
R11548 n1_m1_427200_465600 n1_m1_424000_465600 3.570824
R11549 n1_m1_427200_465600 n1_m1_432000_465600 5.356235
R11550 n1_m1_432000_465600 n1_m1_436800_465600 5.356235
R11551 n1_m1_436800_465600 n1_m1_441600_465600 5.356235
R11552 n1_m1_441600_465600 n1_m1_446400_465600 5.356235
R11553 n1_m1_446400_465600 n1_m1_451200_465600 5.356235
R11554 n1_m1_451200_465600 n1_m1_452000_465600 0.892706
R11555 n1_m1_456000_465600 n1_m1_452000_465600 4.463529
R11556 n1_m1_456000_465600 n1_m1_460800_465600 5.356235
R11557 n1_m1_460800_465600 n1_m1_465600_465600 5.356235
R11558 n1_m1_465600_465600 n1_m1_470400_465600 5.356235
R11559 n1_m1_470400_465600 n1_m1_475200_465600 5.356235
R11560 n1_m1_475200_465600 n1_m1_480000_465600 5.356235
R11561 n1_m1_480000_465600 n1_m1_484800_465600 5.356235
R11562 n1_m1_484800_465600 n1_m1_489600_465600 5.356235
R11563 n1_m1_489600_465600 n1_m1_494400_465600 5.356235
R11564 n1_m1_0_470400 n1_m1_4000_470400 4.463529
R11565 n1_m1_4800_470400 n1_m1_4000_470400 0.892706
R11566 n1_m1_4800_470400 n1_m1_9600_470400 5.356235
R11567 n1_m1_9600_470400 n1_m1_14400_470400 5.356235
R11568 n1_m1_14400_470400 n1_m1_19200_470400 5.356235
R11569 n1_m1_19200_470400 n1_m1_24000_470400 5.356235
R11570 n1_m1_24000_470400 n1_m1_28800_470400 5.356235
R11571 n1_m1_28800_470400 n1_m1_32000_470400 3.570824
R11572 n1_m1_33600_470400 n1_m1_32000_470400 1.785412
R11573 n1_m1_33600_470400 n1_m1_38400_470400 5.356235
R11574 n1_m1_38400_470400 n1_m1_43200_470400 5.356235
R11575 n1_m1_43200_470400 n1_m1_48000_470400 5.356235
R11576 n1_m1_48000_470400 n1_m1_52800_470400 5.356235
R11577 n1_m1_52800_470400 n1_m1_57600_470400 5.356235
R11578 n1_m1_57600_470400 n1_m1_60000_470400 2.678118
R11579 n1_m1_62400_470400 n1_m1_60000_470400 2.678118
R11580 n1_m1_62400_470400 n1_m1_67200_470400 5.356235
R11581 n1_m1_67200_470400 n1_m1_72000_470400 5.356235
R11582 n1_m1_72000_470400 n1_m1_76800_470400 5.356235
R11583 n1_m1_76800_470400 n1_m1_81600_470400 5.356235
R11584 n1_m1_81600_470400 n1_m1_86400_470400 5.356235
R11585 n1_m1_86400_470400 n1_m1_88000_470400 1.785412
R11586 n1_m1_91200_470400 n1_m1_88000_470400 3.570824
R11587 n1_m1_91200_470400 n1_m1_96000_470400 5.356235
R11588 n1_m1_96000_470400 n1_m1_100800_470400 5.356235
R11589 n1_m1_100800_470400 n1_m1_105600_470400 5.356235
R11590 n1_m1_105600_470400 n1_m1_110400_470400 5.356235
R11591 n1_m1_110400_470400 n1_m1_115200_470400 5.356235
R11592 n1_m1_115200_470400 n1_m1_116000_470400 0.892706
R11593 n1_m1_120000_470400 n1_m1_116000_470400 4.463529
R11594 n1_m1_120000_470400 n1_m1_124800_470400 5.356235
R11595 n1_m1_124800_470400 n1_m1_129600_470400 5.356235
R11596 n1_m1_129600_470400 n1_m1_134400_470400 5.356235
R11597 n1_m1_134400_470400 n1_m1_139200_470400 5.356235
R11598 n1_m1_139200_470400 n1_m1_144000_470400 5.356235
R11599 n1_m1_144000_470400 n1_m1_148800_470400 5.356235
R11600 n1_m1_148800_470400 n1_m1_153600_470400 5.356235
R11601 n1_m1_153600_470400 n1_m1_158400_470400 5.356235
R11602 n1_m1_158400_470400 n1_m1_163200_470400 5.356235
R11603 n1_m1_163200_470400 n1_m1_168000_470400 5.356235
R11604 n1_m1_168000_470400 n1_m1_172000_470400 4.463529
R11605 n1_m1_172800_470400 n1_m1_172000_470400 0.892706
R11606 n1_m1_172800_470400 n1_m1_177600_470400 5.356235
R11607 n1_m1_177600_470400 n1_m1_182400_470400 5.356235
R11608 n1_m1_182400_470400 n1_m1_187200_470400 5.356235
R11609 n1_m1_187200_470400 n1_m1_192000_470400 5.356235
R11610 n1_m1_192000_470400 n1_m1_196800_470400 5.356235
R11611 n1_m1_196800_470400 n1_m1_200000_470400 3.570824
R11612 n1_m1_201600_470400 n1_m1_200000_470400 1.785412
R11613 n1_m1_201600_470400 n1_m1_206400_470400 5.356235
R11614 n1_m1_206400_470400 n1_m1_211200_470400 5.356235
R11615 n1_m1_211200_470400 n1_m1_216000_470400 5.356235
R11616 n1_m1_216000_470400 n1_m1_220800_470400 5.356235
R11617 n1_m1_220800_470400 n1_m1_225600_470400 5.356235
R11618 n1_m1_225600_470400 n1_m1_228000_470400 2.678118
R11619 n1_m1_230400_470400 n1_m1_228000_470400 2.678118
R11620 n1_m1_230400_470400 n1_m1_235200_470400 5.356235
R11621 n1_m1_235200_470400 n1_m1_240000_470400 5.356235
R11622 n1_m1_240000_470400 n1_m1_244800_470400 5.356235
R11623 n1_m1_244800_470400 n1_m1_249600_470400 5.356235
R11624 n1_m1_249600_470400 n1_m1_254400_470400 5.356235
R11625 n1_m1_254400_470400 n1_m1_256000_470400 1.785412
R11626 n1_m1_259200_470400 n1_m1_256000_470400 3.570824
R11627 n1_m1_259200_470400 n1_m1_264000_470400 5.356235
R11628 n1_m1_264000_470400 n1_m1_268800_470400 5.356235
R11629 n1_m1_268800_470400 n1_m1_273600_470400 5.356235
R11630 n1_m1_273600_470400 n1_m1_278400_470400 5.356235
R11631 n1_m1_278400_470400 n1_m1_283200_470400 5.356235
R11632 n1_m1_283200_470400 n1_m1_284000_470400 0.892706
R11633 n1_m1_288000_470400 n1_m1_284000_470400 4.463529
R11634 n1_m1_288000_470400 n1_m1_292800_470400 5.356235
R11635 n1_m1_292800_470400 n1_m1_297600_470400 5.356235
R11636 n1_m1_297600_470400 n1_m1_302400_470400 5.356235
R11637 n1_m1_302400_470400 n1_m1_307200_470400 5.356235
R11638 n1_m1_307200_470400 n1_m1_312000_470400 5.356235
R11639 n1_m1_312000_470400 n1_m1_316800_470400 5.356235
R11640 n1_m1_316800_470400 n1_m1_321600_470400 5.356235
R11641 n1_m1_321600_470400 n1_m1_326400_470400 5.356235
R11642 n1_m1_326400_470400 n1_m1_331200_470400 5.356235
R11643 n1_m1_331200_470400 n1_m1_336000_470400 5.356235
R11644 n1_m1_336000_470400 n1_m1_340000_470400 4.463529
R11645 n1_m1_340800_470400 n1_m1_340000_470400 0.892706
R11646 n1_m1_340800_470400 n1_m1_345600_470400 5.356235
R11647 n1_m1_345600_470400 n1_m1_350400_470400 5.356235
R11648 n1_m1_350400_470400 n1_m1_355200_470400 5.356235
R11649 n1_m1_355200_470400 n1_m1_360000_470400 5.356235
R11650 n1_m1_360000_470400 n1_m1_364800_470400 5.356235
R11651 n1_m1_364800_470400 n1_m1_368000_470400 3.570824
R11652 n1_m1_369600_470400 n1_m1_368000_470400 1.785412
R11653 n1_m1_369600_470400 n1_m1_374400_470400 5.356235
R11654 n1_m1_374400_470400 n1_m1_379200_470400 5.356235
R11655 n1_m1_379200_470400 n1_m1_384000_470400 5.356235
R11656 n1_m1_384000_470400 n1_m1_388800_470400 5.356235
R11657 n1_m1_388800_470400 n1_m1_393600_470400 5.356235
R11658 n1_m1_393600_470400 n1_m1_396000_470400 2.678118
R11659 n1_m1_398400_470400 n1_m1_396000_470400 2.678118
R11660 n1_m1_398400_470400 n1_m1_403200_470400 5.356235
R11661 n1_m1_403200_470400 n1_m1_408000_470400 5.356235
R11662 n1_m1_408000_470400 n1_m1_412800_470400 5.356235
R11663 n1_m1_412800_470400 n1_m1_417600_470400 5.356235
R11664 n1_m1_417600_470400 n1_m1_422400_470400 5.356235
R11665 n1_m1_422400_470400 n1_m1_424000_470400 1.785412
R11666 n1_m1_427200_470400 n1_m1_424000_470400 3.570824
R11667 n1_m1_427200_470400 n1_m1_432000_470400 5.356235
R11668 n1_m1_432000_470400 n1_m1_436800_470400 5.356235
R11669 n1_m1_436800_470400 n1_m1_441600_470400 5.356235
R11670 n1_m1_441600_470400 n1_m1_446400_470400 5.356235
R11671 n1_m1_446400_470400 n1_m1_451200_470400 5.356235
R11672 n1_m1_451200_470400 n1_m1_452000_470400 0.892706
R11673 n1_m1_456000_470400 n1_m1_452000_470400 4.463529
R11674 n1_m1_456000_470400 n1_m1_460800_470400 5.356235
R11675 n1_m1_460800_470400 n1_m1_465600_470400 5.356235
R11676 n1_m1_465600_470400 n1_m1_470400_470400 5.356235
R11677 n1_m1_470400_470400 n1_m1_475200_470400 5.356235
R11678 n1_m1_475200_470400 n1_m1_480000_470400 5.356235
R11679 n1_m1_480000_470400 n1_m1_484800_470400 5.356235
R11680 n1_m1_484800_470400 n1_m1_489600_470400 5.356235
R11681 n1_m1_489600_470400 n1_m1_494400_470400 5.356235
R11682 n1_m1_0_475200 n1_m1_4000_475200 4.463529
R11683 n1_m1_4800_475200 n1_m1_4000_475200 0.892706
R11684 n1_m1_4800_475200 n1_m1_9600_475200 5.356235
R11685 n1_m1_9600_475200 n1_m1_14400_475200 5.356235
R11686 n1_m1_14400_475200 n1_m1_19200_475200 5.356235
R11687 n1_m1_19200_475200 n1_m1_24000_475200 5.356235
R11688 n1_m1_24000_475200 n1_m1_28800_475200 5.356235
R11689 n1_m1_28800_475200 n1_m1_32000_475200 3.570824
R11690 n1_m1_33600_475200 n1_m1_32000_475200 1.785412
R11691 n1_m1_33600_475200 n1_m1_38400_475200 5.356235
R11692 n1_m1_38400_475200 n1_m1_43200_475200 5.356235
R11693 n1_m1_43200_475200 n1_m1_48000_475200 5.356235
R11694 n1_m1_48000_475200 n1_m1_52800_475200 5.356235
R11695 n1_m1_52800_475200 n1_m1_57600_475200 5.356235
R11696 n1_m1_57600_475200 n1_m1_60000_475200 2.678118
R11697 n1_m1_62400_475200 n1_m1_60000_475200 2.678118
R11698 n1_m1_62400_475200 n1_m1_67200_475200 5.356235
R11699 n1_m1_67200_475200 n1_m1_72000_475200 5.356235
R11700 n1_m1_72000_475200 n1_m1_76800_475200 5.356235
R11701 n1_m1_76800_475200 n1_m1_81600_475200 5.356235
R11702 n1_m1_81600_475200 n1_m1_86400_475200 5.356235
R11703 n1_m1_86400_475200 n1_m1_88000_475200 1.785412
R11704 n1_m1_91200_475200 n1_m1_88000_475200 3.570824
R11705 n1_m1_91200_475200 n1_m1_96000_475200 5.356235
R11706 n1_m1_96000_475200 n1_m1_100800_475200 5.356235
R11707 n1_m1_100800_475200 n1_m1_105600_475200 5.356235
R11708 n1_m1_105600_475200 n1_m1_110400_475200 5.356235
R11709 n1_m1_110400_475200 n1_m1_115200_475200 5.356235
R11710 n1_m1_115200_475200 n1_m1_116000_475200 0.892706
R11711 n1_m1_120000_475200 n1_m1_116000_475200 4.463529
R11712 n1_m1_120000_475200 n1_m1_124800_475200 5.356235
R11713 n1_m1_124800_475200 n1_m1_129600_475200 5.356235
R11714 n1_m1_129600_475200 n1_m1_134400_475200 5.356235
R11715 n1_m1_134400_475200 n1_m1_139200_475200 5.356235
R11716 n1_m1_139200_475200 n1_m1_144000_475200 5.356235
R11717 n1_m1_144000_475200 n1_m1_148800_475200 5.356235
R11718 n1_m1_148800_475200 n1_m1_153600_475200 5.356235
R11719 n1_m1_153600_475200 n1_m1_158400_475200 5.356235
R11720 n1_m1_158400_475200 n1_m1_163200_475200 5.356235
R11721 n1_m1_163200_475200 n1_m1_168000_475200 5.356235
R11722 n1_m1_168000_475200 n1_m1_172000_475200 4.463529
R11723 n1_m1_172800_475200 n1_m1_172000_475200 0.892706
R11724 n1_m1_172800_475200 n1_m1_177600_475200 5.356235
R11725 n1_m1_177600_475200 n1_m1_182400_475200 5.356235
R11726 n1_m1_182400_475200 n1_m1_187200_475200 5.356235
R11727 n1_m1_187200_475200 n1_m1_192000_475200 5.356235
R11728 n1_m1_192000_475200 n1_m1_196800_475200 5.356235
R11729 n1_m1_196800_475200 n1_m1_200000_475200 3.570824
R11730 n1_m1_201600_475200 n1_m1_200000_475200 1.785412
R11731 n1_m1_201600_475200 n1_m1_206400_475200 5.356235
R11732 n1_m1_206400_475200 n1_m1_211200_475200 5.356235
R11733 n1_m1_211200_475200 n1_m1_216000_475200 5.356235
R11734 n1_m1_216000_475200 n1_m1_220800_475200 5.356235
R11735 n1_m1_220800_475200 n1_m1_225600_475200 5.356235
R11736 n1_m1_225600_475200 n1_m1_228000_475200 2.678118
R11737 n1_m1_230400_475200 n1_m1_228000_475200 2.678118
R11738 n1_m1_230400_475200 n1_m1_235200_475200 5.356235
R11739 n1_m1_235200_475200 n1_m1_240000_475200 5.356235
R11740 n1_m1_240000_475200 n1_m1_244800_475200 5.356235
R11741 n1_m1_244800_475200 n1_m1_249600_475200 5.356235
R11742 n1_m1_249600_475200 n1_m1_254400_475200 5.356235
R11743 n1_m1_254400_475200 n1_m1_256000_475200 1.785412
R11744 n1_m1_259200_475200 n1_m1_256000_475200 3.570824
R11745 n1_m1_259200_475200 n1_m1_264000_475200 5.356235
R11746 n1_m1_264000_475200 n1_m1_268800_475200 5.356235
R11747 n1_m1_268800_475200 n1_m1_273600_475200 5.356235
R11748 n1_m1_273600_475200 n1_m1_278400_475200 5.356235
R11749 n1_m1_278400_475200 n1_m1_283200_475200 5.356235
R11750 n1_m1_283200_475200 n1_m1_284000_475200 0.892706
R11751 n1_m1_288000_475200 n1_m1_284000_475200 4.463529
R11752 n1_m1_288000_475200 n1_m1_292800_475200 5.356235
R11753 n1_m1_292800_475200 n1_m1_297600_475200 5.356235
R11754 n1_m1_297600_475200 n1_m1_302400_475200 5.356235
R11755 n1_m1_302400_475200 n1_m1_307200_475200 5.356235
R11756 n1_m1_307200_475200 n1_m1_312000_475200 5.356235
R11757 n1_m1_312000_475200 n1_m1_316800_475200 5.356235
R11758 n1_m1_316800_475200 n1_m1_321600_475200 5.356235
R11759 n1_m1_321600_475200 n1_m1_326400_475200 5.356235
R11760 n1_m1_326400_475200 n1_m1_331200_475200 5.356235
R11761 n1_m1_331200_475200 n1_m1_336000_475200 5.356235
R11762 n1_m1_336000_475200 n1_m1_340000_475200 4.463529
R11763 n1_m1_340800_475200 n1_m1_340000_475200 0.892706
R11764 n1_m1_340800_475200 n1_m1_345600_475200 5.356235
R11765 n1_m1_345600_475200 n1_m1_350400_475200 5.356235
R11766 n1_m1_350400_475200 n1_m1_355200_475200 5.356235
R11767 n1_m1_355200_475200 n1_m1_360000_475200 5.356235
R11768 n1_m1_360000_475200 n1_m1_364800_475200 5.356235
R11769 n1_m1_364800_475200 n1_m1_368000_475200 3.570824
R11770 n1_m1_369600_475200 n1_m1_368000_475200 1.785412
R11771 n1_m1_369600_475200 n1_m1_374400_475200 5.356235
R11772 n1_m1_374400_475200 n1_m1_379200_475200 5.356235
R11773 n1_m1_379200_475200 n1_m1_384000_475200 5.356235
R11774 n1_m1_384000_475200 n1_m1_388800_475200 5.356235
R11775 n1_m1_388800_475200 n1_m1_393600_475200 5.356235
R11776 n1_m1_393600_475200 n1_m1_396000_475200 2.678118
R11777 n1_m1_398400_475200 n1_m1_396000_475200 2.678118
R11778 n1_m1_398400_475200 n1_m1_403200_475200 5.356235
R11779 n1_m1_403200_475200 n1_m1_408000_475200 5.356235
R11780 n1_m1_408000_475200 n1_m1_412800_475200 5.356235
R11781 n1_m1_412800_475200 n1_m1_417600_475200 5.356235
R11782 n1_m1_417600_475200 n1_m1_422400_475200 5.356235
R11783 n1_m1_422400_475200 n1_m1_424000_475200 1.785412
R11784 n1_m1_427200_475200 n1_m1_424000_475200 3.570824
R11785 n1_m1_427200_475200 n1_m1_432000_475200 5.356235
R11786 n1_m1_432000_475200 n1_m1_436800_475200 5.356235
R11787 n1_m1_436800_475200 n1_m1_441600_475200 5.356235
R11788 n1_m1_441600_475200 n1_m1_446400_475200 5.356235
R11789 n1_m1_446400_475200 n1_m1_451200_475200 5.356235
R11790 n1_m1_451200_475200 n1_m1_452000_475200 0.892706
R11791 n1_m1_456000_475200 n1_m1_452000_475200 4.463529
R11792 n1_m1_456000_475200 n1_m1_460800_475200 5.356235
R11793 n1_m1_460800_475200 n1_m1_465600_475200 5.356235
R11794 n1_m1_465600_475200 n1_m1_470400_475200 5.356235
R11795 n1_m1_470400_475200 n1_m1_475200_475200 5.356235
R11796 n1_m1_475200_475200 n1_m1_480000_475200 5.356235
R11797 n1_m1_480000_475200 n1_m1_484800_475200 5.356235
R11798 n1_m1_484800_475200 n1_m1_489600_475200 5.356235
R11799 n1_m1_489600_475200 n1_m1_494400_475200 5.356235
R11800 n1_m1_0_480000 n1_m1_4000_480000 4.463529
R11801 n1_m1_4800_480000 n1_m1_4000_480000 0.892706
R11802 n1_m1_4800_480000 n1_m1_9600_480000 5.356235
R11803 n1_m1_9600_480000 n1_m1_14400_480000 5.356235
R11804 n1_m1_14400_480000 n1_m1_19200_480000 5.356235
R11805 n1_m1_19200_480000 n1_m1_24000_480000 5.356235
R11806 n1_m1_24000_480000 n1_m1_28800_480000 5.356235
R11807 n1_m1_28800_480000 n1_m1_32000_480000 3.570824
R11808 n1_m1_33600_480000 n1_m1_32000_480000 1.785412
R11809 n1_m1_33600_480000 n1_m1_38400_480000 5.356235
R11810 n1_m1_38400_480000 n1_m1_43200_480000 5.356235
R11811 n1_m1_43200_480000 n1_m1_48000_480000 5.356235
R11812 n1_m1_48000_480000 n1_m1_52800_480000 5.356235
R11813 n1_m1_52800_480000 n1_m1_57600_480000 5.356235
R11814 n1_m1_57600_480000 n1_m1_60000_480000 2.678118
R11815 n1_m1_62400_480000 n1_m1_60000_480000 2.678118
R11816 n1_m1_62400_480000 n1_m1_67200_480000 5.356235
R11817 n1_m1_67200_480000 n1_m1_72000_480000 5.356235
R11818 n1_m1_72000_480000 n1_m1_76800_480000 5.356235
R11819 n1_m1_76800_480000 n1_m1_81600_480000 5.356235
R11820 n1_m1_81600_480000 n1_m1_86400_480000 5.356235
R11821 n1_m1_86400_480000 n1_m1_88000_480000 1.785412
R11822 n1_m1_91200_480000 n1_m1_88000_480000 3.570824
R11823 n1_m1_91200_480000 n1_m1_96000_480000 5.356235
R11824 n1_m1_96000_480000 n1_m1_100800_480000 5.356235
R11825 n1_m1_100800_480000 n1_m1_105600_480000 5.356235
R11826 n1_m1_105600_480000 n1_m1_110400_480000 5.356235
R11827 n1_m1_110400_480000 n1_m1_115200_480000 5.356235
R11828 n1_m1_115200_480000 n1_m1_116000_480000 0.892706
R11829 n1_m1_120000_480000 n1_m1_116000_480000 4.463529
R11830 n1_m1_120000_480000 n1_m1_124800_480000 5.356235
R11831 n1_m1_124800_480000 n1_m1_129600_480000 5.356235
R11832 n1_m1_129600_480000 n1_m1_134400_480000 5.356235
R11833 n1_m1_134400_480000 n1_m1_139200_480000 5.356235
R11834 n1_m1_139200_480000 n1_m1_144000_480000 5.356235
R11835 n1_m1_144000_480000 n1_m1_148800_480000 5.356235
R11836 n1_m1_148800_480000 n1_m1_153600_480000 5.356235
R11837 n1_m1_153600_480000 n1_m1_158400_480000 5.356235
R11838 n1_m1_158400_480000 n1_m1_163200_480000 5.356235
R11839 n1_m1_163200_480000 n1_m1_168000_480000 5.356235
R11840 n1_m1_168000_480000 n1_m1_172000_480000 4.463529
R11841 n1_m1_172800_480000 n1_m1_172000_480000 0.892706
R11842 n1_m1_172800_480000 n1_m1_177600_480000 5.356235
R11843 n1_m1_177600_480000 n1_m1_182400_480000 5.356235
R11844 n1_m1_182400_480000 n1_m1_187200_480000 5.356235
R11845 n1_m1_187200_480000 n1_m1_192000_480000 5.356235
R11846 n1_m1_192000_480000 n1_m1_196800_480000 5.356235
R11847 n1_m1_196800_480000 n1_m1_200000_480000 3.570824
R11848 n1_m1_201600_480000 n1_m1_200000_480000 1.785412
R11849 n1_m1_201600_480000 n1_m1_206400_480000 5.356235
R11850 n1_m1_206400_480000 n1_m1_211200_480000 5.356235
R11851 n1_m1_211200_480000 n1_m1_216000_480000 5.356235
R11852 n1_m1_216000_480000 n1_m1_220800_480000 5.356235
R11853 n1_m1_220800_480000 n1_m1_225600_480000 5.356235
R11854 n1_m1_225600_480000 n1_m1_228000_480000 2.678118
R11855 n1_m1_230400_480000 n1_m1_228000_480000 2.678118
R11856 n1_m1_230400_480000 n1_m1_235200_480000 5.356235
R11857 n1_m1_235200_480000 n1_m1_240000_480000 5.356235
R11858 n1_m1_240000_480000 n1_m1_244800_480000 5.356235
R11859 n1_m1_244800_480000 n1_m1_249600_480000 5.356235
R11860 n1_m1_249600_480000 n1_m1_254400_480000 5.356235
R11861 n1_m1_254400_480000 n1_m1_256000_480000 1.785412
R11862 n1_m1_259200_480000 n1_m1_256000_480000 3.570824
R11863 n1_m1_259200_480000 n1_m1_264000_480000 5.356235
R11864 n1_m1_264000_480000 n1_m1_268800_480000 5.356235
R11865 n1_m1_268800_480000 n1_m1_273600_480000 5.356235
R11866 n1_m1_273600_480000 n1_m1_278400_480000 5.356235
R11867 n1_m1_278400_480000 n1_m1_283200_480000 5.356235
R11868 n1_m1_283200_480000 n1_m1_284000_480000 0.892706
R11869 n1_m1_288000_480000 n1_m1_284000_480000 4.463529
R11870 n1_m1_288000_480000 n1_m1_292800_480000 5.356235
R11871 n1_m1_292800_480000 n1_m1_297600_480000 5.356235
R11872 n1_m1_297600_480000 n1_m1_302400_480000 5.356235
R11873 n1_m1_302400_480000 n1_m1_307200_480000 5.356235
R11874 n1_m1_307200_480000 n1_m1_312000_480000 5.356235
R11875 n1_m1_312000_480000 n1_m1_316800_480000 5.356235
R11876 n1_m1_316800_480000 n1_m1_321600_480000 5.356235
R11877 n1_m1_321600_480000 n1_m1_326400_480000 5.356235
R11878 n1_m1_326400_480000 n1_m1_331200_480000 5.356235
R11879 n1_m1_331200_480000 n1_m1_336000_480000 5.356235
R11880 n1_m1_336000_480000 n1_m1_340000_480000 4.463529
R11881 n1_m1_340800_480000 n1_m1_340000_480000 0.892706
R11882 n1_m1_340800_480000 n1_m1_345600_480000 5.356235
R11883 n1_m1_345600_480000 n1_m1_350400_480000 5.356235
R11884 n1_m1_350400_480000 n1_m1_355200_480000 5.356235
R11885 n1_m1_355200_480000 n1_m1_360000_480000 5.356235
R11886 n1_m1_360000_480000 n1_m1_364800_480000 5.356235
R11887 n1_m1_364800_480000 n1_m1_368000_480000 3.570824
R11888 n1_m1_369600_480000 n1_m1_368000_480000 1.785412
R11889 n1_m1_369600_480000 n1_m1_374400_480000 5.356235
R11890 n1_m1_374400_480000 n1_m1_379200_480000 5.356235
R11891 n1_m1_379200_480000 n1_m1_384000_480000 5.356235
R11892 n1_m1_384000_480000 n1_m1_388800_480000 5.356235
R11893 n1_m1_388800_480000 n1_m1_393600_480000 5.356235
R11894 n1_m1_393600_480000 n1_m1_396000_480000 2.678118
R11895 n1_m1_398400_480000 n1_m1_396000_480000 2.678118
R11896 n1_m1_398400_480000 n1_m1_403200_480000 5.356235
R11897 n1_m1_403200_480000 n1_m1_408000_480000 5.356235
R11898 n1_m1_408000_480000 n1_m1_412800_480000 5.356235
R11899 n1_m1_412800_480000 n1_m1_417600_480000 5.356235
R11900 n1_m1_417600_480000 n1_m1_422400_480000 5.356235
R11901 n1_m1_422400_480000 n1_m1_424000_480000 1.785412
R11902 n1_m1_427200_480000 n1_m1_424000_480000 3.570824
R11903 n1_m1_427200_480000 n1_m1_432000_480000 5.356235
R11904 n1_m1_432000_480000 n1_m1_436800_480000 5.356235
R11905 n1_m1_436800_480000 n1_m1_441600_480000 5.356235
R11906 n1_m1_441600_480000 n1_m1_446400_480000 5.356235
R11907 n1_m1_446400_480000 n1_m1_451200_480000 5.356235
R11908 n1_m1_451200_480000 n1_m1_452000_480000 0.892706
R11909 n1_m1_456000_480000 n1_m1_452000_480000 4.463529
R11910 n1_m1_456000_480000 n1_m1_460800_480000 5.356235
R11911 n1_m1_460800_480000 n1_m1_465600_480000 5.356235
R11912 n1_m1_465600_480000 n1_m1_470400_480000 5.356235
R11913 n1_m1_470400_480000 n1_m1_475200_480000 5.356235
R11914 n1_m1_475200_480000 n1_m1_480000_480000 5.356235
R11915 n1_m1_480000_480000 n1_m1_484800_480000 5.356235
R11916 n1_m1_484800_480000 n1_m1_489600_480000 5.356235
R11917 n1_m1_489600_480000 n1_m1_494400_480000 5.356235
R11918 n1_m1_0_484800 n1_m1_4000_484800 4.463529
R11919 n1_m1_4800_484800 n1_m1_4000_484800 0.892706
R11920 n1_m1_4800_484800 n1_m1_9600_484800 5.356235
R11921 n1_m1_9600_484800 n1_m1_14400_484800 5.356235
R11922 n1_m1_14400_484800 n1_m1_19200_484800 5.356235
R11923 n1_m1_19200_484800 n1_m1_24000_484800 5.356235
R11924 n1_m1_24000_484800 n1_m1_28800_484800 5.356235
R11925 n1_m1_28800_484800 n1_m1_32000_484800 3.570824
R11926 n1_m1_33600_484800 n1_m1_32000_484800 1.785412
R11927 n1_m1_33600_484800 n1_m1_38400_484800 5.356235
R11928 n1_m1_38400_484800 n1_m1_43200_484800 5.356235
R11929 n1_m1_43200_484800 n1_m1_48000_484800 5.356235
R11930 n1_m1_48000_484800 n1_m1_52800_484800 5.356235
R11931 n1_m1_52800_484800 n1_m1_57600_484800 5.356235
R11932 n1_m1_57600_484800 n1_m1_60000_484800 2.678118
R11933 n1_m1_62400_484800 n1_m1_60000_484800 2.678118
R11934 n1_m1_62400_484800 n1_m1_67200_484800 5.356235
R11935 n1_m1_67200_484800 n1_m1_72000_484800 5.356235
R11936 n1_m1_72000_484800 n1_m1_76800_484800 5.356235
R11937 n1_m1_76800_484800 n1_m1_81600_484800 5.356235
R11938 n1_m1_81600_484800 n1_m1_86400_484800 5.356235
R11939 n1_m1_86400_484800 n1_m1_88000_484800 1.785412
R11940 n1_m1_91200_484800 n1_m1_88000_484800 3.570824
R11941 n1_m1_91200_484800 n1_m1_96000_484800 5.356235
R11942 n1_m1_96000_484800 n1_m1_100800_484800 5.356235
R11943 n1_m1_100800_484800 n1_m1_105600_484800 5.356235
R11944 n1_m1_105600_484800 n1_m1_110400_484800 5.356235
R11945 n1_m1_110400_484800 n1_m1_115200_484800 5.356235
R11946 n1_m1_115200_484800 n1_m1_116000_484800 0.892706
R11947 n1_m1_120000_484800 n1_m1_116000_484800 4.463529
R11948 n1_m1_120000_484800 n1_m1_124800_484800 5.356235
R11949 n1_m1_124800_484800 n1_m1_129600_484800 5.356235
R11950 n1_m1_129600_484800 n1_m1_134400_484800 5.356235
R11951 n1_m1_134400_484800 n1_m1_139200_484800 5.356235
R11952 n1_m1_139200_484800 n1_m1_144000_484800 5.356235
R11953 n1_m1_144000_484800 n1_m1_148800_484800 5.356235
R11954 n1_m1_148800_484800 n1_m1_153600_484800 5.356235
R11955 n1_m1_153600_484800 n1_m1_158400_484800 5.356235
R11956 n1_m1_158400_484800 n1_m1_163200_484800 5.356235
R11957 n1_m1_163200_484800 n1_m1_168000_484800 5.356235
R11958 n1_m1_168000_484800 n1_m1_172000_484800 4.463529
R11959 n1_m1_172800_484800 n1_m1_172000_484800 0.892706
R11960 n1_m1_172800_484800 n1_m1_177600_484800 5.356235
R11961 n1_m1_177600_484800 n1_m1_182400_484800 5.356235
R11962 n1_m1_182400_484800 n1_m1_187200_484800 5.356235
R11963 n1_m1_187200_484800 n1_m1_192000_484800 5.356235
R11964 n1_m1_192000_484800 n1_m1_196800_484800 5.356235
R11965 n1_m1_196800_484800 n1_m1_200000_484800 3.570824
R11966 n1_m1_201600_484800 n1_m1_200000_484800 1.785412
R11967 n1_m1_201600_484800 n1_m1_206400_484800 5.356235
R11968 n1_m1_206400_484800 n1_m1_211200_484800 5.356235
R11969 n1_m1_211200_484800 n1_m1_216000_484800 5.356235
R11970 n1_m1_216000_484800 n1_m1_220800_484800 5.356235
R11971 n1_m1_220800_484800 n1_m1_225600_484800 5.356235
R11972 n1_m1_225600_484800 n1_m1_228000_484800 2.678118
R11973 n1_m1_230400_484800 n1_m1_228000_484800 2.678118
R11974 n1_m1_230400_484800 n1_m1_235200_484800 5.356235
R11975 n1_m1_235200_484800 n1_m1_240000_484800 5.356235
R11976 n1_m1_240000_484800 n1_m1_244800_484800 5.356235
R11977 n1_m1_244800_484800 n1_m1_249600_484800 5.356235
R11978 n1_m1_249600_484800 n1_m1_254400_484800 5.356235
R11979 n1_m1_254400_484800 n1_m1_256000_484800 1.785412
R11980 n1_m1_259200_484800 n1_m1_256000_484800 3.570824
R11981 n1_m1_259200_484800 n1_m1_264000_484800 5.356235
R11982 n1_m1_264000_484800 n1_m1_268800_484800 5.356235
R11983 n1_m1_268800_484800 n1_m1_273600_484800 5.356235
R11984 n1_m1_273600_484800 n1_m1_278400_484800 5.356235
R11985 n1_m1_278400_484800 n1_m1_283200_484800 5.356235
R11986 n1_m1_283200_484800 n1_m1_284000_484800 0.892706
R11987 n1_m1_288000_484800 n1_m1_284000_484800 4.463529
R11988 n1_m1_288000_484800 n1_m1_292800_484800 5.356235
R11989 n1_m1_292800_484800 n1_m1_297600_484800 5.356235
R11990 n1_m1_297600_484800 n1_m1_302400_484800 5.356235
R11991 n1_m1_302400_484800 n1_m1_307200_484800 5.356235
R11992 n1_m1_307200_484800 n1_m1_312000_484800 5.356235
R11993 n1_m1_312000_484800 n1_m1_316800_484800 5.356235
R11994 n1_m1_316800_484800 n1_m1_321600_484800 5.356235
R11995 n1_m1_321600_484800 n1_m1_326400_484800 5.356235
R11996 n1_m1_326400_484800 n1_m1_331200_484800 5.356235
R11997 n1_m1_331200_484800 n1_m1_336000_484800 5.356235
R11998 n1_m1_336000_484800 n1_m1_340000_484800 4.463529
R11999 n1_m1_340800_484800 n1_m1_340000_484800 0.892706
R12000 n1_m1_340800_484800 n1_m1_345600_484800 5.356235
R12001 n1_m1_345600_484800 n1_m1_350400_484800 5.356235
R12002 n1_m1_350400_484800 n1_m1_355200_484800 5.356235
R12003 n1_m1_355200_484800 n1_m1_360000_484800 5.356235
R12004 n1_m1_360000_484800 n1_m1_364800_484800 5.356235
R12005 n1_m1_364800_484800 n1_m1_368000_484800 3.570824
R12006 n1_m1_369600_484800 n1_m1_368000_484800 1.785412
R12007 n1_m1_369600_484800 n1_m1_374400_484800 5.356235
R12008 n1_m1_374400_484800 n1_m1_379200_484800 5.356235
R12009 n1_m1_379200_484800 n1_m1_384000_484800 5.356235
R12010 n1_m1_384000_484800 n1_m1_388800_484800 5.356235
R12011 n1_m1_388800_484800 n1_m1_393600_484800 5.356235
R12012 n1_m1_393600_484800 n1_m1_396000_484800 2.678118
R12013 n1_m1_398400_484800 n1_m1_396000_484800 2.678118
R12014 n1_m1_398400_484800 n1_m1_403200_484800 5.356235
R12015 n1_m1_403200_484800 n1_m1_408000_484800 5.356235
R12016 n1_m1_408000_484800 n1_m1_412800_484800 5.356235
R12017 n1_m1_412800_484800 n1_m1_417600_484800 5.356235
R12018 n1_m1_417600_484800 n1_m1_422400_484800 5.356235
R12019 n1_m1_422400_484800 n1_m1_424000_484800 1.785412
R12020 n1_m1_427200_484800 n1_m1_424000_484800 3.570824
R12021 n1_m1_427200_484800 n1_m1_432000_484800 5.356235
R12022 n1_m1_432000_484800 n1_m1_436800_484800 5.356235
R12023 n1_m1_436800_484800 n1_m1_441600_484800 5.356235
R12024 n1_m1_441600_484800 n1_m1_446400_484800 5.356235
R12025 n1_m1_446400_484800 n1_m1_451200_484800 5.356235
R12026 n1_m1_451200_484800 n1_m1_452000_484800 0.892706
R12027 n1_m1_456000_484800 n1_m1_452000_484800 4.463529
R12028 n1_m1_456000_484800 n1_m1_460800_484800 5.356235
R12029 n1_m1_460800_484800 n1_m1_465600_484800 5.356235
R12030 n1_m1_465600_484800 n1_m1_470400_484800 5.356235
R12031 n1_m1_470400_484800 n1_m1_475200_484800 5.356235
R12032 n1_m1_475200_484800 n1_m1_480000_484800 5.356235
R12033 n1_m1_480000_484800 n1_m1_484800_484800 5.356235
R12034 n1_m1_484800_484800 n1_m1_489600_484800 5.356235
R12035 n1_m1_489600_484800 n1_m1_494400_484800 5.356235
R12036 n1_m1_0_489600 n1_m1_4000_489600 4.463529
R12037 n1_m1_4800_489600 n1_m1_4000_489600 0.892706
R12038 n1_m1_4800_489600 n1_m1_9600_489600 5.356235
R12039 n1_m1_9600_489600 n1_m1_14400_489600 5.356235
R12040 n1_m1_14400_489600 n1_m1_19200_489600 5.356235
R12041 n1_m1_19200_489600 n1_m1_24000_489600 5.356235
R12042 n1_m1_24000_489600 n1_m1_28800_489600 5.356235
R12043 n1_m1_28800_489600 n1_m1_32000_489600 3.570824
R12044 n1_m1_33600_489600 n1_m1_32000_489600 1.785412
R12045 n1_m1_33600_489600 n1_m1_38400_489600 5.356235
R12046 n1_m1_38400_489600 n1_m1_43200_489600 5.356235
R12047 n1_m1_43200_489600 n1_m1_48000_489600 5.356235
R12048 n1_m1_48000_489600 n1_m1_52800_489600 5.356235
R12049 n1_m1_52800_489600 n1_m1_57600_489600 5.356235
R12050 n1_m1_57600_489600 n1_m1_60000_489600 2.678118
R12051 n1_m1_62400_489600 n1_m1_60000_489600 2.678118
R12052 n1_m1_62400_489600 n1_m1_67200_489600 5.356235
R12053 n1_m1_67200_489600 n1_m1_72000_489600 5.356235
R12054 n1_m1_72000_489600 n1_m1_76800_489600 5.356235
R12055 n1_m1_76800_489600 n1_m1_81600_489600 5.356235
R12056 n1_m1_81600_489600 n1_m1_86400_489600 5.356235
R12057 n1_m1_86400_489600 n1_m1_88000_489600 1.785412
R12058 n1_m1_91200_489600 n1_m1_88000_489600 3.570824
R12059 n1_m1_91200_489600 n1_m1_96000_489600 5.356235
R12060 n1_m1_96000_489600 n1_m1_100800_489600 5.356235
R12061 n1_m1_100800_489600 n1_m1_105600_489600 5.356235
R12062 n1_m1_105600_489600 n1_m1_110400_489600 5.356235
R12063 n1_m1_110400_489600 n1_m1_115200_489600 5.356235
R12064 n1_m1_115200_489600 n1_m1_116000_489600 0.892706
R12065 n1_m1_120000_489600 n1_m1_116000_489600 4.463529
R12066 n1_m1_120000_489600 n1_m1_124800_489600 5.356235
R12067 n1_m1_124800_489600 n1_m1_129600_489600 5.356235
R12068 n1_m1_129600_489600 n1_m1_134400_489600 5.356235
R12069 n1_m1_134400_489600 n1_m1_139200_489600 5.356235
R12070 n1_m1_139200_489600 n1_m1_144000_489600 5.356235
R12071 n1_m1_144000_489600 n1_m1_148800_489600 5.356235
R12072 n1_m1_148800_489600 n1_m1_153600_489600 5.356235
R12073 n1_m1_153600_489600 n1_m1_158400_489600 5.356235
R12074 n1_m1_158400_489600 n1_m1_163200_489600 5.356235
R12075 n1_m1_163200_489600 n1_m1_168000_489600 5.356235
R12076 n1_m1_168000_489600 n1_m1_172000_489600 4.463529
R12077 n1_m1_172800_489600 n1_m1_172000_489600 0.892706
R12078 n1_m1_172800_489600 n1_m1_177600_489600 5.356235
R12079 n1_m1_177600_489600 n1_m1_182400_489600 5.356235
R12080 n1_m1_182400_489600 n1_m1_187200_489600 5.356235
R12081 n1_m1_187200_489600 n1_m1_192000_489600 5.356235
R12082 n1_m1_192000_489600 n1_m1_196800_489600 5.356235
R12083 n1_m1_196800_489600 n1_m1_200000_489600 3.570824
R12084 n1_m1_201600_489600 n1_m1_200000_489600 1.785412
R12085 n1_m1_201600_489600 n1_m1_206400_489600 5.356235
R12086 n1_m1_206400_489600 n1_m1_211200_489600 5.356235
R12087 n1_m1_211200_489600 n1_m1_216000_489600 5.356235
R12088 n1_m1_216000_489600 n1_m1_220800_489600 5.356235
R12089 n1_m1_220800_489600 n1_m1_225600_489600 5.356235
R12090 n1_m1_225600_489600 n1_m1_228000_489600 2.678118
R12091 n1_m1_230400_489600 n1_m1_228000_489600 2.678118
R12092 n1_m1_230400_489600 n1_m1_235200_489600 5.356235
R12093 n1_m1_235200_489600 n1_m1_240000_489600 5.356235
R12094 n1_m1_240000_489600 n1_m1_244800_489600 5.356235
R12095 n1_m1_244800_489600 n1_m1_249600_489600 5.356235
R12096 n1_m1_249600_489600 n1_m1_254400_489600 5.356235
R12097 n1_m1_254400_489600 n1_m1_256000_489600 1.785412
R12098 n1_m1_259200_489600 n1_m1_256000_489600 3.570824
R12099 n1_m1_259200_489600 n1_m1_264000_489600 5.356235
R12100 n1_m1_264000_489600 n1_m1_268800_489600 5.356235
R12101 n1_m1_268800_489600 n1_m1_273600_489600 5.356235
R12102 n1_m1_273600_489600 n1_m1_278400_489600 5.356235
R12103 n1_m1_278400_489600 n1_m1_283200_489600 5.356235
R12104 n1_m1_283200_489600 n1_m1_284000_489600 0.892706
R12105 n1_m1_288000_489600 n1_m1_284000_489600 4.463529
R12106 n1_m1_288000_489600 n1_m1_292800_489600 5.356235
R12107 n1_m1_292800_489600 n1_m1_297600_489600 5.356235
R12108 n1_m1_297600_489600 n1_m1_302400_489600 5.356235
R12109 n1_m1_302400_489600 n1_m1_307200_489600 5.356235
R12110 n1_m1_307200_489600 n1_m1_312000_489600 5.356235
R12111 n1_m1_312000_489600 n1_m1_316800_489600 5.356235
R12112 n1_m1_316800_489600 n1_m1_321600_489600 5.356235
R12113 n1_m1_321600_489600 n1_m1_326400_489600 5.356235
R12114 n1_m1_326400_489600 n1_m1_331200_489600 5.356235
R12115 n1_m1_331200_489600 n1_m1_336000_489600 5.356235
R12116 n1_m1_336000_489600 n1_m1_340000_489600 4.463529
R12117 n1_m1_340800_489600 n1_m1_340000_489600 0.892706
R12118 n1_m1_340800_489600 n1_m1_345600_489600 5.356235
R12119 n1_m1_345600_489600 n1_m1_350400_489600 5.356235
R12120 n1_m1_350400_489600 n1_m1_355200_489600 5.356235
R12121 n1_m1_355200_489600 n1_m1_360000_489600 5.356235
R12122 n1_m1_360000_489600 n1_m1_364800_489600 5.356235
R12123 n1_m1_364800_489600 n1_m1_368000_489600 3.570824
R12124 n1_m1_369600_489600 n1_m1_368000_489600 1.785412
R12125 n1_m1_369600_489600 n1_m1_374400_489600 5.356235
R12126 n1_m1_374400_489600 n1_m1_379200_489600 5.356235
R12127 n1_m1_379200_489600 n1_m1_384000_489600 5.356235
R12128 n1_m1_384000_489600 n1_m1_388800_489600 5.356235
R12129 n1_m1_388800_489600 n1_m1_393600_489600 5.356235
R12130 n1_m1_393600_489600 n1_m1_396000_489600 2.678118
R12131 n1_m1_398400_489600 n1_m1_396000_489600 2.678118
R12132 n1_m1_398400_489600 n1_m1_403200_489600 5.356235
R12133 n1_m1_403200_489600 n1_m1_408000_489600 5.356235
R12134 n1_m1_408000_489600 n1_m1_412800_489600 5.356235
R12135 n1_m1_412800_489600 n1_m1_417600_489600 5.356235
R12136 n1_m1_417600_489600 n1_m1_422400_489600 5.356235
R12137 n1_m1_422400_489600 n1_m1_424000_489600 1.785412
R12138 n1_m1_427200_489600 n1_m1_424000_489600 3.570824
R12139 n1_m1_427200_489600 n1_m1_432000_489600 5.356235
R12140 n1_m1_432000_489600 n1_m1_436800_489600 5.356235
R12141 n1_m1_436800_489600 n1_m1_441600_489600 5.356235
R12142 n1_m1_441600_489600 n1_m1_446400_489600 5.356235
R12143 n1_m1_446400_489600 n1_m1_451200_489600 5.356235
R12144 n1_m1_451200_489600 n1_m1_452000_489600 0.892706
R12145 n1_m1_456000_489600 n1_m1_452000_489600 4.463529
R12146 n1_m1_456000_489600 n1_m1_460800_489600 5.356235
R12147 n1_m1_460800_489600 n1_m1_465600_489600 5.356235
R12148 n1_m1_465600_489600 n1_m1_470400_489600 5.356235
R12149 n1_m1_470400_489600 n1_m1_475200_489600 5.356235
R12150 n1_m1_475200_489600 n1_m1_480000_489600 5.356235
R12151 n1_m1_480000_489600 n1_m1_484800_489600 5.356235
R12152 n1_m1_484800_489600 n1_m1_489600_489600 5.356235
R12153 n1_m1_489600_489600 n1_m1_494400_489600 5.356235
R12154 n1_m1_0_494400 n1_m1_4000_494400 4.463529
R12155 n1_m1_4800_494400 n1_m1_4000_494400 0.892706
R12156 n1_m1_4800_494400 n1_m1_9600_494400 5.356235
R12157 n1_m1_9600_494400 n1_m1_14400_494400 5.356235
R12158 n1_m1_14400_494400 n1_m1_19200_494400 5.356235
R12159 n1_m1_19200_494400 n1_m1_24000_494400 5.356235
R12160 n1_m1_24000_494400 n1_m1_28800_494400 5.356235
R12161 n1_m1_28800_494400 n1_m1_32000_494400 3.570824
R12162 n1_m1_33600_494400 n1_m1_32000_494400 1.785412
R12163 n1_m1_33600_494400 n1_m1_38400_494400 5.356235
R12164 n1_m1_38400_494400 n1_m1_43200_494400 5.356235
R12165 n1_m1_43200_494400 n1_m1_48000_494400 5.356235
R12166 n1_m1_48000_494400 n1_m1_52800_494400 5.356235
R12167 n1_m1_52800_494400 n1_m1_57600_494400 5.356235
R12168 n1_m1_57600_494400 n1_m1_60000_494400 2.678118
R12169 n1_m1_62400_494400 n1_m1_60000_494400 2.678118
R12170 n1_m1_62400_494400 n1_m1_67200_494400 5.356235
R12171 n1_m1_67200_494400 n1_m1_72000_494400 5.356235
R12172 n1_m1_72000_494400 n1_m1_76800_494400 5.356235
R12173 n1_m1_76800_494400 n1_m1_81600_494400 5.356235
R12174 n1_m1_81600_494400 n1_m1_86400_494400 5.356235
R12175 n1_m1_86400_494400 n1_m1_88000_494400 1.785412
R12176 n1_m1_91200_494400 n1_m1_88000_494400 3.570824
R12177 n1_m1_91200_494400 n1_m1_96000_494400 5.356235
R12178 n1_m1_96000_494400 n1_m1_100800_494400 5.356235
R12179 n1_m1_100800_494400 n1_m1_105600_494400 5.356235
R12180 n1_m1_105600_494400 n1_m1_110400_494400 5.356235
R12181 n1_m1_110400_494400 n1_m1_115200_494400 5.356235
R12182 n1_m1_115200_494400 n1_m1_116000_494400 0.892706
R12183 n1_m1_120000_494400 n1_m1_116000_494400 4.463529
R12184 n1_m1_120000_494400 n1_m1_124800_494400 5.356235
R12185 n1_m1_124800_494400 n1_m1_129600_494400 5.356235
R12186 n1_m1_129600_494400 n1_m1_134400_494400 5.356235
R12187 n1_m1_134400_494400 n1_m1_139200_494400 5.356235
R12188 n1_m1_139200_494400 n1_m1_144000_494400 5.356235
R12189 n1_m1_144000_494400 n1_m1_148800_494400 5.356235
R12190 n1_m1_148800_494400 n1_m1_153600_494400 5.356235
R12191 n1_m1_153600_494400 n1_m1_158400_494400 5.356235
R12192 n1_m1_158400_494400 n1_m1_163200_494400 5.356235
R12193 n1_m1_163200_494400 n1_m1_168000_494400 5.356235
R12194 n1_m1_168000_494400 n1_m1_172000_494400 4.463529
R12195 n1_m1_172800_494400 n1_m1_172000_494400 0.892706
R12196 n1_m1_172800_494400 n1_m1_177600_494400 5.356235
R12197 n1_m1_177600_494400 n1_m1_182400_494400 5.356235
R12198 n1_m1_182400_494400 n1_m1_187200_494400 5.356235
R12199 n1_m1_187200_494400 n1_m1_192000_494400 5.356235
R12200 n1_m1_192000_494400 n1_m1_196800_494400 5.356235
R12201 n1_m1_196800_494400 n1_m1_200000_494400 3.570824
R12202 n1_m1_201600_494400 n1_m1_200000_494400 1.785412
R12203 n1_m1_201600_494400 n1_m1_206400_494400 5.356235
R12204 n1_m1_206400_494400 n1_m1_211200_494400 5.356235
R12205 n1_m1_211200_494400 n1_m1_216000_494400 5.356235
R12206 n1_m1_216000_494400 n1_m1_220800_494400 5.356235
R12207 n1_m1_220800_494400 n1_m1_225600_494400 5.356235
R12208 n1_m1_225600_494400 n1_m1_228000_494400 2.678118
R12209 n1_m1_230400_494400 n1_m1_228000_494400 2.678118
R12210 n1_m1_230400_494400 n1_m1_235200_494400 5.356235
R12211 n1_m1_235200_494400 n1_m1_240000_494400 5.356235
R12212 n1_m1_240000_494400 n1_m1_244800_494400 5.356235
R12213 n1_m1_244800_494400 n1_m1_249600_494400 5.356235
R12214 n1_m1_249600_494400 n1_m1_254400_494400 5.356235
R12215 n1_m1_254400_494400 n1_m1_256000_494400 1.785412
R12216 n1_m1_259200_494400 n1_m1_256000_494400 3.570824
R12217 n1_m1_259200_494400 n1_m1_264000_494400 5.356235
R12218 n1_m1_264000_494400 n1_m1_268800_494400 5.356235
R12219 n1_m1_268800_494400 n1_m1_273600_494400 5.356235
R12220 n1_m1_273600_494400 n1_m1_278400_494400 5.356235
R12221 n1_m1_278400_494400 n1_m1_283200_494400 5.356235
R12222 n1_m1_283200_494400 n1_m1_284000_494400 0.892706
R12223 n1_m1_288000_494400 n1_m1_284000_494400 4.463529
R12224 n1_m1_288000_494400 n1_m1_292800_494400 5.356235
R12225 n1_m1_292800_494400 n1_m1_297600_494400 5.356235
R12226 n1_m1_297600_494400 n1_m1_302400_494400 5.356235
R12227 n1_m1_302400_494400 n1_m1_307200_494400 5.356235
R12228 n1_m1_307200_494400 n1_m1_312000_494400 5.356235
R12229 n1_m1_312000_494400 n1_m1_316800_494400 5.356235
R12230 n1_m1_316800_494400 n1_m1_321600_494400 5.356235
R12231 n1_m1_321600_494400 n1_m1_326400_494400 5.356235
R12232 n1_m1_326400_494400 n1_m1_331200_494400 5.356235
R12233 n1_m1_331200_494400 n1_m1_336000_494400 5.356235
R12234 n1_m1_336000_494400 n1_m1_340000_494400 4.463529
R12235 n1_m1_340800_494400 n1_m1_340000_494400 0.892706
R12236 n1_m1_340800_494400 n1_m1_345600_494400 5.356235
R12237 n1_m1_345600_494400 n1_m1_350400_494400 5.356235
R12238 n1_m1_350400_494400 n1_m1_355200_494400 5.356235
R12239 n1_m1_355200_494400 n1_m1_360000_494400 5.356235
R12240 n1_m1_360000_494400 n1_m1_364800_494400 5.356235
R12241 n1_m1_364800_494400 n1_m1_368000_494400 3.570824
R12242 n1_m1_369600_494400 n1_m1_368000_494400 1.785412
R12243 n1_m1_369600_494400 n1_m1_374400_494400 5.356235
R12244 n1_m1_374400_494400 n1_m1_379200_494400 5.356235
R12245 n1_m1_379200_494400 n1_m1_384000_494400 5.356235
R12246 n1_m1_384000_494400 n1_m1_388800_494400 5.356235
R12247 n1_m1_388800_494400 n1_m1_393600_494400 5.356235
R12248 n1_m1_393600_494400 n1_m1_396000_494400 2.678118
R12249 n1_m1_398400_494400 n1_m1_396000_494400 2.678118
R12250 n1_m1_398400_494400 n1_m1_403200_494400 5.356235
R12251 n1_m1_403200_494400 n1_m1_408000_494400 5.356235
R12252 n1_m1_408000_494400 n1_m1_412800_494400 5.356235
R12253 n1_m1_412800_494400 n1_m1_417600_494400 5.356235
R12254 n1_m1_417600_494400 n1_m1_422400_494400 5.356235
R12255 n1_m1_422400_494400 n1_m1_424000_494400 1.785412
R12256 n1_m1_427200_494400 n1_m1_424000_494400 3.570824
R12257 n1_m1_427200_494400 n1_m1_432000_494400 5.356235
R12258 n1_m1_432000_494400 n1_m1_436800_494400 5.356235
R12259 n1_m1_436800_494400 n1_m1_441600_494400 5.356235
R12260 n1_m1_441600_494400 n1_m1_446400_494400 5.356235
R12261 n1_m1_446400_494400 n1_m1_451200_494400 5.356235
R12262 n1_m1_451200_494400 n1_m1_452000_494400 0.892706
R12263 n1_m1_456000_494400 n1_m1_452000_494400 4.463529
R12264 n1_m1_456000_494400 n1_m1_460800_494400 5.356235
R12265 n1_m1_460800_494400 n1_m1_465600_494400 5.356235
R12266 n1_m1_465600_494400 n1_m1_470400_494400 5.356235
R12267 n1_m1_470400_494400 n1_m1_475200_494400 5.356235
R12268 n1_m1_475200_494400 n1_m1_480000_494400 5.356235
R12269 n1_m1_480000_494400 n1_m1_484800_494400 5.356235
R12270 n1_m1_484800_494400 n1_m1_489600_494400 5.356235
R12271 n1_m1_489600_494400 n1_m1_494400_494400 5.356235
R12272 n1_m4_4000_0 n1_m4_4000_4000 1.166667
R12273 n1_m4_4000_4800 n1_m4_4000_4000 0.233333
R12274 n1_m4_4000_4800 n1_m4_4000_9600 1.400000
R12275 n1_m4_4000_9600 n1_m4_4000_14400 1.400000
R12276 n1_m4_4000_14400 n1_m4_4000_19200 1.400000
R12277 n1_m4_4000_19200 n1_m4_4000_24000 1.400000
R12278 n1_m4_4000_24000 n1_m4_4000_28800 1.400000
R12279 n1_m4_4000_28800 n1_m4_4000_33600 1.400000
R12280 n1_m4_4000_33600 n1_m4_4000_38400 1.400000
R12281 n1_m4_4000_38400 n1_m4_4000_43200 1.400000
R12282 n1_m4_4000_43200 n1_m4_4000_48000 1.400000
R12283 n1_m4_4000_48000 n1_m4_4000_52800 1.400000
R12284 n1_m4_4000_52800 n1_m4_4000_57600 1.400000
R12285 n1_m4_4000_57600 n1_m4_4000_62400 1.400000
R12286 n1_m4_4000_62400 n1_m4_4000_67200 1.400000
R12287 n1_m4_4000_67200 n1_m4_4000_72000 1.400000
R12288 n1_m4_4000_72000 n1_m4_4000_76800 1.400000
R12289 n1_m4_4000_76800 n1_m4_4000_81600 1.400000
R12290 n1_m4_4000_81600 n1_m4_4000_84000 0.700000
R12291 n1_m4_4000_86400 n1_m4_4000_84000 0.700000
R12292 n1_m4_4000_86400 n1_m4_4000_91200 1.400000
R12293 n1_m4_4000_91200 n1_m4_4000_96000 1.400000
R12294 n1_m4_4000_96000 n1_m4_4000_100800 1.400000
R12295 n1_m4_4000_100800 n1_m4_4000_105600 1.400000
R12296 n1_m4_4000_105600 n1_m4_4000_110400 1.400000
R12297 n1_m4_4000_110400 n1_m4_4000_115200 1.400000
R12298 n1_m4_4000_115200 n1_m4_4000_120000 1.400000
R12299 n1_m4_4000_120000 n1_m4_4000_124800 1.400000
R12300 n1_m4_4000_124800 n1_m4_4000_129600 1.400000
R12301 n1_m4_4000_129600 n1_m4_4000_134400 1.400000
R12302 n1_m4_4000_134400 n1_m4_4000_139200 1.400000
R12303 n1_m4_4000_139200 n1_m4_4000_144000 1.400000
R12304 n1_m4_4000_144000 n1_m4_4000_148800 1.400000
R12305 n1_m4_4000_148800 n1_m4_4000_153600 1.400000
R12306 n1_m4_4000_153600 n1_m4_4000_158400 1.400000
R12307 n1_m4_4000_158400 n1_m4_4000_163200 1.400000
R12308 n1_m4_4000_163200 n1_m4_4000_164000 0.233333
R12309 n1_m4_4000_168000 n1_m4_4000_164000 1.166667
R12310 n1_m4_4000_168000 n1_m4_4000_172800 1.400000
R12311 n1_m4_4000_172800 n1_m4_4000_177600 1.400000
R12312 n1_m4_4000_177600 n1_m4_4000_182400 1.400000
R12313 n1_m4_4000_182400 n1_m4_4000_187200 1.400000
R12314 n1_m4_4000_187200 n1_m4_4000_192000 1.400000
R12315 n1_m4_4000_192000 n1_m4_4000_196800 1.400000
R12316 n1_m4_4000_196800 n1_m4_4000_201600 1.400000
R12317 n1_m4_4000_201600 n1_m4_4000_206400 1.400000
R12318 n1_m4_4000_206400 n1_m4_4000_211200 1.400000
R12319 n1_m4_4000_211200 n1_m4_4000_216000 1.400000
R12320 n1_m4_4000_216000 n1_m4_4000_220800 1.400000
R12321 n1_m4_4000_220800 n1_m4_4000_225600 1.400000
R12322 n1_m4_4000_225600 n1_m4_4000_230400 1.400000
R12323 n1_m4_4000_230400 n1_m4_4000_235200 1.400000
R12324 n1_m4_4000_235200 n1_m4_4000_240000 1.400000
R12325 n1_m4_4000_240000 n1_m4_4000_244000 1.166667
R12326 n1_m4_4000_244800 n1_m4_4000_244000 0.233333
R12327 n1_m4_4000_244800 n1_m4_4000_249600 1.400000
R12328 n1_m4_4000_249600 n1_m4_4000_254400 1.400000
R12329 n1_m4_4000_254400 n1_m4_4000_259200 1.400000
R12330 n1_m4_4000_259200 n1_m4_4000_264000 1.400000
R12331 n1_m4_4000_264000 n1_m4_4000_268800 1.400000
R12332 n1_m4_4000_268800 n1_m4_4000_273600 1.400000
R12333 n1_m4_4000_273600 n1_m4_4000_278400 1.400000
R12334 n1_m4_4000_278400 n1_m4_4000_283200 1.400000
R12335 n1_m4_4000_283200 n1_m4_4000_288000 1.400000
R12336 n1_m4_4000_288000 n1_m4_4000_292800 1.400000
R12337 n1_m4_4000_292800 n1_m4_4000_297600 1.400000
R12338 n1_m4_4000_297600 n1_m4_4000_302400 1.400000
R12339 n1_m4_4000_302400 n1_m4_4000_307200 1.400000
R12340 n1_m4_4000_307200 n1_m4_4000_312000 1.400000
R12341 n1_m4_4000_312000 n1_m4_4000_316800 1.400000
R12342 n1_m4_4000_316800 n1_m4_4000_321600 1.400000
R12343 n1_m4_4000_321600 n1_m4_4000_324000 0.700000
R12344 n1_m4_4000_326400 n1_m4_4000_324000 0.700000
R12345 n1_m4_4000_326400 n1_m4_4000_331200 1.400000
R12346 n1_m4_4000_331200 n1_m4_4000_336000 1.400000
R12347 n1_m4_4000_336000 n1_m4_4000_340800 1.400000
R12348 n1_m4_4000_340800 n1_m4_4000_345600 1.400000
R12349 n1_m4_4000_345600 n1_m4_4000_350400 1.400000
R12350 n1_m4_4000_350400 n1_m4_4000_355200 1.400000
R12351 n1_m4_4000_355200 n1_m4_4000_360000 1.400000
R12352 n1_m4_4000_360000 n1_m4_4000_364800 1.400000
R12353 n1_m4_4000_364800 n1_m4_4000_369600 1.400000
R12354 n1_m4_4000_369600 n1_m4_4000_374400 1.400000
R12355 n1_m4_4000_374400 n1_m4_4000_379200 1.400000
R12356 n1_m4_4000_379200 n1_m4_4000_384000 1.400000
R12357 n1_m4_4000_384000 n1_m4_4000_388800 1.400000
R12358 n1_m4_4000_388800 n1_m4_4000_393600 1.400000
R12359 n1_m4_4000_393600 n1_m4_4000_398400 1.400000
R12360 n1_m4_4000_398400 n1_m4_4000_403200 1.400000
R12361 n1_m4_4000_403200 n1_m4_4000_404000 0.233333
R12362 n1_m4_4000_408000 n1_m4_4000_404000 1.166667
R12363 n1_m4_4000_408000 n1_m4_4000_412800 1.400000
R12364 n1_m4_4000_412800 n1_m4_4000_417600 1.400000
R12365 n1_m4_4000_417600 n1_m4_4000_422400 1.400000
R12366 n1_m4_4000_422400 n1_m4_4000_427200 1.400000
R12367 n1_m4_4000_427200 n1_m4_4000_432000 1.400000
R12368 n1_m4_4000_432000 n1_m4_4000_436800 1.400000
R12369 n1_m4_4000_436800 n1_m4_4000_441600 1.400000
R12370 n1_m4_4000_441600 n1_m4_4000_446400 1.400000
R12371 n1_m4_4000_446400 n1_m4_4000_451200 1.400000
R12372 n1_m4_4000_451200 n1_m4_4000_456000 1.400000
R12373 n1_m4_4000_456000 n1_m4_4000_460800 1.400000
R12374 n1_m4_4000_460800 n1_m4_4000_465600 1.400000
R12375 n1_m4_4000_465600 n1_m4_4000_470400 1.400000
R12376 n1_m4_4000_470400 n1_m4_4000_475200 1.400000
R12377 n1_m4_4000_475200 n1_m4_4000_480000 1.400000
R12378 n1_m4_4000_480000 n1_m4_4000_484000 1.166667
R12379 n1_m4_4000_484800 n1_m4_4000_484000 0.233333
R12380 n1_m4_4000_484800 n1_m4_4000_489600 1.400000
R12381 n1_m4_4000_489600 n1_m4_4000_494400 1.400000
R12382 n1_m4_32000_0 n1_m4_32000_4000 1.166667
R12383 n1_m4_32000_4800 n1_m4_32000_4000 0.233333
R12384 n1_m4_32000_4800 n1_m4_32000_9600 1.400000
R12385 n1_m4_32000_9600 n1_m4_32000_14400 1.400000
R12386 n1_m4_32000_14400 n1_m4_32000_19200 1.400000
R12387 n1_m4_32000_19200 n1_m4_32000_24000 1.400000
R12388 n1_m4_32000_24000 n1_m4_32000_28800 1.400000
R12389 n1_m4_32000_28800 n1_m4_32000_33600 1.400000
R12390 n1_m4_32000_33600 n1_m4_32000_38400 1.400000
R12391 n1_m4_32000_38400 n1_m4_32000_43200 1.400000
R12392 n1_m4_32000_43200 n1_m4_32000_48000 1.400000
R12393 n1_m4_32000_48000 n1_m4_32000_52800 1.400000
R12394 n1_m4_32000_52800 n1_m4_32000_57600 1.400000
R12395 n1_m4_32000_57600 n1_m4_32000_62400 1.400000
R12396 n1_m4_32000_62400 n1_m4_32000_67200 1.400000
R12397 n1_m4_32000_67200 n1_m4_32000_72000 1.400000
R12398 n1_m4_32000_72000 n1_m4_32000_76800 1.400000
R12399 n1_m4_32000_76800 n1_m4_32000_81600 1.400000
R12400 n1_m4_32000_81600 n1_m4_32000_84000 0.700000
R12401 n1_m4_32000_86400 n1_m4_32000_84000 0.700000
R12402 n1_m4_32000_86400 n1_m4_32000_91200 1.400000
R12403 n1_m4_32000_91200 n1_m4_32000_96000 1.400000
R12404 n1_m4_32000_96000 n1_m4_32000_100800 1.400000
R12405 n1_m4_32000_100800 n1_m4_32000_105600 1.400000
R12406 n1_m4_32000_105600 n1_m4_32000_110400 1.400000
R12407 n1_m4_32000_110400 n1_m4_32000_115200 1.400000
R12408 n1_m4_32000_115200 n1_m4_32000_120000 1.400000
R12409 n1_m4_32000_120000 n1_m4_32000_124800 1.400000
R12410 n1_m4_32000_124800 n1_m4_32000_129600 1.400000
R12411 n1_m4_32000_129600 n1_m4_32000_134400 1.400000
R12412 n1_m4_32000_134400 n1_m4_32000_139200 1.400000
R12413 n1_m4_32000_139200 n1_m4_32000_144000 1.400000
R12414 n1_m4_32000_144000 n1_m4_32000_148800 1.400000
R12415 n1_m4_32000_148800 n1_m4_32000_153600 1.400000
R12416 n1_m4_32000_153600 n1_m4_32000_158400 1.400000
R12417 n1_m4_32000_158400 n1_m4_32000_163200 1.400000
R12418 n1_m4_32000_163200 n1_m4_32000_164000 0.233333
R12419 n1_m4_32000_168000 n1_m4_32000_164000 1.166667
R12420 n1_m4_32000_168000 n1_m4_32000_172800 1.400000
R12421 n1_m4_32000_172800 n1_m4_32000_177600 1.400000
R12422 n1_m4_32000_177600 n1_m4_32000_182400 1.400000
R12423 n1_m4_32000_182400 n1_m4_32000_187200 1.400000
R12424 n1_m4_32000_187200 n1_m4_32000_192000 1.400000
R12425 n1_m4_32000_192000 n1_m4_32000_196800 1.400000
R12426 n1_m4_32000_196800 n1_m4_32000_201600 1.400000
R12427 n1_m4_32000_201600 n1_m4_32000_206400 1.400000
R12428 n1_m4_32000_206400 n1_m4_32000_211200 1.400000
R12429 n1_m4_32000_211200 n1_m4_32000_216000 1.400000
R12430 n1_m4_32000_216000 n1_m4_32000_220800 1.400000
R12431 n1_m4_32000_220800 n1_m4_32000_225600 1.400000
R12432 n1_m4_32000_225600 n1_m4_32000_230400 1.400000
R12433 n1_m4_32000_230400 n1_m4_32000_235200 1.400000
R12434 n1_m4_32000_235200 n1_m4_32000_240000 1.400000
R12435 n1_m4_32000_240000 n1_m4_32000_244000 1.166667
R12436 n1_m4_32000_244800 n1_m4_32000_244000 0.233333
R12437 n1_m4_32000_244800 n1_m4_32000_249600 1.400000
R12438 n1_m4_32000_249600 n1_m4_32000_254400 1.400000
R12439 n1_m4_32000_254400 n1_m4_32000_259200 1.400000
R12440 n1_m4_32000_259200 n1_m4_32000_264000 1.400000
R12441 n1_m4_32000_264000 n1_m4_32000_268800 1.400000
R12442 n1_m4_32000_268800 n1_m4_32000_273600 1.400000
R12443 n1_m4_32000_273600 n1_m4_32000_278400 1.400000
R12444 n1_m4_32000_278400 n1_m4_32000_283200 1.400000
R12445 n1_m4_32000_283200 n1_m4_32000_288000 1.400000
R12446 n1_m4_32000_288000 n1_m4_32000_292800 1.400000
R12447 n1_m4_32000_292800 n1_m4_32000_297600 1.400000
R12448 n1_m4_32000_297600 n1_m4_32000_302400 1.400000
R12449 n1_m4_32000_302400 n1_m4_32000_307200 1.400000
R12450 n1_m4_32000_307200 n1_m4_32000_312000 1.400000
R12451 n1_m4_32000_312000 n1_m4_32000_316800 1.400000
R12452 n1_m4_32000_316800 n1_m4_32000_321600 1.400000
R12453 n1_m4_32000_321600 n1_m4_32000_324000 0.700000
R12454 n1_m4_32000_326400 n1_m4_32000_324000 0.700000
R12455 n1_m4_32000_326400 n1_m4_32000_331200 1.400000
R12456 n1_m4_32000_331200 n1_m4_32000_336000 1.400000
R12457 n1_m4_32000_336000 n1_m4_32000_340800 1.400000
R12458 n1_m4_32000_340800 n1_m4_32000_345600 1.400000
R12459 n1_m4_32000_345600 n1_m4_32000_350400 1.400000
R12460 n1_m4_32000_350400 n1_m4_32000_355200 1.400000
R12461 n1_m4_32000_355200 n1_m4_32000_360000 1.400000
R12462 n1_m4_32000_360000 n1_m4_32000_364800 1.400000
R12463 n1_m4_32000_364800 n1_m4_32000_369600 1.400000
R12464 n1_m4_32000_369600 n1_m4_32000_374400 1.400000
R12465 n1_m4_32000_374400 n1_m4_32000_379200 1.400000
R12466 n1_m4_32000_379200 n1_m4_32000_384000 1.400000
R12467 n1_m4_32000_384000 n1_m4_32000_388800 1.400000
R12468 n1_m4_32000_388800 n1_m4_32000_393600 1.400000
R12469 n1_m4_32000_393600 n1_m4_32000_398400 1.400000
R12470 n1_m4_32000_398400 n1_m4_32000_403200 1.400000
R12471 n1_m4_32000_403200 n1_m4_32000_404000 0.233333
R12472 n1_m4_32000_408000 n1_m4_32000_404000 1.166667
R12473 n1_m4_32000_408000 n1_m4_32000_412800 1.400000
R12474 n1_m4_32000_412800 n1_m4_32000_417600 1.400000
R12475 n1_m4_32000_417600 n1_m4_32000_422400 1.400000
R12476 n1_m4_32000_422400 n1_m4_32000_427200 1.400000
R12477 n1_m4_32000_427200 n1_m4_32000_432000 1.400000
R12478 n1_m4_32000_432000 n1_m4_32000_436800 1.400000
R12479 n1_m4_32000_436800 n1_m4_32000_441600 1.400000
R12480 n1_m4_32000_441600 n1_m4_32000_446400 1.400000
R12481 n1_m4_32000_446400 n1_m4_32000_451200 1.400000
R12482 n1_m4_32000_451200 n1_m4_32000_456000 1.400000
R12483 n1_m4_32000_456000 n1_m4_32000_460800 1.400000
R12484 n1_m4_32000_460800 n1_m4_32000_465600 1.400000
R12485 n1_m4_32000_465600 n1_m4_32000_470400 1.400000
R12486 n1_m4_32000_470400 n1_m4_32000_475200 1.400000
R12487 n1_m4_32000_475200 n1_m4_32000_480000 1.400000
R12488 n1_m4_32000_480000 n1_m4_32000_484000 1.166667
R12489 n1_m4_32000_484800 n1_m4_32000_484000 0.233333
R12490 n1_m4_32000_484800 n1_m4_32000_489600 1.400000
R12491 n1_m4_32000_489600 n1_m4_32000_494400 1.400000
R12492 n1_m4_60000_0 n1_m4_60000_4000 1.166667
R12493 n1_m4_60000_4800 n1_m4_60000_4000 0.233333
R12494 n1_m4_60000_4800 n1_m4_60000_9600 1.400000
R12495 n1_m4_60000_9600 n1_m4_60000_14400 1.400000
R12496 n1_m4_60000_14400 n1_m4_60000_19200 1.400000
R12497 n1_m4_60000_19200 n1_m4_60000_24000 1.400000
R12498 n1_m4_60000_24000 n1_m4_60000_28800 1.400000
R12499 n1_m4_60000_28800 n1_m4_60000_33600 1.400000
R12500 n1_m4_60000_33600 n1_m4_60000_38400 1.400000
R12501 n1_m4_60000_38400 n1_m4_60000_43200 1.400000
R12502 n1_m4_60000_43200 n1_m4_60000_48000 1.400000
R12503 n1_m4_60000_48000 n1_m4_60000_52800 1.400000
R12504 n1_m4_60000_52800 n1_m4_60000_57600 1.400000
R12505 n1_m4_60000_57600 n1_m4_60000_62400 1.400000
R12506 n1_m4_60000_62400 n1_m4_60000_67200 1.400000
R12507 n1_m4_60000_67200 n1_m4_60000_72000 1.400000
R12508 n1_m4_60000_72000 n1_m4_60000_76800 1.400000
R12509 n1_m4_60000_76800 n1_m4_60000_81600 1.400000
R12510 n1_m4_60000_81600 n1_m4_60000_84000 0.700000
R12511 n1_m4_60000_86400 n1_m4_60000_84000 0.700000
R12512 n1_m4_60000_86400 n1_m4_60000_91200 1.400000
R12513 n1_m4_60000_91200 n1_m4_60000_96000 1.400000
R12514 n1_m4_60000_96000 n1_m4_60000_100800 1.400000
R12515 n1_m4_60000_100800 n1_m4_60000_105600 1.400000
R12516 n1_m4_60000_105600 n1_m4_60000_110400 1.400000
R12517 n1_m4_60000_110400 n1_m4_60000_115200 1.400000
R12518 n1_m4_60000_115200 n1_m4_60000_120000 1.400000
R12519 n1_m4_60000_120000 n1_m4_60000_124800 1.400000
R12520 n1_m4_60000_124800 n1_m4_60000_129600 1.400000
R12521 n1_m4_60000_129600 n1_m4_60000_134400 1.400000
R12522 n1_m4_60000_134400 n1_m4_60000_139200 1.400000
R12523 n1_m4_60000_139200 n1_m4_60000_144000 1.400000
R12524 n1_m4_60000_144000 n1_m4_60000_148800 1.400000
R12525 n1_m4_60000_148800 n1_m4_60000_153600 1.400000
R12526 n1_m4_60000_153600 n1_m4_60000_158400 1.400000
R12527 n1_m4_60000_158400 n1_m4_60000_163200 1.400000
R12528 n1_m4_60000_163200 n1_m4_60000_164000 0.233333
R12529 n1_m4_60000_168000 n1_m4_60000_164000 1.166667
R12530 n1_m4_60000_168000 n1_m4_60000_172800 1.400000
R12531 n1_m4_60000_172800 n1_m4_60000_177600 1.400000
R12532 n1_m4_60000_177600 n1_m4_60000_182400 1.400000
R12533 n1_m4_60000_182400 n1_m4_60000_187200 1.400000
R12534 n1_m4_60000_187200 n1_m4_60000_192000 1.400000
R12535 n1_m4_60000_192000 n1_m4_60000_196800 1.400000
R12536 n1_m4_60000_196800 n1_m4_60000_201600 1.400000
R12537 n1_m4_60000_201600 n1_m4_60000_206400 1.400000
R12538 n1_m4_60000_206400 n1_m4_60000_211200 1.400000
R12539 n1_m4_60000_211200 n1_m4_60000_216000 1.400000
R12540 n1_m4_60000_216000 n1_m4_60000_220800 1.400000
R12541 n1_m4_60000_220800 n1_m4_60000_225600 1.400000
R12542 n1_m4_60000_225600 n1_m4_60000_230400 1.400000
R12543 n1_m4_60000_230400 n1_m4_60000_235200 1.400000
R12544 n1_m4_60000_235200 n1_m4_60000_240000 1.400000
R12545 n1_m4_60000_240000 n1_m4_60000_244000 1.166667
R12546 n1_m4_60000_244800 n1_m4_60000_244000 0.233333
R12547 n1_m4_60000_244800 n1_m4_60000_249600 1.400000
R12548 n1_m4_60000_249600 n1_m4_60000_254400 1.400000
R12549 n1_m4_60000_254400 n1_m4_60000_259200 1.400000
R12550 n1_m4_60000_259200 n1_m4_60000_264000 1.400000
R12551 n1_m4_60000_264000 n1_m4_60000_268800 1.400000
R12552 n1_m4_60000_268800 n1_m4_60000_273600 1.400000
R12553 n1_m4_60000_273600 n1_m4_60000_278400 1.400000
R12554 n1_m4_60000_278400 n1_m4_60000_283200 1.400000
R12555 n1_m4_60000_283200 n1_m4_60000_288000 1.400000
R12556 n1_m4_60000_288000 n1_m4_60000_292800 1.400000
R12557 n1_m4_60000_292800 n1_m4_60000_297600 1.400000
R12558 n1_m4_60000_297600 n1_m4_60000_302400 1.400000
R12559 n1_m4_60000_302400 n1_m4_60000_307200 1.400000
R12560 n1_m4_60000_307200 n1_m4_60000_312000 1.400000
R12561 n1_m4_60000_312000 n1_m4_60000_316800 1.400000
R12562 n1_m4_60000_316800 n1_m4_60000_321600 1.400000
R12563 n1_m4_60000_321600 n1_m4_60000_324000 0.700000
R12564 n1_m4_60000_326400 n1_m4_60000_324000 0.700000
R12565 n1_m4_60000_326400 n1_m4_60000_331200 1.400000
R12566 n1_m4_60000_331200 n1_m4_60000_336000 1.400000
R12567 n1_m4_60000_336000 n1_m4_60000_340800 1.400000
R12568 n1_m4_60000_340800 n1_m4_60000_345600 1.400000
R12569 n1_m4_60000_345600 n1_m4_60000_350400 1.400000
R12570 n1_m4_60000_350400 n1_m4_60000_355200 1.400000
R12571 n1_m4_60000_355200 n1_m4_60000_360000 1.400000
R12572 n1_m4_60000_360000 n1_m4_60000_364800 1.400000
R12573 n1_m4_60000_364800 n1_m4_60000_369600 1.400000
R12574 n1_m4_60000_369600 n1_m4_60000_374400 1.400000
R12575 n1_m4_60000_374400 n1_m4_60000_379200 1.400000
R12576 n1_m4_60000_379200 n1_m4_60000_384000 1.400000
R12577 n1_m4_60000_384000 n1_m4_60000_388800 1.400000
R12578 n1_m4_60000_388800 n1_m4_60000_393600 1.400000
R12579 n1_m4_60000_393600 n1_m4_60000_398400 1.400000
R12580 n1_m4_60000_398400 n1_m4_60000_403200 1.400000
R12581 n1_m4_60000_403200 n1_m4_60000_404000 0.233333
R12582 n1_m4_60000_408000 n1_m4_60000_404000 1.166667
R12583 n1_m4_60000_408000 n1_m4_60000_412800 1.400000
R12584 n1_m4_60000_412800 n1_m4_60000_417600 1.400000
R12585 n1_m4_60000_417600 n1_m4_60000_422400 1.400000
R12586 n1_m4_60000_422400 n1_m4_60000_427200 1.400000
R12587 n1_m4_60000_427200 n1_m4_60000_432000 1.400000
R12588 n1_m4_60000_432000 n1_m4_60000_436800 1.400000
R12589 n1_m4_60000_436800 n1_m4_60000_441600 1.400000
R12590 n1_m4_60000_441600 n1_m4_60000_446400 1.400000
R12591 n1_m4_60000_446400 n1_m4_60000_451200 1.400000
R12592 n1_m4_60000_451200 n1_m4_60000_456000 1.400000
R12593 n1_m4_60000_456000 n1_m4_60000_460800 1.400000
R12594 n1_m4_60000_460800 n1_m4_60000_465600 1.400000
R12595 n1_m4_60000_465600 n1_m4_60000_470400 1.400000
R12596 n1_m4_60000_470400 n1_m4_60000_475200 1.400000
R12597 n1_m4_60000_475200 n1_m4_60000_480000 1.400000
R12598 n1_m4_60000_480000 n1_m4_60000_484000 1.166667
R12599 n1_m4_60000_484800 n1_m4_60000_484000 0.233333
R12600 n1_m4_60000_484800 n1_m4_60000_489600 1.400000
R12601 n1_m4_60000_489600 n1_m4_60000_494400 1.400000
R12602 n1_m4_88000_0 n1_m4_88000_4000 1.166667
R12603 n1_m4_88000_4800 n1_m4_88000_4000 0.233333
R12604 n1_m4_88000_4800 n1_m4_88000_9600 1.400000
R12605 n1_m4_88000_9600 n1_m4_88000_14400 1.400000
R12606 n1_m4_88000_14400 n1_m4_88000_19200 1.400000
R12607 n1_m4_88000_19200 n1_m4_88000_24000 1.400000
R12608 n1_m4_88000_24000 n1_m4_88000_28800 1.400000
R12609 n1_m4_88000_28800 n1_m4_88000_33600 1.400000
R12610 n1_m4_88000_33600 n1_m4_88000_38400 1.400000
R12611 n1_m4_88000_38400 n1_m4_88000_43200 1.400000
R12612 n1_m4_88000_43200 n1_m4_88000_48000 1.400000
R12613 n1_m4_88000_48000 n1_m4_88000_52800 1.400000
R12614 n1_m4_88000_52800 n1_m4_88000_57600 1.400000
R12615 n1_m4_88000_57600 n1_m4_88000_62400 1.400000
R12616 n1_m4_88000_62400 n1_m4_88000_67200 1.400000
R12617 n1_m4_88000_67200 n1_m4_88000_72000 1.400000
R12618 n1_m4_88000_72000 n1_m4_88000_76800 1.400000
R12619 n1_m4_88000_76800 n1_m4_88000_81600 1.400000
R12620 n1_m4_88000_81600 n1_m4_88000_84000 0.700000
R12621 n1_m4_88000_86400 n1_m4_88000_84000 0.700000
R12622 n1_m4_88000_86400 n1_m4_88000_91200 1.400000
R12623 n1_m4_88000_91200 n1_m4_88000_96000 1.400000
R12624 n1_m4_88000_96000 n1_m4_88000_100800 1.400000
R12625 n1_m4_88000_100800 n1_m4_88000_105600 1.400000
R12626 n1_m4_88000_105600 n1_m4_88000_110400 1.400000
R12627 n1_m4_88000_110400 n1_m4_88000_115200 1.400000
R12628 n1_m4_88000_115200 n1_m4_88000_120000 1.400000
R12629 n1_m4_88000_120000 n1_m4_88000_124800 1.400000
R12630 n1_m4_88000_124800 n1_m4_88000_129600 1.400000
R12631 n1_m4_88000_129600 n1_m4_88000_134400 1.400000
R12632 n1_m4_88000_134400 n1_m4_88000_139200 1.400000
R12633 n1_m4_88000_139200 n1_m4_88000_144000 1.400000
R12634 n1_m4_88000_144000 n1_m4_88000_148800 1.400000
R12635 n1_m4_88000_148800 n1_m4_88000_153600 1.400000
R12636 n1_m4_88000_153600 n1_m4_88000_158400 1.400000
R12637 n1_m4_88000_158400 n1_m4_88000_163200 1.400000
R12638 n1_m4_88000_163200 n1_m4_88000_164000 0.233333
R12639 n1_m4_88000_168000 n1_m4_88000_164000 1.166667
R12640 n1_m4_88000_168000 n1_m4_88000_172800 1.400000
R12641 n1_m4_88000_172800 n1_m4_88000_177600 1.400000
R12642 n1_m4_88000_177600 n1_m4_88000_182400 1.400000
R12643 n1_m4_88000_182400 n1_m4_88000_187200 1.400000
R12644 n1_m4_88000_187200 n1_m4_88000_192000 1.400000
R12645 n1_m4_88000_192000 n1_m4_88000_196800 1.400000
R12646 n1_m4_88000_196800 n1_m4_88000_201600 1.400000
R12647 n1_m4_88000_201600 n1_m4_88000_206400 1.400000
R12648 n1_m4_88000_206400 n1_m4_88000_211200 1.400000
R12649 n1_m4_88000_211200 n1_m4_88000_216000 1.400000
R12650 n1_m4_88000_216000 n1_m4_88000_220800 1.400000
R12651 n1_m4_88000_220800 n1_m4_88000_225600 1.400000
R12652 n1_m4_88000_225600 n1_m4_88000_230400 1.400000
R12653 n1_m4_88000_230400 n1_m4_88000_235200 1.400000
R12654 n1_m4_88000_235200 n1_m4_88000_240000 1.400000
R12655 n1_m4_88000_240000 n1_m4_88000_244000 1.166667
R12656 n1_m4_88000_244800 n1_m4_88000_244000 0.233333
R12657 n1_m4_88000_244800 n1_m4_88000_249600 1.400000
R12658 n1_m4_88000_249600 n1_m4_88000_254400 1.400000
R12659 n1_m4_88000_254400 n1_m4_88000_259200 1.400000
R12660 n1_m4_88000_259200 n1_m4_88000_264000 1.400000
R12661 n1_m4_88000_264000 n1_m4_88000_268800 1.400000
R12662 n1_m4_88000_268800 n1_m4_88000_273600 1.400000
R12663 n1_m4_88000_273600 n1_m4_88000_278400 1.400000
R12664 n1_m4_88000_278400 n1_m4_88000_283200 1.400000
R12665 n1_m4_88000_283200 n1_m4_88000_288000 1.400000
R12666 n1_m4_88000_288000 n1_m4_88000_292800 1.400000
R12667 n1_m4_88000_292800 n1_m4_88000_297600 1.400000
R12668 n1_m4_88000_297600 n1_m4_88000_302400 1.400000
R12669 n1_m4_88000_302400 n1_m4_88000_307200 1.400000
R12670 n1_m4_88000_307200 n1_m4_88000_312000 1.400000
R12671 n1_m4_88000_312000 n1_m4_88000_316800 1.400000
R12672 n1_m4_88000_316800 n1_m4_88000_321600 1.400000
R12673 n1_m4_88000_321600 n1_m4_88000_324000 0.700000
R12674 n1_m4_88000_326400 n1_m4_88000_324000 0.700000
R12675 n1_m4_88000_326400 n1_m4_88000_331200 1.400000
R12676 n1_m4_88000_331200 n1_m4_88000_336000 1.400000
R12677 n1_m4_88000_336000 n1_m4_88000_340800 1.400000
R12678 n1_m4_88000_340800 n1_m4_88000_345600 1.400000
R12679 n1_m4_88000_345600 n1_m4_88000_350400 1.400000
R12680 n1_m4_88000_350400 n1_m4_88000_355200 1.400000
R12681 n1_m4_88000_355200 n1_m4_88000_360000 1.400000
R12682 n1_m4_88000_360000 n1_m4_88000_364800 1.400000
R12683 n1_m4_88000_364800 n1_m4_88000_369600 1.400000
R12684 n1_m4_88000_369600 n1_m4_88000_374400 1.400000
R12685 n1_m4_88000_374400 n1_m4_88000_379200 1.400000
R12686 n1_m4_88000_379200 n1_m4_88000_384000 1.400000
R12687 n1_m4_88000_384000 n1_m4_88000_388800 1.400000
R12688 n1_m4_88000_388800 n1_m4_88000_393600 1.400000
R12689 n1_m4_88000_393600 n1_m4_88000_398400 1.400000
R12690 n1_m4_88000_398400 n1_m4_88000_403200 1.400000
R12691 n1_m4_88000_403200 n1_m4_88000_404000 0.233333
R12692 n1_m4_88000_408000 n1_m4_88000_404000 1.166667
R12693 n1_m4_88000_408000 n1_m4_88000_412800 1.400000
R12694 n1_m4_88000_412800 n1_m4_88000_417600 1.400000
R12695 n1_m4_88000_417600 n1_m4_88000_422400 1.400000
R12696 n1_m4_88000_422400 n1_m4_88000_427200 1.400000
R12697 n1_m4_88000_427200 n1_m4_88000_432000 1.400000
R12698 n1_m4_88000_432000 n1_m4_88000_436800 1.400000
R12699 n1_m4_88000_436800 n1_m4_88000_441600 1.400000
R12700 n1_m4_88000_441600 n1_m4_88000_446400 1.400000
R12701 n1_m4_88000_446400 n1_m4_88000_451200 1.400000
R12702 n1_m4_88000_451200 n1_m4_88000_456000 1.400000
R12703 n1_m4_88000_456000 n1_m4_88000_460800 1.400000
R12704 n1_m4_88000_460800 n1_m4_88000_465600 1.400000
R12705 n1_m4_88000_465600 n1_m4_88000_470400 1.400000
R12706 n1_m4_88000_470400 n1_m4_88000_475200 1.400000
R12707 n1_m4_88000_475200 n1_m4_88000_480000 1.400000
R12708 n1_m4_88000_480000 n1_m4_88000_484000 1.166667
R12709 n1_m4_88000_484800 n1_m4_88000_484000 0.233333
R12710 n1_m4_88000_484800 n1_m4_88000_489600 1.400000
R12711 n1_m4_88000_489600 n1_m4_88000_494400 1.400000
R12712 n1_m4_116000_0 n1_m4_116000_4000 1.166667
R12713 n1_m4_116000_4800 n1_m4_116000_4000 0.233333
R12714 n1_m4_116000_4800 n1_m4_116000_9600 1.400000
R12715 n1_m4_116000_9600 n1_m4_116000_14400 1.400000
R12716 n1_m4_116000_14400 n1_m4_116000_19200 1.400000
R12717 n1_m4_116000_19200 n1_m4_116000_24000 1.400000
R12718 n1_m4_116000_24000 n1_m4_116000_28800 1.400000
R12719 n1_m4_116000_28800 n1_m4_116000_33600 1.400000
R12720 n1_m4_116000_33600 n1_m4_116000_38400 1.400000
R12721 n1_m4_116000_38400 n1_m4_116000_43200 1.400000
R12722 n1_m4_116000_43200 n1_m4_116000_48000 1.400000
R12723 n1_m4_116000_48000 n1_m4_116000_52800 1.400000
R12724 n1_m4_116000_52800 n1_m4_116000_57600 1.400000
R12725 n1_m4_116000_57600 n1_m4_116000_62400 1.400000
R12726 n1_m4_116000_62400 n1_m4_116000_67200 1.400000
R12727 n1_m4_116000_67200 n1_m4_116000_72000 1.400000
R12728 n1_m4_116000_72000 n1_m4_116000_76800 1.400000
R12729 n1_m4_116000_76800 n1_m4_116000_81600 1.400000
R12730 n1_m4_116000_81600 n1_m4_116000_84000 0.700000
R12731 n1_m4_116000_86400 n1_m4_116000_84000 0.700000
R12732 n1_m4_116000_86400 n1_m4_116000_91200 1.400000
R12733 n1_m4_116000_91200 n1_m4_116000_96000 1.400000
R12734 n1_m4_116000_96000 n1_m4_116000_100800 1.400000
R12735 n1_m4_116000_100800 n1_m4_116000_105600 1.400000
R12736 n1_m4_116000_105600 n1_m4_116000_110400 1.400000
R12737 n1_m4_116000_110400 n1_m4_116000_115200 1.400000
R12738 n1_m4_116000_115200 n1_m4_116000_120000 1.400000
R12739 n1_m4_116000_120000 n1_m4_116000_124800 1.400000
R12740 n1_m4_116000_124800 n1_m4_116000_129600 1.400000
R12741 n1_m4_116000_129600 n1_m4_116000_134400 1.400000
R12742 n1_m4_116000_134400 n1_m4_116000_139200 1.400000
R12743 n1_m4_116000_139200 n1_m4_116000_144000 1.400000
R12744 n1_m4_116000_144000 n1_m4_116000_148800 1.400000
R12745 n1_m4_116000_148800 n1_m4_116000_153600 1.400000
R12746 n1_m4_116000_153600 n1_m4_116000_158400 1.400000
R12747 n1_m4_116000_158400 n1_m4_116000_163200 1.400000
R12748 n1_m4_116000_163200 n1_m4_116000_164000 0.233333
R12749 n1_m4_116000_168000 n1_m4_116000_164000 1.166667
R12750 n1_m4_116000_168000 n1_m4_116000_172800 1.400000
R12751 n1_m4_116000_172800 n1_m4_116000_177600 1.400000
R12752 n1_m4_116000_177600 n1_m4_116000_182400 1.400000
R12753 n1_m4_116000_182400 n1_m4_116000_187200 1.400000
R12754 n1_m4_116000_187200 n1_m4_116000_192000 1.400000
R12755 n1_m4_116000_192000 n1_m4_116000_196800 1.400000
R12756 n1_m4_116000_196800 n1_m4_116000_201600 1.400000
R12757 n1_m4_116000_201600 n1_m4_116000_206400 1.400000
R12758 n1_m4_116000_206400 n1_m4_116000_211200 1.400000
R12759 n1_m4_116000_211200 n1_m4_116000_216000 1.400000
R12760 n1_m4_116000_216000 n1_m4_116000_220800 1.400000
R12761 n1_m4_116000_220800 n1_m4_116000_225600 1.400000
R12762 n1_m4_116000_225600 n1_m4_116000_230400 1.400000
R12763 n1_m4_116000_230400 n1_m4_116000_235200 1.400000
R12764 n1_m4_116000_235200 n1_m4_116000_240000 1.400000
R12765 n1_m4_116000_240000 n1_m4_116000_244000 1.166667
R12766 n1_m4_116000_244800 n1_m4_116000_244000 0.233333
R12767 n1_m4_116000_244800 n1_m4_116000_249600 1.400000
R12768 n1_m4_116000_249600 n1_m4_116000_254400 1.400000
R12769 n1_m4_116000_254400 n1_m4_116000_259200 1.400000
R12770 n1_m4_116000_259200 n1_m4_116000_264000 1.400000
R12771 n1_m4_116000_264000 n1_m4_116000_268800 1.400000
R12772 n1_m4_116000_268800 n1_m4_116000_273600 1.400000
R12773 n1_m4_116000_273600 n1_m4_116000_278400 1.400000
R12774 n1_m4_116000_278400 n1_m4_116000_283200 1.400000
R12775 n1_m4_116000_283200 n1_m4_116000_288000 1.400000
R12776 n1_m4_116000_288000 n1_m4_116000_292800 1.400000
R12777 n1_m4_116000_292800 n1_m4_116000_297600 1.400000
R12778 n1_m4_116000_297600 n1_m4_116000_302400 1.400000
R12779 n1_m4_116000_302400 n1_m4_116000_307200 1.400000
R12780 n1_m4_116000_307200 n1_m4_116000_312000 1.400000
R12781 n1_m4_116000_312000 n1_m4_116000_316800 1.400000
R12782 n1_m4_116000_316800 n1_m4_116000_321600 1.400000
R12783 n1_m4_116000_321600 n1_m4_116000_324000 0.700000
R12784 n1_m4_116000_326400 n1_m4_116000_324000 0.700000
R12785 n1_m4_116000_326400 n1_m4_116000_331200 1.400000
R12786 n1_m4_116000_331200 n1_m4_116000_336000 1.400000
R12787 n1_m4_116000_336000 n1_m4_116000_340800 1.400000
R12788 n1_m4_116000_340800 n1_m4_116000_345600 1.400000
R12789 n1_m4_116000_345600 n1_m4_116000_350400 1.400000
R12790 n1_m4_116000_350400 n1_m4_116000_355200 1.400000
R12791 n1_m4_116000_355200 n1_m4_116000_360000 1.400000
R12792 n1_m4_116000_360000 n1_m4_116000_364800 1.400000
R12793 n1_m4_116000_364800 n1_m4_116000_369600 1.400000
R12794 n1_m4_116000_369600 n1_m4_116000_374400 1.400000
R12795 n1_m4_116000_374400 n1_m4_116000_379200 1.400000
R12796 n1_m4_116000_379200 n1_m4_116000_384000 1.400000
R12797 n1_m4_116000_384000 n1_m4_116000_388800 1.400000
R12798 n1_m4_116000_388800 n1_m4_116000_393600 1.400000
R12799 n1_m4_116000_393600 n1_m4_116000_398400 1.400000
R12800 n1_m4_116000_398400 n1_m4_116000_403200 1.400000
R12801 n1_m4_116000_403200 n1_m4_116000_404000 0.233333
R12802 n1_m4_116000_408000 n1_m4_116000_404000 1.166667
R12803 n1_m4_116000_408000 n1_m4_116000_412800 1.400000
R12804 n1_m4_116000_412800 n1_m4_116000_417600 1.400000
R12805 n1_m4_116000_417600 n1_m4_116000_422400 1.400000
R12806 n1_m4_116000_422400 n1_m4_116000_427200 1.400000
R12807 n1_m4_116000_427200 n1_m4_116000_432000 1.400000
R12808 n1_m4_116000_432000 n1_m4_116000_436800 1.400000
R12809 n1_m4_116000_436800 n1_m4_116000_441600 1.400000
R12810 n1_m4_116000_441600 n1_m4_116000_446400 1.400000
R12811 n1_m4_116000_446400 n1_m4_116000_451200 1.400000
R12812 n1_m4_116000_451200 n1_m4_116000_456000 1.400000
R12813 n1_m4_116000_456000 n1_m4_116000_460800 1.400000
R12814 n1_m4_116000_460800 n1_m4_116000_465600 1.400000
R12815 n1_m4_116000_465600 n1_m4_116000_470400 1.400000
R12816 n1_m4_116000_470400 n1_m4_116000_475200 1.400000
R12817 n1_m4_116000_475200 n1_m4_116000_480000 1.400000
R12818 n1_m4_116000_480000 n1_m4_116000_484000 1.166667
R12819 n1_m4_116000_484800 n1_m4_116000_484000 0.233333
R12820 n1_m4_116000_484800 n1_m4_116000_489600 1.400000
R12821 n1_m4_116000_489600 n1_m4_116000_494400 1.400000
R12822 n1_m4_144000_0 n1_m4_144000_4000 1.166667
R12823 n1_m4_144000_4800 n1_m4_144000_4000 0.233333
R12824 n1_m4_144000_4800 n1_m4_144000_9600 1.400000
R12825 n1_m4_144000_9600 n1_m4_144000_14400 1.400000
R12826 n1_m4_144000_14400 n1_m4_144000_19200 1.400000
R12827 n1_m4_144000_19200 n1_m4_144000_24000 1.400000
R12828 n1_m4_144000_24000 n1_m4_144000_28800 1.400000
R12829 n1_m4_144000_28800 n1_m4_144000_33600 1.400000
R12830 n1_m4_144000_33600 n1_m4_144000_38400 1.400000
R12831 n1_m4_144000_38400 n1_m4_144000_43200 1.400000
R12832 n1_m4_144000_43200 n1_m4_144000_48000 1.400000
R12833 n1_m4_144000_48000 n1_m4_144000_52800 1.400000
R12834 n1_m4_144000_52800 n1_m4_144000_57600 1.400000
R12835 n1_m4_144000_57600 n1_m4_144000_62400 1.400000
R12836 n1_m4_144000_62400 n1_m4_144000_67200 1.400000
R12837 n1_m4_144000_67200 n1_m4_144000_72000 1.400000
R12838 n1_m4_144000_72000 n1_m4_144000_76800 1.400000
R12839 n1_m4_144000_76800 n1_m4_144000_81600 1.400000
R12840 n1_m4_144000_81600 n1_m4_144000_84000 0.700000
R12841 n1_m4_144000_86400 n1_m4_144000_84000 0.700000
R12842 n1_m4_144000_86400 n1_m4_144000_91200 1.400000
R12843 n1_m4_144000_91200 n1_m4_144000_96000 1.400000
R12844 n1_m4_144000_96000 n1_m4_144000_100800 1.400000
R12845 n1_m4_144000_100800 n1_m4_144000_105600 1.400000
R12846 n1_m4_144000_105600 n1_m4_144000_110400 1.400000
R12847 n1_m4_144000_110400 n1_m4_144000_115200 1.400000
R12848 n1_m4_144000_115200 n1_m4_144000_120000 1.400000
R12849 n1_m4_144000_120000 n1_m4_144000_124800 1.400000
R12850 n1_m4_144000_124800 n1_m4_144000_129600 1.400000
R12851 n1_m4_144000_129600 n1_m4_144000_134400 1.400000
R12852 n1_m4_144000_134400 n1_m4_144000_139200 1.400000
R12853 n1_m4_144000_139200 n1_m4_144000_144000 1.400000
R12854 n1_m4_144000_144000 n1_m4_144000_148800 1.400000
R12855 n1_m4_144000_148800 n1_m4_144000_153600 1.400000
R12856 n1_m4_144000_153600 n1_m4_144000_158400 1.400000
R12857 n1_m4_144000_158400 n1_m4_144000_163200 1.400000
R12858 n1_m4_144000_163200 n1_m4_144000_164000 0.233333
R12859 n1_m4_144000_168000 n1_m4_144000_164000 1.166667
R12860 n1_m4_144000_168000 n1_m4_144000_172800 1.400000
R12861 n1_m4_144000_172800 n1_m4_144000_177600 1.400000
R12862 n1_m4_144000_177600 n1_m4_144000_182400 1.400000
R12863 n1_m4_144000_182400 n1_m4_144000_187200 1.400000
R12864 n1_m4_144000_187200 n1_m4_144000_192000 1.400000
R12865 n1_m4_144000_192000 n1_m4_144000_196800 1.400000
R12866 n1_m4_144000_196800 n1_m4_144000_201600 1.400000
R12867 n1_m4_144000_201600 n1_m4_144000_206400 1.400000
R12868 n1_m4_144000_206400 n1_m4_144000_211200 1.400000
R12869 n1_m4_144000_211200 n1_m4_144000_216000 1.400000
R12870 n1_m4_144000_216000 n1_m4_144000_220800 1.400000
R12871 n1_m4_144000_220800 n1_m4_144000_225600 1.400000
R12872 n1_m4_144000_225600 n1_m4_144000_230400 1.400000
R12873 n1_m4_144000_230400 n1_m4_144000_235200 1.400000
R12874 n1_m4_144000_235200 n1_m4_144000_240000 1.400000
R12875 n1_m4_144000_240000 n1_m4_144000_244000 1.166667
R12876 n1_m4_144000_244800 n1_m4_144000_244000 0.233333
R12877 n1_m4_144000_244800 n1_m4_144000_249600 1.400000
R12878 n1_m4_144000_249600 n1_m4_144000_254400 1.400000
R12879 n1_m4_144000_254400 n1_m4_144000_259200 1.400000
R12880 n1_m4_144000_259200 n1_m4_144000_264000 1.400000
R12881 n1_m4_144000_264000 n1_m4_144000_268800 1.400000
R12882 n1_m4_144000_268800 n1_m4_144000_273600 1.400000
R12883 n1_m4_144000_273600 n1_m4_144000_278400 1.400000
R12884 n1_m4_144000_278400 n1_m4_144000_283200 1.400000
R12885 n1_m4_144000_283200 n1_m4_144000_288000 1.400000
R12886 n1_m4_144000_288000 n1_m4_144000_292800 1.400000
R12887 n1_m4_144000_292800 n1_m4_144000_297600 1.400000
R12888 n1_m4_144000_297600 n1_m4_144000_302400 1.400000
R12889 n1_m4_144000_302400 n1_m4_144000_307200 1.400000
R12890 n1_m4_144000_307200 n1_m4_144000_312000 1.400000
R12891 n1_m4_144000_312000 n1_m4_144000_316800 1.400000
R12892 n1_m4_144000_316800 n1_m4_144000_321600 1.400000
R12893 n1_m4_144000_321600 n1_m4_144000_324000 0.700000
R12894 n1_m4_144000_326400 n1_m4_144000_324000 0.700000
R12895 n1_m4_144000_326400 n1_m4_144000_331200 1.400000
R12896 n1_m4_144000_331200 n1_m4_144000_336000 1.400000
R12897 n1_m4_144000_336000 n1_m4_144000_340800 1.400000
R12898 n1_m4_144000_340800 n1_m4_144000_345600 1.400000
R12899 n1_m4_144000_345600 n1_m4_144000_350400 1.400000
R12900 n1_m4_144000_350400 n1_m4_144000_355200 1.400000
R12901 n1_m4_144000_355200 n1_m4_144000_360000 1.400000
R12902 n1_m4_144000_360000 n1_m4_144000_364800 1.400000
R12903 n1_m4_144000_364800 n1_m4_144000_369600 1.400000
R12904 n1_m4_144000_369600 n1_m4_144000_374400 1.400000
R12905 n1_m4_144000_374400 n1_m4_144000_379200 1.400000
R12906 n1_m4_144000_379200 n1_m4_144000_384000 1.400000
R12907 n1_m4_144000_384000 n1_m4_144000_388800 1.400000
R12908 n1_m4_144000_388800 n1_m4_144000_393600 1.400000
R12909 n1_m4_144000_393600 n1_m4_144000_398400 1.400000
R12910 n1_m4_144000_398400 n1_m4_144000_403200 1.400000
R12911 n1_m4_144000_403200 n1_m4_144000_404000 0.233333
R12912 n1_m4_144000_408000 n1_m4_144000_404000 1.166667
R12913 n1_m4_144000_408000 n1_m4_144000_412800 1.400000
R12914 n1_m4_144000_412800 n1_m4_144000_417600 1.400000
R12915 n1_m4_144000_417600 n1_m4_144000_422400 1.400000
R12916 n1_m4_144000_422400 n1_m4_144000_427200 1.400000
R12917 n1_m4_144000_427200 n1_m4_144000_432000 1.400000
R12918 n1_m4_144000_432000 n1_m4_144000_436800 1.400000
R12919 n1_m4_144000_436800 n1_m4_144000_441600 1.400000
R12920 n1_m4_144000_441600 n1_m4_144000_446400 1.400000
R12921 n1_m4_144000_446400 n1_m4_144000_451200 1.400000
R12922 n1_m4_144000_451200 n1_m4_144000_456000 1.400000
R12923 n1_m4_144000_456000 n1_m4_144000_460800 1.400000
R12924 n1_m4_144000_460800 n1_m4_144000_465600 1.400000
R12925 n1_m4_144000_465600 n1_m4_144000_470400 1.400000
R12926 n1_m4_144000_470400 n1_m4_144000_475200 1.400000
R12927 n1_m4_144000_475200 n1_m4_144000_480000 1.400000
R12928 n1_m4_144000_480000 n1_m4_144000_484000 1.166667
R12929 n1_m4_144000_484800 n1_m4_144000_484000 0.233333
R12930 n1_m4_144000_484800 n1_m4_144000_489600 1.400000
R12931 n1_m4_144000_489600 n1_m4_144000_494400 1.400000
R12932 n1_m4_172000_0 n1_m4_172000_4000 1.166667
R12933 n1_m4_172000_4800 n1_m4_172000_4000 0.233333
R12934 n1_m4_172000_4800 n1_m4_172000_9600 1.400000
R12935 n1_m4_172000_9600 n1_m4_172000_14400 1.400000
R12936 n1_m4_172000_14400 n1_m4_172000_19200 1.400000
R12937 n1_m4_172000_19200 n1_m4_172000_24000 1.400000
R12938 n1_m4_172000_24000 n1_m4_172000_28800 1.400000
R12939 n1_m4_172000_28800 n1_m4_172000_33600 1.400000
R12940 n1_m4_172000_33600 n1_m4_172000_38400 1.400000
R12941 n1_m4_172000_38400 n1_m4_172000_43200 1.400000
R12942 n1_m4_172000_43200 n1_m4_172000_48000 1.400000
R12943 n1_m4_172000_48000 n1_m4_172000_52800 1.400000
R12944 n1_m4_172000_52800 n1_m4_172000_57600 1.400000
R12945 n1_m4_172000_57600 n1_m4_172000_62400 1.400000
R12946 n1_m4_172000_62400 n1_m4_172000_67200 1.400000
R12947 n1_m4_172000_67200 n1_m4_172000_72000 1.400000
R12948 n1_m4_172000_72000 n1_m4_172000_76800 1.400000
R12949 n1_m4_172000_76800 n1_m4_172000_81600 1.400000
R12950 n1_m4_172000_81600 n1_m4_172000_84000 0.700000
R12951 n1_m4_172000_86400 n1_m4_172000_84000 0.700000
R12952 n1_m4_172000_86400 n1_m4_172000_91200 1.400000
R12953 n1_m4_172000_91200 n1_m4_172000_96000 1.400000
R12954 n1_m4_172000_96000 n1_m4_172000_100800 1.400000
R12955 n1_m4_172000_100800 n1_m4_172000_105600 1.400000
R12956 n1_m4_172000_105600 n1_m4_172000_110400 1.400000
R12957 n1_m4_172000_110400 n1_m4_172000_115200 1.400000
R12958 n1_m4_172000_115200 n1_m4_172000_120000 1.400000
R12959 n1_m4_172000_120000 n1_m4_172000_124800 1.400000
R12960 n1_m4_172000_124800 n1_m4_172000_129600 1.400000
R12961 n1_m4_172000_129600 n1_m4_172000_134400 1.400000
R12962 n1_m4_172000_134400 n1_m4_172000_139200 1.400000
R12963 n1_m4_172000_139200 n1_m4_172000_144000 1.400000
R12964 n1_m4_172000_144000 n1_m4_172000_148800 1.400000
R12965 n1_m4_172000_148800 n1_m4_172000_153600 1.400000
R12966 n1_m4_172000_153600 n1_m4_172000_158400 1.400000
R12967 n1_m4_172000_158400 n1_m4_172000_163200 1.400000
R12968 n1_m4_172000_163200 n1_m4_172000_164000 0.233333
R12969 n1_m4_172000_168000 n1_m4_172000_164000 1.166667
R12970 n1_m4_172000_168000 n1_m4_172000_172800 1.400000
R12971 n1_m4_172000_172800 n1_m4_172000_177600 1.400000
R12972 n1_m4_172000_177600 n1_m4_172000_182400 1.400000
R12973 n1_m4_172000_182400 n1_m4_172000_187200 1.400000
R12974 n1_m4_172000_187200 n1_m4_172000_192000 1.400000
R12975 n1_m4_172000_192000 n1_m4_172000_196800 1.400000
R12976 n1_m4_172000_196800 n1_m4_172000_201600 1.400000
R12977 n1_m4_172000_201600 n1_m4_172000_206400 1.400000
R12978 n1_m4_172000_206400 n1_m4_172000_211200 1.400000
R12979 n1_m4_172000_211200 n1_m4_172000_216000 1.400000
R12980 n1_m4_172000_216000 n1_m4_172000_220800 1.400000
R12981 n1_m4_172000_220800 n1_m4_172000_225600 1.400000
R12982 n1_m4_172000_225600 n1_m4_172000_230400 1.400000
R12983 n1_m4_172000_230400 n1_m4_172000_235200 1.400000
R12984 n1_m4_172000_235200 n1_m4_172000_240000 1.400000
R12985 n1_m4_172000_240000 n1_m4_172000_244000 1.166667
R12986 n1_m4_172000_244800 n1_m4_172000_244000 0.233333
R12987 n1_m4_172000_244800 n1_m4_172000_249600 1.400000
R12988 n1_m4_172000_249600 n1_m4_172000_254400 1.400000
R12989 n1_m4_172000_254400 n1_m4_172000_259200 1.400000
R12990 n1_m4_172000_259200 n1_m4_172000_264000 1.400000
R12991 n1_m4_172000_264000 n1_m4_172000_268800 1.400000
R12992 n1_m4_172000_268800 n1_m4_172000_273600 1.400000
R12993 n1_m4_172000_273600 n1_m4_172000_278400 1.400000
R12994 n1_m4_172000_278400 n1_m4_172000_283200 1.400000
R12995 n1_m4_172000_283200 n1_m4_172000_288000 1.400000
R12996 n1_m4_172000_288000 n1_m4_172000_292800 1.400000
R12997 n1_m4_172000_292800 n1_m4_172000_297600 1.400000
R12998 n1_m4_172000_297600 n1_m4_172000_302400 1.400000
R12999 n1_m4_172000_302400 n1_m4_172000_307200 1.400000
R13000 n1_m4_172000_307200 n1_m4_172000_312000 1.400000
R13001 n1_m4_172000_312000 n1_m4_172000_316800 1.400000
R13002 n1_m4_172000_316800 n1_m4_172000_321600 1.400000
R13003 n1_m4_172000_321600 n1_m4_172000_324000 0.700000
R13004 n1_m4_172000_326400 n1_m4_172000_324000 0.700000
R13005 n1_m4_172000_326400 n1_m4_172000_331200 1.400000
R13006 n1_m4_172000_331200 n1_m4_172000_336000 1.400000
R13007 n1_m4_172000_336000 n1_m4_172000_340800 1.400000
R13008 n1_m4_172000_340800 n1_m4_172000_345600 1.400000
R13009 n1_m4_172000_345600 n1_m4_172000_350400 1.400000
R13010 n1_m4_172000_350400 n1_m4_172000_355200 1.400000
R13011 n1_m4_172000_355200 n1_m4_172000_360000 1.400000
R13012 n1_m4_172000_360000 n1_m4_172000_364800 1.400000
R13013 n1_m4_172000_364800 n1_m4_172000_369600 1.400000
R13014 n1_m4_172000_369600 n1_m4_172000_374400 1.400000
R13015 n1_m4_172000_374400 n1_m4_172000_379200 1.400000
R13016 n1_m4_172000_379200 n1_m4_172000_384000 1.400000
R13017 n1_m4_172000_384000 n1_m4_172000_388800 1.400000
R13018 n1_m4_172000_388800 n1_m4_172000_393600 1.400000
R13019 n1_m4_172000_393600 n1_m4_172000_398400 1.400000
R13020 n1_m4_172000_398400 n1_m4_172000_403200 1.400000
R13021 n1_m4_172000_403200 n1_m4_172000_404000 0.233333
R13022 n1_m4_172000_408000 n1_m4_172000_404000 1.166667
R13023 n1_m4_172000_408000 n1_m4_172000_412800 1.400000
R13024 n1_m4_172000_412800 n1_m4_172000_417600 1.400000
R13025 n1_m4_172000_417600 n1_m4_172000_422400 1.400000
R13026 n1_m4_172000_422400 n1_m4_172000_427200 1.400000
R13027 n1_m4_172000_427200 n1_m4_172000_432000 1.400000
R13028 n1_m4_172000_432000 n1_m4_172000_436800 1.400000
R13029 n1_m4_172000_436800 n1_m4_172000_441600 1.400000
R13030 n1_m4_172000_441600 n1_m4_172000_446400 1.400000
R13031 n1_m4_172000_446400 n1_m4_172000_451200 1.400000
R13032 n1_m4_172000_451200 n1_m4_172000_456000 1.400000
R13033 n1_m4_172000_456000 n1_m4_172000_460800 1.400000
R13034 n1_m4_172000_460800 n1_m4_172000_465600 1.400000
R13035 n1_m4_172000_465600 n1_m4_172000_470400 1.400000
R13036 n1_m4_172000_470400 n1_m4_172000_475200 1.400000
R13037 n1_m4_172000_475200 n1_m4_172000_480000 1.400000
R13038 n1_m4_172000_480000 n1_m4_172000_484000 1.166667
R13039 n1_m4_172000_484800 n1_m4_172000_484000 0.233333
R13040 n1_m4_172000_484800 n1_m4_172000_489600 1.400000
R13041 n1_m4_172000_489600 n1_m4_172000_494400 1.400000
R13042 n1_m4_200000_0 n1_m4_200000_4000 1.166667
R13043 n1_m4_200000_4800 n1_m4_200000_4000 0.233333
R13044 n1_m4_200000_4800 n1_m4_200000_9600 1.400000
R13045 n1_m4_200000_9600 n1_m4_200000_14400 1.400000
R13046 n1_m4_200000_14400 n1_m4_200000_19200 1.400000
R13047 n1_m4_200000_19200 n1_m4_200000_24000 1.400000
R13048 n1_m4_200000_24000 n1_m4_200000_28800 1.400000
R13049 n1_m4_200000_28800 n1_m4_200000_33600 1.400000
R13050 n1_m4_200000_33600 n1_m4_200000_38400 1.400000
R13051 n1_m4_200000_38400 n1_m4_200000_43200 1.400000
R13052 n1_m4_200000_43200 n1_m4_200000_48000 1.400000
R13053 n1_m4_200000_48000 n1_m4_200000_52800 1.400000
R13054 n1_m4_200000_52800 n1_m4_200000_57600 1.400000
R13055 n1_m4_200000_57600 n1_m4_200000_62400 1.400000
R13056 n1_m4_200000_62400 n1_m4_200000_67200 1.400000
R13057 n1_m4_200000_67200 n1_m4_200000_72000 1.400000
R13058 n1_m4_200000_72000 n1_m4_200000_76800 1.400000
R13059 n1_m4_200000_76800 n1_m4_200000_81600 1.400000
R13060 n1_m4_200000_81600 n1_m4_200000_84000 0.700000
R13061 n1_m4_200000_86400 n1_m4_200000_84000 0.700000
R13062 n1_m4_200000_86400 n1_m4_200000_91200 1.400000
R13063 n1_m4_200000_91200 n1_m4_200000_96000 1.400000
R13064 n1_m4_200000_96000 n1_m4_200000_100800 1.400000
R13065 n1_m4_200000_100800 n1_m4_200000_105600 1.400000
R13066 n1_m4_200000_105600 n1_m4_200000_110400 1.400000
R13067 n1_m4_200000_110400 n1_m4_200000_115200 1.400000
R13068 n1_m4_200000_115200 n1_m4_200000_120000 1.400000
R13069 n1_m4_200000_120000 n1_m4_200000_124800 1.400000
R13070 n1_m4_200000_124800 n1_m4_200000_129600 1.400000
R13071 n1_m4_200000_129600 n1_m4_200000_134400 1.400000
R13072 n1_m4_200000_134400 n1_m4_200000_139200 1.400000
R13073 n1_m4_200000_139200 n1_m4_200000_144000 1.400000
R13074 n1_m4_200000_144000 n1_m4_200000_148800 1.400000
R13075 n1_m4_200000_148800 n1_m4_200000_153600 1.400000
R13076 n1_m4_200000_153600 n1_m4_200000_158400 1.400000
R13077 n1_m4_200000_158400 n1_m4_200000_163200 1.400000
R13078 n1_m4_200000_163200 n1_m4_200000_164000 0.233333
R13079 n1_m4_200000_168000 n1_m4_200000_164000 1.166667
R13080 n1_m4_200000_168000 n1_m4_200000_172800 1.400000
R13081 n1_m4_200000_172800 n1_m4_200000_177600 1.400000
R13082 n1_m4_200000_177600 n1_m4_200000_182400 1.400000
R13083 n1_m4_200000_182400 n1_m4_200000_187200 1.400000
R13084 n1_m4_200000_187200 n1_m4_200000_192000 1.400000
R13085 n1_m4_200000_192000 n1_m4_200000_196800 1.400000
R13086 n1_m4_200000_196800 n1_m4_200000_201600 1.400000
R13087 n1_m4_200000_201600 n1_m4_200000_206400 1.400000
R13088 n1_m4_200000_206400 n1_m4_200000_211200 1.400000
R13089 n1_m4_200000_211200 n1_m4_200000_216000 1.400000
R13090 n1_m4_200000_216000 n1_m4_200000_220800 1.400000
R13091 n1_m4_200000_220800 n1_m4_200000_225600 1.400000
R13092 n1_m4_200000_225600 n1_m4_200000_230400 1.400000
R13093 n1_m4_200000_230400 n1_m4_200000_235200 1.400000
R13094 n1_m4_200000_235200 n1_m4_200000_240000 1.400000
R13095 n1_m4_200000_240000 n1_m4_200000_244000 1.166667
R13096 n1_m4_200000_244800 n1_m4_200000_244000 0.233333
R13097 n1_m4_200000_244800 n1_m4_200000_249600 1.400000
R13098 n1_m4_200000_249600 n1_m4_200000_254400 1.400000
R13099 n1_m4_200000_254400 n1_m4_200000_259200 1.400000
R13100 n1_m4_200000_259200 n1_m4_200000_264000 1.400000
R13101 n1_m4_200000_264000 n1_m4_200000_268800 1.400000
R13102 n1_m4_200000_268800 n1_m4_200000_273600 1.400000
R13103 n1_m4_200000_273600 n1_m4_200000_278400 1.400000
R13104 n1_m4_200000_278400 n1_m4_200000_283200 1.400000
R13105 n1_m4_200000_283200 n1_m4_200000_288000 1.400000
R13106 n1_m4_200000_288000 n1_m4_200000_292800 1.400000
R13107 n1_m4_200000_292800 n1_m4_200000_297600 1.400000
R13108 n1_m4_200000_297600 n1_m4_200000_302400 1.400000
R13109 n1_m4_200000_302400 n1_m4_200000_307200 1.400000
R13110 n1_m4_200000_307200 n1_m4_200000_312000 1.400000
R13111 n1_m4_200000_312000 n1_m4_200000_316800 1.400000
R13112 n1_m4_200000_316800 n1_m4_200000_321600 1.400000
R13113 n1_m4_200000_321600 n1_m4_200000_324000 0.700000
R13114 n1_m4_200000_326400 n1_m4_200000_324000 0.700000
R13115 n1_m4_200000_326400 n1_m4_200000_331200 1.400000
R13116 n1_m4_200000_331200 n1_m4_200000_336000 1.400000
R13117 n1_m4_200000_336000 n1_m4_200000_340800 1.400000
R13118 n1_m4_200000_340800 n1_m4_200000_345600 1.400000
R13119 n1_m4_200000_345600 n1_m4_200000_350400 1.400000
R13120 n1_m4_200000_350400 n1_m4_200000_355200 1.400000
R13121 n1_m4_200000_355200 n1_m4_200000_360000 1.400000
R13122 n1_m4_200000_360000 n1_m4_200000_364800 1.400000
R13123 n1_m4_200000_364800 n1_m4_200000_369600 1.400000
R13124 n1_m4_200000_369600 n1_m4_200000_374400 1.400000
R13125 n1_m4_200000_374400 n1_m4_200000_379200 1.400000
R13126 n1_m4_200000_379200 n1_m4_200000_384000 1.400000
R13127 n1_m4_200000_384000 n1_m4_200000_388800 1.400000
R13128 n1_m4_200000_388800 n1_m4_200000_393600 1.400000
R13129 n1_m4_200000_393600 n1_m4_200000_398400 1.400000
R13130 n1_m4_200000_398400 n1_m4_200000_403200 1.400000
R13131 n1_m4_200000_403200 n1_m4_200000_404000 0.233333
R13132 n1_m4_200000_408000 n1_m4_200000_404000 1.166667
R13133 n1_m4_200000_408000 n1_m4_200000_412800 1.400000
R13134 n1_m4_200000_412800 n1_m4_200000_417600 1.400000
R13135 n1_m4_200000_417600 n1_m4_200000_422400 1.400000
R13136 n1_m4_200000_422400 n1_m4_200000_427200 1.400000
R13137 n1_m4_200000_427200 n1_m4_200000_432000 1.400000
R13138 n1_m4_200000_432000 n1_m4_200000_436800 1.400000
R13139 n1_m4_200000_436800 n1_m4_200000_441600 1.400000
R13140 n1_m4_200000_441600 n1_m4_200000_446400 1.400000
R13141 n1_m4_200000_446400 n1_m4_200000_451200 1.400000
R13142 n1_m4_200000_451200 n1_m4_200000_456000 1.400000
R13143 n1_m4_200000_456000 n1_m4_200000_460800 1.400000
R13144 n1_m4_200000_460800 n1_m4_200000_465600 1.400000
R13145 n1_m4_200000_465600 n1_m4_200000_470400 1.400000
R13146 n1_m4_200000_470400 n1_m4_200000_475200 1.400000
R13147 n1_m4_200000_475200 n1_m4_200000_480000 1.400000
R13148 n1_m4_200000_480000 n1_m4_200000_484000 1.166667
R13149 n1_m4_200000_484800 n1_m4_200000_484000 0.233333
R13150 n1_m4_200000_484800 n1_m4_200000_489600 1.400000
R13151 n1_m4_200000_489600 n1_m4_200000_494400 1.400000
R13152 n1_m4_228000_196800 n1_m4_228000_201600 1.400000
R13153 n1_m4_228000_201600 n1_m4_228000_206400 1.400000
R13154 n1_m4_228000_206400 n1_m4_228000_211200 1.400000
R13155 n1_m4_228000_211200 n1_m4_228000_216000 1.400000
R13156 n1_m4_228000_216000 n1_m4_228000_220800 1.400000
R13157 n1_m4_228000_220800 n1_m4_228000_225600 1.400000
R13158 n1_m4_228000_225600 n1_m4_228000_230400 1.400000
R13159 n1_m4_228000_230400 n1_m4_228000_235200 1.400000
R13160 n1_m4_228000_235200 n1_m4_228000_240000 1.400000
R13161 n1_m4_228000_240000 n1_m4_228000_244000 1.166667
R13162 n1_m4_228000_244800 n1_m4_228000_244000 0.233333
R13163 n1_m4_228000_244800 n1_m4_228000_249600 1.400000
R13164 n1_m4_228000_249600 n1_m4_228000_254400 1.400000
R13165 n1_m4_228000_254400 n1_m4_228000_259200 1.400000
R13166 n1_m4_228000_259200 n1_m4_228000_264000 1.400000
R13167 n1_m4_228000_264000 n1_m4_228000_268800 1.400000
R13168 n1_m4_228000_268800 n1_m4_228000_273600 1.400000
R13169 n1_m4_228000_273600 n1_m4_228000_278400 1.400000
R13170 n1_m4_228000_278400 n1_m4_228000_283200 1.400000
R13171 n1_m4_228000_283200 n1_m4_228000_288000 1.400000
R13172 n1_m4_228000_288000 n1_m4_228000_292800 1.400000
R13173 n1_m4_228000_292800 n1_m4_228000_297600 1.400000
R13174 n1_m4_228000_297600 n1_m4_228000_302400 1.400000
R13175 n1_m4_228000_302400 n1_m4_228000_307200 1.400000
R13176 n1_m4_228000_307200 n1_m4_228000_312000 1.400000
R13177 n1_m4_228000_312000 n1_m4_228000_316800 1.400000
R13178 n1_m4_228000_316800 n1_m4_228000_321600 1.400000
R13179 n1_m4_228000_321600 n1_m4_228000_324000 0.700000
R13180 n1_m4_228000_326400 n1_m4_228000_324000 0.700000
R13181 n1_m4_228000_326400 n1_m4_228000_331200 1.400000
R13182 n1_m4_228000_331200 n1_m4_228000_336000 1.400000
R13183 n1_m4_228000_336000 n1_m4_228000_340800 1.400000
R13184 n1_m4_228000_340800 n1_m4_228000_345600 1.400000
R13185 n1_m4_228000_345600 n1_m4_228000_350400 1.400000
R13186 n1_m4_228000_350400 n1_m4_228000_355200 1.400000
R13187 n1_m4_228000_355200 n1_m4_228000_360000 1.400000
R13188 n1_m4_228000_360000 n1_m4_228000_364800 1.400000
R13189 n1_m4_228000_364800 n1_m4_228000_369600 1.400000
R13190 n1_m4_228000_369600 n1_m4_228000_374400 1.400000
R13191 n1_m4_228000_374400 n1_m4_228000_379200 1.400000
R13192 n1_m4_228000_379200 n1_m4_228000_384000 1.400000
R13193 n1_m4_228000_384000 n1_m4_228000_388800 1.400000
R13194 n1_m4_228000_388800 n1_m4_228000_393600 1.400000
R13195 n1_m4_228000_393600 n1_m4_228000_398400 1.400000
R13196 n1_m4_228000_398400 n1_m4_228000_403200 1.400000
R13197 n1_m4_228000_403200 n1_m4_228000_404000 0.233333
R13198 n1_m4_228000_408000 n1_m4_228000_404000 1.166667
R13199 n1_m4_228000_408000 n1_m4_228000_412800 1.400000
R13200 n1_m4_228000_412800 n1_m4_228000_417600 1.400000
R13201 n1_m4_228000_417600 n1_m4_228000_422400 1.400000
R13202 n1_m4_228000_422400 n1_m4_228000_427200 1.400000
R13203 n1_m4_228000_427200 n1_m4_228000_432000 1.400000
R13204 n1_m4_228000_432000 n1_m4_228000_436800 1.400000
R13205 n1_m4_228000_436800 n1_m4_228000_441600 1.400000
R13206 n1_m4_228000_441600 n1_m4_228000_446400 1.400000
R13207 n1_m4_228000_446400 n1_m4_228000_451200 1.400000
R13208 n1_m4_228000_451200 n1_m4_228000_456000 1.400000
R13209 n1_m4_228000_456000 n1_m4_228000_460800 1.400000
R13210 n1_m4_228000_460800 n1_m4_228000_465600 1.400000
R13211 n1_m4_228000_465600 n1_m4_228000_470400 1.400000
R13212 n1_m4_228000_470400 n1_m4_228000_475200 1.400000
R13213 n1_m4_228000_475200 n1_m4_228000_480000 1.400000
R13214 n1_m4_228000_480000 n1_m4_228000_484000 1.166667
R13215 n1_m4_228000_484800 n1_m4_228000_484000 0.233333
R13216 n1_m4_228000_484800 n1_m4_228000_489600 1.400000
R13217 n1_m4_228000_489600 n1_m4_228000_494400 1.400000
R13218 n1_m4_256000_196800 n1_m4_256000_201600 1.400000
R13219 n1_m4_256000_201600 n1_m4_256000_206400 1.400000
R13220 n1_m4_256000_206400 n1_m4_256000_211200 1.400000
R13221 n1_m4_256000_211200 n1_m4_256000_216000 1.400000
R13222 n1_m4_256000_216000 n1_m4_256000_220800 1.400000
R13223 n1_m4_256000_220800 n1_m4_256000_225600 1.400000
R13224 n1_m4_256000_225600 n1_m4_256000_230400 1.400000
R13225 n1_m4_256000_230400 n1_m4_256000_235200 1.400000
R13226 n1_m4_256000_235200 n1_m4_256000_240000 1.400000
R13227 n1_m4_256000_240000 n1_m4_256000_244000 1.166667
R13228 n1_m4_256000_244800 n1_m4_256000_244000 0.233333
R13229 n1_m4_256000_244800 n1_m4_256000_249600 1.400000
R13230 n1_m4_256000_249600 n1_m4_256000_254400 1.400000
R13231 n1_m4_256000_254400 n1_m4_256000_259200 1.400000
R13232 n1_m4_256000_259200 n1_m4_256000_264000 1.400000
R13233 n1_m4_256000_264000 n1_m4_256000_268800 1.400000
R13234 n1_m4_256000_268800 n1_m4_256000_273600 1.400000
R13235 n1_m4_256000_273600 n1_m4_256000_278400 1.400000
R13236 n1_m4_256000_278400 n1_m4_256000_283200 1.400000
R13237 n1_m4_256000_283200 n1_m4_256000_288000 1.400000
R13238 n1_m4_256000_288000 n1_m4_256000_292800 1.400000
R13239 n1_m4_256000_292800 n1_m4_256000_297600 1.400000
R13240 n1_m4_256000_297600 n1_m4_256000_302400 1.400000
R13241 n1_m4_256000_302400 n1_m4_256000_307200 1.400000
R13242 n1_m4_256000_307200 n1_m4_256000_312000 1.400000
R13243 n1_m4_256000_312000 n1_m4_256000_316800 1.400000
R13244 n1_m4_256000_316800 n1_m4_256000_321600 1.400000
R13245 n1_m4_256000_321600 n1_m4_256000_324000 0.700000
R13246 n1_m4_256000_326400 n1_m4_256000_324000 0.700000
R13247 n1_m4_256000_326400 n1_m4_256000_331200 1.400000
R13248 n1_m4_256000_331200 n1_m4_256000_336000 1.400000
R13249 n1_m4_256000_336000 n1_m4_256000_340800 1.400000
R13250 n1_m4_256000_340800 n1_m4_256000_345600 1.400000
R13251 n1_m4_256000_345600 n1_m4_256000_350400 1.400000
R13252 n1_m4_256000_350400 n1_m4_256000_355200 1.400000
R13253 n1_m4_256000_355200 n1_m4_256000_360000 1.400000
R13254 n1_m4_256000_360000 n1_m4_256000_364800 1.400000
R13255 n1_m4_256000_364800 n1_m4_256000_369600 1.400000
R13256 n1_m4_256000_369600 n1_m4_256000_374400 1.400000
R13257 n1_m4_256000_374400 n1_m4_256000_379200 1.400000
R13258 n1_m4_256000_379200 n1_m4_256000_384000 1.400000
R13259 n1_m4_256000_384000 n1_m4_256000_388800 1.400000
R13260 n1_m4_256000_388800 n1_m4_256000_393600 1.400000
R13261 n1_m4_256000_393600 n1_m4_256000_398400 1.400000
R13262 n1_m4_256000_398400 n1_m4_256000_403200 1.400000
R13263 n1_m4_256000_403200 n1_m4_256000_404000 0.233333
R13264 n1_m4_256000_408000 n1_m4_256000_404000 1.166667
R13265 n1_m4_256000_408000 n1_m4_256000_412800 1.400000
R13266 n1_m4_256000_412800 n1_m4_256000_417600 1.400000
R13267 n1_m4_256000_417600 n1_m4_256000_422400 1.400000
R13268 n1_m4_256000_422400 n1_m4_256000_427200 1.400000
R13269 n1_m4_256000_427200 n1_m4_256000_432000 1.400000
R13270 n1_m4_256000_432000 n1_m4_256000_436800 1.400000
R13271 n1_m4_256000_436800 n1_m4_256000_441600 1.400000
R13272 n1_m4_256000_441600 n1_m4_256000_446400 1.400000
R13273 n1_m4_256000_446400 n1_m4_256000_451200 1.400000
R13274 n1_m4_256000_451200 n1_m4_256000_456000 1.400000
R13275 n1_m4_256000_456000 n1_m4_256000_460800 1.400000
R13276 n1_m4_256000_460800 n1_m4_256000_465600 1.400000
R13277 n1_m4_256000_465600 n1_m4_256000_470400 1.400000
R13278 n1_m4_256000_470400 n1_m4_256000_475200 1.400000
R13279 n1_m4_256000_475200 n1_m4_256000_480000 1.400000
R13280 n1_m4_256000_480000 n1_m4_256000_484000 1.166667
R13281 n1_m4_256000_484800 n1_m4_256000_484000 0.233333
R13282 n1_m4_256000_484800 n1_m4_256000_489600 1.400000
R13283 n1_m4_256000_489600 n1_m4_256000_494400 1.400000
R13284 n1_m4_284000_196800 n1_m4_284000_201600 1.400000
R13285 n1_m4_284000_201600 n1_m4_284000_206400 1.400000
R13286 n1_m4_284000_206400 n1_m4_284000_211200 1.400000
R13287 n1_m4_284000_211200 n1_m4_284000_216000 1.400000
R13288 n1_m4_284000_216000 n1_m4_284000_220800 1.400000
R13289 n1_m4_284000_220800 n1_m4_284000_225600 1.400000
R13290 n1_m4_284000_225600 n1_m4_284000_230400 1.400000
R13291 n1_m4_284000_230400 n1_m4_284000_235200 1.400000
R13292 n1_m4_284000_235200 n1_m4_284000_240000 1.400000
R13293 n1_m4_284000_240000 n1_m4_284000_244000 1.166667
R13294 n1_m4_284000_244800 n1_m4_284000_244000 0.233333
R13295 n1_m4_284000_244800 n1_m4_284000_249600 1.400000
R13296 n1_m4_284000_249600 n1_m4_284000_254400 1.400000
R13297 n1_m4_284000_254400 n1_m4_284000_259200 1.400000
R13298 n1_m4_284000_259200 n1_m4_284000_264000 1.400000
R13299 n1_m4_284000_264000 n1_m4_284000_268800 1.400000
R13300 n1_m4_284000_268800 n1_m4_284000_273600 1.400000
R13301 n1_m4_284000_273600 n1_m4_284000_278400 1.400000
R13302 n1_m4_284000_278400 n1_m4_284000_283200 1.400000
R13303 n1_m4_284000_283200 n1_m4_284000_288000 1.400000
R13304 n1_m4_284000_288000 n1_m4_284000_292800 1.400000
R13305 n1_m4_284000_292800 n1_m4_284000_297600 1.400000
R13306 n1_m4_284000_297600 n1_m4_284000_302400 1.400000
R13307 n1_m4_284000_302400 n1_m4_284000_307200 1.400000
R13308 n1_m4_284000_307200 n1_m4_284000_312000 1.400000
R13309 n1_m4_284000_312000 n1_m4_284000_316800 1.400000
R13310 n1_m4_284000_316800 n1_m4_284000_321600 1.400000
R13311 n1_m4_284000_321600 n1_m4_284000_324000 0.700000
R13312 n1_m4_284000_326400 n1_m4_284000_324000 0.700000
R13313 n1_m4_284000_326400 n1_m4_284000_331200 1.400000
R13314 n1_m4_284000_331200 n1_m4_284000_336000 1.400000
R13315 n1_m4_284000_336000 n1_m4_284000_340800 1.400000
R13316 n1_m4_284000_340800 n1_m4_284000_345600 1.400000
R13317 n1_m4_284000_345600 n1_m4_284000_350400 1.400000
R13318 n1_m4_284000_350400 n1_m4_284000_355200 1.400000
R13319 n1_m4_284000_355200 n1_m4_284000_360000 1.400000
R13320 n1_m4_284000_360000 n1_m4_284000_364800 1.400000
R13321 n1_m4_284000_364800 n1_m4_284000_369600 1.400000
R13322 n1_m4_284000_369600 n1_m4_284000_374400 1.400000
R13323 n1_m4_284000_374400 n1_m4_284000_379200 1.400000
R13324 n1_m4_284000_379200 n1_m4_284000_384000 1.400000
R13325 n1_m4_284000_384000 n1_m4_284000_388800 1.400000
R13326 n1_m4_284000_388800 n1_m4_284000_393600 1.400000
R13327 n1_m4_284000_393600 n1_m4_284000_398400 1.400000
R13328 n1_m4_284000_398400 n1_m4_284000_403200 1.400000
R13329 n1_m4_284000_403200 n1_m4_284000_404000 0.233333
R13330 n1_m4_284000_408000 n1_m4_284000_404000 1.166667
R13331 n1_m4_284000_408000 n1_m4_284000_412800 1.400000
R13332 n1_m4_284000_412800 n1_m4_284000_417600 1.400000
R13333 n1_m4_284000_417600 n1_m4_284000_422400 1.400000
R13334 n1_m4_284000_422400 n1_m4_284000_427200 1.400000
R13335 n1_m4_284000_427200 n1_m4_284000_432000 1.400000
R13336 n1_m4_284000_432000 n1_m4_284000_436800 1.400000
R13337 n1_m4_284000_436800 n1_m4_284000_441600 1.400000
R13338 n1_m4_284000_441600 n1_m4_284000_446400 1.400000
R13339 n1_m4_284000_446400 n1_m4_284000_451200 1.400000
R13340 n1_m4_284000_451200 n1_m4_284000_456000 1.400000
R13341 n1_m4_284000_456000 n1_m4_284000_460800 1.400000
R13342 n1_m4_284000_460800 n1_m4_284000_465600 1.400000
R13343 n1_m4_284000_465600 n1_m4_284000_470400 1.400000
R13344 n1_m4_284000_470400 n1_m4_284000_475200 1.400000
R13345 n1_m4_284000_475200 n1_m4_284000_480000 1.400000
R13346 n1_m4_284000_480000 n1_m4_284000_484000 1.166667
R13347 n1_m4_284000_484800 n1_m4_284000_484000 0.233333
R13348 n1_m4_284000_484800 n1_m4_284000_489600 1.400000
R13349 n1_m4_284000_489600 n1_m4_284000_494400 1.400000
R13350 n1_m4_312000_0 n1_m4_312000_4000 1.166667
R13351 n1_m4_312000_4800 n1_m4_312000_4000 0.233333
R13352 n1_m4_312000_4800 n1_m4_312000_9600 1.400000
R13353 n1_m4_312000_9600 n1_m4_312000_14400 1.400000
R13354 n1_m4_312000_14400 n1_m4_312000_19200 1.400000
R13355 n1_m4_312000_19200 n1_m4_312000_24000 1.400000
R13356 n1_m4_312000_24000 n1_m4_312000_28800 1.400000
R13357 n1_m4_312000_28800 n1_m4_312000_33600 1.400000
R13358 n1_m4_312000_33600 n1_m4_312000_38400 1.400000
R13359 n1_m4_312000_38400 n1_m4_312000_43200 1.400000
R13360 n1_m4_312000_43200 n1_m4_312000_48000 1.400000
R13361 n1_m4_312000_48000 n1_m4_312000_52800 1.400000
R13362 n1_m4_312000_52800 n1_m4_312000_57600 1.400000
R13363 n1_m4_312000_57600 n1_m4_312000_62400 1.400000
R13364 n1_m4_312000_62400 n1_m4_312000_67200 1.400000
R13365 n1_m4_312000_67200 n1_m4_312000_72000 1.400000
R13366 n1_m4_312000_72000 n1_m4_312000_76800 1.400000
R13367 n1_m4_312000_76800 n1_m4_312000_81600 1.400000
R13368 n1_m4_312000_81600 n1_m4_312000_84000 0.700000
R13369 n1_m4_312000_86400 n1_m4_312000_84000 0.700000
R13370 n1_m4_312000_86400 n1_m4_312000_91200 1.400000
R13371 n1_m4_312000_91200 n1_m4_312000_96000 1.400000
R13372 n1_m4_312000_96000 n1_m4_312000_100800 1.400000
R13373 n1_m4_312000_100800 n1_m4_312000_105600 1.400000
R13374 n1_m4_312000_105600 n1_m4_312000_110400 1.400000
R13375 n1_m4_312000_110400 n1_m4_312000_115200 1.400000
R13376 n1_m4_312000_115200 n1_m4_312000_120000 1.400000
R13377 n1_m4_312000_120000 n1_m4_312000_124800 1.400000
R13378 n1_m4_312000_124800 n1_m4_312000_129600 1.400000
R13379 n1_m4_312000_129600 n1_m4_312000_134400 1.400000
R13380 n1_m4_312000_134400 n1_m4_312000_139200 1.400000
R13381 n1_m4_312000_139200 n1_m4_312000_144000 1.400000
R13382 n1_m4_312000_144000 n1_m4_312000_148800 1.400000
R13383 n1_m4_312000_148800 n1_m4_312000_153600 1.400000
R13384 n1_m4_312000_153600 n1_m4_312000_158400 1.400000
R13385 n1_m4_312000_158400 n1_m4_312000_163200 1.400000
R13386 n1_m4_312000_163200 n1_m4_312000_164000 0.233333
R13387 n1_m4_312000_168000 n1_m4_312000_164000 1.166667
R13388 n1_m4_312000_168000 n1_m4_312000_172800 1.400000
R13389 n1_m4_312000_172800 n1_m4_312000_177600 1.400000
R13390 n1_m4_312000_177600 n1_m4_312000_182400 1.400000
R13391 n1_m4_312000_182400 n1_m4_312000_187200 1.400000
R13392 n1_m4_312000_187200 n1_m4_312000_192000 1.400000
R13393 n1_m4_312000_192000 n1_m4_312000_196800 1.400000
R13394 n1_m4_312000_196800 n1_m4_312000_201600 1.400000
R13395 n1_m4_312000_201600 n1_m4_312000_206400 1.400000
R13396 n1_m4_312000_206400 n1_m4_312000_211200 1.400000
R13397 n1_m4_312000_211200 n1_m4_312000_216000 1.400000
R13398 n1_m4_312000_216000 n1_m4_312000_220800 1.400000
R13399 n1_m4_312000_220800 n1_m4_312000_225600 1.400000
R13400 n1_m4_312000_225600 n1_m4_312000_230400 1.400000
R13401 n1_m4_312000_230400 n1_m4_312000_235200 1.400000
R13402 n1_m4_312000_235200 n1_m4_312000_240000 1.400000
R13403 n1_m4_312000_240000 n1_m4_312000_244000 1.166667
R13404 n1_m4_312000_244800 n1_m4_312000_244000 0.233333
R13405 n1_m4_312000_244800 n1_m4_312000_249600 1.400000
R13406 n1_m4_312000_249600 n1_m4_312000_254400 1.400000
R13407 n1_m4_312000_254400 n1_m4_312000_259200 1.400000
R13408 n1_m4_312000_259200 n1_m4_312000_264000 1.400000
R13409 n1_m4_312000_264000 n1_m4_312000_268800 1.400000
R13410 n1_m4_312000_268800 n1_m4_312000_273600 1.400000
R13411 n1_m4_312000_273600 n1_m4_312000_278400 1.400000
R13412 n1_m4_312000_278400 n1_m4_312000_283200 1.400000
R13413 n1_m4_312000_283200 n1_m4_312000_288000 1.400000
R13414 n1_m4_312000_288000 n1_m4_312000_292800 1.400000
R13415 n1_m4_312000_292800 n1_m4_312000_297600 1.400000
R13416 n1_m4_312000_297600 n1_m4_312000_302400 1.400000
R13417 n1_m4_312000_302400 n1_m4_312000_307200 1.400000
R13418 n1_m4_312000_307200 n1_m4_312000_312000 1.400000
R13419 n1_m4_312000_312000 n1_m4_312000_316800 1.400000
R13420 n1_m4_312000_316800 n1_m4_312000_321600 1.400000
R13421 n1_m4_312000_321600 n1_m4_312000_324000 0.700000
R13422 n1_m4_312000_326400 n1_m4_312000_324000 0.700000
R13423 n1_m4_312000_326400 n1_m4_312000_331200 1.400000
R13424 n1_m4_312000_331200 n1_m4_312000_336000 1.400000
R13425 n1_m4_312000_336000 n1_m4_312000_340800 1.400000
R13426 n1_m4_312000_340800 n1_m4_312000_345600 1.400000
R13427 n1_m4_312000_345600 n1_m4_312000_350400 1.400000
R13428 n1_m4_312000_350400 n1_m4_312000_355200 1.400000
R13429 n1_m4_312000_355200 n1_m4_312000_360000 1.400000
R13430 n1_m4_312000_360000 n1_m4_312000_364800 1.400000
R13431 n1_m4_312000_364800 n1_m4_312000_369600 1.400000
R13432 n1_m4_312000_369600 n1_m4_312000_374400 1.400000
R13433 n1_m4_312000_374400 n1_m4_312000_379200 1.400000
R13434 n1_m4_312000_379200 n1_m4_312000_384000 1.400000
R13435 n1_m4_312000_384000 n1_m4_312000_388800 1.400000
R13436 n1_m4_312000_388800 n1_m4_312000_393600 1.400000
R13437 n1_m4_312000_393600 n1_m4_312000_398400 1.400000
R13438 n1_m4_312000_398400 n1_m4_312000_403200 1.400000
R13439 n1_m4_312000_403200 n1_m4_312000_404000 0.233333
R13440 n1_m4_312000_408000 n1_m4_312000_404000 1.166667
R13441 n1_m4_312000_408000 n1_m4_312000_412800 1.400000
R13442 n1_m4_312000_412800 n1_m4_312000_417600 1.400000
R13443 n1_m4_312000_417600 n1_m4_312000_422400 1.400000
R13444 n1_m4_312000_422400 n1_m4_312000_427200 1.400000
R13445 n1_m4_312000_427200 n1_m4_312000_432000 1.400000
R13446 n1_m4_312000_432000 n1_m4_312000_436800 1.400000
R13447 n1_m4_312000_436800 n1_m4_312000_441600 1.400000
R13448 n1_m4_312000_441600 n1_m4_312000_446400 1.400000
R13449 n1_m4_312000_446400 n1_m4_312000_451200 1.400000
R13450 n1_m4_312000_451200 n1_m4_312000_456000 1.400000
R13451 n1_m4_312000_456000 n1_m4_312000_460800 1.400000
R13452 n1_m4_312000_460800 n1_m4_312000_465600 1.400000
R13453 n1_m4_312000_465600 n1_m4_312000_470400 1.400000
R13454 n1_m4_312000_470400 n1_m4_312000_475200 1.400000
R13455 n1_m4_312000_475200 n1_m4_312000_480000 1.400000
R13456 n1_m4_312000_480000 n1_m4_312000_484000 1.166667
R13457 n1_m4_312000_484800 n1_m4_312000_484000 0.233333
R13458 n1_m4_312000_484800 n1_m4_312000_489600 1.400000
R13459 n1_m4_312000_489600 n1_m4_312000_494400 1.400000
R13460 n1_m4_340000_196800 n1_m4_340000_201600 1.400000
R13461 n1_m4_340000_201600 n1_m4_340000_206400 1.400000
R13462 n1_m4_340000_206400 n1_m4_340000_211200 1.400000
R13463 n1_m4_340000_211200 n1_m4_340000_216000 1.400000
R13464 n1_m4_340000_216000 n1_m4_340000_220800 1.400000
R13465 n1_m4_340000_220800 n1_m4_340000_225600 1.400000
R13466 n1_m4_340000_225600 n1_m4_340000_230400 1.400000
R13467 n1_m4_340000_230400 n1_m4_340000_235200 1.400000
R13468 n1_m4_340000_235200 n1_m4_340000_240000 1.400000
R13469 n1_m4_340000_240000 n1_m4_340000_244000 1.166667
R13470 n1_m4_340000_244800 n1_m4_340000_244000 0.233333
R13471 n1_m4_340000_244800 n1_m4_340000_249600 1.400000
R13472 n1_m4_340000_249600 n1_m4_340000_254400 1.400000
R13473 n1_m4_340000_254400 n1_m4_340000_259200 1.400000
R13474 n1_m4_340000_259200 n1_m4_340000_264000 1.400000
R13475 n1_m4_340000_264000 n1_m4_340000_268800 1.400000
R13476 n1_m4_340000_268800 n1_m4_340000_273600 1.400000
R13477 n1_m4_340000_273600 n1_m4_340000_278400 1.400000
R13478 n1_m4_340000_278400 n1_m4_340000_283200 1.400000
R13479 n1_m4_340000_283200 n1_m4_340000_288000 1.400000
R13480 n1_m4_340000_288000 n1_m4_340000_292800 1.400000
R13481 n1_m4_340000_292800 n1_m4_340000_297600 1.400000
R13482 n1_m4_340000_297600 n1_m4_340000_302400 1.400000
R13483 n1_m4_340000_302400 n1_m4_340000_307200 1.400000
R13484 n1_m4_340000_307200 n1_m4_340000_312000 1.400000
R13485 n1_m4_340000_312000 n1_m4_340000_316800 1.400000
R13486 n1_m4_340000_316800 n1_m4_340000_321600 1.400000
R13487 n1_m4_340000_321600 n1_m4_340000_324000 0.700000
R13488 n1_m4_340000_326400 n1_m4_340000_324000 0.700000
R13489 n1_m4_340000_326400 n1_m4_340000_331200 1.400000
R13490 n1_m4_340000_331200 n1_m4_340000_336000 1.400000
R13491 n1_m4_340000_336000 n1_m4_340000_340800 1.400000
R13492 n1_m4_340000_340800 n1_m4_340000_345600 1.400000
R13493 n1_m4_340000_345600 n1_m4_340000_350400 1.400000
R13494 n1_m4_340000_350400 n1_m4_340000_355200 1.400000
R13495 n1_m4_340000_355200 n1_m4_340000_360000 1.400000
R13496 n1_m4_340000_360000 n1_m4_340000_364800 1.400000
R13497 n1_m4_340000_364800 n1_m4_340000_369600 1.400000
R13498 n1_m4_340000_369600 n1_m4_340000_374400 1.400000
R13499 n1_m4_340000_374400 n1_m4_340000_379200 1.400000
R13500 n1_m4_340000_379200 n1_m4_340000_384000 1.400000
R13501 n1_m4_340000_384000 n1_m4_340000_388800 1.400000
R13502 n1_m4_340000_388800 n1_m4_340000_393600 1.400000
R13503 n1_m4_340000_393600 n1_m4_340000_398400 1.400000
R13504 n1_m4_340000_398400 n1_m4_340000_403200 1.400000
R13505 n1_m4_340000_403200 n1_m4_340000_404000 0.233333
R13506 n1_m4_340000_408000 n1_m4_340000_404000 1.166667
R13507 n1_m4_340000_408000 n1_m4_340000_412800 1.400000
R13508 n1_m4_340000_412800 n1_m4_340000_417600 1.400000
R13509 n1_m4_340000_417600 n1_m4_340000_422400 1.400000
R13510 n1_m4_340000_422400 n1_m4_340000_427200 1.400000
R13511 n1_m4_340000_427200 n1_m4_340000_432000 1.400000
R13512 n1_m4_340000_432000 n1_m4_340000_436800 1.400000
R13513 n1_m4_340000_436800 n1_m4_340000_441600 1.400000
R13514 n1_m4_340000_441600 n1_m4_340000_446400 1.400000
R13515 n1_m4_340000_446400 n1_m4_340000_451200 1.400000
R13516 n1_m4_340000_451200 n1_m4_340000_456000 1.400000
R13517 n1_m4_340000_456000 n1_m4_340000_460800 1.400000
R13518 n1_m4_340000_460800 n1_m4_340000_465600 1.400000
R13519 n1_m4_340000_465600 n1_m4_340000_470400 1.400000
R13520 n1_m4_340000_470400 n1_m4_340000_475200 1.400000
R13521 n1_m4_340000_475200 n1_m4_340000_480000 1.400000
R13522 n1_m4_340000_480000 n1_m4_340000_484000 1.166667
R13523 n1_m4_340000_484800 n1_m4_340000_484000 0.233333
R13524 n1_m4_340000_484800 n1_m4_340000_489600 1.400000
R13525 n1_m4_340000_489600 n1_m4_340000_494400 1.400000
R13526 n1_m4_368000_196800 n1_m4_368000_201600 1.400000
R13527 n1_m4_368000_201600 n1_m4_368000_206400 1.400000
R13528 n1_m4_368000_206400 n1_m4_368000_211200 1.400000
R13529 n1_m4_368000_211200 n1_m4_368000_216000 1.400000
R13530 n1_m4_368000_216000 n1_m4_368000_220800 1.400000
R13531 n1_m4_368000_220800 n1_m4_368000_225600 1.400000
R13532 n1_m4_368000_225600 n1_m4_368000_230400 1.400000
R13533 n1_m4_368000_230400 n1_m4_368000_235200 1.400000
R13534 n1_m4_368000_235200 n1_m4_368000_240000 1.400000
R13535 n1_m4_368000_240000 n1_m4_368000_244000 1.166667
R13536 n1_m4_368000_244800 n1_m4_368000_244000 0.233333
R13537 n1_m4_368000_244800 n1_m4_368000_249600 1.400000
R13538 n1_m4_368000_249600 n1_m4_368000_254400 1.400000
R13539 n1_m4_368000_254400 n1_m4_368000_259200 1.400000
R13540 n1_m4_368000_259200 n1_m4_368000_264000 1.400000
R13541 n1_m4_368000_264000 n1_m4_368000_268800 1.400000
R13542 n1_m4_368000_268800 n1_m4_368000_273600 1.400000
R13543 n1_m4_368000_273600 n1_m4_368000_278400 1.400000
R13544 n1_m4_368000_278400 n1_m4_368000_283200 1.400000
R13545 n1_m4_368000_283200 n1_m4_368000_288000 1.400000
R13546 n1_m4_368000_288000 n1_m4_368000_292800 1.400000
R13547 n1_m4_368000_292800 n1_m4_368000_297600 1.400000
R13548 n1_m4_368000_297600 n1_m4_368000_302400 1.400000
R13549 n1_m4_368000_302400 n1_m4_368000_307200 1.400000
R13550 n1_m4_368000_307200 n1_m4_368000_312000 1.400000
R13551 n1_m4_368000_312000 n1_m4_368000_316800 1.400000
R13552 n1_m4_368000_316800 n1_m4_368000_321600 1.400000
R13553 n1_m4_368000_321600 n1_m4_368000_324000 0.700000
R13554 n1_m4_368000_326400 n1_m4_368000_324000 0.700000
R13555 n1_m4_368000_326400 n1_m4_368000_331200 1.400000
R13556 n1_m4_368000_331200 n1_m4_368000_336000 1.400000
R13557 n1_m4_368000_336000 n1_m4_368000_340800 1.400000
R13558 n1_m4_368000_340800 n1_m4_368000_345600 1.400000
R13559 n1_m4_368000_345600 n1_m4_368000_350400 1.400000
R13560 n1_m4_368000_350400 n1_m4_368000_355200 1.400000
R13561 n1_m4_368000_355200 n1_m4_368000_360000 1.400000
R13562 n1_m4_368000_360000 n1_m4_368000_364800 1.400000
R13563 n1_m4_368000_364800 n1_m4_368000_369600 1.400000
R13564 n1_m4_368000_369600 n1_m4_368000_374400 1.400000
R13565 n1_m4_368000_374400 n1_m4_368000_379200 1.400000
R13566 n1_m4_368000_379200 n1_m4_368000_384000 1.400000
R13567 n1_m4_368000_384000 n1_m4_368000_388800 1.400000
R13568 n1_m4_368000_388800 n1_m4_368000_393600 1.400000
R13569 n1_m4_368000_393600 n1_m4_368000_398400 1.400000
R13570 n1_m4_368000_398400 n1_m4_368000_403200 1.400000
R13571 n1_m4_368000_403200 n1_m4_368000_404000 0.233333
R13572 n1_m4_368000_408000 n1_m4_368000_404000 1.166667
R13573 n1_m4_368000_408000 n1_m4_368000_412800 1.400000
R13574 n1_m4_368000_412800 n1_m4_368000_417600 1.400000
R13575 n1_m4_368000_417600 n1_m4_368000_422400 1.400000
R13576 n1_m4_368000_422400 n1_m4_368000_427200 1.400000
R13577 n1_m4_368000_427200 n1_m4_368000_432000 1.400000
R13578 n1_m4_368000_432000 n1_m4_368000_436800 1.400000
R13579 n1_m4_368000_436800 n1_m4_368000_441600 1.400000
R13580 n1_m4_368000_441600 n1_m4_368000_446400 1.400000
R13581 n1_m4_368000_446400 n1_m4_368000_451200 1.400000
R13582 n1_m4_368000_451200 n1_m4_368000_456000 1.400000
R13583 n1_m4_368000_456000 n1_m4_368000_460800 1.400000
R13584 n1_m4_368000_460800 n1_m4_368000_465600 1.400000
R13585 n1_m4_368000_465600 n1_m4_368000_470400 1.400000
R13586 n1_m4_368000_470400 n1_m4_368000_475200 1.400000
R13587 n1_m4_368000_475200 n1_m4_368000_480000 1.400000
R13588 n1_m4_368000_480000 n1_m4_368000_484000 1.166667
R13589 n1_m4_368000_484800 n1_m4_368000_484000 0.233333
R13590 n1_m4_368000_484800 n1_m4_368000_489600 1.400000
R13591 n1_m4_368000_489600 n1_m4_368000_494400 1.400000
R13592 n1_m4_396000_196800 n1_m4_396000_201600 1.400000
R13593 n1_m4_396000_201600 n1_m4_396000_206400 1.400000
R13594 n1_m4_396000_206400 n1_m4_396000_211200 1.400000
R13595 n1_m4_396000_211200 n1_m4_396000_216000 1.400000
R13596 n1_m4_396000_216000 n1_m4_396000_220800 1.400000
R13597 n1_m4_396000_220800 n1_m4_396000_225600 1.400000
R13598 n1_m4_396000_225600 n1_m4_396000_230400 1.400000
R13599 n1_m4_396000_230400 n1_m4_396000_235200 1.400000
R13600 n1_m4_396000_235200 n1_m4_396000_240000 1.400000
R13601 n1_m4_396000_240000 n1_m4_396000_244000 1.166667
R13602 n1_m4_396000_244800 n1_m4_396000_244000 0.233333
R13603 n1_m4_396000_244800 n1_m4_396000_249600 1.400000
R13604 n1_m4_396000_249600 n1_m4_396000_254400 1.400000
R13605 n1_m4_396000_254400 n1_m4_396000_259200 1.400000
R13606 n1_m4_396000_259200 n1_m4_396000_264000 1.400000
R13607 n1_m4_396000_264000 n1_m4_396000_268800 1.400000
R13608 n1_m4_396000_268800 n1_m4_396000_273600 1.400000
R13609 n1_m4_396000_273600 n1_m4_396000_278400 1.400000
R13610 n1_m4_396000_278400 n1_m4_396000_283200 1.400000
R13611 n1_m4_396000_283200 n1_m4_396000_288000 1.400000
R13612 n1_m4_396000_288000 n1_m4_396000_292800 1.400000
R13613 n1_m4_396000_292800 n1_m4_396000_297600 1.400000
R13614 n1_m4_396000_297600 n1_m4_396000_302400 1.400000
R13615 n1_m4_396000_302400 n1_m4_396000_307200 1.400000
R13616 n1_m4_396000_307200 n1_m4_396000_312000 1.400000
R13617 n1_m4_396000_312000 n1_m4_396000_316800 1.400000
R13618 n1_m4_396000_316800 n1_m4_396000_321600 1.400000
R13619 n1_m4_396000_321600 n1_m4_396000_324000 0.700000
R13620 n1_m4_396000_326400 n1_m4_396000_324000 0.700000
R13621 n1_m4_396000_326400 n1_m4_396000_331200 1.400000
R13622 n1_m4_396000_331200 n1_m4_396000_336000 1.400000
R13623 n1_m4_396000_336000 n1_m4_396000_340800 1.400000
R13624 n1_m4_396000_340800 n1_m4_396000_345600 1.400000
R13625 n1_m4_396000_345600 n1_m4_396000_350400 1.400000
R13626 n1_m4_396000_350400 n1_m4_396000_355200 1.400000
R13627 n1_m4_396000_355200 n1_m4_396000_360000 1.400000
R13628 n1_m4_396000_360000 n1_m4_396000_364800 1.400000
R13629 n1_m4_396000_364800 n1_m4_396000_369600 1.400000
R13630 n1_m4_396000_369600 n1_m4_396000_374400 1.400000
R13631 n1_m4_396000_374400 n1_m4_396000_379200 1.400000
R13632 n1_m4_396000_379200 n1_m4_396000_384000 1.400000
R13633 n1_m4_396000_384000 n1_m4_396000_388800 1.400000
R13634 n1_m4_396000_388800 n1_m4_396000_393600 1.400000
R13635 n1_m4_396000_393600 n1_m4_396000_398400 1.400000
R13636 n1_m4_396000_398400 n1_m4_396000_403200 1.400000
R13637 n1_m4_396000_403200 n1_m4_396000_404000 0.233333
R13638 n1_m4_396000_408000 n1_m4_396000_404000 1.166667
R13639 n1_m4_396000_408000 n1_m4_396000_412800 1.400000
R13640 n1_m4_396000_412800 n1_m4_396000_417600 1.400000
R13641 n1_m4_396000_417600 n1_m4_396000_422400 1.400000
R13642 n1_m4_396000_422400 n1_m4_396000_427200 1.400000
R13643 n1_m4_396000_427200 n1_m4_396000_432000 1.400000
R13644 n1_m4_396000_432000 n1_m4_396000_436800 1.400000
R13645 n1_m4_396000_436800 n1_m4_396000_441600 1.400000
R13646 n1_m4_396000_441600 n1_m4_396000_446400 1.400000
R13647 n1_m4_396000_446400 n1_m4_396000_451200 1.400000
R13648 n1_m4_396000_451200 n1_m4_396000_456000 1.400000
R13649 n1_m4_396000_456000 n1_m4_396000_460800 1.400000
R13650 n1_m4_396000_460800 n1_m4_396000_465600 1.400000
R13651 n1_m4_396000_465600 n1_m4_396000_470400 1.400000
R13652 n1_m4_396000_470400 n1_m4_396000_475200 1.400000
R13653 n1_m4_396000_475200 n1_m4_396000_480000 1.400000
R13654 n1_m4_396000_480000 n1_m4_396000_484000 1.166667
R13655 n1_m4_396000_484800 n1_m4_396000_484000 0.233333
R13656 n1_m4_396000_484800 n1_m4_396000_489600 1.400000
R13657 n1_m4_396000_489600 n1_m4_396000_494400 1.400000
R13658 n1_m4_424000_0 n1_m4_424000_4000 1.166667
R13659 n1_m4_424000_4800 n1_m4_424000_4000 0.233333
R13660 n1_m4_424000_4800 n1_m4_424000_9600 1.400000
R13661 n1_m4_424000_9600 n1_m4_424000_14400 1.400000
R13662 n1_m4_424000_14400 n1_m4_424000_19200 1.400000
R13663 n1_m4_424000_19200 n1_m4_424000_24000 1.400000
R13664 n1_m4_424000_24000 n1_m4_424000_28800 1.400000
R13665 n1_m4_424000_28800 n1_m4_424000_33600 1.400000
R13666 n1_m4_424000_33600 n1_m4_424000_38400 1.400000
R13667 n1_m4_424000_38400 n1_m4_424000_43200 1.400000
R13668 n1_m4_424000_43200 n1_m4_424000_48000 1.400000
R13669 n1_m4_424000_48000 n1_m4_424000_52800 1.400000
R13670 n1_m4_424000_52800 n1_m4_424000_57600 1.400000
R13671 n1_m4_424000_57600 n1_m4_424000_62400 1.400000
R13672 n1_m4_424000_62400 n1_m4_424000_67200 1.400000
R13673 n1_m4_424000_67200 n1_m4_424000_72000 1.400000
R13674 n1_m4_424000_72000 n1_m4_424000_76800 1.400000
R13675 n1_m4_424000_76800 n1_m4_424000_81600 1.400000
R13676 n1_m4_424000_81600 n1_m4_424000_84000 0.700000
R13677 n1_m4_424000_86400 n1_m4_424000_84000 0.700000
R13678 n1_m4_424000_86400 n1_m4_424000_91200 1.400000
R13679 n1_m4_424000_91200 n1_m4_424000_96000 1.400000
R13680 n1_m4_424000_96000 n1_m4_424000_100800 1.400000
R13681 n1_m4_424000_100800 n1_m4_424000_105600 1.400000
R13682 n1_m4_424000_105600 n1_m4_424000_110400 1.400000
R13683 n1_m4_424000_110400 n1_m4_424000_115200 1.400000
R13684 n1_m4_424000_115200 n1_m4_424000_120000 1.400000
R13685 n1_m4_424000_120000 n1_m4_424000_124800 1.400000
R13686 n1_m4_424000_124800 n1_m4_424000_129600 1.400000
R13687 n1_m4_424000_129600 n1_m4_424000_134400 1.400000
R13688 n1_m4_424000_134400 n1_m4_424000_139200 1.400000
R13689 n1_m4_424000_139200 n1_m4_424000_144000 1.400000
R13690 n1_m4_424000_144000 n1_m4_424000_148800 1.400000
R13691 n1_m4_424000_148800 n1_m4_424000_153600 1.400000
R13692 n1_m4_424000_153600 n1_m4_424000_158400 1.400000
R13693 n1_m4_424000_158400 n1_m4_424000_163200 1.400000
R13694 n1_m4_424000_163200 n1_m4_424000_164000 0.233333
R13695 n1_m4_424000_168000 n1_m4_424000_164000 1.166667
R13696 n1_m4_424000_168000 n1_m4_424000_172800 1.400000
R13697 n1_m4_424000_172800 n1_m4_424000_177600 1.400000
R13698 n1_m4_424000_177600 n1_m4_424000_182400 1.400000
R13699 n1_m4_424000_182400 n1_m4_424000_187200 1.400000
R13700 n1_m4_424000_187200 n1_m4_424000_192000 1.400000
R13701 n1_m4_424000_192000 n1_m4_424000_196800 1.400000
R13702 n1_m4_424000_196800 n1_m4_424000_201600 1.400000
R13703 n1_m4_424000_201600 n1_m4_424000_206400 1.400000
R13704 n1_m4_424000_206400 n1_m4_424000_211200 1.400000
R13705 n1_m4_424000_211200 n1_m4_424000_216000 1.400000
R13706 n1_m4_424000_216000 n1_m4_424000_220800 1.400000
R13707 n1_m4_424000_220800 n1_m4_424000_225600 1.400000
R13708 n1_m4_424000_225600 n1_m4_424000_230400 1.400000
R13709 n1_m4_424000_230400 n1_m4_424000_235200 1.400000
R13710 n1_m4_424000_235200 n1_m4_424000_240000 1.400000
R13711 n1_m4_424000_240000 n1_m4_424000_244000 1.166667
R13712 n1_m4_424000_244800 n1_m4_424000_244000 0.233333
R13713 n1_m4_424000_244800 n1_m4_424000_249600 1.400000
R13714 n1_m4_424000_249600 n1_m4_424000_254400 1.400000
R13715 n1_m4_424000_254400 n1_m4_424000_259200 1.400000
R13716 n1_m4_424000_259200 n1_m4_424000_264000 1.400000
R13717 n1_m4_424000_264000 n1_m4_424000_268800 1.400000
R13718 n1_m4_424000_268800 n1_m4_424000_273600 1.400000
R13719 n1_m4_424000_273600 n1_m4_424000_278400 1.400000
R13720 n1_m4_424000_278400 n1_m4_424000_283200 1.400000
R13721 n1_m4_424000_283200 n1_m4_424000_288000 1.400000
R13722 n1_m4_424000_288000 n1_m4_424000_292800 1.400000
R13723 n1_m4_424000_292800 n1_m4_424000_297600 1.400000
R13724 n1_m4_424000_297600 n1_m4_424000_302400 1.400000
R13725 n1_m4_424000_302400 n1_m4_424000_307200 1.400000
R13726 n1_m4_424000_307200 n1_m4_424000_312000 1.400000
R13727 n1_m4_424000_312000 n1_m4_424000_316800 1.400000
R13728 n1_m4_424000_316800 n1_m4_424000_321600 1.400000
R13729 n1_m4_424000_321600 n1_m4_424000_324000 0.700000
R13730 n1_m4_424000_326400 n1_m4_424000_324000 0.700000
R13731 n1_m4_424000_326400 n1_m4_424000_331200 1.400000
R13732 n1_m4_424000_331200 n1_m4_424000_336000 1.400000
R13733 n1_m4_424000_336000 n1_m4_424000_340800 1.400000
R13734 n1_m4_424000_340800 n1_m4_424000_345600 1.400000
R13735 n1_m4_424000_345600 n1_m4_424000_350400 1.400000
R13736 n1_m4_424000_350400 n1_m4_424000_355200 1.400000
R13737 n1_m4_424000_355200 n1_m4_424000_360000 1.400000
R13738 n1_m4_424000_360000 n1_m4_424000_364800 1.400000
R13739 n1_m4_424000_364800 n1_m4_424000_369600 1.400000
R13740 n1_m4_424000_369600 n1_m4_424000_374400 1.400000
R13741 n1_m4_424000_374400 n1_m4_424000_379200 1.400000
R13742 n1_m4_424000_379200 n1_m4_424000_384000 1.400000
R13743 n1_m4_424000_384000 n1_m4_424000_388800 1.400000
R13744 n1_m4_424000_388800 n1_m4_424000_393600 1.400000
R13745 n1_m4_424000_393600 n1_m4_424000_398400 1.400000
R13746 n1_m4_424000_398400 n1_m4_424000_403200 1.400000
R13747 n1_m4_424000_403200 n1_m4_424000_404000 0.233333
R13748 n1_m4_424000_408000 n1_m4_424000_404000 1.166667
R13749 n1_m4_424000_408000 n1_m4_424000_412800 1.400000
R13750 n1_m4_424000_412800 n1_m4_424000_417600 1.400000
R13751 n1_m4_424000_417600 n1_m4_424000_422400 1.400000
R13752 n1_m4_424000_422400 n1_m4_424000_427200 1.400000
R13753 n1_m4_424000_427200 n1_m4_424000_432000 1.400000
R13754 n1_m4_424000_432000 n1_m4_424000_436800 1.400000
R13755 n1_m4_424000_436800 n1_m4_424000_441600 1.400000
R13756 n1_m4_424000_441600 n1_m4_424000_446400 1.400000
R13757 n1_m4_424000_446400 n1_m4_424000_451200 1.400000
R13758 n1_m4_424000_451200 n1_m4_424000_456000 1.400000
R13759 n1_m4_424000_456000 n1_m4_424000_460800 1.400000
R13760 n1_m4_424000_460800 n1_m4_424000_465600 1.400000
R13761 n1_m4_424000_465600 n1_m4_424000_470400 1.400000
R13762 n1_m4_424000_470400 n1_m4_424000_475200 1.400000
R13763 n1_m4_424000_475200 n1_m4_424000_480000 1.400000
R13764 n1_m4_424000_480000 n1_m4_424000_484000 1.166667
R13765 n1_m4_424000_484800 n1_m4_424000_484000 0.233333
R13766 n1_m4_424000_484800 n1_m4_424000_489600 1.400000
R13767 n1_m4_424000_489600 n1_m4_424000_494400 1.400000
R13768 n1_m4_452000_0 n1_m4_452000_4000 1.166667
R13769 n1_m4_452000_4800 n1_m4_452000_4000 0.233333
R13770 n1_m4_452000_4800 n1_m4_452000_9600 1.400000
R13771 n1_m4_452000_9600 n1_m4_452000_14400 1.400000
R13772 n1_m4_452000_14400 n1_m4_452000_19200 1.400000
R13773 n1_m4_452000_19200 n1_m4_452000_24000 1.400000
R13774 n1_m4_452000_24000 n1_m4_452000_28800 1.400000
R13775 n1_m4_452000_28800 n1_m4_452000_33600 1.400000
R13776 n1_m4_452000_33600 n1_m4_452000_38400 1.400000
R13777 n1_m4_452000_38400 n1_m4_452000_43200 1.400000
R13778 n1_m4_452000_43200 n1_m4_452000_48000 1.400000
R13779 n1_m4_452000_48000 n1_m4_452000_52800 1.400000
R13780 n1_m4_452000_52800 n1_m4_452000_57600 1.400000
R13781 n1_m4_452000_57600 n1_m4_452000_62400 1.400000
R13782 n1_m4_452000_62400 n1_m4_452000_67200 1.400000
R13783 n1_m4_452000_67200 n1_m4_452000_72000 1.400000
R13784 n1_m4_452000_72000 n1_m4_452000_76800 1.400000
R13785 n1_m4_452000_76800 n1_m4_452000_81600 1.400000
R13786 n1_m4_452000_81600 n1_m4_452000_84000 0.700000
R13787 n1_m4_452000_86400 n1_m4_452000_84000 0.700000
R13788 n1_m4_452000_86400 n1_m4_452000_91200 1.400000
R13789 n1_m4_452000_91200 n1_m4_452000_96000 1.400000
R13790 n1_m4_452000_96000 n1_m4_452000_100800 1.400000
R13791 n1_m4_452000_100800 n1_m4_452000_105600 1.400000
R13792 n1_m4_452000_105600 n1_m4_452000_110400 1.400000
R13793 n1_m4_452000_110400 n1_m4_452000_115200 1.400000
R13794 n1_m4_452000_115200 n1_m4_452000_120000 1.400000
R13795 n1_m4_452000_120000 n1_m4_452000_124800 1.400000
R13796 n1_m4_452000_124800 n1_m4_452000_129600 1.400000
R13797 n1_m4_452000_129600 n1_m4_452000_134400 1.400000
R13798 n1_m4_452000_134400 n1_m4_452000_139200 1.400000
R13799 n1_m4_452000_139200 n1_m4_452000_144000 1.400000
R13800 n1_m4_452000_144000 n1_m4_452000_148800 1.400000
R13801 n1_m4_452000_148800 n1_m4_452000_153600 1.400000
R13802 n1_m4_452000_153600 n1_m4_452000_158400 1.400000
R13803 n1_m4_452000_158400 n1_m4_452000_163200 1.400000
R13804 n1_m4_452000_163200 n1_m4_452000_164000 0.233333
R13805 n1_m4_452000_168000 n1_m4_452000_164000 1.166667
R13806 n1_m4_452000_168000 n1_m4_452000_172800 1.400000
R13807 n1_m4_452000_172800 n1_m4_452000_177600 1.400000
R13808 n1_m4_452000_177600 n1_m4_452000_182400 1.400000
R13809 n1_m4_452000_182400 n1_m4_452000_187200 1.400000
R13810 n1_m4_452000_187200 n1_m4_452000_192000 1.400000
R13811 n1_m4_452000_192000 n1_m4_452000_196800 1.400000
R13812 n1_m4_452000_398400 n1_m4_452000_403200 1.400000
R13813 n1_m4_452000_403200 n1_m4_452000_404000 0.233333
R13814 n1_m4_452000_408000 n1_m4_452000_404000 1.166667
R13815 n1_m4_452000_408000 n1_m4_452000_412800 1.400000
R13816 n1_m4_452000_412800 n1_m4_452000_417600 1.400000
R13817 n1_m4_452000_417600 n1_m4_452000_422400 1.400000
R13818 n1_m4_452000_422400 n1_m4_452000_427200 1.400000
R13819 n1_m4_452000_427200 n1_m4_452000_432000 1.400000
R13820 n1_m4_452000_432000 n1_m4_452000_436800 1.400000
R13821 n1_m4_452000_436800 n1_m4_452000_441600 1.400000
R13822 n1_m4_452000_441600 n1_m4_452000_446400 1.400000
R13823 n1_m4_452000_446400 n1_m4_452000_451200 1.400000
R13824 n1_m4_452000_451200 n1_m4_452000_456000 1.400000
R13825 n1_m4_452000_456000 n1_m4_452000_460800 1.400000
R13826 n1_m4_452000_460800 n1_m4_452000_465600 1.400000
R13827 n1_m4_452000_465600 n1_m4_452000_470400 1.400000
R13828 n1_m4_452000_470400 n1_m4_452000_475200 1.400000
R13829 n1_m4_452000_475200 n1_m4_452000_480000 1.400000
R13830 n1_m4_452000_480000 n1_m4_452000_484000 1.166667
R13831 n1_m4_452000_484800 n1_m4_452000_484000 0.233333
R13832 n1_m4_452000_484800 n1_m4_452000_489600 1.400000
R13833 n1_m4_452000_489600 n1_m4_452000_494400 1.400000
R13834 n1_m4_480000_0 n1_m4_480000_4000 1.166667
R13835 n1_m4_480000_4800 n1_m4_480000_4000 0.233333
R13836 n1_m4_480000_4800 n1_m4_480000_9600 1.400000
R13837 n1_m4_480000_9600 n1_m4_480000_14400 1.400000
R13838 n1_m4_480000_14400 n1_m4_480000_19200 1.400000
R13839 n1_m4_480000_19200 n1_m4_480000_24000 1.400000
R13840 n1_m4_480000_24000 n1_m4_480000_28800 1.400000
R13841 n1_m4_480000_28800 n1_m4_480000_33600 1.400000
R13842 n1_m4_480000_33600 n1_m4_480000_38400 1.400000
R13843 n1_m4_480000_38400 n1_m4_480000_43200 1.400000
R13844 n1_m4_480000_43200 n1_m4_480000_48000 1.400000
R13845 n1_m4_480000_48000 n1_m4_480000_52800 1.400000
R13846 n1_m4_480000_52800 n1_m4_480000_57600 1.400000
R13847 n1_m4_480000_57600 n1_m4_480000_62400 1.400000
R13848 n1_m4_480000_62400 n1_m4_480000_67200 1.400000
R13849 n1_m4_480000_67200 n1_m4_480000_72000 1.400000
R13850 n1_m4_480000_72000 n1_m4_480000_76800 1.400000
R13851 n1_m4_480000_76800 n1_m4_480000_81600 1.400000
R13852 n1_m4_480000_81600 n1_m4_480000_84000 0.700000
R13853 n1_m4_480000_86400 n1_m4_480000_84000 0.700000
R13854 n1_m4_480000_86400 n1_m4_480000_91200 1.400000
R13855 n1_m4_480000_91200 n1_m4_480000_96000 1.400000
R13856 n1_m4_480000_96000 n1_m4_480000_100800 1.400000
R13857 n1_m4_480000_100800 n1_m4_480000_105600 1.400000
R13858 n1_m4_480000_105600 n1_m4_480000_110400 1.400000
R13859 n1_m4_480000_110400 n1_m4_480000_115200 1.400000
R13860 n1_m4_480000_115200 n1_m4_480000_120000 1.400000
R13861 n1_m4_480000_120000 n1_m4_480000_124800 1.400000
R13862 n1_m4_480000_124800 n1_m4_480000_129600 1.400000
R13863 n1_m4_480000_129600 n1_m4_480000_134400 1.400000
R13864 n1_m4_480000_134400 n1_m4_480000_139200 1.400000
R13865 n1_m4_480000_139200 n1_m4_480000_144000 1.400000
R13866 n1_m4_480000_144000 n1_m4_480000_148800 1.400000
R13867 n1_m4_480000_148800 n1_m4_480000_153600 1.400000
R13868 n1_m4_480000_153600 n1_m4_480000_158400 1.400000
R13869 n1_m4_480000_158400 n1_m4_480000_163200 1.400000
R13870 n1_m4_480000_163200 n1_m4_480000_164000 0.233333
R13871 n1_m4_480000_168000 n1_m4_480000_164000 1.166667
R13872 n1_m4_480000_168000 n1_m4_480000_172800 1.400000
R13873 n1_m4_480000_172800 n1_m4_480000_177600 1.400000
R13874 n1_m4_480000_177600 n1_m4_480000_182400 1.400000
R13875 n1_m4_480000_182400 n1_m4_480000_187200 1.400000
R13876 n1_m4_480000_187200 n1_m4_480000_192000 1.400000
R13877 n1_m4_480000_192000 n1_m4_480000_196800 1.400000
R13878 n1_m4_480000_398400 n1_m4_480000_403200 1.400000
R13879 n1_m4_480000_403200 n1_m4_480000_404000 0.233333
R13880 n1_m4_480000_408000 n1_m4_480000_404000 1.166667
R13881 n1_m4_480000_408000 n1_m4_480000_412800 1.400000
R13882 n1_m4_480000_412800 n1_m4_480000_417600 1.400000
R13883 n1_m4_480000_417600 n1_m4_480000_422400 1.400000
R13884 n1_m4_480000_422400 n1_m4_480000_427200 1.400000
R13885 n1_m4_480000_427200 n1_m4_480000_432000 1.400000
R13886 n1_m4_480000_432000 n1_m4_480000_436800 1.400000
R13887 n1_m4_480000_436800 n1_m4_480000_441600 1.400000
R13888 n1_m4_480000_441600 n1_m4_480000_446400 1.400000
R13889 n1_m4_480000_446400 n1_m4_480000_451200 1.400000
R13890 n1_m4_480000_451200 n1_m4_480000_456000 1.400000
R13891 n1_m4_480000_456000 n1_m4_480000_460800 1.400000
R13892 n1_m4_480000_460800 n1_m4_480000_465600 1.400000
R13893 n1_m4_480000_465600 n1_m4_480000_470400 1.400000
R13894 n1_m4_480000_470400 n1_m4_480000_475200 1.400000
R13895 n1_m4_480000_475200 n1_m4_480000_480000 1.400000
R13896 n1_m4_480000_480000 n1_m4_480000_484000 1.166667
R13897 n1_m4_480000_484800 n1_m4_480000_484000 0.233333
R13898 n1_m4_480000_484800 n1_m4_480000_489600 1.400000
R13899 n1_m4_480000_489600 n1_m4_480000_494400 1.400000
R13900 n1_m7_4000_4000 n1_m7_26400_4000 0.594240
R13901 n1_m7_32000_4000 n1_m7_26400_4000 0.148560
R13902 n1_m7_32000_4000 n1_m7_48800_4000 0.445680
R13903 n1_m7_60000_4000 n1_m7_48800_4000 0.297120
R13904 n1_m7_60000_4000 n1_m7_71200_4000 0.297120
R13905 n1_m7_88000_4000 n1_m7_71200_4000 0.445680
R13906 n1_m7_88000_4000 n1_m7_93600_4000 0.148560
R13907 n1_m7_116000_4000 n1_m7_93600_4000 0.594240
R13908 n1_m7_116000_4000 n1_m7_138400_4000 0.594240
R13909 n1_m7_144000_4000 n1_m7_138400_4000 0.148560
R13910 n1_m7_144000_4000 n1_m7_160800_4000 0.445680
R13911 n1_m7_172000_4000 n1_m7_160800_4000 0.297120
R13912 n1_m7_172000_4000 n1_m7_183200_4000 0.297120
R13913 n1_m7_200000_4000 n1_m7_183200_4000 0.445680
R13914 n1_m7_200000_4000 n1_m7_205600_4000 0.148560
R13915 n1_m7_228000_4000 n1_m7_205600_4000 0.594240
R13916 n1_m7_228000_4000 n1_m7_250400_4000 0.594240
R13917 n1_m7_256000_4000 n1_m7_250400_4000 0.148560
R13918 n1_m7_256000_4000 n1_m7_272800_4000 0.445680
R13919 n1_m7_284000_4000 n1_m7_272800_4000 0.297120
R13920 n1_m7_284000_4000 n1_m7_295200_4000 0.297120
R13921 n1_m7_312000_4000 n1_m7_295200_4000 0.445680
R13922 n1_m7_312000_4000 n1_m7_317600_4000 0.148560
R13923 n1_m7_340000_4000 n1_m7_317600_4000 0.594240
R13924 n1_m7_340000_4000 n1_m7_362400_4000 0.594240
R13925 n1_m7_368000_4000 n1_m7_362400_4000 0.148560
R13926 n1_m7_368000_4000 n1_m7_384800_4000 0.445680
R13927 n1_m7_396000_4000 n1_m7_384800_4000 0.297120
R13928 n1_m7_396000_4000 n1_m7_407200_4000 0.297120
R13929 n1_m7_424000_4000 n1_m7_407200_4000 0.445680
R13930 n1_m7_424000_4000 n1_m7_429600_4000 0.148560
R13931 n1_m7_452000_4000 n1_m7_429600_4000 0.594240
R13932 n1_m7_452000_4000 n1_m7_474400_4000 0.594240
R13933 n1_m7_480000_4000 n1_m7_474400_4000 0.148560
R13934 n1_m7_480000_4000 n1_m7_496800_4000 0.445680
R13935 n1_m7_4000_84000 n1_m7_26400_84000 0.594240
R13936 n1_m7_32000_84000 n1_m7_26400_84000 0.148560
R13937 n1_m7_32000_84000 n1_m7_48800_84000 0.445680
R13938 n1_m7_60000_84000 n1_m7_48800_84000 0.297120
R13939 n1_m7_60000_84000 n1_m7_71200_84000 0.297120
R13940 n1_m7_88000_84000 n1_m7_71200_84000 0.445680
R13941 n1_m7_88000_84000 n1_m7_93600_84000 0.148560
R13942 n1_m7_116000_84000 n1_m7_93600_84000 0.594240
R13943 n1_m7_116000_84000 n1_m7_138400_84000 0.594240
R13944 n1_m7_144000_84000 n1_m7_138400_84000 0.148560
R13945 n1_m7_144000_84000 n1_m7_160800_84000 0.445680
R13946 n1_m7_172000_84000 n1_m7_160800_84000 0.297120
R13947 n1_m7_172000_84000 n1_m7_183200_84000 0.297120
R13948 n1_m7_200000_84000 n1_m7_183200_84000 0.445680
R13949 n1_m7_200000_84000 n1_m7_205600_84000 0.148560
R13950 n1_m7_228000_84000 n1_m7_205600_84000 0.594240
R13951 n1_m7_228000_84000 n1_m7_250400_84000 0.594240
R13952 n1_m7_256000_84000 n1_m7_250400_84000 0.148560
R13953 n1_m7_256000_84000 n1_m7_272800_84000 0.445680
R13954 n1_m7_284000_84000 n1_m7_272800_84000 0.297120
R13955 n1_m7_284000_84000 n1_m7_295200_84000 0.297120
R13956 n1_m7_312000_84000 n1_m7_295200_84000 0.445680
R13957 n1_m7_312000_84000 n1_m7_317600_84000 0.148560
R13958 n1_m7_340000_84000 n1_m7_317600_84000 0.594240
R13959 n1_m7_340000_84000 n1_m7_362400_84000 0.594240
R13960 n1_m7_368000_84000 n1_m7_362400_84000 0.148560
R13961 n1_m7_368000_84000 n1_m7_384800_84000 0.445680
R13962 n1_m7_396000_84000 n1_m7_384800_84000 0.297120
R13963 n1_m7_396000_84000 n1_m7_407200_84000 0.297120
R13964 n1_m7_424000_84000 n1_m7_407200_84000 0.445680
R13965 n1_m7_424000_84000 n1_m7_429600_84000 0.148560
R13966 n1_m7_452000_84000 n1_m7_429600_84000 0.594240
R13967 n1_m7_452000_84000 n1_m7_474400_84000 0.594240
R13968 n1_m7_480000_84000 n1_m7_474400_84000 0.148560
R13969 n1_m7_480000_84000 n1_m7_496800_84000 0.445680
R13970 n1_m7_4000_164000 n1_m7_26400_164000 0.594240
R13971 n1_m7_32000_164000 n1_m7_26400_164000 0.148560
R13972 n1_m7_32000_164000 n1_m7_48800_164000 0.445680
R13973 n1_m7_60000_164000 n1_m7_48800_164000 0.297120
R13974 n1_m7_60000_164000 n1_m7_71200_164000 0.297120
R13975 n1_m7_88000_164000 n1_m7_71200_164000 0.445680
R13976 n1_m7_88000_164000 n1_m7_93600_164000 0.148560
R13977 n1_m7_116000_164000 n1_m7_93600_164000 0.594240
R13978 n1_m7_116000_164000 n1_m7_138400_164000 0.594240
R13979 n1_m7_144000_164000 n1_m7_138400_164000 0.148560
R13980 n1_m7_144000_164000 n1_m7_160800_164000 0.445680
R13981 n1_m7_172000_164000 n1_m7_160800_164000 0.297120
R13982 n1_m7_172000_164000 n1_m7_183200_164000 0.297120
R13983 n1_m7_200000_164000 n1_m7_183200_164000 0.445680
R13984 n1_m7_200000_164000 n1_m7_205600_164000 0.148560
R13985 n1_m7_228000_164000 n1_m7_205600_164000 0.594240
R13986 n1_m7_228000_164000 n1_m7_250400_164000 0.594240
R13987 n1_m7_256000_164000 n1_m7_250400_164000 0.148560
R13988 n1_m7_256000_164000 n1_m7_272800_164000 0.445680
R13989 n1_m7_284000_164000 n1_m7_272800_164000 0.297120
R13990 n1_m7_284000_164000 n1_m7_295200_164000 0.297120
R13991 n1_m7_312000_164000 n1_m7_295200_164000 0.445680
R13992 n1_m7_312000_164000 n1_m7_317600_164000 0.148560
R13993 n1_m7_340000_164000 n1_m7_317600_164000 0.594240
R13994 n1_m7_340000_164000 n1_m7_362400_164000 0.594240
R13995 n1_m7_368000_164000 n1_m7_362400_164000 0.148560
R13996 n1_m7_368000_164000 n1_m7_384800_164000 0.445680
R13997 n1_m7_396000_164000 n1_m7_384800_164000 0.297120
R13998 n1_m7_396000_164000 n1_m7_407200_164000 0.297120
R13999 n1_m7_424000_164000 n1_m7_407200_164000 0.445680
R14000 n1_m7_424000_164000 n1_m7_429600_164000 0.148560
R14001 n1_m7_452000_164000 n1_m7_429600_164000 0.594240
R14002 n1_m7_452000_164000 n1_m7_474400_164000 0.594240
R14003 n1_m7_480000_164000 n1_m7_474400_164000 0.148560
R14004 n1_m7_480000_164000 n1_m7_496800_164000 0.445680
R14005 n1_m7_4000_244000 n1_m7_26400_244000 0.594240
R14006 n1_m7_32000_244000 n1_m7_26400_244000 0.148560
R14007 n1_m7_32000_244000 n1_m7_48800_244000 0.445680
R14008 n1_m7_60000_244000 n1_m7_48800_244000 0.297120
R14009 n1_m7_60000_244000 n1_m7_71200_244000 0.297120
R14010 n1_m7_88000_244000 n1_m7_71200_244000 0.445680
R14011 n1_m7_88000_244000 n1_m7_93600_244000 0.148560
R14012 n1_m7_116000_244000 n1_m7_93600_244000 0.594240
R14013 n1_m7_116000_244000 n1_m7_138400_244000 0.594240
R14014 n1_m7_144000_244000 n1_m7_138400_244000 0.148560
R14015 n1_m7_144000_244000 n1_m7_160800_244000 0.445680
R14016 n1_m7_172000_244000 n1_m7_160800_244000 0.297120
R14017 n1_m7_172000_244000 n1_m7_183200_244000 0.297120
R14018 n1_m7_200000_244000 n1_m7_183200_244000 0.445680
R14019 n1_m7_200000_244000 n1_m7_205600_244000 0.148560
R14020 n1_m7_228000_244000 n1_m7_205600_244000 0.594240
R14021 n1_m7_228000_244000 n1_m7_250400_244000 0.594240
R14022 n1_m7_256000_244000 n1_m7_250400_244000 0.148560
R14023 n1_m7_256000_244000 n1_m7_272800_244000 0.445680
R14024 n1_m7_284000_244000 n1_m7_272800_244000 0.297120
R14025 n1_m7_284000_244000 n1_m7_295200_244000 0.297120
R14026 n1_m7_312000_244000 n1_m7_295200_244000 0.445680
R14027 n1_m7_312000_244000 n1_m7_317600_244000 0.148560
R14028 n1_m7_340000_244000 n1_m7_317600_244000 0.594240
R14029 n1_m7_340000_244000 n1_m7_362400_244000 0.594240
R14030 n1_m7_368000_244000 n1_m7_362400_244000 0.148560
R14031 n1_m7_368000_244000 n1_m7_384800_244000 0.445680
R14032 n1_m7_396000_244000 n1_m7_384800_244000 0.297120
R14033 n1_m7_396000_244000 n1_m7_407200_244000 0.297120
R14034 n1_m7_424000_244000 n1_m7_407200_244000 0.445680
R14035 n1_m7_424000_244000 n1_m7_429600_244000 0.148560
R14036 n1_m7_452000_244000 n1_m7_429600_244000 0.594240
R14037 n1_m7_452000_244000 n1_m7_474400_244000 0.594240
R14038 n1_m7_480000_244000 n1_m7_474400_244000 0.148560
R14039 n1_m7_480000_244000 n1_m7_496800_244000 0.445680
R14040 n1_m7_4000_324000 n1_m7_26400_324000 0.594240
R14041 n1_m7_32000_324000 n1_m7_26400_324000 0.148560
R14042 n1_m7_32000_324000 n1_m7_48800_324000 0.445680
R14043 n1_m7_60000_324000 n1_m7_48800_324000 0.297120
R14044 n1_m7_60000_324000 n1_m7_71200_324000 0.297120
R14045 n1_m7_88000_324000 n1_m7_71200_324000 0.445680
R14046 n1_m7_88000_324000 n1_m7_93600_324000 0.148560
R14047 n1_m7_116000_324000 n1_m7_93600_324000 0.594240
R14048 n1_m7_116000_324000 n1_m7_138400_324000 0.594240
R14049 n1_m7_144000_324000 n1_m7_138400_324000 0.148560
R14050 n1_m7_144000_324000 n1_m7_160800_324000 0.445680
R14051 n1_m7_172000_324000 n1_m7_160800_324000 0.297120
R14052 n1_m7_172000_324000 n1_m7_183200_324000 0.297120
R14053 n1_m7_200000_324000 n1_m7_183200_324000 0.445680
R14054 n1_m7_200000_324000 n1_m7_205600_324000 0.148560
R14055 n1_m7_228000_324000 n1_m7_205600_324000 0.594240
R14056 n1_m7_228000_324000 n1_m7_250400_324000 0.594240
R14057 n1_m7_256000_324000 n1_m7_250400_324000 0.148560
R14058 n1_m7_256000_324000 n1_m7_272800_324000 0.445680
R14059 n1_m7_284000_324000 n1_m7_272800_324000 0.297120
R14060 n1_m7_284000_324000 n1_m7_295200_324000 0.297120
R14061 n1_m7_312000_324000 n1_m7_295200_324000 0.445680
R14062 n1_m7_312000_324000 n1_m7_317600_324000 0.148560
R14063 n1_m7_340000_324000 n1_m7_317600_324000 0.594240
R14064 n1_m7_340000_324000 n1_m7_362400_324000 0.594240
R14065 n1_m7_368000_324000 n1_m7_362400_324000 0.148560
R14066 n1_m7_368000_324000 n1_m7_384800_324000 0.445680
R14067 n1_m7_396000_324000 n1_m7_384800_324000 0.297120
R14068 n1_m7_396000_324000 n1_m7_407200_324000 0.297120
R14069 n1_m7_424000_324000 n1_m7_407200_324000 0.445680
R14070 n1_m7_424000_324000 n1_m7_429600_324000 0.148560
R14071 n1_m7_452000_324000 n1_m7_429600_324000 0.594240
R14072 n1_m7_452000_324000 n1_m7_474400_324000 0.594240
R14073 n1_m7_480000_324000 n1_m7_474400_324000 0.148560
R14074 n1_m7_480000_324000 n1_m7_496800_324000 0.445680
R14075 n1_m7_4000_404000 n1_m7_26400_404000 0.594240
R14076 n1_m7_32000_404000 n1_m7_26400_404000 0.148560
R14077 n1_m7_32000_404000 n1_m7_48800_404000 0.445680
R14078 n1_m7_60000_404000 n1_m7_48800_404000 0.297120
R14079 n1_m7_60000_404000 n1_m7_71200_404000 0.297120
R14080 n1_m7_88000_404000 n1_m7_71200_404000 0.445680
R14081 n1_m7_88000_404000 n1_m7_93600_404000 0.148560
R14082 n1_m7_116000_404000 n1_m7_93600_404000 0.594240
R14083 n1_m7_116000_404000 n1_m7_138400_404000 0.594240
R14084 n1_m7_144000_404000 n1_m7_138400_404000 0.148560
R14085 n1_m7_144000_404000 n1_m7_160800_404000 0.445680
R14086 n1_m7_172000_404000 n1_m7_160800_404000 0.297120
R14087 n1_m7_172000_404000 n1_m7_183200_404000 0.297120
R14088 n1_m7_200000_404000 n1_m7_183200_404000 0.445680
R14089 n1_m7_200000_404000 n1_m7_205600_404000 0.148560
R14090 n1_m7_228000_404000 n1_m7_205600_404000 0.594240
R14091 n1_m7_228000_404000 n1_m7_250400_404000 0.594240
R14092 n1_m7_256000_404000 n1_m7_250400_404000 0.148560
R14093 n1_m7_256000_404000 n1_m7_272800_404000 0.445680
R14094 n1_m7_284000_404000 n1_m7_272800_404000 0.297120
R14095 n1_m7_284000_404000 n1_m7_295200_404000 0.297120
R14096 n1_m7_312000_404000 n1_m7_295200_404000 0.445680
R14097 n1_m7_312000_404000 n1_m7_317600_404000 0.148560
R14098 n1_m7_340000_404000 n1_m7_317600_404000 0.594240
R14099 n1_m7_340000_404000 n1_m7_362400_404000 0.594240
R14100 n1_m7_368000_404000 n1_m7_362400_404000 0.148560
R14101 n1_m7_368000_404000 n1_m7_384800_404000 0.445680
R14102 n1_m7_396000_404000 n1_m7_384800_404000 0.297120
R14103 n1_m7_396000_404000 n1_m7_407200_404000 0.297120
R14104 n1_m7_424000_404000 n1_m7_407200_404000 0.445680
R14105 n1_m7_424000_404000 n1_m7_429600_404000 0.148560
R14106 n1_m7_452000_404000 n1_m7_429600_404000 0.594240
R14107 n1_m7_452000_404000 n1_m7_474400_404000 0.594240
R14108 n1_m7_480000_404000 n1_m7_474400_404000 0.148560
R14109 n1_m7_480000_404000 n1_m7_496800_404000 0.445680
R14110 n1_m7_4000_484000 n1_m7_26400_484000 0.594240
R14111 n1_m7_32000_484000 n1_m7_26400_484000 0.148560
R14112 n1_m7_32000_484000 n1_m7_48800_484000 0.445680
R14113 n1_m7_60000_484000 n1_m7_48800_484000 0.297120
R14114 n1_m7_60000_484000 n1_m7_71200_484000 0.297120
R14115 n1_m7_88000_484000 n1_m7_71200_484000 0.445680
R14116 n1_m7_88000_484000 n1_m7_93600_484000 0.148560
R14117 n1_m7_116000_484000 n1_m7_93600_484000 0.594240
R14118 n1_m7_116000_484000 n1_m7_138400_484000 0.594240
R14119 n1_m7_144000_484000 n1_m7_138400_484000 0.148560
R14120 n1_m7_144000_484000 n1_m7_160800_484000 0.445680
R14121 n1_m7_172000_484000 n1_m7_160800_484000 0.297120
R14122 n1_m7_172000_484000 n1_m7_183200_484000 0.297120
R14123 n1_m7_200000_484000 n1_m7_183200_484000 0.445680
R14124 n1_m7_200000_484000 n1_m7_205600_484000 0.148560
R14125 n1_m7_228000_484000 n1_m7_205600_484000 0.594240
R14126 n1_m7_228000_484000 n1_m7_250400_484000 0.594240
R14127 n1_m7_256000_484000 n1_m7_250400_484000 0.148560
R14128 n1_m7_256000_484000 n1_m7_272800_484000 0.445680
R14129 n1_m7_284000_484000 n1_m7_272800_484000 0.297120
R14130 n1_m7_284000_484000 n1_m7_295200_484000 0.297120
R14131 n1_m7_312000_484000 n1_m7_295200_484000 0.445680
R14132 n1_m7_312000_484000 n1_m7_317600_484000 0.148560
R14133 n1_m7_340000_484000 n1_m7_317600_484000 0.594240
R14134 n1_m7_340000_484000 n1_m7_362400_484000 0.594240
R14135 n1_m7_368000_484000 n1_m7_362400_484000 0.148560
R14136 n1_m7_368000_484000 n1_m7_384800_484000 0.445680
R14137 n1_m7_396000_484000 n1_m7_384800_484000 0.297120
R14138 n1_m7_396000_484000 n1_m7_407200_484000 0.297120
R14139 n1_m7_424000_484000 n1_m7_407200_484000 0.445680
R14140 n1_m7_424000_484000 n1_m7_429600_484000 0.148560
R14141 n1_m7_452000_484000 n1_m7_429600_484000 0.594240
R14142 n1_m7_452000_484000 n1_m7_474400_484000 0.594240
R14143 n1_m7_480000_484000 n1_m7_474400_484000 0.148560
R14144 n1_m7_480000_484000 n1_m7_496800_484000 0.445680
R14145 n1_m8_4000_4000 n1_m8_4000_26400 0.120000
R14146 n1_m8_4000_26400 n1_m8_4000_48800 0.120000
R14147 n1_m8_4000_48800 n1_m8_4000_71200 0.120000
R14148 n1_m8_4000_84000 n1_m8_4000_71200 0.068571
R14149 n1_m8_4000_84000 n1_m8_4000_93600 0.051429
R14150 n1_m8_4000_93600 n1_m8_4000_116000 0.120000
R14151 n1_m8_4000_116000 n1_m8_4000_138400 0.120000
R14152 n1_m8_4000_138400 n1_m8_4000_160800 0.120000
R14153 n1_m8_4000_164000 n1_m8_4000_160800 0.017143
R14154 n1_m8_4000_164000 n1_m8_4000_183200 0.102857
R14155 n1_m8_4000_183200 n1_m8_4000_205600 0.120000
R14156 n1_m8_4000_205600 n1_m8_4000_228000 0.120000
R14157 n1_m8_4000_244000 n1_m8_4000_228000 0.085714
R14158 n1_m8_4000_244000 n1_m8_4000_250400 0.034286
R14159 n1_m8_4000_250400 n1_m8_4000_272800 0.120000
R14160 n1_m8_4000_272800 n1_m8_4000_295200 0.120000
R14161 n1_m8_4000_295200 n1_m8_4000_317600 0.120000
R14162 n1_m8_4000_324000 n1_m8_4000_317600 0.034286
R14163 n1_m8_4000_324000 n1_m8_4000_340000 0.085714
R14164 n1_m8_4000_340000 n1_m8_4000_362400 0.120000
R14165 n1_m8_4000_362400 n1_m8_4000_384800 0.120000
R14166 n1_m8_4000_404000 n1_m8_4000_384800 0.102857
R14167 n1_m8_4000_404000 n1_m8_4000_407200 0.017143
R14168 n1_m8_4000_407200 n1_m8_4000_429600 0.120000
R14169 n1_m8_4000_429600 n1_m8_4000_452000 0.120000
R14170 n1_m8_4000_452000 n1_m8_4000_474400 0.120000
R14171 n1_m8_4000_484000 n1_m8_4000_474400 0.051429
R14172 n1_m8_4000_484000 n1_m8_4000_496800 0.068571
R14173 n1_m8_26400_4000 n1_m8_26400_26400 0.120000
R14174 n1_m8_26400_26400 n1_m8_26400_48800 0.120000
R14175 n1_m8_26400_48800 n1_m8_26400_71200 0.120000
R14176 n1_m8_26400_84000 n1_m8_26400_71200 0.068571
R14177 n1_m8_26400_84000 n1_m8_26400_93600 0.051429
R14178 n1_m8_26400_93600 n1_m8_26400_116000 0.120000
R14179 n1_m8_26400_116000 n1_m8_26400_138400 0.120000
R14180 n1_m8_26400_138400 n1_m8_26400_160800 0.120000
R14181 n1_m8_26400_164000 n1_m8_26400_160800 0.017143
R14182 n1_m8_26400_164000 n1_m8_26400_183200 0.102857
R14183 n1_m8_26400_183200 n1_m8_26400_205600 0.120000
R14184 n1_m8_26400_205600 n1_m8_26400_228000 0.120000
R14185 n1_m8_26400_244000 n1_m8_26400_228000 0.085714
R14186 n1_m8_26400_244000 n1_m8_26400_250400 0.034286
R14187 n1_m8_26400_250400 n1_m8_26400_272800 0.120000
R14188 n1_m8_26400_272800 n1_m8_26400_295200 0.120000
R14189 n1_m8_26400_295200 n1_m8_26400_317600 0.120000
R14190 n1_m8_26400_324000 n1_m8_26400_317600 0.034286
R14191 n1_m8_26400_324000 n1_m8_26400_340000 0.085714
R14192 n1_m8_26400_340000 n1_m8_26400_362400 0.120000
R14193 n1_m8_26400_362400 n1_m8_26400_384800 0.120000
R14194 n1_m8_26400_404000 n1_m8_26400_384800 0.102857
R14195 n1_m8_26400_404000 n1_m8_26400_407200 0.017143
R14196 n1_m8_26400_407200 n1_m8_26400_429600 0.120000
R14197 n1_m8_26400_429600 n1_m8_26400_452000 0.120000
R14198 n1_m8_26400_452000 n1_m8_26400_474400 0.120000
R14199 n1_m8_26400_484000 n1_m8_26400_474400 0.051429
R14200 n1_m8_26400_484000 n1_m8_26400_496800 0.068571
R14201 n1_m8_48800_4000 n1_m8_48800_26400 0.120000
R14202 n1_m8_48800_26400 n1_m8_48800_48800 0.120000
R14203 n1_m8_48800_48800 n1_m8_48800_71200 0.120000
R14204 n1_m8_48800_84000 n1_m8_48800_71200 0.068571
R14205 n1_m8_48800_84000 n1_m8_48800_93600 0.051429
R14206 n1_m8_48800_93600 n1_m8_48800_116000 0.120000
R14207 n1_m8_48800_116000 n1_m8_48800_138400 0.120000
R14208 n1_m8_48800_138400 n1_m8_48800_160800 0.120000
R14209 n1_m8_48800_164000 n1_m8_48800_160800 0.017143
R14210 n1_m8_48800_164000 n1_m8_48800_183200 0.102857
R14211 n1_m8_48800_183200 n1_m8_48800_205600 0.120000
R14212 n1_m8_48800_205600 n1_m8_48800_228000 0.120000
R14213 n1_m8_48800_244000 n1_m8_48800_228000 0.085714
R14214 n1_m8_48800_244000 n1_m8_48800_250400 0.034286
R14215 n1_m8_48800_250400 n1_m8_48800_272800 0.120000
R14216 n1_m8_48800_272800 n1_m8_48800_295200 0.120000
R14217 n1_m8_48800_295200 n1_m8_48800_317600 0.120000
R14218 n1_m8_48800_324000 n1_m8_48800_317600 0.034286
R14219 n1_m8_48800_324000 n1_m8_48800_340000 0.085714
R14220 n1_m8_48800_340000 n1_m8_48800_362400 0.120000
R14221 n1_m8_48800_362400 n1_m8_48800_384800 0.120000
R14222 n1_m8_48800_404000 n1_m8_48800_384800 0.102857
R14223 n1_m8_48800_404000 n1_m8_48800_407200 0.017143
R14224 n1_m8_48800_407200 n1_m8_48800_429600 0.120000
R14225 n1_m8_48800_429600 n1_m8_48800_452000 0.120000
R14226 n1_m8_48800_452000 n1_m8_48800_474400 0.120000
R14227 n1_m8_48800_484000 n1_m8_48800_474400 0.051429
R14228 n1_m8_48800_484000 n1_m8_48800_496800 0.068571
R14229 n1_m8_71200_4000 n1_m8_71200_26400 0.120000
R14230 n1_m8_71200_26400 n1_m8_71200_48800 0.120000
R14231 n1_m8_71200_48800 n1_m8_71200_71200 0.120000
R14232 n1_m8_71200_84000 n1_m8_71200_71200 0.068571
R14233 n1_m8_71200_84000 n1_m8_71200_93600 0.051429
R14234 n1_m8_71200_93600 n1_m8_71200_116000 0.120000
R14235 n1_m8_71200_116000 n1_m8_71200_138400 0.120000
R14236 n1_m8_71200_138400 n1_m8_71200_160800 0.120000
R14237 n1_m8_71200_164000 n1_m8_71200_160800 0.017143
R14238 n1_m8_71200_164000 n1_m8_71200_183200 0.102857
R14239 n1_m8_71200_183200 n1_m8_71200_205600 0.120000
R14240 n1_m8_71200_205600 n1_m8_71200_228000 0.120000
R14241 n1_m8_71200_244000 n1_m8_71200_228000 0.085714
R14242 n1_m8_71200_244000 n1_m8_71200_250400 0.034286
R14243 n1_m8_71200_250400 n1_m8_71200_272800 0.120000
R14244 n1_m8_71200_272800 n1_m8_71200_295200 0.120000
R14245 n1_m8_71200_295200 n1_m8_71200_317600 0.120000
R14246 n1_m8_71200_324000 n1_m8_71200_317600 0.034286
R14247 n1_m8_71200_324000 n1_m8_71200_340000 0.085714
R14248 n1_m8_71200_340000 n1_m8_71200_362400 0.120000
R14249 n1_m8_71200_362400 n1_m8_71200_384800 0.120000
R14250 n1_m8_71200_404000 n1_m8_71200_384800 0.102857
R14251 n1_m8_71200_404000 n1_m8_71200_407200 0.017143
R14252 n1_m8_71200_407200 n1_m8_71200_429600 0.120000
R14253 n1_m8_71200_429600 n1_m8_71200_452000 0.120000
R14254 n1_m8_71200_452000 n1_m8_71200_474400 0.120000
R14255 n1_m8_71200_484000 n1_m8_71200_474400 0.051429
R14256 n1_m8_71200_484000 n1_m8_71200_496800 0.068571
R14257 n1_m8_93600_4000 n1_m8_93600_26400 0.120000
R14258 n1_m8_93600_26400 n1_m8_93600_48800 0.120000
R14259 n1_m8_93600_48800 n1_m8_93600_71200 0.120000
R14260 n1_m8_93600_84000 n1_m8_93600_71200 0.068571
R14261 n1_m8_93600_84000 n1_m8_93600_93600 0.051429
R14262 n1_m8_93600_93600 n1_m8_93600_116000 0.120000
R14263 n1_m8_93600_116000 n1_m8_93600_138400 0.120000
R14264 n1_m8_93600_138400 n1_m8_93600_160800 0.120000
R14265 n1_m8_93600_164000 n1_m8_93600_160800 0.017143
R14266 n1_m8_93600_164000 n1_m8_93600_183200 0.102857
R14267 n1_m8_93600_183200 n1_m8_93600_205600 0.120000
R14268 n1_m8_93600_205600 n1_m8_93600_228000 0.120000
R14269 n1_m8_93600_244000 n1_m8_93600_228000 0.085714
R14270 n1_m8_93600_244000 n1_m8_93600_250400 0.034286
R14271 n1_m8_93600_250400 n1_m8_93600_272800 0.120000
R14272 n1_m8_93600_272800 n1_m8_93600_295200 0.120000
R14273 n1_m8_93600_295200 n1_m8_93600_317600 0.120000
R14274 n1_m8_93600_324000 n1_m8_93600_317600 0.034286
R14275 n1_m8_93600_324000 n1_m8_93600_340000 0.085714
R14276 n1_m8_93600_340000 n1_m8_93600_362400 0.120000
R14277 n1_m8_93600_362400 n1_m8_93600_384800 0.120000
R14278 n1_m8_93600_404000 n1_m8_93600_384800 0.102857
R14279 n1_m8_93600_404000 n1_m8_93600_407200 0.017143
R14280 n1_m8_93600_407200 n1_m8_93600_429600 0.120000
R14281 n1_m8_93600_429600 n1_m8_93600_452000 0.120000
R14282 n1_m8_93600_452000 n1_m8_93600_474400 0.120000
R14283 n1_m8_93600_484000 n1_m8_93600_474400 0.051429
R14284 n1_m8_93600_484000 n1_m8_93600_496800 0.068571
R14285 n1_m8_116000_4000 n1_m8_116000_26400 0.120000
R14286 n1_m8_116000_26400 n1_m8_116000_48800 0.120000
R14287 n1_m8_116000_48800 n1_m8_116000_71200 0.120000
R14288 n1_m8_116000_84000 n1_m8_116000_71200 0.068571
R14289 n1_m8_116000_84000 n1_m8_116000_93600 0.051429
R14290 n1_m8_116000_93600 n1_m8_116000_116000 0.120000
R14291 n1_m8_116000_116000 n1_m8_116000_138400 0.120000
R14292 n1_m8_116000_138400 n1_m8_116000_160800 0.120000
R14293 n1_m8_116000_164000 n1_m8_116000_160800 0.017143
R14294 n1_m8_116000_164000 n1_m8_116000_183200 0.102857
R14295 n1_m8_116000_183200 n1_m8_116000_205600 0.120000
R14296 n1_m8_116000_205600 n1_m8_116000_228000 0.120000
R14297 n1_m8_116000_244000 n1_m8_116000_228000 0.085714
R14298 n1_m8_116000_244000 n1_m8_116000_250400 0.034286
R14299 n1_m8_116000_250400 n1_m8_116000_272800 0.120000
R14300 n1_m8_116000_272800 n1_m8_116000_295200 0.120000
R14301 n1_m8_116000_295200 n1_m8_116000_317600 0.120000
R14302 n1_m8_116000_324000 n1_m8_116000_317600 0.034286
R14303 n1_m8_116000_324000 n1_m8_116000_340000 0.085714
R14304 n1_m8_116000_340000 n1_m8_116000_362400 0.120000
R14305 n1_m8_116000_362400 n1_m8_116000_384800 0.120000
R14306 n1_m8_116000_404000 n1_m8_116000_384800 0.102857
R14307 n1_m8_116000_404000 n1_m8_116000_407200 0.017143
R14308 n1_m8_116000_407200 n1_m8_116000_429600 0.120000
R14309 n1_m8_116000_429600 n1_m8_116000_452000 0.120000
R14310 n1_m8_116000_452000 n1_m8_116000_474400 0.120000
R14311 n1_m8_116000_484000 n1_m8_116000_474400 0.051429
R14312 n1_m8_116000_484000 n1_m8_116000_496800 0.068571
R14313 n1_m8_138400_4000 n1_m8_138400_26400 0.120000
R14314 n1_m8_138400_26400 n1_m8_138400_48800 0.120000
R14315 n1_m8_138400_48800 n1_m8_138400_71200 0.120000
R14316 n1_m8_138400_84000 n1_m8_138400_71200 0.068571
R14317 n1_m8_138400_84000 n1_m8_138400_93600 0.051429
R14318 n1_m8_138400_93600 n1_m8_138400_116000 0.120000
R14319 n1_m8_138400_116000 n1_m8_138400_138400 0.120000
R14320 n1_m8_138400_138400 n1_m8_138400_160800 0.120000
R14321 n1_m8_138400_164000 n1_m8_138400_160800 0.017143
R14322 n1_m8_138400_164000 n1_m8_138400_183200 0.102857
R14323 n1_m8_138400_183200 n1_m8_138400_205600 0.120000
R14324 n1_m8_138400_205600 n1_m8_138400_228000 0.120000
R14325 n1_m8_138400_244000 n1_m8_138400_228000 0.085714
R14326 n1_m8_138400_244000 n1_m8_138400_250400 0.034286
R14327 n1_m8_138400_250400 n1_m8_138400_272800 0.120000
R14328 n1_m8_138400_272800 n1_m8_138400_295200 0.120000
R14329 n1_m8_138400_295200 n1_m8_138400_317600 0.120000
R14330 n1_m8_138400_324000 n1_m8_138400_317600 0.034286
R14331 n1_m8_138400_324000 n1_m8_138400_340000 0.085714
R14332 n1_m8_138400_340000 n1_m8_138400_362400 0.120000
R14333 n1_m8_138400_362400 n1_m8_138400_384800 0.120000
R14334 n1_m8_138400_404000 n1_m8_138400_384800 0.102857
R14335 n1_m8_138400_404000 n1_m8_138400_407200 0.017143
R14336 n1_m8_138400_407200 n1_m8_138400_429600 0.120000
R14337 n1_m8_138400_429600 n1_m8_138400_452000 0.120000
R14338 n1_m8_138400_452000 n1_m8_138400_474400 0.120000
R14339 n1_m8_138400_484000 n1_m8_138400_474400 0.051429
R14340 n1_m8_138400_484000 n1_m8_138400_496800 0.068571
R14341 n1_m8_160800_4000 n1_m8_160800_26400 0.120000
R14342 n1_m8_160800_26400 n1_m8_160800_48800 0.120000
R14343 n1_m8_160800_48800 n1_m8_160800_71200 0.120000
R14344 n1_m8_160800_84000 n1_m8_160800_71200 0.068571
R14345 n1_m8_160800_84000 n1_m8_160800_93600 0.051429
R14346 n1_m8_160800_93600 n1_m8_160800_116000 0.120000
R14347 n1_m8_160800_116000 n1_m8_160800_138400 0.120000
R14348 n1_m8_160800_138400 n1_m8_160800_160800 0.120000
R14349 n1_m8_160800_164000 n1_m8_160800_160800 0.017143
R14350 n1_m8_160800_164000 n1_m8_160800_183200 0.102857
R14351 n1_m8_160800_183200 n1_m8_160800_205600 0.120000
R14352 n1_m8_160800_205600 n1_m8_160800_228000 0.120000
R14353 n1_m8_160800_244000 n1_m8_160800_228000 0.085714
R14354 n1_m8_160800_244000 n1_m8_160800_250400 0.034286
R14355 n1_m8_160800_250400 n1_m8_160800_272800 0.120000
R14356 n1_m8_160800_272800 n1_m8_160800_295200 0.120000
R14357 n1_m8_160800_295200 n1_m8_160800_317600 0.120000
R14358 n1_m8_160800_324000 n1_m8_160800_317600 0.034286
R14359 n1_m8_160800_324000 n1_m8_160800_340000 0.085714
R14360 n1_m8_160800_340000 n1_m8_160800_362400 0.120000
R14361 n1_m8_160800_362400 n1_m8_160800_384800 0.120000
R14362 n1_m8_160800_404000 n1_m8_160800_384800 0.102857
R14363 n1_m8_160800_404000 n1_m8_160800_407200 0.017143
R14364 n1_m8_160800_407200 n1_m8_160800_429600 0.120000
R14365 n1_m8_160800_429600 n1_m8_160800_452000 0.120000
R14366 n1_m8_160800_452000 n1_m8_160800_474400 0.120000
R14367 n1_m8_160800_484000 n1_m8_160800_474400 0.051429
R14368 n1_m8_160800_484000 n1_m8_160800_496800 0.068571
R14369 n1_m8_183200_4000 n1_m8_183200_26400 0.120000
R14370 n1_m8_183200_26400 n1_m8_183200_48800 0.120000
R14371 n1_m8_183200_48800 n1_m8_183200_71200 0.120000
R14372 n1_m8_183200_84000 n1_m8_183200_71200 0.068571
R14373 n1_m8_183200_84000 n1_m8_183200_93600 0.051429
R14374 n1_m8_183200_93600 n1_m8_183200_116000 0.120000
R14375 n1_m8_183200_116000 n1_m8_183200_138400 0.120000
R14376 n1_m8_183200_138400 n1_m8_183200_160800 0.120000
R14377 n1_m8_183200_164000 n1_m8_183200_160800 0.017143
R14378 n1_m8_183200_164000 n1_m8_183200_183200 0.102857
R14379 n1_m8_183200_183200 n1_m8_183200_205600 0.120000
R14380 n1_m8_183200_205600 n1_m8_183200_228000 0.120000
R14381 n1_m8_183200_244000 n1_m8_183200_228000 0.085714
R14382 n1_m8_183200_244000 n1_m8_183200_250400 0.034286
R14383 n1_m8_183200_250400 n1_m8_183200_272800 0.120000
R14384 n1_m8_183200_272800 n1_m8_183200_295200 0.120000
R14385 n1_m8_183200_295200 n1_m8_183200_317600 0.120000
R14386 n1_m8_183200_324000 n1_m8_183200_317600 0.034286
R14387 n1_m8_183200_324000 n1_m8_183200_340000 0.085714
R14388 n1_m8_183200_340000 n1_m8_183200_362400 0.120000
R14389 n1_m8_183200_362400 n1_m8_183200_384800 0.120000
R14390 n1_m8_183200_404000 n1_m8_183200_384800 0.102857
R14391 n1_m8_183200_404000 n1_m8_183200_407200 0.017143
R14392 n1_m8_183200_407200 n1_m8_183200_429600 0.120000
R14393 n1_m8_183200_429600 n1_m8_183200_452000 0.120000
R14394 n1_m8_183200_452000 n1_m8_183200_474400 0.120000
R14395 n1_m8_183200_484000 n1_m8_183200_474400 0.051429
R14396 n1_m8_183200_484000 n1_m8_183200_496800 0.068571
R14397 n1_m8_205600_4000 n1_m8_205600_26400 0.120000
R14398 n1_m8_205600_26400 n1_m8_205600_48800 0.120000
R14399 n1_m8_205600_48800 n1_m8_205600_71200 0.120000
R14400 n1_m8_205600_84000 n1_m8_205600_71200 0.068571
R14401 n1_m8_205600_84000 n1_m8_205600_93600 0.051429
R14402 n1_m8_205600_93600 n1_m8_205600_116000 0.120000
R14403 n1_m8_205600_116000 n1_m8_205600_138400 0.120000
R14404 n1_m8_205600_138400 n1_m8_205600_160800 0.120000
R14405 n1_m8_205600_164000 n1_m8_205600_160800 0.017143
R14406 n1_m8_205600_164000 n1_m8_205600_183200 0.102857
R14407 n1_m8_205600_183200 n1_m8_205600_205600 0.120000
R14408 n1_m8_205600_205600 n1_m8_205600_228000 0.120000
R14409 n1_m8_205600_244000 n1_m8_205600_228000 0.085714
R14410 n1_m8_205600_244000 n1_m8_205600_250400 0.034286
R14411 n1_m8_205600_250400 n1_m8_205600_272800 0.120000
R14412 n1_m8_205600_272800 n1_m8_205600_295200 0.120000
R14413 n1_m8_205600_295200 n1_m8_205600_317600 0.120000
R14414 n1_m8_205600_324000 n1_m8_205600_317600 0.034286
R14415 n1_m8_205600_324000 n1_m8_205600_340000 0.085714
R14416 n1_m8_205600_340000 n1_m8_205600_362400 0.120000
R14417 n1_m8_205600_362400 n1_m8_205600_384800 0.120000
R14418 n1_m8_205600_404000 n1_m8_205600_384800 0.102857
R14419 n1_m8_205600_404000 n1_m8_205600_407200 0.017143
R14420 n1_m8_205600_407200 n1_m8_205600_429600 0.120000
R14421 n1_m8_205600_429600 n1_m8_205600_452000 0.120000
R14422 n1_m8_205600_452000 n1_m8_205600_474400 0.120000
R14423 n1_m8_205600_484000 n1_m8_205600_474400 0.051429
R14424 n1_m8_205600_484000 n1_m8_205600_496800 0.068571
R14425 n1_m8_228000_4000 n1_m8_228000_26400 0.120000
R14426 n1_m8_228000_26400 n1_m8_228000_48800 0.120000
R14427 n1_m8_228000_48800 n1_m8_228000_71200 0.120000
R14428 n1_m8_228000_84000 n1_m8_228000_71200 0.068571
R14429 n1_m8_228000_84000 n1_m8_228000_93600 0.051429
R14430 n1_m8_228000_93600 n1_m8_228000_116000 0.120000
R14431 n1_m8_228000_116000 n1_m8_228000_138400 0.120000
R14432 n1_m8_228000_138400 n1_m8_228000_160800 0.120000
R14433 n1_m8_228000_164000 n1_m8_228000_160800 0.017143
R14434 n1_m8_228000_164000 n1_m8_228000_183200 0.102857
R14435 n1_m8_228000_183200 n1_m8_228000_205600 0.120000
R14436 n1_m8_228000_205600 n1_m8_228000_228000 0.120000
R14437 n1_m8_228000_244000 n1_m8_228000_228000 0.085714
R14438 n1_m8_228000_244000 n1_m8_228000_250400 0.034286
R14439 n1_m8_228000_250400 n1_m8_228000_272800 0.120000
R14440 n1_m8_228000_272800 n1_m8_228000_295200 0.120000
R14441 n1_m8_228000_295200 n1_m8_228000_317600 0.120000
R14442 n1_m8_228000_324000 n1_m8_228000_317600 0.034286
R14443 n1_m8_228000_324000 n1_m8_228000_340000 0.085714
R14444 n1_m8_228000_340000 n1_m8_228000_362400 0.120000
R14445 n1_m8_228000_362400 n1_m8_228000_384800 0.120000
R14446 n1_m8_228000_404000 n1_m8_228000_384800 0.102857
R14447 n1_m8_228000_404000 n1_m8_228000_407200 0.017143
R14448 n1_m8_228000_407200 n1_m8_228000_429600 0.120000
R14449 n1_m8_228000_429600 n1_m8_228000_452000 0.120000
R14450 n1_m8_228000_452000 n1_m8_228000_474400 0.120000
R14451 n1_m8_228000_484000 n1_m8_228000_474400 0.051429
R14452 n1_m8_228000_484000 n1_m8_228000_496800 0.068571
R14453 n1_m8_250400_4000 n1_m8_250400_26400 0.120000
R14454 n1_m8_250400_26400 n1_m8_250400_48800 0.120000
R14455 n1_m8_250400_48800 n1_m8_250400_71200 0.120000
R14456 n1_m8_250400_84000 n1_m8_250400_71200 0.068571
R14457 n1_m8_250400_84000 n1_m8_250400_93600 0.051429
R14458 n1_m8_250400_93600 n1_m8_250400_116000 0.120000
R14459 n1_m8_250400_116000 n1_m8_250400_138400 0.120000
R14460 n1_m8_250400_138400 n1_m8_250400_160800 0.120000
R14461 n1_m8_250400_164000 n1_m8_250400_160800 0.017143
R14462 n1_m8_250400_164000 n1_m8_250400_183200 0.102857
R14463 n1_m8_250400_183200 n1_m8_250400_205600 0.120000
R14464 n1_m8_250400_205600 n1_m8_250400_228000 0.120000
R14465 n1_m8_250400_244000 n1_m8_250400_228000 0.085714
R14466 n1_m8_250400_244000 n1_m8_250400_250400 0.034286
R14467 n1_m8_250400_250400 n1_m8_250400_272800 0.120000
R14468 n1_m8_250400_272800 n1_m8_250400_295200 0.120000
R14469 n1_m8_250400_295200 n1_m8_250400_317600 0.120000
R14470 n1_m8_250400_324000 n1_m8_250400_317600 0.034286
R14471 n1_m8_250400_324000 n1_m8_250400_340000 0.085714
R14472 n1_m8_250400_340000 n1_m8_250400_362400 0.120000
R14473 n1_m8_250400_362400 n1_m8_250400_384800 0.120000
R14474 n1_m8_250400_404000 n1_m8_250400_384800 0.102857
R14475 n1_m8_250400_404000 n1_m8_250400_407200 0.017143
R14476 n1_m8_250400_407200 n1_m8_250400_429600 0.120000
R14477 n1_m8_250400_429600 n1_m8_250400_452000 0.120000
R14478 n1_m8_250400_452000 n1_m8_250400_474400 0.120000
R14479 n1_m8_250400_484000 n1_m8_250400_474400 0.051429
R14480 n1_m8_250400_484000 n1_m8_250400_496800 0.068571
R14481 n1_m8_272800_4000 n1_m8_272800_26400 0.120000
R14482 n1_m8_272800_26400 n1_m8_272800_48800 0.120000
R14483 n1_m8_272800_48800 n1_m8_272800_71200 0.120000
R14484 n1_m8_272800_84000 n1_m8_272800_71200 0.068571
R14485 n1_m8_272800_84000 n1_m8_272800_93600 0.051429
R14486 n1_m8_272800_93600 n1_m8_272800_116000 0.120000
R14487 n1_m8_272800_116000 n1_m8_272800_138400 0.120000
R14488 n1_m8_272800_138400 n1_m8_272800_160800 0.120000
R14489 n1_m8_272800_164000 n1_m8_272800_160800 0.017143
R14490 n1_m8_272800_164000 n1_m8_272800_183200 0.102857
R14491 n1_m8_272800_183200 n1_m8_272800_205600 0.120000
R14492 n1_m8_272800_205600 n1_m8_272800_228000 0.120000
R14493 n1_m8_272800_244000 n1_m8_272800_228000 0.085714
R14494 n1_m8_272800_244000 n1_m8_272800_250400 0.034286
R14495 n1_m8_272800_250400 n1_m8_272800_272800 0.120000
R14496 n1_m8_272800_272800 n1_m8_272800_295200 0.120000
R14497 n1_m8_272800_295200 n1_m8_272800_317600 0.120000
R14498 n1_m8_272800_324000 n1_m8_272800_317600 0.034286
R14499 n1_m8_272800_324000 n1_m8_272800_340000 0.085714
R14500 n1_m8_272800_340000 n1_m8_272800_362400 0.120000
R14501 n1_m8_272800_362400 n1_m8_272800_384800 0.120000
R14502 n1_m8_272800_404000 n1_m8_272800_384800 0.102857
R14503 n1_m8_272800_404000 n1_m8_272800_407200 0.017143
R14504 n1_m8_272800_407200 n1_m8_272800_429600 0.120000
R14505 n1_m8_272800_429600 n1_m8_272800_452000 0.120000
R14506 n1_m8_272800_452000 n1_m8_272800_474400 0.120000
R14507 n1_m8_272800_484000 n1_m8_272800_474400 0.051429
R14508 n1_m8_272800_484000 n1_m8_272800_496800 0.068571
R14509 n1_m8_295200_4000 n1_m8_295200_26400 0.120000
R14510 n1_m8_295200_26400 n1_m8_295200_48800 0.120000
R14511 n1_m8_295200_48800 n1_m8_295200_71200 0.120000
R14512 n1_m8_295200_84000 n1_m8_295200_71200 0.068571
R14513 n1_m8_295200_84000 n1_m8_295200_93600 0.051429
R14514 n1_m8_295200_93600 n1_m8_295200_116000 0.120000
R14515 n1_m8_295200_116000 n1_m8_295200_138400 0.120000
R14516 n1_m8_295200_138400 n1_m8_295200_160800 0.120000
R14517 n1_m8_295200_164000 n1_m8_295200_160800 0.017143
R14518 n1_m8_295200_164000 n1_m8_295200_183200 0.102857
R14519 n1_m8_295200_183200 n1_m8_295200_205600 0.120000
R14520 n1_m8_295200_205600 n1_m8_295200_228000 0.120000
R14521 n1_m8_295200_244000 n1_m8_295200_228000 0.085714
R14522 n1_m8_295200_244000 n1_m8_295200_250400 0.034286
R14523 n1_m8_295200_250400 n1_m8_295200_272800 0.120000
R14524 n1_m8_295200_272800 n1_m8_295200_295200 0.120000
R14525 n1_m8_295200_295200 n1_m8_295200_317600 0.120000
R14526 n1_m8_295200_324000 n1_m8_295200_317600 0.034286
R14527 n1_m8_295200_324000 n1_m8_295200_340000 0.085714
R14528 n1_m8_295200_340000 n1_m8_295200_362400 0.120000
R14529 n1_m8_295200_362400 n1_m8_295200_384800 0.120000
R14530 n1_m8_295200_404000 n1_m8_295200_384800 0.102857
R14531 n1_m8_295200_404000 n1_m8_295200_407200 0.017143
R14532 n1_m8_295200_407200 n1_m8_295200_429600 0.120000
R14533 n1_m8_295200_429600 n1_m8_295200_452000 0.120000
R14534 n1_m8_295200_452000 n1_m8_295200_474400 0.120000
R14535 n1_m8_295200_484000 n1_m8_295200_474400 0.051429
R14536 n1_m8_295200_484000 n1_m8_295200_496800 0.068571
R14537 n1_m8_317600_4000 n1_m8_317600_26400 0.120000
R14538 n1_m8_317600_26400 n1_m8_317600_48800 0.120000
R14539 n1_m8_317600_48800 n1_m8_317600_71200 0.120000
R14540 n1_m8_317600_84000 n1_m8_317600_71200 0.068571
R14541 n1_m8_317600_84000 n1_m8_317600_93600 0.051429
R14542 n1_m8_317600_93600 n1_m8_317600_116000 0.120000
R14543 n1_m8_317600_116000 n1_m8_317600_138400 0.120000
R14544 n1_m8_317600_138400 n1_m8_317600_160800 0.120000
R14545 n1_m8_317600_164000 n1_m8_317600_160800 0.017143
R14546 n1_m8_317600_164000 n1_m8_317600_183200 0.102857
R14547 n1_m8_317600_183200 n1_m8_317600_205600 0.120000
R14548 n1_m8_317600_205600 n1_m8_317600_228000 0.120000
R14549 n1_m8_317600_244000 n1_m8_317600_228000 0.085714
R14550 n1_m8_317600_244000 n1_m8_317600_250400 0.034286
R14551 n1_m8_317600_250400 n1_m8_317600_272800 0.120000
R14552 n1_m8_317600_272800 n1_m8_317600_295200 0.120000
R14553 n1_m8_317600_295200 n1_m8_317600_317600 0.120000
R14554 n1_m8_317600_324000 n1_m8_317600_317600 0.034286
R14555 n1_m8_317600_324000 n1_m8_317600_340000 0.085714
R14556 n1_m8_317600_340000 n1_m8_317600_362400 0.120000
R14557 n1_m8_317600_362400 n1_m8_317600_384800 0.120000
R14558 n1_m8_317600_404000 n1_m8_317600_384800 0.102857
R14559 n1_m8_317600_404000 n1_m8_317600_407200 0.017143
R14560 n1_m8_317600_407200 n1_m8_317600_429600 0.120000
R14561 n1_m8_317600_429600 n1_m8_317600_452000 0.120000
R14562 n1_m8_317600_452000 n1_m8_317600_474400 0.120000
R14563 n1_m8_317600_484000 n1_m8_317600_474400 0.051429
R14564 n1_m8_317600_484000 n1_m8_317600_496800 0.068571
R14565 n1_m8_340000_4000 n1_m8_340000_26400 0.120000
R14566 n1_m8_340000_26400 n1_m8_340000_48800 0.120000
R14567 n1_m8_340000_48800 n1_m8_340000_71200 0.120000
R14568 n1_m8_340000_84000 n1_m8_340000_71200 0.068571
R14569 n1_m8_340000_84000 n1_m8_340000_93600 0.051429
R14570 n1_m8_340000_93600 n1_m8_340000_116000 0.120000
R14571 n1_m8_340000_116000 n1_m8_340000_138400 0.120000
R14572 n1_m8_340000_138400 n1_m8_340000_160800 0.120000
R14573 n1_m8_340000_164000 n1_m8_340000_160800 0.017143
R14574 n1_m8_340000_164000 n1_m8_340000_183200 0.102857
R14575 n1_m8_340000_183200 n1_m8_340000_205600 0.120000
R14576 n1_m8_340000_205600 n1_m8_340000_228000 0.120000
R14577 n1_m8_340000_244000 n1_m8_340000_228000 0.085714
R14578 n1_m8_340000_244000 n1_m8_340000_250400 0.034286
R14579 n1_m8_340000_250400 n1_m8_340000_272800 0.120000
R14580 n1_m8_340000_272800 n1_m8_340000_295200 0.120000
R14581 n1_m8_340000_295200 n1_m8_340000_317600 0.120000
R14582 n1_m8_340000_324000 n1_m8_340000_317600 0.034286
R14583 n1_m8_340000_324000 n1_m8_340000_340000 0.085714
R14584 n1_m8_340000_340000 n1_m8_340000_362400 0.120000
R14585 n1_m8_340000_362400 n1_m8_340000_384800 0.120000
R14586 n1_m8_340000_404000 n1_m8_340000_384800 0.102857
R14587 n1_m8_340000_404000 n1_m8_340000_407200 0.017143
R14588 n1_m8_340000_407200 n1_m8_340000_429600 0.120000
R14589 n1_m8_340000_429600 n1_m8_340000_452000 0.120000
R14590 n1_m8_340000_452000 n1_m8_340000_474400 0.120000
R14591 n1_m8_340000_484000 n1_m8_340000_474400 0.051429
R14592 n1_m8_340000_484000 n1_m8_340000_496800 0.068571
R14593 n1_m8_362400_4000 n1_m8_362400_26400 0.120000
R14594 n1_m8_362400_26400 n1_m8_362400_48800 0.120000
R14595 n1_m8_362400_48800 n1_m8_362400_71200 0.120000
R14596 n1_m8_362400_84000 n1_m8_362400_71200 0.068571
R14597 n1_m8_362400_84000 n1_m8_362400_93600 0.051429
R14598 n1_m8_362400_93600 n1_m8_362400_116000 0.120000
R14599 n1_m8_362400_116000 n1_m8_362400_138400 0.120000
R14600 n1_m8_362400_138400 n1_m8_362400_160800 0.120000
R14601 n1_m8_362400_164000 n1_m8_362400_160800 0.017143
R14602 n1_m8_362400_164000 n1_m8_362400_183200 0.102857
R14603 n1_m8_362400_183200 n1_m8_362400_205600 0.120000
R14604 n1_m8_362400_205600 n1_m8_362400_228000 0.120000
R14605 n1_m8_362400_244000 n1_m8_362400_228000 0.085714
R14606 n1_m8_362400_244000 n1_m8_362400_250400 0.034286
R14607 n1_m8_362400_250400 n1_m8_362400_272800 0.120000
R14608 n1_m8_362400_272800 n1_m8_362400_295200 0.120000
R14609 n1_m8_362400_295200 n1_m8_362400_317600 0.120000
R14610 n1_m8_362400_324000 n1_m8_362400_317600 0.034286
R14611 n1_m8_362400_324000 n1_m8_362400_340000 0.085714
R14612 n1_m8_362400_340000 n1_m8_362400_362400 0.120000
R14613 n1_m8_362400_362400 n1_m8_362400_384800 0.120000
R14614 n1_m8_362400_404000 n1_m8_362400_384800 0.102857
R14615 n1_m8_362400_404000 n1_m8_362400_407200 0.017143
R14616 n1_m8_362400_407200 n1_m8_362400_429600 0.120000
R14617 n1_m8_362400_429600 n1_m8_362400_452000 0.120000
R14618 n1_m8_362400_452000 n1_m8_362400_474400 0.120000
R14619 n1_m8_362400_484000 n1_m8_362400_474400 0.051429
R14620 n1_m8_362400_484000 n1_m8_362400_496800 0.068571
R14621 n1_m8_384800_4000 n1_m8_384800_26400 0.120000
R14622 n1_m8_384800_26400 n1_m8_384800_48800 0.120000
R14623 n1_m8_384800_48800 n1_m8_384800_71200 0.120000
R14624 n1_m8_384800_84000 n1_m8_384800_71200 0.068571
R14625 n1_m8_384800_84000 n1_m8_384800_93600 0.051429
R14626 n1_m8_384800_93600 n1_m8_384800_116000 0.120000
R14627 n1_m8_384800_116000 n1_m8_384800_138400 0.120000
R14628 n1_m8_384800_138400 n1_m8_384800_160800 0.120000
R14629 n1_m8_384800_164000 n1_m8_384800_160800 0.017143
R14630 n1_m8_384800_164000 n1_m8_384800_183200 0.102857
R14631 n1_m8_384800_183200 n1_m8_384800_205600 0.120000
R14632 n1_m8_384800_205600 n1_m8_384800_228000 0.120000
R14633 n1_m8_384800_244000 n1_m8_384800_228000 0.085714
R14634 n1_m8_384800_244000 n1_m8_384800_250400 0.034286
R14635 n1_m8_384800_250400 n1_m8_384800_272800 0.120000
R14636 n1_m8_384800_272800 n1_m8_384800_295200 0.120000
R14637 n1_m8_384800_295200 n1_m8_384800_317600 0.120000
R14638 n1_m8_384800_324000 n1_m8_384800_317600 0.034286
R14639 n1_m8_384800_324000 n1_m8_384800_340000 0.085714
R14640 n1_m8_384800_340000 n1_m8_384800_362400 0.120000
R14641 n1_m8_384800_362400 n1_m8_384800_384800 0.120000
R14642 n1_m8_384800_404000 n1_m8_384800_384800 0.102857
R14643 n1_m8_384800_404000 n1_m8_384800_407200 0.017143
R14644 n1_m8_384800_407200 n1_m8_384800_429600 0.120000
R14645 n1_m8_384800_429600 n1_m8_384800_452000 0.120000
R14646 n1_m8_384800_452000 n1_m8_384800_474400 0.120000
R14647 n1_m8_384800_484000 n1_m8_384800_474400 0.051429
R14648 n1_m8_384800_484000 n1_m8_384800_496800 0.068571
R14649 n1_m8_407200_4000 n1_m8_407200_26400 0.120000
R14650 n1_m8_407200_26400 n1_m8_407200_48800 0.120000
R14651 n1_m8_407200_48800 n1_m8_407200_71200 0.120000
R14652 n1_m8_407200_84000 n1_m8_407200_71200 0.068571
R14653 n1_m8_407200_84000 n1_m8_407200_93600 0.051429
R14654 n1_m8_407200_93600 n1_m8_407200_116000 0.120000
R14655 n1_m8_407200_116000 n1_m8_407200_138400 0.120000
R14656 n1_m8_407200_138400 n1_m8_407200_160800 0.120000
R14657 n1_m8_407200_164000 n1_m8_407200_160800 0.017143
R14658 n1_m8_407200_164000 n1_m8_407200_183200 0.102857
R14659 n1_m8_407200_183200 n1_m8_407200_205600 0.120000
R14660 n1_m8_407200_205600 n1_m8_407200_228000 0.120000
R14661 n1_m8_407200_244000 n1_m8_407200_228000 0.085714
R14662 n1_m8_407200_244000 n1_m8_407200_250400 0.034286
R14663 n1_m8_407200_250400 n1_m8_407200_272800 0.120000
R14664 n1_m8_407200_272800 n1_m8_407200_295200 0.120000
R14665 n1_m8_407200_295200 n1_m8_407200_317600 0.120000
R14666 n1_m8_407200_324000 n1_m8_407200_317600 0.034286
R14667 n1_m8_407200_324000 n1_m8_407200_340000 0.085714
R14668 n1_m8_407200_340000 n1_m8_407200_362400 0.120000
R14669 n1_m8_407200_362400 n1_m8_407200_384800 0.120000
R14670 n1_m8_407200_404000 n1_m8_407200_384800 0.102857
R14671 n1_m8_407200_404000 n1_m8_407200_407200 0.017143
R14672 n1_m8_407200_407200 n1_m8_407200_429600 0.120000
R14673 n1_m8_407200_429600 n1_m8_407200_452000 0.120000
R14674 n1_m8_407200_452000 n1_m8_407200_474400 0.120000
R14675 n1_m8_407200_484000 n1_m8_407200_474400 0.051429
R14676 n1_m8_407200_484000 n1_m8_407200_496800 0.068571
R14677 n1_m8_429600_4000 n1_m8_429600_26400 0.120000
R14678 n1_m8_429600_26400 n1_m8_429600_48800 0.120000
R14679 n1_m8_429600_48800 n1_m8_429600_71200 0.120000
R14680 n1_m8_429600_84000 n1_m8_429600_71200 0.068571
R14681 n1_m8_429600_84000 n1_m8_429600_93600 0.051429
R14682 n1_m8_429600_93600 n1_m8_429600_116000 0.120000
R14683 n1_m8_429600_116000 n1_m8_429600_138400 0.120000
R14684 n1_m8_429600_138400 n1_m8_429600_160800 0.120000
R14685 n1_m8_429600_164000 n1_m8_429600_160800 0.017143
R14686 n1_m8_429600_164000 n1_m8_429600_183200 0.102857
R14687 n1_m8_429600_183200 n1_m8_429600_205600 0.120000
R14688 n1_m8_429600_205600 n1_m8_429600_228000 0.120000
R14689 n1_m8_429600_244000 n1_m8_429600_228000 0.085714
R14690 n1_m8_429600_244000 n1_m8_429600_250400 0.034286
R14691 n1_m8_429600_250400 n1_m8_429600_272800 0.120000
R14692 n1_m8_429600_272800 n1_m8_429600_295200 0.120000
R14693 n1_m8_429600_295200 n1_m8_429600_317600 0.120000
R14694 n1_m8_429600_324000 n1_m8_429600_317600 0.034286
R14695 n1_m8_429600_324000 n1_m8_429600_340000 0.085714
R14696 n1_m8_429600_340000 n1_m8_429600_362400 0.120000
R14697 n1_m8_429600_362400 n1_m8_429600_384800 0.120000
R14698 n1_m8_429600_404000 n1_m8_429600_384800 0.102857
R14699 n1_m8_429600_404000 n1_m8_429600_407200 0.017143
R14700 n1_m8_429600_407200 n1_m8_429600_429600 0.120000
R14701 n1_m8_429600_429600 n1_m8_429600_452000 0.120000
R14702 n1_m8_429600_452000 n1_m8_429600_474400 0.120000
R14703 n1_m8_429600_484000 n1_m8_429600_474400 0.051429
R14704 n1_m8_429600_484000 n1_m8_429600_496800 0.068571
R14705 n1_m8_452000_4000 n1_m8_452000_26400 0.120000
R14706 n1_m8_452000_26400 n1_m8_452000_48800 0.120000
R14707 n1_m8_452000_48800 n1_m8_452000_71200 0.120000
R14708 n1_m8_452000_84000 n1_m8_452000_71200 0.068571
R14709 n1_m8_452000_84000 n1_m8_452000_93600 0.051429
R14710 n1_m8_452000_93600 n1_m8_452000_116000 0.120000
R14711 n1_m8_452000_116000 n1_m8_452000_138400 0.120000
R14712 n1_m8_452000_138400 n1_m8_452000_160800 0.120000
R14713 n1_m8_452000_164000 n1_m8_452000_160800 0.017143
R14714 n1_m8_452000_164000 n1_m8_452000_183200 0.102857
R14715 n1_m8_452000_183200 n1_m8_452000_205600 0.120000
R14716 n1_m8_452000_205600 n1_m8_452000_228000 0.120000
R14717 n1_m8_452000_244000 n1_m8_452000_228000 0.085714
R14718 n1_m8_452000_244000 n1_m8_452000_250400 0.034286
R14719 n1_m8_452000_250400 n1_m8_452000_272800 0.120000
R14720 n1_m8_452000_272800 n1_m8_452000_295200 0.120000
R14721 n1_m8_452000_295200 n1_m8_452000_317600 0.120000
R14722 n1_m8_452000_324000 n1_m8_452000_317600 0.034286
R14723 n1_m8_452000_324000 n1_m8_452000_340000 0.085714
R14724 n1_m8_452000_340000 n1_m8_452000_362400 0.120000
R14725 n1_m8_452000_362400 n1_m8_452000_384800 0.120000
R14726 n1_m8_452000_404000 n1_m8_452000_384800 0.102857
R14727 n1_m8_452000_404000 n1_m8_452000_407200 0.017143
R14728 n1_m8_452000_407200 n1_m8_452000_429600 0.120000
R14729 n1_m8_452000_429600 n1_m8_452000_452000 0.120000
R14730 n1_m8_452000_452000 n1_m8_452000_474400 0.120000
R14731 n1_m8_452000_484000 n1_m8_452000_474400 0.051429
R14732 n1_m8_452000_484000 n1_m8_452000_496800 0.068571
R14733 n1_m8_474400_4000 n1_m8_474400_26400 0.120000
R14734 n1_m8_474400_26400 n1_m8_474400_48800 0.120000
R14735 n1_m8_474400_48800 n1_m8_474400_71200 0.120000
R14736 n1_m8_474400_84000 n1_m8_474400_71200 0.068571
R14737 n1_m8_474400_84000 n1_m8_474400_93600 0.051429
R14738 n1_m8_474400_93600 n1_m8_474400_116000 0.120000
R14739 n1_m8_474400_116000 n1_m8_474400_138400 0.120000
R14740 n1_m8_474400_138400 n1_m8_474400_160800 0.120000
R14741 n1_m8_474400_164000 n1_m8_474400_160800 0.017143
R14742 n1_m8_474400_164000 n1_m8_474400_183200 0.102857
R14743 n1_m8_474400_183200 n1_m8_474400_205600 0.120000
R14744 n1_m8_474400_205600 n1_m8_474400_228000 0.120000
R14745 n1_m8_474400_244000 n1_m8_474400_228000 0.085714
R14746 n1_m8_474400_244000 n1_m8_474400_250400 0.034286
R14747 n1_m8_474400_250400 n1_m8_474400_272800 0.120000
R14748 n1_m8_474400_272800 n1_m8_474400_295200 0.120000
R14749 n1_m8_474400_295200 n1_m8_474400_317600 0.120000
R14750 n1_m8_474400_324000 n1_m8_474400_317600 0.034286
R14751 n1_m8_474400_324000 n1_m8_474400_340000 0.085714
R14752 n1_m8_474400_340000 n1_m8_474400_362400 0.120000
R14753 n1_m8_474400_362400 n1_m8_474400_384800 0.120000
R14754 n1_m8_474400_404000 n1_m8_474400_384800 0.102857
R14755 n1_m8_474400_404000 n1_m8_474400_407200 0.017143
R14756 n1_m8_474400_407200 n1_m8_474400_429600 0.120000
R14757 n1_m8_474400_429600 n1_m8_474400_452000 0.120000
R14758 n1_m8_474400_452000 n1_m8_474400_474400 0.120000
R14759 n1_m8_474400_484000 n1_m8_474400_474400 0.051429
R14760 n1_m8_474400_484000 n1_m8_474400_496800 0.068571
R14761 n1_m8_496800_4000 n1_m8_496800_26400 0.120000
R14762 n1_m8_496800_26400 n1_m8_496800_48800 0.120000
R14763 n1_m8_496800_48800 n1_m8_496800_71200 0.120000
R14764 n1_m8_496800_84000 n1_m8_496800_71200 0.068571
R14765 n1_m8_496800_84000 n1_m8_496800_93600 0.051429
R14766 n1_m8_496800_93600 n1_m8_496800_116000 0.120000
R14767 n1_m8_496800_116000 n1_m8_496800_138400 0.120000
R14768 n1_m8_496800_138400 n1_m8_496800_160800 0.120000
R14769 n1_m8_496800_164000 n1_m8_496800_160800 0.017143
R14770 n1_m8_496800_164000 n1_m8_496800_183200 0.102857
R14771 n1_m8_496800_183200 n1_m8_496800_205600 0.120000
R14772 n1_m8_496800_205600 n1_m8_496800_228000 0.120000
R14773 n1_m8_496800_244000 n1_m8_496800_228000 0.085714
R14774 n1_m8_496800_244000 n1_m8_496800_250400 0.034286
R14775 n1_m8_496800_250400 n1_m8_496800_272800 0.120000
R14776 n1_m8_496800_272800 n1_m8_496800_295200 0.120000
R14777 n1_m8_496800_295200 n1_m8_496800_317600 0.120000
R14778 n1_m8_496800_324000 n1_m8_496800_317600 0.034286
R14779 n1_m8_496800_324000 n1_m8_496800_340000 0.085714
R14780 n1_m8_496800_340000 n1_m8_496800_362400 0.120000
R14781 n1_m8_496800_362400 n1_m8_496800_384800 0.120000
R14782 n1_m8_496800_404000 n1_m8_496800_384800 0.102857
R14783 n1_m8_496800_404000 n1_m8_496800_407200 0.017143
R14784 n1_m8_496800_407200 n1_m8_496800_429600 0.120000
R14785 n1_m8_496800_429600 n1_m8_496800_452000 0.120000
R14786 n1_m8_496800_452000 n1_m8_496800_474400 0.120000
R14787 n1_m8_496800_484000 n1_m8_496800_474400 0.051429
R14788 n1_m8_496800_484000 n1_m8_496800_496800 0.068571
R14789 n1_m9_4000_4000 n1_m9_26400_4000 0.096000
R14790 n1_m9_26400_4000 n1_m9_48800_4000 0.096000
R14791 n1_m9_48800_4000 n1_m9_71200_4000 0.096000
R14792 n1_m9_71200_4000 n1_m9_93600_4000 0.096000
R14793 n1_m9_93600_4000 n1_m9_116000_4000 0.096000
R14794 n1_m9_116000_4000 n1_m9_138400_4000 0.096000
R14795 n1_m9_138400_4000 n1_m9_160800_4000 0.096000
R14796 n1_m9_160800_4000 n1_m9_183200_4000 0.096000
R14797 n1_m9_183200_4000 n1_m9_205600_4000 0.096000
R14798 n1_m9_205600_4000 n1_m9_228000_4000 0.096000
R14799 n1_m9_228000_4000 n1_m9_250400_4000 0.096000
R14800 n1_m9_250400_4000 n1_m9_272800_4000 0.096000
R14801 n1_m9_272800_4000 n1_m9_295200_4000 0.096000
R14802 n1_m9_295200_4000 n1_m9_317600_4000 0.096000
R14803 n1_m9_317600_4000 n1_m9_340000_4000 0.096000
R14804 n1_m9_340000_4000 n1_m9_362400_4000 0.096000
R14805 n1_m9_362400_4000 n1_m9_384800_4000 0.096000
R14806 n1_m9_384800_4000 n1_m9_407200_4000 0.096000
R14807 n1_m9_407200_4000 n1_m9_429600_4000 0.096000
R14808 n1_m9_429600_4000 n1_m9_452000_4000 0.096000
R14809 n1_m9_452000_4000 n1_m9_474400_4000 0.096000
R14810 n1_m9_474400_4000 n1_m9_496800_4000 0.096000
R14811 n1_m9_4000_26400 n1_m9_26400_26400 0.096000
R14812 n1_m9_26400_26400 n1_m9_48800_26400 0.096000
R14813 n1_m9_48800_26400 n1_m9_71200_26400 0.096000
R14814 n1_m9_71200_26400 n1_m9_93600_26400 0.096000
R14815 n1_m9_93600_26400 n1_m9_116000_26400 0.096000
R14816 n1_m9_116000_26400 n1_m9_138400_26400 0.096000
R14817 n1_m9_138400_26400 n1_m9_160800_26400 0.096000
R14818 n1_m9_160800_26400 n1_m9_183200_26400 0.096000
R14819 n1_m9_183200_26400 n1_m9_205600_26400 0.096000
R14820 n1_m9_205600_26400 n1_m9_228000_26400 0.096000
R14821 n1_m9_228000_26400 n1_m9_250400_26400 0.096000
R14822 n1_m9_250400_26400 n1_m9_272800_26400 0.096000
R14823 n1_m9_272800_26400 n1_m9_295200_26400 0.096000
R14824 n1_m9_295200_26400 n1_m9_317600_26400 0.096000
R14825 n1_m9_317600_26400 n1_m9_340000_26400 0.096000
R14826 n1_m9_340000_26400 n1_m9_362400_26400 0.096000
R14827 n1_m9_362400_26400 n1_m9_384800_26400 0.096000
R14828 n1_m9_384800_26400 n1_m9_407200_26400 0.096000
R14829 n1_m9_407200_26400 n1_m9_429600_26400 0.096000
R14830 n1_m9_429600_26400 n1_m9_452000_26400 0.096000
R14831 n1_m9_452000_26400 n1_m9_474400_26400 0.096000
R14832 n1_m9_474400_26400 n1_m9_496800_26400 0.096000
R14833 n1_m9_4000_48800 n1_m9_26400_48800 0.096000
R14834 n1_m9_26400_48800 n1_m9_48800_48800 0.096000
R14835 n1_m9_48800_48800 n1_m9_71200_48800 0.096000
R14836 n1_m9_71200_48800 n1_m9_93600_48800 0.096000
R14837 n1_m9_93600_48800 n1_m9_116000_48800 0.096000
R14838 n1_m9_116000_48800 n1_m9_138400_48800 0.096000
R14839 n1_m9_138400_48800 n1_m9_160800_48800 0.096000
R14840 n1_m9_160800_48800 n1_m9_183200_48800 0.096000
R14841 n1_m9_183200_48800 n1_m9_205600_48800 0.096000
R14842 n1_m9_205600_48800 n1_m9_228000_48800 0.096000
R14843 n1_m9_228000_48800 n1_m9_250400_48800 0.096000
R14844 n1_m9_250400_48800 n1_m9_272800_48800 0.096000
R14845 n1_m9_272800_48800 n1_m9_295200_48800 0.096000
R14846 n1_m9_295200_48800 n1_m9_317600_48800 0.096000
R14847 n1_m9_317600_48800 n1_m9_340000_48800 0.096000
R14848 n1_m9_340000_48800 n1_m9_362400_48800 0.096000
R14849 n1_m9_362400_48800 n1_m9_384800_48800 0.096000
R14850 n1_m9_384800_48800 n1_m9_407200_48800 0.096000
R14851 n1_m9_407200_48800 n1_m9_429600_48800 0.096000
R14852 n1_m9_429600_48800 n1_m9_452000_48800 0.096000
R14853 n1_m9_452000_48800 n1_m9_474400_48800 0.096000
R14854 n1_m9_474400_48800 n1_m9_496800_48800 0.096000
R14855 n1_m9_4000_71200 n1_m9_26400_71200 0.096000
R14856 n1_m9_26400_71200 n1_m9_48800_71200 0.096000
R14857 n1_m9_48800_71200 n1_m9_71200_71200 0.096000
R14858 n1_m9_71200_71200 n1_m9_93600_71200 0.096000
R14859 n1_m9_93600_71200 n1_m9_116000_71200 0.096000
R14860 n1_m9_116000_71200 n1_m9_138400_71200 0.096000
R14861 n1_m9_138400_71200 n1_m9_160800_71200 0.096000
R14862 n1_m9_160800_71200 n1_m9_183200_71200 0.096000
R14863 n1_m9_183200_71200 n1_m9_205600_71200 0.096000
R14864 n1_m9_205600_71200 n1_m9_228000_71200 0.096000
R14865 n1_m9_228000_71200 n1_m9_250400_71200 0.096000
R14866 n1_m9_250400_71200 n1_m9_272800_71200 0.096000
R14867 n1_m9_272800_71200 n1_m9_295200_71200 0.096000
R14868 n1_m9_295200_71200 n1_m9_317600_71200 0.096000
R14869 n1_m9_317600_71200 n1_m9_340000_71200 0.096000
R14870 n1_m9_340000_71200 n1_m9_362400_71200 0.096000
R14871 n1_m9_362400_71200 n1_m9_384800_71200 0.096000
R14872 n1_m9_384800_71200 n1_m9_407200_71200 0.096000
R14873 n1_m9_407200_71200 n1_m9_429600_71200 0.096000
R14874 n1_m9_429600_71200 n1_m9_452000_71200 0.096000
R14875 n1_m9_452000_71200 n1_m9_474400_71200 0.096000
R14876 n1_m9_474400_71200 n1_m9_496800_71200 0.096000
R14877 n1_m9_4000_93600 n1_m9_26400_93600 0.096000
R14878 n1_m9_26400_93600 n1_m9_48800_93600 0.096000
R14879 n1_m9_48800_93600 n1_m9_71200_93600 0.096000
R14880 n1_m9_71200_93600 n1_m9_93600_93600 0.096000
R14881 n1_m9_93600_93600 n1_m9_116000_93600 0.096000
R14882 n1_m9_116000_93600 n1_m9_138400_93600 0.096000
R14883 n1_m9_138400_93600 n1_m9_160800_93600 0.096000
R14884 n1_m9_160800_93600 n1_m9_183200_93600 0.096000
R14885 n1_m9_183200_93600 n1_m9_205600_93600 0.096000
R14886 n1_m9_205600_93600 n1_m9_228000_93600 0.096000
R14887 n1_m9_228000_93600 n1_m9_250400_93600 0.096000
R14888 n1_m9_250400_93600 n1_m9_272800_93600 0.096000
R14889 n1_m9_272800_93600 n1_m9_295200_93600 0.096000
R14890 n1_m9_295200_93600 n1_m9_317600_93600 0.096000
R14891 n1_m9_317600_93600 n1_m9_340000_93600 0.096000
R14892 n1_m9_340000_93600 n1_m9_362400_93600 0.096000
R14893 n1_m9_362400_93600 n1_m9_384800_93600 0.096000
R14894 n1_m9_384800_93600 n1_m9_407200_93600 0.096000
R14895 n1_m9_407200_93600 n1_m9_429600_93600 0.096000
R14896 n1_m9_429600_93600 n1_m9_452000_93600 0.096000
R14897 n1_m9_452000_93600 n1_m9_474400_93600 0.096000
R14898 n1_m9_474400_93600 n1_m9_496800_93600 0.096000
R14899 n1_m9_4000_116000 n1_m9_26400_116000 0.096000
R14900 n1_m9_26400_116000 n1_m9_48800_116000 0.096000
R14901 n1_m9_48800_116000 n1_m9_71200_116000 0.096000
R14902 n1_m9_71200_116000 n1_m9_93600_116000 0.096000
R14903 n1_m9_93600_116000 n1_m9_116000_116000 0.096000
R14904 n1_m9_116000_116000 n1_m9_138400_116000 0.096000
R14905 n1_m9_138400_116000 n1_m9_160800_116000 0.096000
R14906 n1_m9_160800_116000 n1_m9_183200_116000 0.096000
R14907 n1_m9_183200_116000 n1_m9_205600_116000 0.096000
R14908 n1_m9_205600_116000 n1_m9_228000_116000 0.096000
R14909 n1_m9_228000_116000 n1_m9_250400_116000 0.096000
R14910 n1_m9_250400_116000 n1_m9_272800_116000 0.096000
R14911 n1_m9_272800_116000 n1_m9_295200_116000 0.096000
R14912 n1_m9_295200_116000 n1_m9_317600_116000 0.096000
R14913 n1_m9_317600_116000 n1_m9_340000_116000 0.096000
R14914 n1_m9_340000_116000 n1_m9_362400_116000 0.096000
R14915 n1_m9_362400_116000 n1_m9_384800_116000 0.096000
R14916 n1_m9_384800_116000 n1_m9_407200_116000 0.096000
R14917 n1_m9_407200_116000 n1_m9_429600_116000 0.096000
R14918 n1_m9_429600_116000 n1_m9_452000_116000 0.096000
R14919 n1_m9_452000_116000 n1_m9_474400_116000 0.096000
R14920 n1_m9_474400_116000 n1_m9_496800_116000 0.096000
R14921 n1_m9_4000_138400 n1_m9_26400_138400 0.096000
R14922 n1_m9_26400_138400 n1_m9_48800_138400 0.096000
R14923 n1_m9_48800_138400 n1_m9_71200_138400 0.096000
R14924 n1_m9_71200_138400 n1_m9_93600_138400 0.096000
R14925 n1_m9_93600_138400 n1_m9_116000_138400 0.096000
R14926 n1_m9_116000_138400 n1_m9_138400_138400 0.096000
R14927 n1_m9_138400_138400 n1_m9_160800_138400 0.096000
R14928 n1_m9_160800_138400 n1_m9_183200_138400 0.096000
R14929 n1_m9_183200_138400 n1_m9_205600_138400 0.096000
R14930 n1_m9_205600_138400 n1_m9_228000_138400 0.096000
R14931 n1_m9_228000_138400 n1_m9_250400_138400 0.096000
R14932 n1_m9_250400_138400 n1_m9_272800_138400 0.096000
R14933 n1_m9_272800_138400 n1_m9_295200_138400 0.096000
R14934 n1_m9_295200_138400 n1_m9_317600_138400 0.096000
R14935 n1_m9_317600_138400 n1_m9_340000_138400 0.096000
R14936 n1_m9_340000_138400 n1_m9_362400_138400 0.096000
R14937 n1_m9_362400_138400 n1_m9_384800_138400 0.096000
R14938 n1_m9_384800_138400 n1_m9_407200_138400 0.096000
R14939 n1_m9_407200_138400 n1_m9_429600_138400 0.096000
R14940 n1_m9_429600_138400 n1_m9_452000_138400 0.096000
R14941 n1_m9_452000_138400 n1_m9_474400_138400 0.096000
R14942 n1_m9_474400_138400 n1_m9_496800_138400 0.096000
R14943 n1_m9_4000_160800 n1_m9_26400_160800 0.096000
R14944 n1_m9_26400_160800 n1_m9_48800_160800 0.096000
R14945 n1_m9_48800_160800 n1_m9_71200_160800 0.096000
R14946 n1_m9_71200_160800 n1_m9_93600_160800 0.096000
R14947 n1_m9_93600_160800 n1_m9_116000_160800 0.096000
R14948 n1_m9_116000_160800 n1_m9_138400_160800 0.096000
R14949 n1_m9_138400_160800 n1_m9_160800_160800 0.096000
R14950 n1_m9_160800_160800 n1_m9_183200_160800 0.096000
R14951 n1_m9_183200_160800 n1_m9_205600_160800 0.096000
R14952 n1_m9_205600_160800 n1_m9_228000_160800 0.096000
R14953 n1_m9_228000_160800 n1_m9_250400_160800 0.096000
R14954 n1_m9_250400_160800 n1_m9_272800_160800 0.096000
R14955 n1_m9_272800_160800 n1_m9_295200_160800 0.096000
R14956 n1_m9_295200_160800 n1_m9_317600_160800 0.096000
R14957 n1_m9_317600_160800 n1_m9_340000_160800 0.096000
R14958 n1_m9_340000_160800 n1_m9_362400_160800 0.096000
R14959 n1_m9_362400_160800 n1_m9_384800_160800 0.096000
R14960 n1_m9_384800_160800 n1_m9_407200_160800 0.096000
R14961 n1_m9_407200_160800 n1_m9_429600_160800 0.096000
R14962 n1_m9_429600_160800 n1_m9_452000_160800 0.096000
R14963 n1_m9_452000_160800 n1_m9_474400_160800 0.096000
R14964 n1_m9_474400_160800 n1_m9_496800_160800 0.096000
R14965 n1_m9_4000_183200 n1_m9_26400_183200 0.096000
R14966 n1_m9_26400_183200 n1_m9_48800_183200 0.096000
R14967 n1_m9_48800_183200 n1_m9_71200_183200 0.096000
R14968 n1_m9_71200_183200 n1_m9_93600_183200 0.096000
R14969 n1_m9_93600_183200 n1_m9_116000_183200 0.096000
R14970 n1_m9_116000_183200 n1_m9_138400_183200 0.096000
R14971 n1_m9_138400_183200 n1_m9_160800_183200 0.096000
R14972 n1_m9_160800_183200 n1_m9_183200_183200 0.096000
R14973 n1_m9_183200_183200 n1_m9_205600_183200 0.096000
R14974 n1_m9_205600_183200 n1_m9_228000_183200 0.096000
R14975 n1_m9_228000_183200 n1_m9_250400_183200 0.096000
R14976 n1_m9_250400_183200 n1_m9_272800_183200 0.096000
R14977 n1_m9_272800_183200 n1_m9_295200_183200 0.096000
R14978 n1_m9_295200_183200 n1_m9_317600_183200 0.096000
R14979 n1_m9_317600_183200 n1_m9_340000_183200 0.096000
R14980 n1_m9_340000_183200 n1_m9_362400_183200 0.096000
R14981 n1_m9_362400_183200 n1_m9_384800_183200 0.096000
R14982 n1_m9_384800_183200 n1_m9_407200_183200 0.096000
R14983 n1_m9_407200_183200 n1_m9_429600_183200 0.096000
R14984 n1_m9_429600_183200 n1_m9_452000_183200 0.096000
R14985 n1_m9_452000_183200 n1_m9_474400_183200 0.096000
R14986 n1_m9_474400_183200 n1_m9_496800_183200 0.096000
R14987 n1_m9_4000_205600 n1_m9_26400_205600 0.096000
R14988 n1_m9_26400_205600 n1_m9_48800_205600 0.096000
R14989 n1_m9_48800_205600 n1_m9_71200_205600 0.096000
R14990 n1_m9_71200_205600 n1_m9_93600_205600 0.096000
R14991 n1_m9_93600_205600 n1_m9_116000_205600 0.096000
R14992 n1_m9_116000_205600 n1_m9_138400_205600 0.096000
R14993 n1_m9_138400_205600 n1_m9_160800_205600 0.096000
R14994 n1_m9_160800_205600 n1_m9_183200_205600 0.096000
R14995 n1_m9_183200_205600 n1_m9_205600_205600 0.096000
R14996 n1_m9_205600_205600 n1_m9_228000_205600 0.096000
R14997 n1_m9_228000_205600 n1_m9_250400_205600 0.096000
R14998 n1_m9_250400_205600 n1_m9_272800_205600 0.096000
R14999 n1_m9_272800_205600 n1_m9_295200_205600 0.096000
R15000 n1_m9_295200_205600 n1_m9_317600_205600 0.096000
R15001 n1_m9_317600_205600 n1_m9_340000_205600 0.096000
R15002 n1_m9_340000_205600 n1_m9_362400_205600 0.096000
R15003 n1_m9_362400_205600 n1_m9_384800_205600 0.096000
R15004 n1_m9_384800_205600 n1_m9_407200_205600 0.096000
R15005 n1_m9_407200_205600 n1_m9_429600_205600 0.096000
R15006 n1_m9_429600_205600 n1_m9_452000_205600 0.096000
R15007 n1_m9_452000_205600 n1_m9_474400_205600 0.096000
R15008 n1_m9_474400_205600 n1_m9_496800_205600 0.096000
R15009 n1_m9_4000_228000 n1_m9_26400_228000 0.096000
R15010 n1_m9_26400_228000 n1_m9_48800_228000 0.096000
R15011 n1_m9_48800_228000 n1_m9_71200_228000 0.096000
R15012 n1_m9_71200_228000 n1_m9_93600_228000 0.096000
R15013 n1_m9_93600_228000 n1_m9_116000_228000 0.096000
R15014 n1_m9_116000_228000 n1_m9_138400_228000 0.096000
R15015 n1_m9_138400_228000 n1_m9_160800_228000 0.096000
R15016 n1_m9_160800_228000 n1_m9_183200_228000 0.096000
R15017 n1_m9_183200_228000 n1_m9_205600_228000 0.096000
R15018 n1_m9_205600_228000 n1_m9_228000_228000 0.096000
R15019 n1_m9_228000_228000 n1_m9_250400_228000 0.096000
R15020 n1_m9_250400_228000 n1_m9_272800_228000 0.096000
R15021 n1_m9_272800_228000 n1_m9_295200_228000 0.096000
R15022 n1_m9_295200_228000 n1_m9_317600_228000 0.096000
R15023 n1_m9_317600_228000 n1_m9_340000_228000 0.096000
R15024 n1_m9_340000_228000 n1_m9_362400_228000 0.096000
R15025 n1_m9_362400_228000 n1_m9_384800_228000 0.096000
R15026 n1_m9_384800_228000 n1_m9_407200_228000 0.096000
R15027 n1_m9_407200_228000 n1_m9_429600_228000 0.096000
R15028 n1_m9_429600_228000 n1_m9_452000_228000 0.096000
R15029 n1_m9_452000_228000 n1_m9_474400_228000 0.096000
R15030 n1_m9_474400_228000 n1_m9_496800_228000 0.096000
R15031 n1_m9_4000_250400 n1_m9_26400_250400 0.096000
R15032 n1_m9_26400_250400 n1_m9_48800_250400 0.096000
R15033 n1_m9_48800_250400 n1_m9_71200_250400 0.096000
R15034 n1_m9_71200_250400 n1_m9_93600_250400 0.096000
R15035 n1_m9_93600_250400 n1_m9_116000_250400 0.096000
R15036 n1_m9_116000_250400 n1_m9_138400_250400 0.096000
R15037 n1_m9_138400_250400 n1_m9_160800_250400 0.096000
R15038 n1_m9_160800_250400 n1_m9_183200_250400 0.096000
R15039 n1_m9_183200_250400 n1_m9_205600_250400 0.096000
R15040 n1_m9_205600_250400 n1_m9_228000_250400 0.096000
R15041 n1_m9_228000_250400 n1_m9_250400_250400 0.096000
R15042 n1_m9_250400_250400 n1_m9_272800_250400 0.096000
R15043 n1_m9_272800_250400 n1_m9_295200_250400 0.096000
R15044 n1_m9_295200_250400 n1_m9_317600_250400 0.096000
R15045 n1_m9_317600_250400 n1_m9_340000_250400 0.096000
R15046 n1_m9_340000_250400 n1_m9_362400_250400 0.096000
R15047 n1_m9_362400_250400 n1_m9_384800_250400 0.096000
R15048 n1_m9_384800_250400 n1_m9_407200_250400 0.096000
R15049 n1_m9_407200_250400 n1_m9_429600_250400 0.096000
R15050 n1_m9_429600_250400 n1_m9_452000_250400 0.096000
R15051 n1_m9_452000_250400 n1_m9_474400_250400 0.096000
R15052 n1_m9_474400_250400 n1_m9_496800_250400 0.096000
R15053 n1_m9_4000_272800 n1_m9_26400_272800 0.096000
R15054 n1_m9_26400_272800 n1_m9_48800_272800 0.096000
R15055 n1_m9_48800_272800 n1_m9_71200_272800 0.096000
R15056 n1_m9_71200_272800 n1_m9_93600_272800 0.096000
R15057 n1_m9_93600_272800 n1_m9_116000_272800 0.096000
R15058 n1_m9_116000_272800 n1_m9_138400_272800 0.096000
R15059 n1_m9_138400_272800 n1_m9_160800_272800 0.096000
R15060 n1_m9_160800_272800 n1_m9_183200_272800 0.096000
R15061 n1_m9_183200_272800 n1_m9_205600_272800 0.096000
R15062 n1_m9_205600_272800 n1_m9_228000_272800 0.096000
R15063 n1_m9_228000_272800 n1_m9_250400_272800 0.096000
R15064 n1_m9_250400_272800 n1_m9_272800_272800 0.096000
R15065 n1_m9_272800_272800 n1_m9_295200_272800 0.096000
R15066 n1_m9_295200_272800 n1_m9_317600_272800 0.096000
R15067 n1_m9_317600_272800 n1_m9_340000_272800 0.096000
R15068 n1_m9_340000_272800 n1_m9_362400_272800 0.096000
R15069 n1_m9_362400_272800 n1_m9_384800_272800 0.096000
R15070 n1_m9_384800_272800 n1_m9_407200_272800 0.096000
R15071 n1_m9_407200_272800 n1_m9_429600_272800 0.096000
R15072 n1_m9_429600_272800 n1_m9_452000_272800 0.096000
R15073 n1_m9_452000_272800 n1_m9_474400_272800 0.096000
R15074 n1_m9_474400_272800 n1_m9_496800_272800 0.096000
R15075 n1_m9_4000_295200 n1_m9_26400_295200 0.096000
R15076 n1_m9_26400_295200 n1_m9_48800_295200 0.096000
R15077 n1_m9_48800_295200 n1_m9_71200_295200 0.096000
R15078 n1_m9_71200_295200 n1_m9_93600_295200 0.096000
R15079 n1_m9_93600_295200 n1_m9_116000_295200 0.096000
R15080 n1_m9_116000_295200 n1_m9_138400_295200 0.096000
R15081 n1_m9_138400_295200 n1_m9_160800_295200 0.096000
R15082 n1_m9_160800_295200 n1_m9_183200_295200 0.096000
R15083 n1_m9_183200_295200 n1_m9_205600_295200 0.096000
R15084 n1_m9_205600_295200 n1_m9_228000_295200 0.096000
R15085 n1_m9_228000_295200 n1_m9_250400_295200 0.096000
R15086 n1_m9_250400_295200 n1_m9_272800_295200 0.096000
R15087 n1_m9_272800_295200 n1_m9_295200_295200 0.096000
R15088 n1_m9_295200_295200 n1_m9_317600_295200 0.096000
R15089 n1_m9_317600_295200 n1_m9_340000_295200 0.096000
R15090 n1_m9_340000_295200 n1_m9_362400_295200 0.096000
R15091 n1_m9_362400_295200 n1_m9_384800_295200 0.096000
R15092 n1_m9_384800_295200 n1_m9_407200_295200 0.096000
R15093 n1_m9_407200_295200 n1_m9_429600_295200 0.096000
R15094 n1_m9_429600_295200 n1_m9_452000_295200 0.096000
R15095 n1_m9_452000_295200 n1_m9_474400_295200 0.096000
R15096 n1_m9_474400_295200 n1_m9_496800_295200 0.096000
R15097 n1_m9_4000_317600 n1_m9_26400_317600 0.096000
R15098 n1_m9_26400_317600 n1_m9_48800_317600 0.096000
R15099 n1_m9_48800_317600 n1_m9_71200_317600 0.096000
R15100 n1_m9_71200_317600 n1_m9_93600_317600 0.096000
R15101 n1_m9_93600_317600 n1_m9_116000_317600 0.096000
R15102 n1_m9_116000_317600 n1_m9_138400_317600 0.096000
R15103 n1_m9_138400_317600 n1_m9_160800_317600 0.096000
R15104 n1_m9_160800_317600 n1_m9_183200_317600 0.096000
R15105 n1_m9_183200_317600 n1_m9_205600_317600 0.096000
R15106 n1_m9_205600_317600 n1_m9_228000_317600 0.096000
R15107 n1_m9_228000_317600 n1_m9_250400_317600 0.096000
R15108 n1_m9_250400_317600 n1_m9_272800_317600 0.096000
R15109 n1_m9_272800_317600 n1_m9_295200_317600 0.096000
R15110 n1_m9_295200_317600 n1_m9_317600_317600 0.096000
R15111 n1_m9_317600_317600 n1_m9_340000_317600 0.096000
R15112 n1_m9_340000_317600 n1_m9_362400_317600 0.096000
R15113 n1_m9_362400_317600 n1_m9_384800_317600 0.096000
R15114 n1_m9_384800_317600 n1_m9_407200_317600 0.096000
R15115 n1_m9_407200_317600 n1_m9_429600_317600 0.096000
R15116 n1_m9_429600_317600 n1_m9_452000_317600 0.096000
R15117 n1_m9_452000_317600 n1_m9_474400_317600 0.096000
R15118 n1_m9_474400_317600 n1_m9_496800_317600 0.096000
R15119 n1_m9_4000_340000 n1_m9_26400_340000 0.096000
R15120 n1_m9_26400_340000 n1_m9_48800_340000 0.096000
R15121 n1_m9_48800_340000 n1_m9_71200_340000 0.096000
R15122 n1_m9_71200_340000 n1_m9_93600_340000 0.096000
R15123 n1_m9_93600_340000 n1_m9_116000_340000 0.096000
R15124 n1_m9_116000_340000 n1_m9_138400_340000 0.096000
R15125 n1_m9_138400_340000 n1_m9_160800_340000 0.096000
R15126 n1_m9_160800_340000 n1_m9_183200_340000 0.096000
R15127 n1_m9_183200_340000 n1_m9_205600_340000 0.096000
R15128 n1_m9_205600_340000 n1_m9_228000_340000 0.096000
R15129 n1_m9_228000_340000 n1_m9_250400_340000 0.096000
R15130 n1_m9_250400_340000 n1_m9_272800_340000 0.096000
R15131 n1_m9_272800_340000 n1_m9_295200_340000 0.096000
R15132 n1_m9_295200_340000 n1_m9_317600_340000 0.096000
R15133 n1_m9_317600_340000 n1_m9_340000_340000 0.096000
R15134 n1_m9_340000_340000 n1_m9_362400_340000 0.096000
R15135 n1_m9_362400_340000 n1_m9_384800_340000 0.096000
R15136 n1_m9_384800_340000 n1_m9_407200_340000 0.096000
R15137 n1_m9_407200_340000 n1_m9_429600_340000 0.096000
R15138 n1_m9_429600_340000 n1_m9_452000_340000 0.096000
R15139 n1_m9_452000_340000 n1_m9_474400_340000 0.096000
R15140 n1_m9_474400_340000 n1_m9_496800_340000 0.096000
R15141 n1_m9_4000_362400 n1_m9_26400_362400 0.096000
R15142 n1_m9_26400_362400 n1_m9_48800_362400 0.096000
R15143 n1_m9_48800_362400 n1_m9_71200_362400 0.096000
R15144 n1_m9_71200_362400 n1_m9_93600_362400 0.096000
R15145 n1_m9_93600_362400 n1_m9_116000_362400 0.096000
R15146 n1_m9_116000_362400 n1_m9_138400_362400 0.096000
R15147 n1_m9_138400_362400 n1_m9_160800_362400 0.096000
R15148 n1_m9_160800_362400 n1_m9_183200_362400 0.096000
R15149 n1_m9_183200_362400 n1_m9_205600_362400 0.096000
R15150 n1_m9_205600_362400 n1_m9_228000_362400 0.096000
R15151 n1_m9_228000_362400 n1_m9_250400_362400 0.096000
R15152 n1_m9_250400_362400 n1_m9_272800_362400 0.096000
R15153 n1_m9_272800_362400 n1_m9_295200_362400 0.096000
R15154 n1_m9_295200_362400 n1_m9_317600_362400 0.096000
R15155 n1_m9_317600_362400 n1_m9_340000_362400 0.096000
R15156 n1_m9_340000_362400 n1_m9_362400_362400 0.096000
R15157 n1_m9_362400_362400 n1_m9_384800_362400 0.096000
R15158 n1_m9_384800_362400 n1_m9_407200_362400 0.096000
R15159 n1_m9_407200_362400 n1_m9_429600_362400 0.096000
R15160 n1_m9_429600_362400 n1_m9_452000_362400 0.096000
R15161 n1_m9_452000_362400 n1_m9_474400_362400 0.096000
R15162 n1_m9_474400_362400 n1_m9_496800_362400 0.096000
R15163 n1_m9_4000_384800 n1_m9_26400_384800 0.096000
R15164 n1_m9_26400_384800 n1_m9_48800_384800 0.096000
R15165 n1_m9_48800_384800 n1_m9_71200_384800 0.096000
R15166 n1_m9_71200_384800 n1_m9_93600_384800 0.096000
R15167 n1_m9_93600_384800 n1_m9_116000_384800 0.096000
R15168 n1_m9_116000_384800 n1_m9_138400_384800 0.096000
R15169 n1_m9_138400_384800 n1_m9_160800_384800 0.096000
R15170 n1_m9_160800_384800 n1_m9_183200_384800 0.096000
R15171 n1_m9_183200_384800 n1_m9_205600_384800 0.096000
R15172 n1_m9_205600_384800 n1_m9_228000_384800 0.096000
R15173 n1_m9_228000_384800 n1_m9_250400_384800 0.096000
R15174 n1_m9_250400_384800 n1_m9_272800_384800 0.096000
R15175 n1_m9_272800_384800 n1_m9_295200_384800 0.096000
R15176 n1_m9_295200_384800 n1_m9_317600_384800 0.096000
R15177 n1_m9_317600_384800 n1_m9_340000_384800 0.096000
R15178 n1_m9_340000_384800 n1_m9_362400_384800 0.096000
R15179 n1_m9_362400_384800 n1_m9_384800_384800 0.096000
R15180 n1_m9_384800_384800 n1_m9_407200_384800 0.096000
R15181 n1_m9_407200_384800 n1_m9_429600_384800 0.096000
R15182 n1_m9_429600_384800 n1_m9_452000_384800 0.096000
R15183 n1_m9_452000_384800 n1_m9_474400_384800 0.096000
R15184 n1_m9_474400_384800 n1_m9_496800_384800 0.096000
R15185 n1_m9_4000_407200 n1_m9_26400_407200 0.096000
R15186 n1_m9_26400_407200 n1_m9_48800_407200 0.096000
R15187 n1_m9_48800_407200 n1_m9_71200_407200 0.096000
R15188 n1_m9_71200_407200 n1_m9_93600_407200 0.096000
R15189 n1_m9_93600_407200 n1_m9_116000_407200 0.096000
R15190 n1_m9_116000_407200 n1_m9_138400_407200 0.096000
R15191 n1_m9_138400_407200 n1_m9_160800_407200 0.096000
R15192 n1_m9_160800_407200 n1_m9_183200_407200 0.096000
R15193 n1_m9_183200_407200 n1_m9_205600_407200 0.096000
R15194 n1_m9_205600_407200 n1_m9_228000_407200 0.096000
R15195 n1_m9_228000_407200 n1_m9_250400_407200 0.096000
R15196 n1_m9_250400_407200 n1_m9_272800_407200 0.096000
R15197 n1_m9_272800_407200 n1_m9_295200_407200 0.096000
R15198 n1_m9_295200_407200 n1_m9_317600_407200 0.096000
R15199 n1_m9_317600_407200 n1_m9_340000_407200 0.096000
R15200 n1_m9_340000_407200 n1_m9_362400_407200 0.096000
R15201 n1_m9_362400_407200 n1_m9_384800_407200 0.096000
R15202 n1_m9_384800_407200 n1_m9_407200_407200 0.096000
R15203 n1_m9_407200_407200 n1_m9_429600_407200 0.096000
R15204 n1_m9_429600_407200 n1_m9_452000_407200 0.096000
R15205 n1_m9_452000_407200 n1_m9_474400_407200 0.096000
R15206 n1_m9_474400_407200 n1_m9_496800_407200 0.096000
R15207 n1_m9_4000_429600 n1_m9_26400_429600 0.096000
R15208 n1_m9_26400_429600 n1_m9_48800_429600 0.096000
R15209 n1_m9_48800_429600 n1_m9_71200_429600 0.096000
R15210 n1_m9_71200_429600 n1_m9_93600_429600 0.096000
R15211 n1_m9_93600_429600 n1_m9_116000_429600 0.096000
R15212 n1_m9_116000_429600 n1_m9_138400_429600 0.096000
R15213 n1_m9_138400_429600 n1_m9_160800_429600 0.096000
R15214 n1_m9_160800_429600 n1_m9_183200_429600 0.096000
R15215 n1_m9_183200_429600 n1_m9_205600_429600 0.096000
R15216 n1_m9_205600_429600 n1_m9_228000_429600 0.096000
R15217 n1_m9_228000_429600 n1_m9_250400_429600 0.096000
R15218 n1_m9_250400_429600 n1_m9_272800_429600 0.096000
R15219 n1_m9_272800_429600 n1_m9_295200_429600 0.096000
R15220 n1_m9_295200_429600 n1_m9_317600_429600 0.096000
R15221 n1_m9_317600_429600 n1_m9_340000_429600 0.096000
R15222 n1_m9_340000_429600 n1_m9_362400_429600 0.096000
R15223 n1_m9_362400_429600 n1_m9_384800_429600 0.096000
R15224 n1_m9_384800_429600 n1_m9_407200_429600 0.096000
R15225 n1_m9_407200_429600 n1_m9_429600_429600 0.096000
R15226 n1_m9_429600_429600 n1_m9_452000_429600 0.096000
R15227 n1_m9_452000_429600 n1_m9_474400_429600 0.096000
R15228 n1_m9_474400_429600 n1_m9_496800_429600 0.096000
R15229 n1_m9_4000_452000 n1_m9_26400_452000 0.096000
R15230 n1_m9_26400_452000 n1_m9_48800_452000 0.096000
R15231 n1_m9_48800_452000 n1_m9_71200_452000 0.096000
R15232 n1_m9_71200_452000 n1_m9_93600_452000 0.096000
R15233 n1_m9_93600_452000 n1_m9_116000_452000 0.096000
R15234 n1_m9_116000_452000 n1_m9_138400_452000 0.096000
R15235 n1_m9_138400_452000 n1_m9_160800_452000 0.096000
R15236 n1_m9_160800_452000 n1_m9_183200_452000 0.096000
R15237 n1_m9_183200_452000 n1_m9_205600_452000 0.096000
R15238 n1_m9_205600_452000 n1_m9_228000_452000 0.096000
R15239 n1_m9_228000_452000 n1_m9_250400_452000 0.096000
R15240 n1_m9_250400_452000 n1_m9_272800_452000 0.096000
R15241 n1_m9_272800_452000 n1_m9_295200_452000 0.096000
R15242 n1_m9_295200_452000 n1_m9_317600_452000 0.096000
R15243 n1_m9_317600_452000 n1_m9_340000_452000 0.096000
R15244 n1_m9_340000_452000 n1_m9_362400_452000 0.096000
R15245 n1_m9_362400_452000 n1_m9_384800_452000 0.096000
R15246 n1_m9_384800_452000 n1_m9_407200_452000 0.096000
R15247 n1_m9_407200_452000 n1_m9_429600_452000 0.096000
R15248 n1_m9_429600_452000 n1_m9_452000_452000 0.096000
R15249 n1_m9_452000_452000 n1_m9_474400_452000 0.096000
R15250 n1_m9_474400_452000 n1_m9_496800_452000 0.096000
R15251 n1_m9_4000_474400 n1_m9_26400_474400 0.096000
R15252 n1_m9_26400_474400 n1_m9_48800_474400 0.096000
R15253 n1_m9_48800_474400 n1_m9_71200_474400 0.096000
R15254 n1_m9_71200_474400 n1_m9_93600_474400 0.096000
R15255 n1_m9_93600_474400 n1_m9_116000_474400 0.096000
R15256 n1_m9_116000_474400 n1_m9_138400_474400 0.096000
R15257 n1_m9_138400_474400 n1_m9_160800_474400 0.096000
R15258 n1_m9_160800_474400 n1_m9_183200_474400 0.096000
R15259 n1_m9_183200_474400 n1_m9_205600_474400 0.096000
R15260 n1_m9_205600_474400 n1_m9_228000_474400 0.096000
R15261 n1_m9_228000_474400 n1_m9_250400_474400 0.096000
R15262 n1_m9_250400_474400 n1_m9_272800_474400 0.096000
R15263 n1_m9_272800_474400 n1_m9_295200_474400 0.096000
R15264 n1_m9_295200_474400 n1_m9_317600_474400 0.096000
R15265 n1_m9_317600_474400 n1_m9_340000_474400 0.096000
R15266 n1_m9_340000_474400 n1_m9_362400_474400 0.096000
R15267 n1_m9_362400_474400 n1_m9_384800_474400 0.096000
R15268 n1_m9_384800_474400 n1_m9_407200_474400 0.096000
R15269 n1_m9_407200_474400 n1_m9_429600_474400 0.096000
R15270 n1_m9_429600_474400 n1_m9_452000_474400 0.096000
R15271 n1_m9_452000_474400 n1_m9_474400_474400 0.096000
R15272 n1_m9_474400_474400 n1_m9_496800_474400 0.096000
R15273 n1_m9_4000_496800 n1_m9_26400_496800 0.096000
R15274 n1_m9_26400_496800 n1_m9_48800_496800 0.096000
R15275 n1_m9_48800_496800 n1_m9_71200_496800 0.096000
R15276 n1_m9_71200_496800 n1_m9_93600_496800 0.096000
R15277 n1_m9_93600_496800 n1_m9_116000_496800 0.096000
R15278 n1_m9_116000_496800 n1_m9_138400_496800 0.096000
R15279 n1_m9_138400_496800 n1_m9_160800_496800 0.096000
R15280 n1_m9_160800_496800 n1_m9_183200_496800 0.096000
R15281 n1_m9_183200_496800 n1_m9_205600_496800 0.096000
R15282 n1_m9_205600_496800 n1_m9_228000_496800 0.096000
R15283 n1_m9_228000_496800 n1_m9_250400_496800 0.096000
R15284 n1_m9_250400_496800 n1_m9_272800_496800 0.096000
R15285 n1_m9_272800_496800 n1_m9_295200_496800 0.096000
R15286 n1_m9_295200_496800 n1_m9_317600_496800 0.096000
R15287 n1_m9_317600_496800 n1_m9_340000_496800 0.096000
R15288 n1_m9_340000_496800 n1_m9_362400_496800 0.096000
R15289 n1_m9_362400_496800 n1_m9_384800_496800 0.096000
R15290 n1_m9_384800_496800 n1_m9_407200_496800 0.096000
R15291 n1_m9_407200_496800 n1_m9_429600_496800 0.096000
R15292 n1_m9_429600_496800 n1_m9_452000_496800 0.096000
R15293 n1_m9_452000_496800 n1_m9_474400_496800 0.096000
R15294 n1_m9_474400_496800 n1_m9_496800_496800 0.096000
R15295 n1_m1_4000_0 n1_m4_4000_0 15.000000
R15296 n1_m1_4000_4800 n1_m4_4000_4800 15.000000
R15297 n1_m1_4000_9600 n1_m4_4000_9600 15.000000
R15298 n1_m1_4000_14400 n1_m4_4000_14400 15.000000
R15299 n1_m1_4000_19200 n1_m4_4000_19200 15.000000
R15300 n1_m1_4000_24000 n1_m4_4000_24000 15.000000
R15301 n1_m1_4000_28800 n1_m4_4000_28800 15.000000
R15302 n1_m1_4000_33600 n1_m4_4000_33600 15.000000
R15303 n1_m1_4000_38400 n1_m4_4000_38400 15.000000
R15304 n1_m1_4000_43200 n1_m4_4000_43200 15.000000
R15305 n1_m1_4000_48000 n1_m4_4000_48000 15.000000
R15306 n1_m1_4000_52800 n1_m4_4000_52800 15.000000
R15307 n1_m1_4000_57600 n1_m4_4000_57600 15.000000
R15308 n1_m1_4000_62400 n1_m4_4000_62400 15.000000
R15309 n1_m1_4000_67200 n1_m4_4000_67200 15.000000
R15310 n1_m1_4000_72000 n1_m4_4000_72000 15.000000
R15311 n1_m1_4000_76800 n1_m4_4000_76800 15.000000
R15312 n1_m1_4000_81600 n1_m4_4000_81600 15.000000
R15313 n1_m1_4000_86400 n1_m4_4000_86400 15.000000
R15314 n1_m1_4000_91200 n1_m4_4000_91200 15.000000
R15315 n1_m1_4000_96000 n1_m4_4000_96000 15.000000
R15316 n1_m1_4000_100800 n1_m4_4000_100800 15.000000
R15317 n1_m1_4000_105600 n1_m4_4000_105600 15.000000
R15318 n1_m1_4000_110400 n1_m4_4000_110400 15.000000
R15319 n1_m1_4000_115200 n1_m4_4000_115200 15.000000
R15320 n1_m1_4000_120000 n1_m4_4000_120000 15.000000
R15321 n1_m1_4000_124800 n1_m4_4000_124800 15.000000
R15322 n1_m1_4000_129600 n1_m4_4000_129600 15.000000
R15323 n1_m1_4000_134400 n1_m4_4000_134400 15.000000
R15324 n1_m1_4000_139200 n1_m4_4000_139200 15.000000
R15325 n1_m1_4000_144000 n1_m4_4000_144000 15.000000
R15326 n1_m1_4000_148800 n1_m4_4000_148800 15.000000
R15327 n1_m1_4000_153600 n1_m4_4000_153600 15.000000
R15328 n1_m1_4000_158400 n1_m4_4000_158400 15.000000
R15329 n1_m1_4000_163200 n1_m4_4000_163200 15.000000
R15330 n1_m1_4000_168000 n1_m4_4000_168000 15.000000
R15331 n1_m1_4000_172800 n1_m4_4000_172800 15.000000
R15332 n1_m1_4000_177600 n1_m4_4000_177600 15.000000
R15333 n1_m1_4000_182400 n1_m4_4000_182400 15.000000
R15334 n1_m1_4000_187200 n1_m4_4000_187200 15.000000
R15335 n1_m1_4000_192000 n1_m4_4000_192000 15.000000
R15336 n1_m1_4000_196800 n1_m4_4000_196800 15.000000
R15337 n1_m1_4000_201600 n1_m4_4000_201600 15.000000
R15338 n1_m1_4000_206400 n1_m4_4000_206400 15.000000
R15339 n1_m1_4000_211200 n1_m4_4000_211200 15.000000
R15340 n1_m1_4000_216000 n1_m4_4000_216000 15.000000
R15341 n1_m1_4000_220800 n1_m4_4000_220800 15.000000
R15342 n1_m1_4000_225600 n1_m4_4000_225600 15.000000
R15343 n1_m1_4000_230400 n1_m4_4000_230400 15.000000
R15344 n1_m1_4000_235200 n1_m4_4000_235200 15.000000
R15345 n1_m1_4000_240000 n1_m4_4000_240000 15.000000
R15346 n1_m1_4000_244800 n1_m4_4000_244800 15.000000
R15347 n1_m1_4000_249600 n1_m4_4000_249600 15.000000
R15348 n1_m1_4000_254400 n1_m4_4000_254400 15.000000
R15349 n1_m1_4000_259200 n1_m4_4000_259200 15.000000
R15350 n1_m1_4000_264000 n1_m4_4000_264000 15.000000
R15351 n1_m1_4000_268800 n1_m4_4000_268800 15.000000
R15352 n1_m1_4000_273600 n1_m4_4000_273600 15.000000
R15353 n1_m1_4000_278400 n1_m4_4000_278400 15.000000
R15354 n1_m1_4000_283200 n1_m4_4000_283200 15.000000
R15355 n1_m1_4000_288000 n1_m4_4000_288000 15.000000
R15356 n1_m1_4000_292800 n1_m4_4000_292800 15.000000
R15357 n1_m1_4000_297600 n1_m4_4000_297600 15.000000
R15358 n1_m1_4000_302400 n1_m4_4000_302400 15.000000
R15359 n1_m1_4000_307200 n1_m4_4000_307200 15.000000
R15360 n1_m1_4000_312000 n1_m4_4000_312000 15.000000
R15361 n1_m1_4000_316800 n1_m4_4000_316800 15.000000
R15362 n1_m1_4000_321600 n1_m4_4000_321600 15.000000
R15363 n1_m1_4000_326400 n1_m4_4000_326400 15.000000
R15364 n1_m1_4000_331200 n1_m4_4000_331200 15.000000
R15365 n1_m1_4000_336000 n1_m4_4000_336000 15.000000
R15366 n1_m1_4000_340800 n1_m4_4000_340800 15.000000
R15367 n1_m1_4000_345600 n1_m4_4000_345600 15.000000
R15368 n1_m1_4000_350400 n1_m4_4000_350400 15.000000
R15369 n1_m1_4000_355200 n1_m4_4000_355200 15.000000
R15370 n1_m1_4000_360000 n1_m4_4000_360000 15.000000
R15371 n1_m1_4000_364800 n1_m4_4000_364800 15.000000
R15372 n1_m1_4000_369600 n1_m4_4000_369600 15.000000
R15373 n1_m1_4000_374400 n1_m4_4000_374400 15.000000
R15374 n1_m1_4000_379200 n1_m4_4000_379200 15.000000
R15375 n1_m1_4000_384000 n1_m4_4000_384000 15.000000
R15376 n1_m1_4000_388800 n1_m4_4000_388800 15.000000
R15377 n1_m1_4000_393600 n1_m4_4000_393600 15.000000
R15378 n1_m1_4000_398400 n1_m4_4000_398400 15.000000
R15379 n1_m1_4000_403200 n1_m4_4000_403200 15.000000
R15380 n1_m1_4000_408000 n1_m4_4000_408000 15.000000
R15381 n1_m1_4000_412800 n1_m4_4000_412800 15.000000
R15382 n1_m1_4000_417600 n1_m4_4000_417600 15.000000
R15383 n1_m1_4000_422400 n1_m4_4000_422400 15.000000
R15384 n1_m1_4000_427200 n1_m4_4000_427200 15.000000
R15385 n1_m1_4000_432000 n1_m4_4000_432000 15.000000
R15386 n1_m1_4000_436800 n1_m4_4000_436800 15.000000
R15387 n1_m1_4000_441600 n1_m4_4000_441600 15.000000
R15388 n1_m1_4000_446400 n1_m4_4000_446400 15.000000
R15389 n1_m1_4000_451200 n1_m4_4000_451200 15.000000
R15390 n1_m1_4000_456000 n1_m4_4000_456000 15.000000
R15391 n1_m1_4000_460800 n1_m4_4000_460800 15.000000
R15392 n1_m1_4000_465600 n1_m4_4000_465600 15.000000
R15393 n1_m1_4000_470400 n1_m4_4000_470400 15.000000
R15394 n1_m1_4000_475200 n1_m4_4000_475200 15.000000
R15395 n1_m1_4000_480000 n1_m4_4000_480000 15.000000
R15396 n1_m1_4000_484800 n1_m4_4000_484800 15.000000
R15397 n1_m1_4000_489600 n1_m4_4000_489600 15.000000
R15398 n1_m1_4000_494400 n1_m4_4000_494400 15.000000
R15399 n1_m1_32000_0 n1_m4_32000_0 15.000000
R15400 n1_m1_32000_4800 n1_m4_32000_4800 15.000000
R15401 n1_m1_32000_9600 n1_m4_32000_9600 15.000000
R15402 n1_m1_32000_14400 n1_m4_32000_14400 15.000000
R15403 n1_m1_32000_19200 n1_m4_32000_19200 15.000000
R15404 n1_m1_32000_24000 n1_m4_32000_24000 15.000000
R15405 n1_m1_32000_28800 n1_m4_32000_28800 15.000000
R15406 n1_m1_32000_33600 n1_m4_32000_33600 15.000000
R15407 n1_m1_32000_38400 n1_m4_32000_38400 15.000000
R15408 n1_m1_32000_43200 n1_m4_32000_43200 15.000000
R15409 n1_m1_32000_48000 n1_m4_32000_48000 15.000000
R15410 n1_m1_32000_52800 n1_m4_32000_52800 15.000000
R15411 n1_m1_32000_57600 n1_m4_32000_57600 15.000000
R15412 n1_m1_32000_62400 n1_m4_32000_62400 15.000000
R15413 n1_m1_32000_67200 n1_m4_32000_67200 15.000000
R15414 n1_m1_32000_72000 n1_m4_32000_72000 15.000000
R15415 n1_m1_32000_76800 n1_m4_32000_76800 15.000000
R15416 n1_m1_32000_81600 n1_m4_32000_81600 15.000000
R15417 n1_m1_32000_86400 n1_m4_32000_86400 15.000000
R15418 n1_m1_32000_91200 n1_m4_32000_91200 15.000000
R15419 n1_m1_32000_96000 n1_m4_32000_96000 15.000000
R15420 n1_m1_32000_100800 n1_m4_32000_100800 15.000000
R15421 n1_m1_32000_105600 n1_m4_32000_105600 15.000000
R15422 n1_m1_32000_110400 n1_m4_32000_110400 15.000000
R15423 n1_m1_32000_115200 n1_m4_32000_115200 15.000000
R15424 n1_m1_32000_120000 n1_m4_32000_120000 15.000000
R15425 n1_m1_32000_124800 n1_m4_32000_124800 15.000000
R15426 n1_m1_32000_129600 n1_m4_32000_129600 15.000000
R15427 n1_m1_32000_134400 n1_m4_32000_134400 15.000000
R15428 n1_m1_32000_139200 n1_m4_32000_139200 15.000000
R15429 n1_m1_32000_144000 n1_m4_32000_144000 15.000000
R15430 n1_m1_32000_148800 n1_m4_32000_148800 15.000000
R15431 n1_m1_32000_153600 n1_m4_32000_153600 15.000000
R15432 n1_m1_32000_158400 n1_m4_32000_158400 15.000000
R15433 n1_m1_32000_163200 n1_m4_32000_163200 15.000000
R15434 n1_m1_32000_168000 n1_m4_32000_168000 15.000000
R15435 n1_m1_32000_172800 n1_m4_32000_172800 15.000000
R15436 n1_m1_32000_177600 n1_m4_32000_177600 15.000000
R15437 n1_m1_32000_182400 n1_m4_32000_182400 15.000000
R15438 n1_m1_32000_187200 n1_m4_32000_187200 15.000000
R15439 n1_m1_32000_192000 n1_m4_32000_192000 15.000000
R15440 n1_m1_32000_196800 n1_m4_32000_196800 15.000000
R15441 n1_m1_32000_201600 n1_m4_32000_201600 15.000000
R15442 n1_m1_32000_206400 n1_m4_32000_206400 15.000000
R15443 n1_m1_32000_211200 n1_m4_32000_211200 15.000000
R15444 n1_m1_32000_216000 n1_m4_32000_216000 15.000000
R15445 n1_m1_32000_220800 n1_m4_32000_220800 15.000000
R15446 n1_m1_32000_225600 n1_m4_32000_225600 15.000000
R15447 n1_m1_32000_230400 n1_m4_32000_230400 15.000000
R15448 n1_m1_32000_235200 n1_m4_32000_235200 15.000000
R15449 n1_m1_32000_240000 n1_m4_32000_240000 15.000000
R15450 n1_m1_32000_244800 n1_m4_32000_244800 15.000000
R15451 n1_m1_32000_249600 n1_m4_32000_249600 15.000000
R15452 n1_m1_32000_254400 n1_m4_32000_254400 15.000000
R15453 n1_m1_32000_259200 n1_m4_32000_259200 15.000000
R15454 n1_m1_32000_264000 n1_m4_32000_264000 15.000000
R15455 n1_m1_32000_268800 n1_m4_32000_268800 15.000000
R15456 n1_m1_32000_273600 n1_m4_32000_273600 15.000000
R15457 n1_m1_32000_278400 n1_m4_32000_278400 15.000000
R15458 n1_m1_32000_283200 n1_m4_32000_283200 15.000000
R15459 n1_m1_32000_288000 n1_m4_32000_288000 15.000000
R15460 n1_m1_32000_292800 n1_m4_32000_292800 15.000000
R15461 n1_m1_32000_297600 n1_m4_32000_297600 15.000000
R15462 n1_m1_32000_302400 n1_m4_32000_302400 15.000000
R15463 n1_m1_32000_307200 n1_m4_32000_307200 15.000000
R15464 n1_m1_32000_312000 n1_m4_32000_312000 15.000000
R15465 n1_m1_32000_316800 n1_m4_32000_316800 15.000000
R15466 n1_m1_32000_321600 n1_m4_32000_321600 15.000000
R15467 n1_m1_32000_326400 n1_m4_32000_326400 15.000000
R15468 n1_m1_32000_331200 n1_m4_32000_331200 15.000000
R15469 n1_m1_32000_336000 n1_m4_32000_336000 15.000000
R15470 n1_m1_32000_340800 n1_m4_32000_340800 15.000000
R15471 n1_m1_32000_345600 n1_m4_32000_345600 15.000000
R15472 n1_m1_32000_350400 n1_m4_32000_350400 15.000000
R15473 n1_m1_32000_355200 n1_m4_32000_355200 15.000000
R15474 n1_m1_32000_360000 n1_m4_32000_360000 15.000000
R15475 n1_m1_32000_364800 n1_m4_32000_364800 15.000000
R15476 n1_m1_32000_369600 n1_m4_32000_369600 15.000000
R15477 n1_m1_32000_374400 n1_m4_32000_374400 15.000000
R15478 n1_m1_32000_379200 n1_m4_32000_379200 15.000000
R15479 n1_m1_32000_384000 n1_m4_32000_384000 15.000000
R15480 n1_m1_32000_388800 n1_m4_32000_388800 15.000000
R15481 n1_m1_32000_393600 n1_m4_32000_393600 15.000000
R15482 n1_m1_32000_398400 n1_m4_32000_398400 15.000000
R15483 n1_m1_32000_403200 n1_m4_32000_403200 15.000000
R15484 n1_m1_32000_408000 n1_m4_32000_408000 15.000000
R15485 n1_m1_32000_412800 n1_m4_32000_412800 15.000000
R15486 n1_m1_32000_417600 n1_m4_32000_417600 15.000000
R15487 n1_m1_32000_422400 n1_m4_32000_422400 15.000000
R15488 n1_m1_32000_427200 n1_m4_32000_427200 15.000000
R15489 n1_m1_32000_432000 n1_m4_32000_432000 15.000000
R15490 n1_m1_32000_436800 n1_m4_32000_436800 15.000000
R15491 n1_m1_32000_441600 n1_m4_32000_441600 15.000000
R15492 n1_m1_32000_446400 n1_m4_32000_446400 15.000000
R15493 n1_m1_32000_451200 n1_m4_32000_451200 15.000000
R15494 n1_m1_32000_456000 n1_m4_32000_456000 15.000000
R15495 n1_m1_32000_460800 n1_m4_32000_460800 15.000000
R15496 n1_m1_32000_465600 n1_m4_32000_465600 15.000000
R15497 n1_m1_32000_470400 n1_m4_32000_470400 15.000000
R15498 n1_m1_32000_475200 n1_m4_32000_475200 15.000000
R15499 n1_m1_32000_480000 n1_m4_32000_480000 15.000000
R15500 n1_m1_32000_484800 n1_m4_32000_484800 15.000000
R15501 n1_m1_32000_489600 n1_m4_32000_489600 15.000000
R15502 n1_m1_32000_494400 n1_m4_32000_494400 15.000000
R15503 n1_m1_60000_0 n1_m4_60000_0 15.000000
R15504 n1_m1_60000_4800 n1_m4_60000_4800 15.000000
R15505 n1_m1_60000_9600 n1_m4_60000_9600 15.000000
R15506 n1_m1_60000_14400 n1_m4_60000_14400 15.000000
R15507 n1_m1_60000_19200 n1_m4_60000_19200 15.000000
R15508 n1_m1_60000_24000 n1_m4_60000_24000 15.000000
R15509 n1_m1_60000_28800 n1_m4_60000_28800 15.000000
R15510 n1_m1_60000_33600 n1_m4_60000_33600 15.000000
R15511 n1_m1_60000_38400 n1_m4_60000_38400 15.000000
R15512 n1_m1_60000_43200 n1_m4_60000_43200 15.000000
R15513 n1_m1_60000_48000 n1_m4_60000_48000 15.000000
R15514 n1_m1_60000_52800 n1_m4_60000_52800 15.000000
R15515 n1_m1_60000_57600 n1_m4_60000_57600 15.000000
R15516 n1_m1_60000_62400 n1_m4_60000_62400 15.000000
R15517 n1_m1_60000_67200 n1_m4_60000_67200 15.000000
R15518 n1_m1_60000_72000 n1_m4_60000_72000 15.000000
R15519 n1_m1_60000_76800 n1_m4_60000_76800 15.000000
R15520 n1_m1_60000_81600 n1_m4_60000_81600 15.000000
R15521 n1_m1_60000_86400 n1_m4_60000_86400 15.000000
R15522 n1_m1_60000_91200 n1_m4_60000_91200 15.000000
R15523 n1_m1_60000_96000 n1_m4_60000_96000 15.000000
R15524 n1_m1_60000_100800 n1_m4_60000_100800 15.000000
R15525 n1_m1_60000_105600 n1_m4_60000_105600 15.000000
R15526 n1_m1_60000_110400 n1_m4_60000_110400 15.000000
R15527 n1_m1_60000_115200 n1_m4_60000_115200 15.000000
R15528 n1_m1_60000_120000 n1_m4_60000_120000 15.000000
R15529 n1_m1_60000_124800 n1_m4_60000_124800 15.000000
R15530 n1_m1_60000_129600 n1_m4_60000_129600 15.000000
R15531 n1_m1_60000_134400 n1_m4_60000_134400 15.000000
R15532 n1_m1_60000_139200 n1_m4_60000_139200 15.000000
R15533 n1_m1_60000_144000 n1_m4_60000_144000 15.000000
R15534 n1_m1_60000_148800 n1_m4_60000_148800 15.000000
R15535 n1_m1_60000_153600 n1_m4_60000_153600 15.000000
R15536 n1_m1_60000_158400 n1_m4_60000_158400 15.000000
R15537 n1_m1_60000_163200 n1_m4_60000_163200 15.000000
R15538 n1_m1_60000_168000 n1_m4_60000_168000 15.000000
R15539 n1_m1_60000_172800 n1_m4_60000_172800 15.000000
R15540 n1_m1_60000_177600 n1_m4_60000_177600 15.000000
R15541 n1_m1_60000_182400 n1_m4_60000_182400 15.000000
R15542 n1_m1_60000_187200 n1_m4_60000_187200 15.000000
R15543 n1_m1_60000_192000 n1_m4_60000_192000 15.000000
R15544 n1_m1_60000_196800 n1_m4_60000_196800 15.000000
R15545 n1_m1_60000_201600 n1_m4_60000_201600 15.000000
R15546 n1_m1_60000_206400 n1_m4_60000_206400 15.000000
R15547 n1_m1_60000_211200 n1_m4_60000_211200 15.000000
R15548 n1_m1_60000_216000 n1_m4_60000_216000 15.000000
R15549 n1_m1_60000_220800 n1_m4_60000_220800 15.000000
R15550 n1_m1_60000_225600 n1_m4_60000_225600 15.000000
R15551 n1_m1_60000_230400 n1_m4_60000_230400 15.000000
R15552 n1_m1_60000_235200 n1_m4_60000_235200 15.000000
R15553 n1_m1_60000_240000 n1_m4_60000_240000 15.000000
R15554 n1_m1_60000_244800 n1_m4_60000_244800 15.000000
R15555 n1_m1_60000_249600 n1_m4_60000_249600 15.000000
R15556 n1_m1_60000_254400 n1_m4_60000_254400 15.000000
R15557 n1_m1_60000_259200 n1_m4_60000_259200 15.000000
R15558 n1_m1_60000_264000 n1_m4_60000_264000 15.000000
R15559 n1_m1_60000_268800 n1_m4_60000_268800 15.000000
R15560 n1_m1_60000_273600 n1_m4_60000_273600 15.000000
R15561 n1_m1_60000_278400 n1_m4_60000_278400 15.000000
R15562 n1_m1_60000_283200 n1_m4_60000_283200 15.000000
R15563 n1_m1_60000_288000 n1_m4_60000_288000 15.000000
R15564 n1_m1_60000_292800 n1_m4_60000_292800 15.000000
R15565 n1_m1_60000_297600 n1_m4_60000_297600 15.000000
R15566 n1_m1_60000_302400 n1_m4_60000_302400 15.000000
R15567 n1_m1_60000_307200 n1_m4_60000_307200 15.000000
R15568 n1_m1_60000_312000 n1_m4_60000_312000 15.000000
R15569 n1_m1_60000_316800 n1_m4_60000_316800 15.000000
R15570 n1_m1_60000_321600 n1_m4_60000_321600 15.000000
R15571 n1_m1_60000_326400 n1_m4_60000_326400 15.000000
R15572 n1_m1_60000_331200 n1_m4_60000_331200 15.000000
R15573 n1_m1_60000_336000 n1_m4_60000_336000 15.000000
R15574 n1_m1_60000_340800 n1_m4_60000_340800 15.000000
R15575 n1_m1_60000_345600 n1_m4_60000_345600 15.000000
R15576 n1_m1_60000_350400 n1_m4_60000_350400 15.000000
R15577 n1_m1_60000_355200 n1_m4_60000_355200 15.000000
R15578 n1_m1_60000_360000 n1_m4_60000_360000 15.000000
R15579 n1_m1_60000_364800 n1_m4_60000_364800 15.000000
R15580 n1_m1_60000_369600 n1_m4_60000_369600 15.000000
R15581 n1_m1_60000_374400 n1_m4_60000_374400 15.000000
R15582 n1_m1_60000_379200 n1_m4_60000_379200 15.000000
R15583 n1_m1_60000_384000 n1_m4_60000_384000 15.000000
R15584 n1_m1_60000_388800 n1_m4_60000_388800 15.000000
R15585 n1_m1_60000_393600 n1_m4_60000_393600 15.000000
R15586 n1_m1_60000_398400 n1_m4_60000_398400 15.000000
R15587 n1_m1_60000_403200 n1_m4_60000_403200 15.000000
R15588 n1_m1_60000_408000 n1_m4_60000_408000 15.000000
R15589 n1_m1_60000_412800 n1_m4_60000_412800 15.000000
R15590 n1_m1_60000_417600 n1_m4_60000_417600 15.000000
R15591 n1_m1_60000_422400 n1_m4_60000_422400 15.000000
R15592 n1_m1_60000_427200 n1_m4_60000_427200 15.000000
R15593 n1_m1_60000_432000 n1_m4_60000_432000 15.000000
R15594 n1_m1_60000_436800 n1_m4_60000_436800 15.000000
R15595 n1_m1_60000_441600 n1_m4_60000_441600 15.000000
R15596 n1_m1_60000_446400 n1_m4_60000_446400 15.000000
R15597 n1_m1_60000_451200 n1_m4_60000_451200 15.000000
R15598 n1_m1_60000_456000 n1_m4_60000_456000 15.000000
R15599 n1_m1_60000_460800 n1_m4_60000_460800 15.000000
R15600 n1_m1_60000_465600 n1_m4_60000_465600 15.000000
R15601 n1_m1_60000_470400 n1_m4_60000_470400 15.000000
R15602 n1_m1_60000_475200 n1_m4_60000_475200 15.000000
R15603 n1_m1_60000_480000 n1_m4_60000_480000 15.000000
R15604 n1_m1_60000_484800 n1_m4_60000_484800 15.000000
R15605 n1_m1_60000_489600 n1_m4_60000_489600 15.000000
R15606 n1_m1_60000_494400 n1_m4_60000_494400 15.000000
R15607 n1_m1_88000_0 n1_m4_88000_0 15.000000
R15608 n1_m1_88000_4800 n1_m4_88000_4800 15.000000
R15609 n1_m1_88000_9600 n1_m4_88000_9600 15.000000
R15610 n1_m1_88000_14400 n1_m4_88000_14400 15.000000
R15611 n1_m1_88000_19200 n1_m4_88000_19200 15.000000
R15612 n1_m1_88000_24000 n1_m4_88000_24000 15.000000
R15613 n1_m1_88000_28800 n1_m4_88000_28800 15.000000
R15614 n1_m1_88000_33600 n1_m4_88000_33600 15.000000
R15615 n1_m1_88000_38400 n1_m4_88000_38400 15.000000
R15616 n1_m1_88000_43200 n1_m4_88000_43200 15.000000
R15617 n1_m1_88000_48000 n1_m4_88000_48000 15.000000
R15618 n1_m1_88000_52800 n1_m4_88000_52800 15.000000
R15619 n1_m1_88000_57600 n1_m4_88000_57600 15.000000
R15620 n1_m1_88000_62400 n1_m4_88000_62400 15.000000
R15621 n1_m1_88000_67200 n1_m4_88000_67200 15.000000
R15622 n1_m1_88000_72000 n1_m4_88000_72000 15.000000
R15623 n1_m1_88000_76800 n1_m4_88000_76800 15.000000
R15624 n1_m1_88000_81600 n1_m4_88000_81600 15.000000
R15625 n1_m1_88000_86400 n1_m4_88000_86400 15.000000
R15626 n1_m1_88000_91200 n1_m4_88000_91200 15.000000
R15627 n1_m1_88000_96000 n1_m4_88000_96000 15.000000
R15628 n1_m1_88000_100800 n1_m4_88000_100800 15.000000
R15629 n1_m1_88000_105600 n1_m4_88000_105600 15.000000
R15630 n1_m1_88000_110400 n1_m4_88000_110400 15.000000
R15631 n1_m1_88000_115200 n1_m4_88000_115200 15.000000
R15632 n1_m1_88000_120000 n1_m4_88000_120000 15.000000
R15633 n1_m1_88000_124800 n1_m4_88000_124800 15.000000
R15634 n1_m1_88000_129600 n1_m4_88000_129600 15.000000
R15635 n1_m1_88000_134400 n1_m4_88000_134400 15.000000
R15636 n1_m1_88000_139200 n1_m4_88000_139200 15.000000
R15637 n1_m1_88000_144000 n1_m4_88000_144000 15.000000
R15638 n1_m1_88000_148800 n1_m4_88000_148800 15.000000
R15639 n1_m1_88000_153600 n1_m4_88000_153600 15.000000
R15640 n1_m1_88000_158400 n1_m4_88000_158400 15.000000
R15641 n1_m1_88000_163200 n1_m4_88000_163200 15.000000
R15642 n1_m1_88000_168000 n1_m4_88000_168000 15.000000
R15643 n1_m1_88000_172800 n1_m4_88000_172800 15.000000
R15644 n1_m1_88000_177600 n1_m4_88000_177600 15.000000
R15645 n1_m1_88000_182400 n1_m4_88000_182400 15.000000
R15646 n1_m1_88000_187200 n1_m4_88000_187200 15.000000
R15647 n1_m1_88000_192000 n1_m4_88000_192000 15.000000
R15648 n1_m1_88000_196800 n1_m4_88000_196800 15.000000
R15649 n1_m1_88000_201600 n1_m4_88000_201600 15.000000
R15650 n1_m1_88000_206400 n1_m4_88000_206400 15.000000
R15651 n1_m1_88000_211200 n1_m4_88000_211200 15.000000
R15652 n1_m1_88000_216000 n1_m4_88000_216000 15.000000
R15653 n1_m1_88000_220800 n1_m4_88000_220800 15.000000
R15654 n1_m1_88000_225600 n1_m4_88000_225600 15.000000
R15655 n1_m1_88000_230400 n1_m4_88000_230400 15.000000
R15656 n1_m1_88000_235200 n1_m4_88000_235200 15.000000
R15657 n1_m1_88000_240000 n1_m4_88000_240000 15.000000
R15658 n1_m1_88000_244800 n1_m4_88000_244800 15.000000
R15659 n1_m1_88000_249600 n1_m4_88000_249600 15.000000
R15660 n1_m1_88000_254400 n1_m4_88000_254400 15.000000
R15661 n1_m1_88000_259200 n1_m4_88000_259200 15.000000
R15662 n1_m1_88000_264000 n1_m4_88000_264000 15.000000
R15663 n1_m1_88000_268800 n1_m4_88000_268800 15.000000
R15664 n1_m1_88000_273600 n1_m4_88000_273600 15.000000
R15665 n1_m1_88000_278400 n1_m4_88000_278400 15.000000
R15666 n1_m1_88000_283200 n1_m4_88000_283200 15.000000
R15667 n1_m1_88000_288000 n1_m4_88000_288000 15.000000
R15668 n1_m1_88000_292800 n1_m4_88000_292800 15.000000
R15669 n1_m1_88000_297600 n1_m4_88000_297600 15.000000
R15670 n1_m1_88000_302400 n1_m4_88000_302400 15.000000
R15671 n1_m1_88000_307200 n1_m4_88000_307200 15.000000
R15672 n1_m1_88000_312000 n1_m4_88000_312000 15.000000
R15673 n1_m1_88000_316800 n1_m4_88000_316800 15.000000
R15674 n1_m1_88000_321600 n1_m4_88000_321600 15.000000
R15675 n1_m1_88000_326400 n1_m4_88000_326400 15.000000
R15676 n1_m1_88000_331200 n1_m4_88000_331200 15.000000
R15677 n1_m1_88000_336000 n1_m4_88000_336000 15.000000
R15678 n1_m1_88000_340800 n1_m4_88000_340800 15.000000
R15679 n1_m1_88000_345600 n1_m4_88000_345600 15.000000
R15680 n1_m1_88000_350400 n1_m4_88000_350400 15.000000
R15681 n1_m1_88000_355200 n1_m4_88000_355200 15.000000
R15682 n1_m1_88000_360000 n1_m4_88000_360000 15.000000
R15683 n1_m1_88000_364800 n1_m4_88000_364800 15.000000
R15684 n1_m1_88000_369600 n1_m4_88000_369600 15.000000
R15685 n1_m1_88000_374400 n1_m4_88000_374400 15.000000
R15686 n1_m1_88000_379200 n1_m4_88000_379200 15.000000
R15687 n1_m1_88000_384000 n1_m4_88000_384000 15.000000
R15688 n1_m1_88000_388800 n1_m4_88000_388800 15.000000
R15689 n1_m1_88000_393600 n1_m4_88000_393600 15.000000
R15690 n1_m1_88000_398400 n1_m4_88000_398400 15.000000
R15691 n1_m1_88000_403200 n1_m4_88000_403200 15.000000
R15692 n1_m1_88000_408000 n1_m4_88000_408000 15.000000
R15693 n1_m1_88000_412800 n1_m4_88000_412800 15.000000
R15694 n1_m1_88000_417600 n1_m4_88000_417600 15.000000
R15695 n1_m1_88000_422400 n1_m4_88000_422400 15.000000
R15696 n1_m1_88000_427200 n1_m4_88000_427200 15.000000
R15697 n1_m1_88000_432000 n1_m4_88000_432000 15.000000
R15698 n1_m1_88000_436800 n1_m4_88000_436800 15.000000
R15699 n1_m1_88000_441600 n1_m4_88000_441600 15.000000
R15700 n1_m1_88000_446400 n1_m4_88000_446400 15.000000
R15701 n1_m1_88000_451200 n1_m4_88000_451200 15.000000
R15702 n1_m1_88000_456000 n1_m4_88000_456000 15.000000
R15703 n1_m1_88000_460800 n1_m4_88000_460800 15.000000
R15704 n1_m1_88000_465600 n1_m4_88000_465600 15.000000
R15705 n1_m1_88000_470400 n1_m4_88000_470400 15.000000
R15706 n1_m1_88000_475200 n1_m4_88000_475200 15.000000
R15707 n1_m1_88000_480000 n1_m4_88000_480000 15.000000
R15708 n1_m1_88000_484800 n1_m4_88000_484800 15.000000
R15709 n1_m1_88000_489600 n1_m4_88000_489600 15.000000
R15710 n1_m1_88000_494400 n1_m4_88000_494400 15.000000
R15711 n1_m1_116000_0 n1_m4_116000_0 15.000000
R15712 n1_m1_116000_4800 n1_m4_116000_4800 15.000000
R15713 n1_m1_116000_9600 n1_m4_116000_9600 15.000000
R15714 n1_m1_116000_14400 n1_m4_116000_14400 15.000000
R15715 n1_m1_116000_19200 n1_m4_116000_19200 15.000000
R15716 n1_m1_116000_24000 n1_m4_116000_24000 15.000000
R15717 n1_m1_116000_28800 n1_m4_116000_28800 15.000000
R15718 n1_m1_116000_33600 n1_m4_116000_33600 15.000000
R15719 n1_m1_116000_38400 n1_m4_116000_38400 15.000000
R15720 n1_m1_116000_43200 n1_m4_116000_43200 15.000000
R15721 n1_m1_116000_48000 n1_m4_116000_48000 15.000000
R15722 n1_m1_116000_52800 n1_m4_116000_52800 15.000000
R15723 n1_m1_116000_57600 n1_m4_116000_57600 15.000000
R15724 n1_m1_116000_62400 n1_m4_116000_62400 15.000000
R15725 n1_m1_116000_67200 n1_m4_116000_67200 15.000000
R15726 n1_m1_116000_72000 n1_m4_116000_72000 15.000000
R15727 n1_m1_116000_76800 n1_m4_116000_76800 15.000000
R15728 n1_m1_116000_81600 n1_m4_116000_81600 15.000000
R15729 n1_m1_116000_86400 n1_m4_116000_86400 15.000000
R15730 n1_m1_116000_91200 n1_m4_116000_91200 15.000000
R15731 n1_m1_116000_96000 n1_m4_116000_96000 15.000000
R15732 n1_m1_116000_100800 n1_m4_116000_100800 15.000000
R15733 n1_m1_116000_105600 n1_m4_116000_105600 15.000000
R15734 n1_m1_116000_110400 n1_m4_116000_110400 15.000000
R15735 n1_m1_116000_115200 n1_m4_116000_115200 15.000000
R15736 n1_m1_116000_120000 n1_m4_116000_120000 15.000000
R15737 n1_m1_116000_124800 n1_m4_116000_124800 15.000000
R15738 n1_m1_116000_129600 n1_m4_116000_129600 15.000000
R15739 n1_m1_116000_134400 n1_m4_116000_134400 15.000000
R15740 n1_m1_116000_139200 n1_m4_116000_139200 15.000000
R15741 n1_m1_116000_144000 n1_m4_116000_144000 15.000000
R15742 n1_m1_116000_148800 n1_m4_116000_148800 15.000000
R15743 n1_m1_116000_153600 n1_m4_116000_153600 15.000000
R15744 n1_m1_116000_158400 n1_m4_116000_158400 15.000000
R15745 n1_m1_116000_163200 n1_m4_116000_163200 15.000000
R15746 n1_m1_116000_168000 n1_m4_116000_168000 15.000000
R15747 n1_m1_116000_172800 n1_m4_116000_172800 15.000000
R15748 n1_m1_116000_177600 n1_m4_116000_177600 15.000000
R15749 n1_m1_116000_182400 n1_m4_116000_182400 15.000000
R15750 n1_m1_116000_187200 n1_m4_116000_187200 15.000000
R15751 n1_m1_116000_192000 n1_m4_116000_192000 15.000000
R15752 n1_m1_116000_196800 n1_m4_116000_196800 15.000000
R15753 n1_m1_116000_201600 n1_m4_116000_201600 15.000000
R15754 n1_m1_116000_206400 n1_m4_116000_206400 15.000000
R15755 n1_m1_116000_211200 n1_m4_116000_211200 15.000000
R15756 n1_m1_116000_216000 n1_m4_116000_216000 15.000000
R15757 n1_m1_116000_220800 n1_m4_116000_220800 15.000000
R15758 n1_m1_116000_225600 n1_m4_116000_225600 15.000000
R15759 n1_m1_116000_230400 n1_m4_116000_230400 15.000000
R15760 n1_m1_116000_235200 n1_m4_116000_235200 15.000000
R15761 n1_m1_116000_240000 n1_m4_116000_240000 15.000000
R15762 n1_m1_116000_244800 n1_m4_116000_244800 15.000000
R15763 n1_m1_116000_249600 n1_m4_116000_249600 15.000000
R15764 n1_m1_116000_254400 n1_m4_116000_254400 15.000000
R15765 n1_m1_116000_259200 n1_m4_116000_259200 15.000000
R15766 n1_m1_116000_264000 n1_m4_116000_264000 15.000000
R15767 n1_m1_116000_268800 n1_m4_116000_268800 15.000000
R15768 n1_m1_116000_273600 n1_m4_116000_273600 15.000000
R15769 n1_m1_116000_278400 n1_m4_116000_278400 15.000000
R15770 n1_m1_116000_283200 n1_m4_116000_283200 15.000000
R15771 n1_m1_116000_288000 n1_m4_116000_288000 15.000000
R15772 n1_m1_116000_292800 n1_m4_116000_292800 15.000000
R15773 n1_m1_116000_297600 n1_m4_116000_297600 15.000000
R15774 n1_m1_116000_302400 n1_m4_116000_302400 15.000000
R15775 n1_m1_116000_307200 n1_m4_116000_307200 15.000000
R15776 n1_m1_116000_312000 n1_m4_116000_312000 15.000000
R15777 n1_m1_116000_316800 n1_m4_116000_316800 15.000000
R15778 n1_m1_116000_321600 n1_m4_116000_321600 15.000000
R15779 n1_m1_116000_326400 n1_m4_116000_326400 15.000000
R15780 n1_m1_116000_331200 n1_m4_116000_331200 15.000000
R15781 n1_m1_116000_336000 n1_m4_116000_336000 15.000000
R15782 n1_m1_116000_340800 n1_m4_116000_340800 15.000000
R15783 n1_m1_116000_345600 n1_m4_116000_345600 15.000000
R15784 n1_m1_116000_350400 n1_m4_116000_350400 15.000000
R15785 n1_m1_116000_355200 n1_m4_116000_355200 15.000000
R15786 n1_m1_116000_360000 n1_m4_116000_360000 15.000000
R15787 n1_m1_116000_364800 n1_m4_116000_364800 15.000000
R15788 n1_m1_116000_369600 n1_m4_116000_369600 15.000000
R15789 n1_m1_116000_374400 n1_m4_116000_374400 15.000000
R15790 n1_m1_116000_379200 n1_m4_116000_379200 15.000000
R15791 n1_m1_116000_384000 n1_m4_116000_384000 15.000000
R15792 n1_m1_116000_388800 n1_m4_116000_388800 15.000000
R15793 n1_m1_116000_393600 n1_m4_116000_393600 15.000000
R15794 n1_m1_116000_398400 n1_m4_116000_398400 15.000000
R15795 n1_m1_116000_403200 n1_m4_116000_403200 15.000000
R15796 n1_m1_116000_408000 n1_m4_116000_408000 15.000000
R15797 n1_m1_116000_412800 n1_m4_116000_412800 15.000000
R15798 n1_m1_116000_417600 n1_m4_116000_417600 15.000000
R15799 n1_m1_116000_422400 n1_m4_116000_422400 15.000000
R15800 n1_m1_116000_427200 n1_m4_116000_427200 15.000000
R15801 n1_m1_116000_432000 n1_m4_116000_432000 15.000000
R15802 n1_m1_116000_436800 n1_m4_116000_436800 15.000000
R15803 n1_m1_116000_441600 n1_m4_116000_441600 15.000000
R15804 n1_m1_116000_446400 n1_m4_116000_446400 15.000000
R15805 n1_m1_116000_451200 n1_m4_116000_451200 15.000000
R15806 n1_m1_116000_456000 n1_m4_116000_456000 15.000000
R15807 n1_m1_116000_460800 n1_m4_116000_460800 15.000000
R15808 n1_m1_116000_465600 n1_m4_116000_465600 15.000000
R15809 n1_m1_116000_470400 n1_m4_116000_470400 15.000000
R15810 n1_m1_116000_475200 n1_m4_116000_475200 15.000000
R15811 n1_m1_116000_480000 n1_m4_116000_480000 15.000000
R15812 n1_m1_116000_484800 n1_m4_116000_484800 15.000000
R15813 n1_m1_116000_489600 n1_m4_116000_489600 15.000000
R15814 n1_m1_116000_494400 n1_m4_116000_494400 15.000000
R15815 n1_m1_144000_0 n1_m4_144000_0 15.000000
R15816 n1_m1_144000_4800 n1_m4_144000_4800 15.000000
R15817 n1_m1_144000_9600 n1_m4_144000_9600 15.000000
R15818 n1_m1_144000_14400 n1_m4_144000_14400 15.000000
R15819 n1_m1_144000_19200 n1_m4_144000_19200 15.000000
R15820 n1_m1_144000_24000 n1_m4_144000_24000 15.000000
R15821 n1_m1_144000_28800 n1_m4_144000_28800 15.000000
R15822 n1_m1_144000_33600 n1_m4_144000_33600 15.000000
R15823 n1_m1_144000_38400 n1_m4_144000_38400 15.000000
R15824 n1_m1_144000_43200 n1_m4_144000_43200 15.000000
R15825 n1_m1_144000_48000 n1_m4_144000_48000 15.000000
R15826 n1_m1_144000_52800 n1_m4_144000_52800 15.000000
R15827 n1_m1_144000_57600 n1_m4_144000_57600 15.000000
R15828 n1_m1_144000_62400 n1_m4_144000_62400 15.000000
R15829 n1_m1_144000_67200 n1_m4_144000_67200 15.000000
R15830 n1_m1_144000_72000 n1_m4_144000_72000 15.000000
R15831 n1_m1_144000_76800 n1_m4_144000_76800 15.000000
R15832 n1_m1_144000_81600 n1_m4_144000_81600 15.000000
R15833 n1_m1_144000_86400 n1_m4_144000_86400 15.000000
R15834 n1_m1_144000_91200 n1_m4_144000_91200 15.000000
R15835 n1_m1_144000_96000 n1_m4_144000_96000 15.000000
R15836 n1_m1_144000_100800 n1_m4_144000_100800 15.000000
R15837 n1_m1_144000_105600 n1_m4_144000_105600 15.000000
R15838 n1_m1_144000_110400 n1_m4_144000_110400 15.000000
R15839 n1_m1_144000_115200 n1_m4_144000_115200 15.000000
R15840 n1_m1_144000_120000 n1_m4_144000_120000 15.000000
R15841 n1_m1_144000_124800 n1_m4_144000_124800 15.000000
R15842 n1_m1_144000_129600 n1_m4_144000_129600 15.000000
R15843 n1_m1_144000_134400 n1_m4_144000_134400 15.000000
R15844 n1_m1_144000_139200 n1_m4_144000_139200 15.000000
R15845 n1_m1_144000_144000 n1_m4_144000_144000 15.000000
R15846 n1_m1_144000_148800 n1_m4_144000_148800 15.000000
R15847 n1_m1_144000_153600 n1_m4_144000_153600 15.000000
R15848 n1_m1_144000_158400 n1_m4_144000_158400 15.000000
R15849 n1_m1_144000_163200 n1_m4_144000_163200 15.000000
R15850 n1_m1_144000_168000 n1_m4_144000_168000 15.000000
R15851 n1_m1_144000_172800 n1_m4_144000_172800 15.000000
R15852 n1_m1_144000_177600 n1_m4_144000_177600 15.000000
R15853 n1_m1_144000_182400 n1_m4_144000_182400 15.000000
R15854 n1_m1_144000_187200 n1_m4_144000_187200 15.000000
R15855 n1_m1_144000_192000 n1_m4_144000_192000 15.000000
R15856 n1_m1_144000_196800 n1_m4_144000_196800 15.000000
R15857 n1_m1_144000_201600 n1_m4_144000_201600 15.000000
R15858 n1_m1_144000_206400 n1_m4_144000_206400 15.000000
R15859 n1_m1_144000_211200 n1_m4_144000_211200 15.000000
R15860 n1_m1_144000_216000 n1_m4_144000_216000 15.000000
R15861 n1_m1_144000_220800 n1_m4_144000_220800 15.000000
R15862 n1_m1_144000_225600 n1_m4_144000_225600 15.000000
R15863 n1_m1_144000_230400 n1_m4_144000_230400 15.000000
R15864 n1_m1_144000_235200 n1_m4_144000_235200 15.000000
R15865 n1_m1_144000_240000 n1_m4_144000_240000 15.000000
R15866 n1_m1_144000_244800 n1_m4_144000_244800 15.000000
R15867 n1_m1_144000_249600 n1_m4_144000_249600 15.000000
R15868 n1_m1_144000_254400 n1_m4_144000_254400 15.000000
R15869 n1_m1_144000_259200 n1_m4_144000_259200 15.000000
R15870 n1_m1_144000_264000 n1_m4_144000_264000 15.000000
R15871 n1_m1_144000_268800 n1_m4_144000_268800 15.000000
R15872 n1_m1_144000_273600 n1_m4_144000_273600 15.000000
R15873 n1_m1_144000_278400 n1_m4_144000_278400 15.000000
R15874 n1_m1_144000_283200 n1_m4_144000_283200 15.000000
R15875 n1_m1_144000_288000 n1_m4_144000_288000 15.000000
R15876 n1_m1_144000_292800 n1_m4_144000_292800 15.000000
R15877 n1_m1_144000_297600 n1_m4_144000_297600 15.000000
R15878 n1_m1_144000_302400 n1_m4_144000_302400 15.000000
R15879 n1_m1_144000_307200 n1_m4_144000_307200 15.000000
R15880 n1_m1_144000_312000 n1_m4_144000_312000 15.000000
R15881 n1_m1_144000_316800 n1_m4_144000_316800 15.000000
R15882 n1_m1_144000_321600 n1_m4_144000_321600 15.000000
R15883 n1_m1_144000_326400 n1_m4_144000_326400 15.000000
R15884 n1_m1_144000_331200 n1_m4_144000_331200 15.000000
R15885 n1_m1_144000_336000 n1_m4_144000_336000 15.000000
R15886 n1_m1_144000_340800 n1_m4_144000_340800 15.000000
R15887 n1_m1_144000_345600 n1_m4_144000_345600 15.000000
R15888 n1_m1_144000_350400 n1_m4_144000_350400 15.000000
R15889 n1_m1_144000_355200 n1_m4_144000_355200 15.000000
R15890 n1_m1_144000_360000 n1_m4_144000_360000 15.000000
R15891 n1_m1_144000_364800 n1_m4_144000_364800 15.000000
R15892 n1_m1_144000_369600 n1_m4_144000_369600 15.000000
R15893 n1_m1_144000_374400 n1_m4_144000_374400 15.000000
R15894 n1_m1_144000_379200 n1_m4_144000_379200 15.000000
R15895 n1_m1_144000_384000 n1_m4_144000_384000 15.000000
R15896 n1_m1_144000_388800 n1_m4_144000_388800 15.000000
R15897 n1_m1_144000_393600 n1_m4_144000_393600 15.000000
R15898 n1_m1_144000_398400 n1_m4_144000_398400 15.000000
R15899 n1_m1_144000_403200 n1_m4_144000_403200 15.000000
R15900 n1_m1_144000_408000 n1_m4_144000_408000 15.000000
R15901 n1_m1_144000_412800 n1_m4_144000_412800 15.000000
R15902 n1_m1_144000_417600 n1_m4_144000_417600 15.000000
R15903 n1_m1_144000_422400 n1_m4_144000_422400 15.000000
R15904 n1_m1_144000_427200 n1_m4_144000_427200 15.000000
R15905 n1_m1_144000_432000 n1_m4_144000_432000 15.000000
R15906 n1_m1_144000_436800 n1_m4_144000_436800 15.000000
R15907 n1_m1_144000_441600 n1_m4_144000_441600 15.000000
R15908 n1_m1_144000_446400 n1_m4_144000_446400 15.000000
R15909 n1_m1_144000_451200 n1_m4_144000_451200 15.000000
R15910 n1_m1_144000_456000 n1_m4_144000_456000 15.000000
R15911 n1_m1_144000_460800 n1_m4_144000_460800 15.000000
R15912 n1_m1_144000_465600 n1_m4_144000_465600 15.000000
R15913 n1_m1_144000_470400 n1_m4_144000_470400 15.000000
R15914 n1_m1_144000_475200 n1_m4_144000_475200 15.000000
R15915 n1_m1_144000_480000 n1_m4_144000_480000 15.000000
R15916 n1_m1_144000_484800 n1_m4_144000_484800 15.000000
R15917 n1_m1_144000_489600 n1_m4_144000_489600 15.000000
R15918 n1_m1_144000_494400 n1_m4_144000_494400 15.000000
R15919 n1_m1_172000_0 n1_m4_172000_0 15.000000
R15920 n1_m1_172000_4800 n1_m4_172000_4800 15.000000
R15921 n1_m1_172000_9600 n1_m4_172000_9600 15.000000
R15922 n1_m1_172000_14400 n1_m4_172000_14400 15.000000
R15923 n1_m1_172000_19200 n1_m4_172000_19200 15.000000
R15924 n1_m1_172000_24000 n1_m4_172000_24000 15.000000
R15925 n1_m1_172000_28800 n1_m4_172000_28800 15.000000
R15926 n1_m1_172000_33600 n1_m4_172000_33600 15.000000
R15927 n1_m1_172000_38400 n1_m4_172000_38400 15.000000
R15928 n1_m1_172000_43200 n1_m4_172000_43200 15.000000
R15929 n1_m1_172000_48000 n1_m4_172000_48000 15.000000
R15930 n1_m1_172000_52800 n1_m4_172000_52800 15.000000
R15931 n1_m1_172000_57600 n1_m4_172000_57600 15.000000
R15932 n1_m1_172000_62400 n1_m4_172000_62400 15.000000
R15933 n1_m1_172000_67200 n1_m4_172000_67200 15.000000
R15934 n1_m1_172000_72000 n1_m4_172000_72000 15.000000
R15935 n1_m1_172000_76800 n1_m4_172000_76800 15.000000
R15936 n1_m1_172000_81600 n1_m4_172000_81600 15.000000
R15937 n1_m1_172000_86400 n1_m4_172000_86400 15.000000
R15938 n1_m1_172000_91200 n1_m4_172000_91200 15.000000
R15939 n1_m1_172000_96000 n1_m4_172000_96000 15.000000
R15940 n1_m1_172000_100800 n1_m4_172000_100800 15.000000
R15941 n1_m1_172000_105600 n1_m4_172000_105600 15.000000
R15942 n1_m1_172000_110400 n1_m4_172000_110400 15.000000
R15943 n1_m1_172000_115200 n1_m4_172000_115200 15.000000
R15944 n1_m1_172000_120000 n1_m4_172000_120000 15.000000
R15945 n1_m1_172000_124800 n1_m4_172000_124800 15.000000
R15946 n1_m1_172000_129600 n1_m4_172000_129600 15.000000
R15947 n1_m1_172000_134400 n1_m4_172000_134400 15.000000
R15948 n1_m1_172000_139200 n1_m4_172000_139200 15.000000
R15949 n1_m1_172000_144000 n1_m4_172000_144000 15.000000
R15950 n1_m1_172000_148800 n1_m4_172000_148800 15.000000
R15951 n1_m1_172000_153600 n1_m4_172000_153600 15.000000
R15952 n1_m1_172000_158400 n1_m4_172000_158400 15.000000
R15953 n1_m1_172000_163200 n1_m4_172000_163200 15.000000
R15954 n1_m1_172000_168000 n1_m4_172000_168000 15.000000
R15955 n1_m1_172000_172800 n1_m4_172000_172800 15.000000
R15956 n1_m1_172000_177600 n1_m4_172000_177600 15.000000
R15957 n1_m1_172000_182400 n1_m4_172000_182400 15.000000
R15958 n1_m1_172000_187200 n1_m4_172000_187200 15.000000
R15959 n1_m1_172000_192000 n1_m4_172000_192000 15.000000
R15960 n1_m1_172000_196800 n1_m4_172000_196800 15.000000
R15961 n1_m1_172000_201600 n1_m4_172000_201600 15.000000
R15962 n1_m1_172000_206400 n1_m4_172000_206400 15.000000
R15963 n1_m1_172000_211200 n1_m4_172000_211200 15.000000
R15964 n1_m1_172000_216000 n1_m4_172000_216000 15.000000
R15965 n1_m1_172000_220800 n1_m4_172000_220800 15.000000
R15966 n1_m1_172000_225600 n1_m4_172000_225600 15.000000
R15967 n1_m1_172000_230400 n1_m4_172000_230400 15.000000
R15968 n1_m1_172000_235200 n1_m4_172000_235200 15.000000
R15969 n1_m1_172000_240000 n1_m4_172000_240000 15.000000
R15970 n1_m1_172000_244800 n1_m4_172000_244800 15.000000
R15971 n1_m1_172000_249600 n1_m4_172000_249600 15.000000
R15972 n1_m1_172000_254400 n1_m4_172000_254400 15.000000
R15973 n1_m1_172000_259200 n1_m4_172000_259200 15.000000
R15974 n1_m1_172000_264000 n1_m4_172000_264000 15.000000
R15975 n1_m1_172000_268800 n1_m4_172000_268800 15.000000
R15976 n1_m1_172000_273600 n1_m4_172000_273600 15.000000
R15977 n1_m1_172000_278400 n1_m4_172000_278400 15.000000
R15978 n1_m1_172000_283200 n1_m4_172000_283200 15.000000
R15979 n1_m1_172000_288000 n1_m4_172000_288000 15.000000
R15980 n1_m1_172000_292800 n1_m4_172000_292800 15.000000
R15981 n1_m1_172000_297600 n1_m4_172000_297600 15.000000
R15982 n1_m1_172000_302400 n1_m4_172000_302400 15.000000
R15983 n1_m1_172000_307200 n1_m4_172000_307200 15.000000
R15984 n1_m1_172000_312000 n1_m4_172000_312000 15.000000
R15985 n1_m1_172000_316800 n1_m4_172000_316800 15.000000
R15986 n1_m1_172000_321600 n1_m4_172000_321600 15.000000
R15987 n1_m1_172000_326400 n1_m4_172000_326400 15.000000
R15988 n1_m1_172000_331200 n1_m4_172000_331200 15.000000
R15989 n1_m1_172000_336000 n1_m4_172000_336000 15.000000
R15990 n1_m1_172000_340800 n1_m4_172000_340800 15.000000
R15991 n1_m1_172000_345600 n1_m4_172000_345600 15.000000
R15992 n1_m1_172000_350400 n1_m4_172000_350400 15.000000
R15993 n1_m1_172000_355200 n1_m4_172000_355200 15.000000
R15994 n1_m1_172000_360000 n1_m4_172000_360000 15.000000
R15995 n1_m1_172000_364800 n1_m4_172000_364800 15.000000
R15996 n1_m1_172000_369600 n1_m4_172000_369600 15.000000
R15997 n1_m1_172000_374400 n1_m4_172000_374400 15.000000
R15998 n1_m1_172000_379200 n1_m4_172000_379200 15.000000
R15999 n1_m1_172000_384000 n1_m4_172000_384000 15.000000
R16000 n1_m1_172000_388800 n1_m4_172000_388800 15.000000
R16001 n1_m1_172000_393600 n1_m4_172000_393600 15.000000
R16002 n1_m1_172000_398400 n1_m4_172000_398400 15.000000
R16003 n1_m1_172000_403200 n1_m4_172000_403200 15.000000
R16004 n1_m1_172000_408000 n1_m4_172000_408000 15.000000
R16005 n1_m1_172000_412800 n1_m4_172000_412800 15.000000
R16006 n1_m1_172000_417600 n1_m4_172000_417600 15.000000
R16007 n1_m1_172000_422400 n1_m4_172000_422400 15.000000
R16008 n1_m1_172000_427200 n1_m4_172000_427200 15.000000
R16009 n1_m1_172000_432000 n1_m4_172000_432000 15.000000
R16010 n1_m1_172000_436800 n1_m4_172000_436800 15.000000
R16011 n1_m1_172000_441600 n1_m4_172000_441600 15.000000
R16012 n1_m1_172000_446400 n1_m4_172000_446400 15.000000
R16013 n1_m1_172000_451200 n1_m4_172000_451200 15.000000
R16014 n1_m1_172000_456000 n1_m4_172000_456000 15.000000
R16015 n1_m1_172000_460800 n1_m4_172000_460800 15.000000
R16016 n1_m1_172000_465600 n1_m4_172000_465600 15.000000
R16017 n1_m1_172000_470400 n1_m4_172000_470400 15.000000
R16018 n1_m1_172000_475200 n1_m4_172000_475200 15.000000
R16019 n1_m1_172000_480000 n1_m4_172000_480000 15.000000
R16020 n1_m1_172000_484800 n1_m4_172000_484800 15.000000
R16021 n1_m1_172000_489600 n1_m4_172000_489600 15.000000
R16022 n1_m1_172000_494400 n1_m4_172000_494400 15.000000
R16023 n1_m1_200000_0 n1_m4_200000_0 15.000000
R16024 n1_m1_200000_4800 n1_m4_200000_4800 15.000000
R16025 n1_m1_200000_9600 n1_m4_200000_9600 15.000000
R16026 n1_m1_200000_14400 n1_m4_200000_14400 15.000000
R16027 n1_m1_200000_19200 n1_m4_200000_19200 15.000000
R16028 n1_m1_200000_24000 n1_m4_200000_24000 15.000000
R16029 n1_m1_200000_28800 n1_m4_200000_28800 15.000000
R16030 n1_m1_200000_33600 n1_m4_200000_33600 15.000000
R16031 n1_m1_200000_38400 n1_m4_200000_38400 15.000000
R16032 n1_m1_200000_43200 n1_m4_200000_43200 15.000000
R16033 n1_m1_200000_48000 n1_m4_200000_48000 15.000000
R16034 n1_m1_200000_52800 n1_m4_200000_52800 15.000000
R16035 n1_m1_200000_57600 n1_m4_200000_57600 15.000000
R16036 n1_m1_200000_62400 n1_m4_200000_62400 15.000000
R16037 n1_m1_200000_67200 n1_m4_200000_67200 15.000000
R16038 n1_m1_200000_72000 n1_m4_200000_72000 15.000000
R16039 n1_m1_200000_76800 n1_m4_200000_76800 15.000000
R16040 n1_m1_200000_81600 n1_m4_200000_81600 15.000000
R16041 n1_m1_200000_86400 n1_m4_200000_86400 15.000000
R16042 n1_m1_200000_91200 n1_m4_200000_91200 15.000000
R16043 n1_m1_200000_96000 n1_m4_200000_96000 15.000000
R16044 n1_m1_200000_100800 n1_m4_200000_100800 15.000000
R16045 n1_m1_200000_105600 n1_m4_200000_105600 15.000000
R16046 n1_m1_200000_110400 n1_m4_200000_110400 15.000000
R16047 n1_m1_200000_115200 n1_m4_200000_115200 15.000000
R16048 n1_m1_200000_120000 n1_m4_200000_120000 15.000000
R16049 n1_m1_200000_124800 n1_m4_200000_124800 15.000000
R16050 n1_m1_200000_129600 n1_m4_200000_129600 15.000000
R16051 n1_m1_200000_134400 n1_m4_200000_134400 15.000000
R16052 n1_m1_200000_139200 n1_m4_200000_139200 15.000000
R16053 n1_m1_200000_144000 n1_m4_200000_144000 15.000000
R16054 n1_m1_200000_148800 n1_m4_200000_148800 15.000000
R16055 n1_m1_200000_153600 n1_m4_200000_153600 15.000000
R16056 n1_m1_200000_158400 n1_m4_200000_158400 15.000000
R16057 n1_m1_200000_163200 n1_m4_200000_163200 15.000000
R16058 n1_m1_200000_168000 n1_m4_200000_168000 15.000000
R16059 n1_m1_200000_172800 n1_m4_200000_172800 15.000000
R16060 n1_m1_200000_177600 n1_m4_200000_177600 15.000000
R16061 n1_m1_200000_182400 n1_m4_200000_182400 15.000000
R16062 n1_m1_200000_187200 n1_m4_200000_187200 15.000000
R16063 n1_m1_200000_192000 n1_m4_200000_192000 15.000000
R16064 n1_m1_200000_196800 n1_m4_200000_196800 15.000000
R16065 n1_m1_200000_201600 n1_m4_200000_201600 15.000000
R16066 n1_m1_200000_206400 n1_m4_200000_206400 15.000000
R16067 n1_m1_200000_211200 n1_m4_200000_211200 15.000000
R16068 n1_m1_200000_216000 n1_m4_200000_216000 15.000000
R16069 n1_m1_200000_220800 n1_m4_200000_220800 15.000000
R16070 n1_m1_200000_225600 n1_m4_200000_225600 15.000000
R16071 n1_m1_200000_230400 n1_m4_200000_230400 15.000000
R16072 n1_m1_200000_235200 n1_m4_200000_235200 15.000000
R16073 n1_m1_200000_240000 n1_m4_200000_240000 15.000000
R16074 n1_m1_200000_244800 n1_m4_200000_244800 15.000000
R16075 n1_m1_200000_249600 n1_m4_200000_249600 15.000000
R16076 n1_m1_200000_254400 n1_m4_200000_254400 15.000000
R16077 n1_m1_200000_259200 n1_m4_200000_259200 15.000000
R16078 n1_m1_200000_264000 n1_m4_200000_264000 15.000000
R16079 n1_m1_200000_268800 n1_m4_200000_268800 15.000000
R16080 n1_m1_200000_273600 n1_m4_200000_273600 15.000000
R16081 n1_m1_200000_278400 n1_m4_200000_278400 15.000000
R16082 n1_m1_200000_283200 n1_m4_200000_283200 15.000000
R16083 n1_m1_200000_288000 n1_m4_200000_288000 15.000000
R16084 n1_m1_200000_292800 n1_m4_200000_292800 15.000000
R16085 n1_m1_200000_297600 n1_m4_200000_297600 15.000000
R16086 n1_m1_200000_302400 n1_m4_200000_302400 15.000000
R16087 n1_m1_200000_307200 n1_m4_200000_307200 15.000000
R16088 n1_m1_200000_312000 n1_m4_200000_312000 15.000000
R16089 n1_m1_200000_316800 n1_m4_200000_316800 15.000000
R16090 n1_m1_200000_321600 n1_m4_200000_321600 15.000000
R16091 n1_m1_200000_326400 n1_m4_200000_326400 15.000000
R16092 n1_m1_200000_331200 n1_m4_200000_331200 15.000000
R16093 n1_m1_200000_336000 n1_m4_200000_336000 15.000000
R16094 n1_m1_200000_340800 n1_m4_200000_340800 15.000000
R16095 n1_m1_200000_345600 n1_m4_200000_345600 15.000000
R16096 n1_m1_200000_350400 n1_m4_200000_350400 15.000000
R16097 n1_m1_200000_355200 n1_m4_200000_355200 15.000000
R16098 n1_m1_200000_360000 n1_m4_200000_360000 15.000000
R16099 n1_m1_200000_364800 n1_m4_200000_364800 15.000000
R16100 n1_m1_200000_369600 n1_m4_200000_369600 15.000000
R16101 n1_m1_200000_374400 n1_m4_200000_374400 15.000000
R16102 n1_m1_200000_379200 n1_m4_200000_379200 15.000000
R16103 n1_m1_200000_384000 n1_m4_200000_384000 15.000000
R16104 n1_m1_200000_388800 n1_m4_200000_388800 15.000000
R16105 n1_m1_200000_393600 n1_m4_200000_393600 15.000000
R16106 n1_m1_200000_398400 n1_m4_200000_398400 15.000000
R16107 n1_m1_200000_403200 n1_m4_200000_403200 15.000000
R16108 n1_m1_200000_408000 n1_m4_200000_408000 15.000000
R16109 n1_m1_200000_412800 n1_m4_200000_412800 15.000000
R16110 n1_m1_200000_417600 n1_m4_200000_417600 15.000000
R16111 n1_m1_200000_422400 n1_m4_200000_422400 15.000000
R16112 n1_m1_200000_427200 n1_m4_200000_427200 15.000000
R16113 n1_m1_200000_432000 n1_m4_200000_432000 15.000000
R16114 n1_m1_200000_436800 n1_m4_200000_436800 15.000000
R16115 n1_m1_200000_441600 n1_m4_200000_441600 15.000000
R16116 n1_m1_200000_446400 n1_m4_200000_446400 15.000000
R16117 n1_m1_200000_451200 n1_m4_200000_451200 15.000000
R16118 n1_m1_200000_456000 n1_m4_200000_456000 15.000000
R16119 n1_m1_200000_460800 n1_m4_200000_460800 15.000000
R16120 n1_m1_200000_465600 n1_m4_200000_465600 15.000000
R16121 n1_m1_200000_470400 n1_m4_200000_470400 15.000000
R16122 n1_m1_200000_475200 n1_m4_200000_475200 15.000000
R16123 n1_m1_200000_480000 n1_m4_200000_480000 15.000000
R16124 n1_m1_200000_484800 n1_m4_200000_484800 15.000000
R16125 n1_m1_200000_489600 n1_m4_200000_489600 15.000000
R16126 n1_m1_200000_494400 n1_m4_200000_494400 15.000000
R16127 n1_m1_228000_0 n1_m4_228000_0 15.000000
R16128 n1_m1_228000_201600 n1_m4_228000_201600 15.000000
R16129 n1_m1_228000_206400 n1_m4_228000_206400 15.000000
R16130 n1_m1_228000_211200 n1_m4_228000_211200 15.000000
R16131 n1_m1_228000_216000 n1_m4_228000_216000 15.000000
R16132 n1_m1_228000_220800 n1_m4_228000_220800 15.000000
R16133 n1_m1_228000_225600 n1_m4_228000_225600 15.000000
R16134 n1_m1_228000_230400 n1_m4_228000_230400 15.000000
R16135 n1_m1_228000_235200 n1_m4_228000_235200 15.000000
R16136 n1_m1_228000_240000 n1_m4_228000_240000 15.000000
R16137 n1_m1_228000_244800 n1_m4_228000_244800 15.000000
R16138 n1_m1_228000_249600 n1_m4_228000_249600 15.000000
R16139 n1_m1_228000_254400 n1_m4_228000_254400 15.000000
R16140 n1_m1_228000_259200 n1_m4_228000_259200 15.000000
R16141 n1_m1_228000_264000 n1_m4_228000_264000 15.000000
R16142 n1_m1_228000_268800 n1_m4_228000_268800 15.000000
R16143 n1_m1_228000_273600 n1_m4_228000_273600 15.000000
R16144 n1_m1_228000_278400 n1_m4_228000_278400 15.000000
R16145 n1_m1_228000_283200 n1_m4_228000_283200 15.000000
R16146 n1_m1_228000_288000 n1_m4_228000_288000 15.000000
R16147 n1_m1_228000_292800 n1_m4_228000_292800 15.000000
R16148 n1_m1_228000_297600 n1_m4_228000_297600 15.000000
R16149 n1_m1_228000_302400 n1_m4_228000_302400 15.000000
R16150 n1_m1_228000_307200 n1_m4_228000_307200 15.000000
R16151 n1_m1_228000_312000 n1_m4_228000_312000 15.000000
R16152 n1_m1_228000_316800 n1_m4_228000_316800 15.000000
R16153 n1_m1_228000_321600 n1_m4_228000_321600 15.000000
R16154 n1_m1_228000_326400 n1_m4_228000_326400 15.000000
R16155 n1_m1_228000_331200 n1_m4_228000_331200 15.000000
R16156 n1_m1_228000_336000 n1_m4_228000_336000 15.000000
R16157 n1_m1_228000_340800 n1_m4_228000_340800 15.000000
R16158 n1_m1_228000_345600 n1_m4_228000_345600 15.000000
R16159 n1_m1_228000_350400 n1_m4_228000_350400 15.000000
R16160 n1_m1_228000_355200 n1_m4_228000_355200 15.000000
R16161 n1_m1_228000_360000 n1_m4_228000_360000 15.000000
R16162 n1_m1_228000_364800 n1_m4_228000_364800 15.000000
R16163 n1_m1_228000_369600 n1_m4_228000_369600 15.000000
R16164 n1_m1_228000_374400 n1_m4_228000_374400 15.000000
R16165 n1_m1_228000_379200 n1_m4_228000_379200 15.000000
R16166 n1_m1_228000_384000 n1_m4_228000_384000 15.000000
R16167 n1_m1_228000_388800 n1_m4_228000_388800 15.000000
R16168 n1_m1_228000_393600 n1_m4_228000_393600 15.000000
R16169 n1_m1_228000_398400 n1_m4_228000_398400 15.000000
R16170 n1_m1_228000_403200 n1_m4_228000_403200 15.000000
R16171 n1_m1_228000_408000 n1_m4_228000_408000 15.000000
R16172 n1_m1_228000_412800 n1_m4_228000_412800 15.000000
R16173 n1_m1_228000_417600 n1_m4_228000_417600 15.000000
R16174 n1_m1_228000_422400 n1_m4_228000_422400 15.000000
R16175 n1_m1_228000_427200 n1_m4_228000_427200 15.000000
R16176 n1_m1_228000_432000 n1_m4_228000_432000 15.000000
R16177 n1_m1_228000_436800 n1_m4_228000_436800 15.000000
R16178 n1_m1_228000_441600 n1_m4_228000_441600 15.000000
R16179 n1_m1_228000_446400 n1_m4_228000_446400 15.000000
R16180 n1_m1_228000_451200 n1_m4_228000_451200 15.000000
R16181 n1_m1_228000_456000 n1_m4_228000_456000 15.000000
R16182 n1_m1_228000_460800 n1_m4_228000_460800 15.000000
R16183 n1_m1_228000_465600 n1_m4_228000_465600 15.000000
R16184 n1_m1_228000_470400 n1_m4_228000_470400 15.000000
R16185 n1_m1_228000_475200 n1_m4_228000_475200 15.000000
R16186 n1_m1_228000_480000 n1_m4_228000_480000 15.000000
R16187 n1_m1_228000_484800 n1_m4_228000_484800 15.000000
R16188 n1_m1_228000_489600 n1_m4_228000_489600 15.000000
R16189 n1_m1_228000_494400 n1_m4_228000_494400 15.000000
R16190 n1_m1_256000_0 n1_m4_256000_0 15.000000
R16191 n1_m1_256000_201600 n1_m4_256000_201600 15.000000
R16192 n1_m1_256000_206400 n1_m4_256000_206400 15.000000
R16193 n1_m1_256000_211200 n1_m4_256000_211200 15.000000
R16194 n1_m1_256000_216000 n1_m4_256000_216000 15.000000
R16195 n1_m1_256000_220800 n1_m4_256000_220800 15.000000
R16196 n1_m1_256000_225600 n1_m4_256000_225600 15.000000
R16197 n1_m1_256000_230400 n1_m4_256000_230400 15.000000
R16198 n1_m1_256000_235200 n1_m4_256000_235200 15.000000
R16199 n1_m1_256000_240000 n1_m4_256000_240000 15.000000
R16200 n1_m1_256000_244800 n1_m4_256000_244800 15.000000
R16201 n1_m1_256000_249600 n1_m4_256000_249600 15.000000
R16202 n1_m1_256000_254400 n1_m4_256000_254400 15.000000
R16203 n1_m1_256000_259200 n1_m4_256000_259200 15.000000
R16204 n1_m1_256000_264000 n1_m4_256000_264000 15.000000
R16205 n1_m1_256000_268800 n1_m4_256000_268800 15.000000
R16206 n1_m1_256000_273600 n1_m4_256000_273600 15.000000
R16207 n1_m1_256000_278400 n1_m4_256000_278400 15.000000
R16208 n1_m1_256000_283200 n1_m4_256000_283200 15.000000
R16209 n1_m1_256000_288000 n1_m4_256000_288000 15.000000
R16210 n1_m1_256000_292800 n1_m4_256000_292800 15.000000
R16211 n1_m1_256000_297600 n1_m4_256000_297600 15.000000
R16212 n1_m1_256000_302400 n1_m4_256000_302400 15.000000
R16213 n1_m1_256000_307200 n1_m4_256000_307200 15.000000
R16214 n1_m1_256000_312000 n1_m4_256000_312000 15.000000
R16215 n1_m1_256000_316800 n1_m4_256000_316800 15.000000
R16216 n1_m1_256000_321600 n1_m4_256000_321600 15.000000
R16217 n1_m1_256000_326400 n1_m4_256000_326400 15.000000
R16218 n1_m1_256000_331200 n1_m4_256000_331200 15.000000
R16219 n1_m1_256000_336000 n1_m4_256000_336000 15.000000
R16220 n1_m1_256000_340800 n1_m4_256000_340800 15.000000
R16221 n1_m1_256000_345600 n1_m4_256000_345600 15.000000
R16222 n1_m1_256000_350400 n1_m4_256000_350400 15.000000
R16223 n1_m1_256000_355200 n1_m4_256000_355200 15.000000
R16224 n1_m1_256000_360000 n1_m4_256000_360000 15.000000
R16225 n1_m1_256000_364800 n1_m4_256000_364800 15.000000
R16226 n1_m1_256000_369600 n1_m4_256000_369600 15.000000
R16227 n1_m1_256000_374400 n1_m4_256000_374400 15.000000
R16228 n1_m1_256000_379200 n1_m4_256000_379200 15.000000
R16229 n1_m1_256000_384000 n1_m4_256000_384000 15.000000
R16230 n1_m1_256000_388800 n1_m4_256000_388800 15.000000
R16231 n1_m1_256000_393600 n1_m4_256000_393600 15.000000
R16232 n1_m1_256000_398400 n1_m4_256000_398400 15.000000
R16233 n1_m1_256000_403200 n1_m4_256000_403200 15.000000
R16234 n1_m1_256000_408000 n1_m4_256000_408000 15.000000
R16235 n1_m1_256000_412800 n1_m4_256000_412800 15.000000
R16236 n1_m1_256000_417600 n1_m4_256000_417600 15.000000
R16237 n1_m1_256000_422400 n1_m4_256000_422400 15.000000
R16238 n1_m1_256000_427200 n1_m4_256000_427200 15.000000
R16239 n1_m1_256000_432000 n1_m4_256000_432000 15.000000
R16240 n1_m1_256000_436800 n1_m4_256000_436800 15.000000
R16241 n1_m1_256000_441600 n1_m4_256000_441600 15.000000
R16242 n1_m1_256000_446400 n1_m4_256000_446400 15.000000
R16243 n1_m1_256000_451200 n1_m4_256000_451200 15.000000
R16244 n1_m1_256000_456000 n1_m4_256000_456000 15.000000
R16245 n1_m1_256000_460800 n1_m4_256000_460800 15.000000
R16246 n1_m1_256000_465600 n1_m4_256000_465600 15.000000
R16247 n1_m1_256000_470400 n1_m4_256000_470400 15.000000
R16248 n1_m1_256000_475200 n1_m4_256000_475200 15.000000
R16249 n1_m1_256000_480000 n1_m4_256000_480000 15.000000
R16250 n1_m1_256000_484800 n1_m4_256000_484800 15.000000
R16251 n1_m1_256000_489600 n1_m4_256000_489600 15.000000
R16252 n1_m1_256000_494400 n1_m4_256000_494400 15.000000
R16253 n1_m1_284000_0 n1_m4_284000_0 15.000000
R16254 n1_m1_284000_201600 n1_m4_284000_201600 15.000000
R16255 n1_m1_284000_206400 n1_m4_284000_206400 15.000000
R16256 n1_m1_284000_211200 n1_m4_284000_211200 15.000000
R16257 n1_m1_284000_216000 n1_m4_284000_216000 15.000000
R16258 n1_m1_284000_220800 n1_m4_284000_220800 15.000000
R16259 n1_m1_284000_225600 n1_m4_284000_225600 15.000000
R16260 n1_m1_284000_230400 n1_m4_284000_230400 15.000000
R16261 n1_m1_284000_235200 n1_m4_284000_235200 15.000000
R16262 n1_m1_284000_240000 n1_m4_284000_240000 15.000000
R16263 n1_m1_284000_244800 n1_m4_284000_244800 15.000000
R16264 n1_m1_284000_249600 n1_m4_284000_249600 15.000000
R16265 n1_m1_284000_254400 n1_m4_284000_254400 15.000000
R16266 n1_m1_284000_259200 n1_m4_284000_259200 15.000000
R16267 n1_m1_284000_264000 n1_m4_284000_264000 15.000000
R16268 n1_m1_284000_268800 n1_m4_284000_268800 15.000000
R16269 n1_m1_284000_273600 n1_m4_284000_273600 15.000000
R16270 n1_m1_284000_278400 n1_m4_284000_278400 15.000000
R16271 n1_m1_284000_283200 n1_m4_284000_283200 15.000000
R16272 n1_m1_284000_288000 n1_m4_284000_288000 15.000000
R16273 n1_m1_284000_292800 n1_m4_284000_292800 15.000000
R16274 n1_m1_284000_297600 n1_m4_284000_297600 15.000000
R16275 n1_m1_284000_302400 n1_m4_284000_302400 15.000000
R16276 n1_m1_284000_307200 n1_m4_284000_307200 15.000000
R16277 n1_m1_284000_312000 n1_m4_284000_312000 15.000000
R16278 n1_m1_284000_316800 n1_m4_284000_316800 15.000000
R16279 n1_m1_284000_321600 n1_m4_284000_321600 15.000000
R16280 n1_m1_284000_326400 n1_m4_284000_326400 15.000000
R16281 n1_m1_284000_331200 n1_m4_284000_331200 15.000000
R16282 n1_m1_284000_336000 n1_m4_284000_336000 15.000000
R16283 n1_m1_284000_340800 n1_m4_284000_340800 15.000000
R16284 n1_m1_284000_345600 n1_m4_284000_345600 15.000000
R16285 n1_m1_284000_350400 n1_m4_284000_350400 15.000000
R16286 n1_m1_284000_355200 n1_m4_284000_355200 15.000000
R16287 n1_m1_284000_360000 n1_m4_284000_360000 15.000000
R16288 n1_m1_284000_364800 n1_m4_284000_364800 15.000000
R16289 n1_m1_284000_369600 n1_m4_284000_369600 15.000000
R16290 n1_m1_284000_374400 n1_m4_284000_374400 15.000000
R16291 n1_m1_284000_379200 n1_m4_284000_379200 15.000000
R16292 n1_m1_284000_384000 n1_m4_284000_384000 15.000000
R16293 n1_m1_284000_388800 n1_m4_284000_388800 15.000000
R16294 n1_m1_284000_393600 n1_m4_284000_393600 15.000000
R16295 n1_m1_284000_398400 n1_m4_284000_398400 15.000000
R16296 n1_m1_284000_403200 n1_m4_284000_403200 15.000000
R16297 n1_m1_284000_408000 n1_m4_284000_408000 15.000000
R16298 n1_m1_284000_412800 n1_m4_284000_412800 15.000000
R16299 n1_m1_284000_417600 n1_m4_284000_417600 15.000000
R16300 n1_m1_284000_422400 n1_m4_284000_422400 15.000000
R16301 n1_m1_284000_427200 n1_m4_284000_427200 15.000000
R16302 n1_m1_284000_432000 n1_m4_284000_432000 15.000000
R16303 n1_m1_284000_436800 n1_m4_284000_436800 15.000000
R16304 n1_m1_284000_441600 n1_m4_284000_441600 15.000000
R16305 n1_m1_284000_446400 n1_m4_284000_446400 15.000000
R16306 n1_m1_284000_451200 n1_m4_284000_451200 15.000000
R16307 n1_m1_284000_456000 n1_m4_284000_456000 15.000000
R16308 n1_m1_284000_460800 n1_m4_284000_460800 15.000000
R16309 n1_m1_284000_465600 n1_m4_284000_465600 15.000000
R16310 n1_m1_284000_470400 n1_m4_284000_470400 15.000000
R16311 n1_m1_284000_475200 n1_m4_284000_475200 15.000000
R16312 n1_m1_284000_480000 n1_m4_284000_480000 15.000000
R16313 n1_m1_284000_484800 n1_m4_284000_484800 15.000000
R16314 n1_m1_284000_489600 n1_m4_284000_489600 15.000000
R16315 n1_m1_284000_494400 n1_m4_284000_494400 15.000000
R16316 n1_m1_312000_0 n1_m4_312000_0 15.000000
R16317 n1_m1_312000_4800 n1_m4_312000_4800 15.000000
R16318 n1_m1_312000_9600 n1_m4_312000_9600 15.000000
R16319 n1_m1_312000_14400 n1_m4_312000_14400 15.000000
R16320 n1_m1_312000_19200 n1_m4_312000_19200 15.000000
R16321 n1_m1_312000_24000 n1_m4_312000_24000 15.000000
R16322 n1_m1_312000_28800 n1_m4_312000_28800 15.000000
R16323 n1_m1_312000_33600 n1_m4_312000_33600 15.000000
R16324 n1_m1_312000_38400 n1_m4_312000_38400 15.000000
R16325 n1_m1_312000_43200 n1_m4_312000_43200 15.000000
R16326 n1_m1_312000_48000 n1_m4_312000_48000 15.000000
R16327 n1_m1_312000_52800 n1_m4_312000_52800 15.000000
R16328 n1_m1_312000_57600 n1_m4_312000_57600 15.000000
R16329 n1_m1_312000_62400 n1_m4_312000_62400 15.000000
R16330 n1_m1_312000_67200 n1_m4_312000_67200 15.000000
R16331 n1_m1_312000_72000 n1_m4_312000_72000 15.000000
R16332 n1_m1_312000_76800 n1_m4_312000_76800 15.000000
R16333 n1_m1_312000_81600 n1_m4_312000_81600 15.000000
R16334 n1_m1_312000_86400 n1_m4_312000_86400 15.000000
R16335 n1_m1_312000_91200 n1_m4_312000_91200 15.000000
R16336 n1_m1_312000_96000 n1_m4_312000_96000 15.000000
R16337 n1_m1_312000_100800 n1_m4_312000_100800 15.000000
R16338 n1_m1_312000_105600 n1_m4_312000_105600 15.000000
R16339 n1_m1_312000_110400 n1_m4_312000_110400 15.000000
R16340 n1_m1_312000_115200 n1_m4_312000_115200 15.000000
R16341 n1_m1_312000_120000 n1_m4_312000_120000 15.000000
R16342 n1_m1_312000_124800 n1_m4_312000_124800 15.000000
R16343 n1_m1_312000_129600 n1_m4_312000_129600 15.000000
R16344 n1_m1_312000_134400 n1_m4_312000_134400 15.000000
R16345 n1_m1_312000_139200 n1_m4_312000_139200 15.000000
R16346 n1_m1_312000_144000 n1_m4_312000_144000 15.000000
R16347 n1_m1_312000_148800 n1_m4_312000_148800 15.000000
R16348 n1_m1_312000_153600 n1_m4_312000_153600 15.000000
R16349 n1_m1_312000_158400 n1_m4_312000_158400 15.000000
R16350 n1_m1_312000_163200 n1_m4_312000_163200 15.000000
R16351 n1_m1_312000_168000 n1_m4_312000_168000 15.000000
R16352 n1_m1_312000_172800 n1_m4_312000_172800 15.000000
R16353 n1_m1_312000_177600 n1_m4_312000_177600 15.000000
R16354 n1_m1_312000_182400 n1_m4_312000_182400 15.000000
R16355 n1_m1_312000_187200 n1_m4_312000_187200 15.000000
R16356 n1_m1_312000_192000 n1_m4_312000_192000 15.000000
R16357 n1_m1_312000_196800 n1_m4_312000_196800 15.000000
R16358 n1_m1_312000_201600 n1_m4_312000_201600 15.000000
R16359 n1_m1_312000_206400 n1_m4_312000_206400 15.000000
R16360 n1_m1_312000_211200 n1_m4_312000_211200 15.000000
R16361 n1_m1_312000_216000 n1_m4_312000_216000 15.000000
R16362 n1_m1_312000_220800 n1_m4_312000_220800 15.000000
R16363 n1_m1_312000_225600 n1_m4_312000_225600 15.000000
R16364 n1_m1_312000_230400 n1_m4_312000_230400 15.000000
R16365 n1_m1_312000_235200 n1_m4_312000_235200 15.000000
R16366 n1_m1_312000_240000 n1_m4_312000_240000 15.000000
R16367 n1_m1_312000_244800 n1_m4_312000_244800 15.000000
R16368 n1_m1_312000_249600 n1_m4_312000_249600 15.000000
R16369 n1_m1_312000_254400 n1_m4_312000_254400 15.000000
R16370 n1_m1_312000_259200 n1_m4_312000_259200 15.000000
R16371 n1_m1_312000_264000 n1_m4_312000_264000 15.000000
R16372 n1_m1_312000_268800 n1_m4_312000_268800 15.000000
R16373 n1_m1_312000_273600 n1_m4_312000_273600 15.000000
R16374 n1_m1_312000_278400 n1_m4_312000_278400 15.000000
R16375 n1_m1_312000_283200 n1_m4_312000_283200 15.000000
R16376 n1_m1_312000_288000 n1_m4_312000_288000 15.000000
R16377 n1_m1_312000_292800 n1_m4_312000_292800 15.000000
R16378 n1_m1_312000_297600 n1_m4_312000_297600 15.000000
R16379 n1_m1_312000_302400 n1_m4_312000_302400 15.000000
R16380 n1_m1_312000_307200 n1_m4_312000_307200 15.000000
R16381 n1_m1_312000_312000 n1_m4_312000_312000 15.000000
R16382 n1_m1_312000_316800 n1_m4_312000_316800 15.000000
R16383 n1_m1_312000_321600 n1_m4_312000_321600 15.000000
R16384 n1_m1_312000_326400 n1_m4_312000_326400 15.000000
R16385 n1_m1_312000_331200 n1_m4_312000_331200 15.000000
R16386 n1_m1_312000_336000 n1_m4_312000_336000 15.000000
R16387 n1_m1_312000_340800 n1_m4_312000_340800 15.000000
R16388 n1_m1_312000_345600 n1_m4_312000_345600 15.000000
R16389 n1_m1_312000_350400 n1_m4_312000_350400 15.000000
R16390 n1_m1_312000_355200 n1_m4_312000_355200 15.000000
R16391 n1_m1_312000_360000 n1_m4_312000_360000 15.000000
R16392 n1_m1_312000_364800 n1_m4_312000_364800 15.000000
R16393 n1_m1_312000_369600 n1_m4_312000_369600 15.000000
R16394 n1_m1_312000_374400 n1_m4_312000_374400 15.000000
R16395 n1_m1_312000_379200 n1_m4_312000_379200 15.000000
R16396 n1_m1_312000_384000 n1_m4_312000_384000 15.000000
R16397 n1_m1_312000_388800 n1_m4_312000_388800 15.000000
R16398 n1_m1_312000_393600 n1_m4_312000_393600 15.000000
R16399 n1_m1_312000_398400 n1_m4_312000_398400 15.000000
R16400 n1_m1_312000_403200 n1_m4_312000_403200 15.000000
R16401 n1_m1_312000_408000 n1_m4_312000_408000 15.000000
R16402 n1_m1_312000_412800 n1_m4_312000_412800 15.000000
R16403 n1_m1_312000_417600 n1_m4_312000_417600 15.000000
R16404 n1_m1_312000_422400 n1_m4_312000_422400 15.000000
R16405 n1_m1_312000_427200 n1_m4_312000_427200 15.000000
R16406 n1_m1_312000_432000 n1_m4_312000_432000 15.000000
R16407 n1_m1_312000_436800 n1_m4_312000_436800 15.000000
R16408 n1_m1_312000_441600 n1_m4_312000_441600 15.000000
R16409 n1_m1_312000_446400 n1_m4_312000_446400 15.000000
R16410 n1_m1_312000_451200 n1_m4_312000_451200 15.000000
R16411 n1_m1_312000_456000 n1_m4_312000_456000 15.000000
R16412 n1_m1_312000_460800 n1_m4_312000_460800 15.000000
R16413 n1_m1_312000_465600 n1_m4_312000_465600 15.000000
R16414 n1_m1_312000_470400 n1_m4_312000_470400 15.000000
R16415 n1_m1_312000_475200 n1_m4_312000_475200 15.000000
R16416 n1_m1_312000_480000 n1_m4_312000_480000 15.000000
R16417 n1_m1_312000_484800 n1_m4_312000_484800 15.000000
R16418 n1_m1_312000_489600 n1_m4_312000_489600 15.000000
R16419 n1_m1_312000_494400 n1_m4_312000_494400 15.000000
R16420 n1_m1_340000_0 n1_m4_340000_0 15.000000
R16421 n1_m1_340000_201600 n1_m4_340000_201600 15.000000
R16422 n1_m1_340000_206400 n1_m4_340000_206400 15.000000
R16423 n1_m1_340000_211200 n1_m4_340000_211200 15.000000
R16424 n1_m1_340000_216000 n1_m4_340000_216000 15.000000
R16425 n1_m1_340000_220800 n1_m4_340000_220800 15.000000
R16426 n1_m1_340000_225600 n1_m4_340000_225600 15.000000
R16427 n1_m1_340000_230400 n1_m4_340000_230400 15.000000
R16428 n1_m1_340000_235200 n1_m4_340000_235200 15.000000
R16429 n1_m1_340000_240000 n1_m4_340000_240000 15.000000
R16430 n1_m1_340000_244800 n1_m4_340000_244800 15.000000
R16431 n1_m1_340000_249600 n1_m4_340000_249600 15.000000
R16432 n1_m1_340000_254400 n1_m4_340000_254400 15.000000
R16433 n1_m1_340000_259200 n1_m4_340000_259200 15.000000
R16434 n1_m1_340000_264000 n1_m4_340000_264000 15.000000
R16435 n1_m1_340000_268800 n1_m4_340000_268800 15.000000
R16436 n1_m1_340000_273600 n1_m4_340000_273600 15.000000
R16437 n1_m1_340000_278400 n1_m4_340000_278400 15.000000
R16438 n1_m1_340000_283200 n1_m4_340000_283200 15.000000
R16439 n1_m1_340000_288000 n1_m4_340000_288000 15.000000
R16440 n1_m1_340000_292800 n1_m4_340000_292800 15.000000
R16441 n1_m1_340000_297600 n1_m4_340000_297600 15.000000
R16442 n1_m1_340000_302400 n1_m4_340000_302400 15.000000
R16443 n1_m1_340000_307200 n1_m4_340000_307200 15.000000
R16444 n1_m1_340000_312000 n1_m4_340000_312000 15.000000
R16445 n1_m1_340000_316800 n1_m4_340000_316800 15.000000
R16446 n1_m1_340000_321600 n1_m4_340000_321600 15.000000
R16447 n1_m1_340000_326400 n1_m4_340000_326400 15.000000
R16448 n1_m1_340000_331200 n1_m4_340000_331200 15.000000
R16449 n1_m1_340000_336000 n1_m4_340000_336000 15.000000
R16450 n1_m1_340000_340800 n1_m4_340000_340800 15.000000
R16451 n1_m1_340000_345600 n1_m4_340000_345600 15.000000
R16452 n1_m1_340000_350400 n1_m4_340000_350400 15.000000
R16453 n1_m1_340000_355200 n1_m4_340000_355200 15.000000
R16454 n1_m1_340000_360000 n1_m4_340000_360000 15.000000
R16455 n1_m1_340000_364800 n1_m4_340000_364800 15.000000
R16456 n1_m1_340000_369600 n1_m4_340000_369600 15.000000
R16457 n1_m1_340000_374400 n1_m4_340000_374400 15.000000
R16458 n1_m1_340000_379200 n1_m4_340000_379200 15.000000
R16459 n1_m1_340000_384000 n1_m4_340000_384000 15.000000
R16460 n1_m1_340000_388800 n1_m4_340000_388800 15.000000
R16461 n1_m1_340000_393600 n1_m4_340000_393600 15.000000
R16462 n1_m1_340000_398400 n1_m4_340000_398400 15.000000
R16463 n1_m1_340000_403200 n1_m4_340000_403200 15.000000
R16464 n1_m1_340000_408000 n1_m4_340000_408000 15.000000
R16465 n1_m1_340000_412800 n1_m4_340000_412800 15.000000
R16466 n1_m1_340000_417600 n1_m4_340000_417600 15.000000
R16467 n1_m1_340000_422400 n1_m4_340000_422400 15.000000
R16468 n1_m1_340000_427200 n1_m4_340000_427200 15.000000
R16469 n1_m1_340000_432000 n1_m4_340000_432000 15.000000
R16470 n1_m1_340000_436800 n1_m4_340000_436800 15.000000
R16471 n1_m1_340000_441600 n1_m4_340000_441600 15.000000
R16472 n1_m1_340000_446400 n1_m4_340000_446400 15.000000
R16473 n1_m1_340000_451200 n1_m4_340000_451200 15.000000
R16474 n1_m1_340000_456000 n1_m4_340000_456000 15.000000
R16475 n1_m1_340000_460800 n1_m4_340000_460800 15.000000
R16476 n1_m1_340000_465600 n1_m4_340000_465600 15.000000
R16477 n1_m1_340000_470400 n1_m4_340000_470400 15.000000
R16478 n1_m1_340000_475200 n1_m4_340000_475200 15.000000
R16479 n1_m1_340000_480000 n1_m4_340000_480000 15.000000
R16480 n1_m1_340000_484800 n1_m4_340000_484800 15.000000
R16481 n1_m1_340000_489600 n1_m4_340000_489600 15.000000
R16482 n1_m1_340000_494400 n1_m4_340000_494400 15.000000
R16483 n1_m1_368000_0 n1_m4_368000_0 15.000000
R16484 n1_m1_368000_201600 n1_m4_368000_201600 15.000000
R16485 n1_m1_368000_206400 n1_m4_368000_206400 15.000000
R16486 n1_m1_368000_211200 n1_m4_368000_211200 15.000000
R16487 n1_m1_368000_216000 n1_m4_368000_216000 15.000000
R16488 n1_m1_368000_220800 n1_m4_368000_220800 15.000000
R16489 n1_m1_368000_225600 n1_m4_368000_225600 15.000000
R16490 n1_m1_368000_230400 n1_m4_368000_230400 15.000000
R16491 n1_m1_368000_235200 n1_m4_368000_235200 15.000000
R16492 n1_m1_368000_240000 n1_m4_368000_240000 15.000000
R16493 n1_m1_368000_244800 n1_m4_368000_244800 15.000000
R16494 n1_m1_368000_249600 n1_m4_368000_249600 15.000000
R16495 n1_m1_368000_254400 n1_m4_368000_254400 15.000000
R16496 n1_m1_368000_259200 n1_m4_368000_259200 15.000000
R16497 n1_m1_368000_264000 n1_m4_368000_264000 15.000000
R16498 n1_m1_368000_268800 n1_m4_368000_268800 15.000000
R16499 n1_m1_368000_273600 n1_m4_368000_273600 15.000000
R16500 n1_m1_368000_278400 n1_m4_368000_278400 15.000000
R16501 n1_m1_368000_283200 n1_m4_368000_283200 15.000000
R16502 n1_m1_368000_288000 n1_m4_368000_288000 15.000000
R16503 n1_m1_368000_292800 n1_m4_368000_292800 15.000000
R16504 n1_m1_368000_297600 n1_m4_368000_297600 15.000000
R16505 n1_m1_368000_302400 n1_m4_368000_302400 15.000000
R16506 n1_m1_368000_307200 n1_m4_368000_307200 15.000000
R16507 n1_m1_368000_312000 n1_m4_368000_312000 15.000000
R16508 n1_m1_368000_316800 n1_m4_368000_316800 15.000000
R16509 n1_m1_368000_321600 n1_m4_368000_321600 15.000000
R16510 n1_m1_368000_326400 n1_m4_368000_326400 15.000000
R16511 n1_m1_368000_331200 n1_m4_368000_331200 15.000000
R16512 n1_m1_368000_336000 n1_m4_368000_336000 15.000000
R16513 n1_m1_368000_340800 n1_m4_368000_340800 15.000000
R16514 n1_m1_368000_345600 n1_m4_368000_345600 15.000000
R16515 n1_m1_368000_350400 n1_m4_368000_350400 15.000000
R16516 n1_m1_368000_355200 n1_m4_368000_355200 15.000000
R16517 n1_m1_368000_360000 n1_m4_368000_360000 15.000000
R16518 n1_m1_368000_364800 n1_m4_368000_364800 15.000000
R16519 n1_m1_368000_369600 n1_m4_368000_369600 15.000000
R16520 n1_m1_368000_374400 n1_m4_368000_374400 15.000000
R16521 n1_m1_368000_379200 n1_m4_368000_379200 15.000000
R16522 n1_m1_368000_384000 n1_m4_368000_384000 15.000000
R16523 n1_m1_368000_388800 n1_m4_368000_388800 15.000000
R16524 n1_m1_368000_393600 n1_m4_368000_393600 15.000000
R16525 n1_m1_368000_398400 n1_m4_368000_398400 15.000000
R16526 n1_m1_368000_403200 n1_m4_368000_403200 15.000000
R16527 n1_m1_368000_408000 n1_m4_368000_408000 15.000000
R16528 n1_m1_368000_412800 n1_m4_368000_412800 15.000000
R16529 n1_m1_368000_417600 n1_m4_368000_417600 15.000000
R16530 n1_m1_368000_422400 n1_m4_368000_422400 15.000000
R16531 n1_m1_368000_427200 n1_m4_368000_427200 15.000000
R16532 n1_m1_368000_432000 n1_m4_368000_432000 15.000000
R16533 n1_m1_368000_436800 n1_m4_368000_436800 15.000000
R16534 n1_m1_368000_441600 n1_m4_368000_441600 15.000000
R16535 n1_m1_368000_446400 n1_m4_368000_446400 15.000000
R16536 n1_m1_368000_451200 n1_m4_368000_451200 15.000000
R16537 n1_m1_368000_456000 n1_m4_368000_456000 15.000000
R16538 n1_m1_368000_460800 n1_m4_368000_460800 15.000000
R16539 n1_m1_368000_465600 n1_m4_368000_465600 15.000000
R16540 n1_m1_368000_470400 n1_m4_368000_470400 15.000000
R16541 n1_m1_368000_475200 n1_m4_368000_475200 15.000000
R16542 n1_m1_368000_480000 n1_m4_368000_480000 15.000000
R16543 n1_m1_368000_484800 n1_m4_368000_484800 15.000000
R16544 n1_m1_368000_489600 n1_m4_368000_489600 15.000000
R16545 n1_m1_368000_494400 n1_m4_368000_494400 15.000000
R16546 n1_m1_396000_0 n1_m4_396000_0 15.000000
R16547 n1_m1_396000_201600 n1_m4_396000_201600 15.000000
R16548 n1_m1_396000_206400 n1_m4_396000_206400 15.000000
R16549 n1_m1_396000_211200 n1_m4_396000_211200 15.000000
R16550 n1_m1_396000_216000 n1_m4_396000_216000 15.000000
R16551 n1_m1_396000_220800 n1_m4_396000_220800 15.000000
R16552 n1_m1_396000_225600 n1_m4_396000_225600 15.000000
R16553 n1_m1_396000_230400 n1_m4_396000_230400 15.000000
R16554 n1_m1_396000_235200 n1_m4_396000_235200 15.000000
R16555 n1_m1_396000_240000 n1_m4_396000_240000 15.000000
R16556 n1_m1_396000_244800 n1_m4_396000_244800 15.000000
R16557 n1_m1_396000_249600 n1_m4_396000_249600 15.000000
R16558 n1_m1_396000_254400 n1_m4_396000_254400 15.000000
R16559 n1_m1_396000_259200 n1_m4_396000_259200 15.000000
R16560 n1_m1_396000_264000 n1_m4_396000_264000 15.000000
R16561 n1_m1_396000_268800 n1_m4_396000_268800 15.000000
R16562 n1_m1_396000_273600 n1_m4_396000_273600 15.000000
R16563 n1_m1_396000_278400 n1_m4_396000_278400 15.000000
R16564 n1_m1_396000_283200 n1_m4_396000_283200 15.000000
R16565 n1_m1_396000_288000 n1_m4_396000_288000 15.000000
R16566 n1_m1_396000_292800 n1_m4_396000_292800 15.000000
R16567 n1_m1_396000_297600 n1_m4_396000_297600 15.000000
R16568 n1_m1_396000_302400 n1_m4_396000_302400 15.000000
R16569 n1_m1_396000_307200 n1_m4_396000_307200 15.000000
R16570 n1_m1_396000_312000 n1_m4_396000_312000 15.000000
R16571 n1_m1_396000_316800 n1_m4_396000_316800 15.000000
R16572 n1_m1_396000_321600 n1_m4_396000_321600 15.000000
R16573 n1_m1_396000_326400 n1_m4_396000_326400 15.000000
R16574 n1_m1_396000_331200 n1_m4_396000_331200 15.000000
R16575 n1_m1_396000_336000 n1_m4_396000_336000 15.000000
R16576 n1_m1_396000_340800 n1_m4_396000_340800 15.000000
R16577 n1_m1_396000_345600 n1_m4_396000_345600 15.000000
R16578 n1_m1_396000_350400 n1_m4_396000_350400 15.000000
R16579 n1_m1_396000_355200 n1_m4_396000_355200 15.000000
R16580 n1_m1_396000_360000 n1_m4_396000_360000 15.000000
R16581 n1_m1_396000_364800 n1_m4_396000_364800 15.000000
R16582 n1_m1_396000_369600 n1_m4_396000_369600 15.000000
R16583 n1_m1_396000_374400 n1_m4_396000_374400 15.000000
R16584 n1_m1_396000_379200 n1_m4_396000_379200 15.000000
R16585 n1_m1_396000_384000 n1_m4_396000_384000 15.000000
R16586 n1_m1_396000_388800 n1_m4_396000_388800 15.000000
R16587 n1_m1_396000_393600 n1_m4_396000_393600 15.000000
R16588 n1_m1_396000_398400 n1_m4_396000_398400 15.000000
R16589 n1_m1_396000_403200 n1_m4_396000_403200 15.000000
R16590 n1_m1_396000_408000 n1_m4_396000_408000 15.000000
R16591 n1_m1_396000_412800 n1_m4_396000_412800 15.000000
R16592 n1_m1_396000_417600 n1_m4_396000_417600 15.000000
R16593 n1_m1_396000_422400 n1_m4_396000_422400 15.000000
R16594 n1_m1_396000_427200 n1_m4_396000_427200 15.000000
R16595 n1_m1_396000_432000 n1_m4_396000_432000 15.000000
R16596 n1_m1_396000_436800 n1_m4_396000_436800 15.000000
R16597 n1_m1_396000_441600 n1_m4_396000_441600 15.000000
R16598 n1_m1_396000_446400 n1_m4_396000_446400 15.000000
R16599 n1_m1_396000_451200 n1_m4_396000_451200 15.000000
R16600 n1_m1_396000_456000 n1_m4_396000_456000 15.000000
R16601 n1_m1_396000_460800 n1_m4_396000_460800 15.000000
R16602 n1_m1_396000_465600 n1_m4_396000_465600 15.000000
R16603 n1_m1_396000_470400 n1_m4_396000_470400 15.000000
R16604 n1_m1_396000_475200 n1_m4_396000_475200 15.000000
R16605 n1_m1_396000_480000 n1_m4_396000_480000 15.000000
R16606 n1_m1_396000_484800 n1_m4_396000_484800 15.000000
R16607 n1_m1_396000_489600 n1_m4_396000_489600 15.000000
R16608 n1_m1_396000_494400 n1_m4_396000_494400 15.000000
R16609 n1_m1_424000_0 n1_m4_424000_0 15.000000
R16610 n1_m1_424000_4800 n1_m4_424000_4800 15.000000
R16611 n1_m1_424000_9600 n1_m4_424000_9600 15.000000
R16612 n1_m1_424000_14400 n1_m4_424000_14400 15.000000
R16613 n1_m1_424000_19200 n1_m4_424000_19200 15.000000
R16614 n1_m1_424000_24000 n1_m4_424000_24000 15.000000
R16615 n1_m1_424000_28800 n1_m4_424000_28800 15.000000
R16616 n1_m1_424000_33600 n1_m4_424000_33600 15.000000
R16617 n1_m1_424000_38400 n1_m4_424000_38400 15.000000
R16618 n1_m1_424000_43200 n1_m4_424000_43200 15.000000
R16619 n1_m1_424000_48000 n1_m4_424000_48000 15.000000
R16620 n1_m1_424000_52800 n1_m4_424000_52800 15.000000
R16621 n1_m1_424000_57600 n1_m4_424000_57600 15.000000
R16622 n1_m1_424000_62400 n1_m4_424000_62400 15.000000
R16623 n1_m1_424000_67200 n1_m4_424000_67200 15.000000
R16624 n1_m1_424000_72000 n1_m4_424000_72000 15.000000
R16625 n1_m1_424000_76800 n1_m4_424000_76800 15.000000
R16626 n1_m1_424000_81600 n1_m4_424000_81600 15.000000
R16627 n1_m1_424000_86400 n1_m4_424000_86400 15.000000
R16628 n1_m1_424000_91200 n1_m4_424000_91200 15.000000
R16629 n1_m1_424000_96000 n1_m4_424000_96000 15.000000
R16630 n1_m1_424000_100800 n1_m4_424000_100800 15.000000
R16631 n1_m1_424000_105600 n1_m4_424000_105600 15.000000
R16632 n1_m1_424000_110400 n1_m4_424000_110400 15.000000
R16633 n1_m1_424000_115200 n1_m4_424000_115200 15.000000
R16634 n1_m1_424000_120000 n1_m4_424000_120000 15.000000
R16635 n1_m1_424000_124800 n1_m4_424000_124800 15.000000
R16636 n1_m1_424000_129600 n1_m4_424000_129600 15.000000
R16637 n1_m1_424000_134400 n1_m4_424000_134400 15.000000
R16638 n1_m1_424000_139200 n1_m4_424000_139200 15.000000
R16639 n1_m1_424000_144000 n1_m4_424000_144000 15.000000
R16640 n1_m1_424000_148800 n1_m4_424000_148800 15.000000
R16641 n1_m1_424000_153600 n1_m4_424000_153600 15.000000
R16642 n1_m1_424000_158400 n1_m4_424000_158400 15.000000
R16643 n1_m1_424000_163200 n1_m4_424000_163200 15.000000
R16644 n1_m1_424000_168000 n1_m4_424000_168000 15.000000
R16645 n1_m1_424000_172800 n1_m4_424000_172800 15.000000
R16646 n1_m1_424000_177600 n1_m4_424000_177600 15.000000
R16647 n1_m1_424000_182400 n1_m4_424000_182400 15.000000
R16648 n1_m1_424000_187200 n1_m4_424000_187200 15.000000
R16649 n1_m1_424000_192000 n1_m4_424000_192000 15.000000
R16650 n1_m1_424000_196800 n1_m4_424000_196800 15.000000
R16651 n1_m1_424000_201600 n1_m4_424000_201600 15.000000
R16652 n1_m1_424000_206400 n1_m4_424000_206400 15.000000
R16653 n1_m1_424000_211200 n1_m4_424000_211200 15.000000
R16654 n1_m1_424000_216000 n1_m4_424000_216000 15.000000
R16655 n1_m1_424000_220800 n1_m4_424000_220800 15.000000
R16656 n1_m1_424000_225600 n1_m4_424000_225600 15.000000
R16657 n1_m1_424000_230400 n1_m4_424000_230400 15.000000
R16658 n1_m1_424000_235200 n1_m4_424000_235200 15.000000
R16659 n1_m1_424000_240000 n1_m4_424000_240000 15.000000
R16660 n1_m1_424000_244800 n1_m4_424000_244800 15.000000
R16661 n1_m1_424000_249600 n1_m4_424000_249600 15.000000
R16662 n1_m1_424000_254400 n1_m4_424000_254400 15.000000
R16663 n1_m1_424000_259200 n1_m4_424000_259200 15.000000
R16664 n1_m1_424000_264000 n1_m4_424000_264000 15.000000
R16665 n1_m1_424000_268800 n1_m4_424000_268800 15.000000
R16666 n1_m1_424000_273600 n1_m4_424000_273600 15.000000
R16667 n1_m1_424000_278400 n1_m4_424000_278400 15.000000
R16668 n1_m1_424000_283200 n1_m4_424000_283200 15.000000
R16669 n1_m1_424000_288000 n1_m4_424000_288000 15.000000
R16670 n1_m1_424000_292800 n1_m4_424000_292800 15.000000
R16671 n1_m1_424000_297600 n1_m4_424000_297600 15.000000
R16672 n1_m1_424000_302400 n1_m4_424000_302400 15.000000
R16673 n1_m1_424000_307200 n1_m4_424000_307200 15.000000
R16674 n1_m1_424000_312000 n1_m4_424000_312000 15.000000
R16675 n1_m1_424000_316800 n1_m4_424000_316800 15.000000
R16676 n1_m1_424000_321600 n1_m4_424000_321600 15.000000
R16677 n1_m1_424000_326400 n1_m4_424000_326400 15.000000
R16678 n1_m1_424000_331200 n1_m4_424000_331200 15.000000
R16679 n1_m1_424000_336000 n1_m4_424000_336000 15.000000
R16680 n1_m1_424000_340800 n1_m4_424000_340800 15.000000
R16681 n1_m1_424000_345600 n1_m4_424000_345600 15.000000
R16682 n1_m1_424000_350400 n1_m4_424000_350400 15.000000
R16683 n1_m1_424000_355200 n1_m4_424000_355200 15.000000
R16684 n1_m1_424000_360000 n1_m4_424000_360000 15.000000
R16685 n1_m1_424000_364800 n1_m4_424000_364800 15.000000
R16686 n1_m1_424000_369600 n1_m4_424000_369600 15.000000
R16687 n1_m1_424000_374400 n1_m4_424000_374400 15.000000
R16688 n1_m1_424000_379200 n1_m4_424000_379200 15.000000
R16689 n1_m1_424000_384000 n1_m4_424000_384000 15.000000
R16690 n1_m1_424000_388800 n1_m4_424000_388800 15.000000
R16691 n1_m1_424000_393600 n1_m4_424000_393600 15.000000
R16692 n1_m1_424000_398400 n1_m4_424000_398400 15.000000
R16693 n1_m1_424000_403200 n1_m4_424000_403200 15.000000
R16694 n1_m1_424000_408000 n1_m4_424000_408000 15.000000
R16695 n1_m1_424000_412800 n1_m4_424000_412800 15.000000
R16696 n1_m1_424000_417600 n1_m4_424000_417600 15.000000
R16697 n1_m1_424000_422400 n1_m4_424000_422400 15.000000
R16698 n1_m1_424000_427200 n1_m4_424000_427200 15.000000
R16699 n1_m1_424000_432000 n1_m4_424000_432000 15.000000
R16700 n1_m1_424000_436800 n1_m4_424000_436800 15.000000
R16701 n1_m1_424000_441600 n1_m4_424000_441600 15.000000
R16702 n1_m1_424000_446400 n1_m4_424000_446400 15.000000
R16703 n1_m1_424000_451200 n1_m4_424000_451200 15.000000
R16704 n1_m1_424000_456000 n1_m4_424000_456000 15.000000
R16705 n1_m1_424000_460800 n1_m4_424000_460800 15.000000
R16706 n1_m1_424000_465600 n1_m4_424000_465600 15.000000
R16707 n1_m1_424000_470400 n1_m4_424000_470400 15.000000
R16708 n1_m1_424000_475200 n1_m4_424000_475200 15.000000
R16709 n1_m1_424000_480000 n1_m4_424000_480000 15.000000
R16710 n1_m1_424000_484800 n1_m4_424000_484800 15.000000
R16711 n1_m1_424000_489600 n1_m4_424000_489600 15.000000
R16712 n1_m1_424000_494400 n1_m4_424000_494400 15.000000
R16713 n1_m1_452000_0 n1_m4_452000_0 15.000000
R16714 n1_m1_452000_4800 n1_m4_452000_4800 15.000000
R16715 n1_m1_452000_9600 n1_m4_452000_9600 15.000000
R16716 n1_m1_452000_14400 n1_m4_452000_14400 15.000000
R16717 n1_m1_452000_19200 n1_m4_452000_19200 15.000000
R16718 n1_m1_452000_24000 n1_m4_452000_24000 15.000000
R16719 n1_m1_452000_28800 n1_m4_452000_28800 15.000000
R16720 n1_m1_452000_33600 n1_m4_452000_33600 15.000000
R16721 n1_m1_452000_38400 n1_m4_452000_38400 15.000000
R16722 n1_m1_452000_43200 n1_m4_452000_43200 15.000000
R16723 n1_m1_452000_48000 n1_m4_452000_48000 15.000000
R16724 n1_m1_452000_52800 n1_m4_452000_52800 15.000000
R16725 n1_m1_452000_57600 n1_m4_452000_57600 15.000000
R16726 n1_m1_452000_62400 n1_m4_452000_62400 15.000000
R16727 n1_m1_452000_67200 n1_m4_452000_67200 15.000000
R16728 n1_m1_452000_72000 n1_m4_452000_72000 15.000000
R16729 n1_m1_452000_76800 n1_m4_452000_76800 15.000000
R16730 n1_m1_452000_81600 n1_m4_452000_81600 15.000000
R16731 n1_m1_452000_86400 n1_m4_452000_86400 15.000000
R16732 n1_m1_452000_91200 n1_m4_452000_91200 15.000000
R16733 n1_m1_452000_96000 n1_m4_452000_96000 15.000000
R16734 n1_m1_452000_100800 n1_m4_452000_100800 15.000000
R16735 n1_m1_452000_105600 n1_m4_452000_105600 15.000000
R16736 n1_m1_452000_110400 n1_m4_452000_110400 15.000000
R16737 n1_m1_452000_115200 n1_m4_452000_115200 15.000000
R16738 n1_m1_452000_120000 n1_m4_452000_120000 15.000000
R16739 n1_m1_452000_124800 n1_m4_452000_124800 15.000000
R16740 n1_m1_452000_129600 n1_m4_452000_129600 15.000000
R16741 n1_m1_452000_134400 n1_m4_452000_134400 15.000000
R16742 n1_m1_452000_139200 n1_m4_452000_139200 15.000000
R16743 n1_m1_452000_144000 n1_m4_452000_144000 15.000000
R16744 n1_m1_452000_148800 n1_m4_452000_148800 15.000000
R16745 n1_m1_452000_153600 n1_m4_452000_153600 15.000000
R16746 n1_m1_452000_158400 n1_m4_452000_158400 15.000000
R16747 n1_m1_452000_163200 n1_m4_452000_163200 15.000000
R16748 n1_m1_452000_168000 n1_m4_452000_168000 15.000000
R16749 n1_m1_452000_172800 n1_m4_452000_172800 15.000000
R16750 n1_m1_452000_177600 n1_m4_452000_177600 15.000000
R16751 n1_m1_452000_182400 n1_m4_452000_182400 15.000000
R16752 n1_m1_452000_187200 n1_m4_452000_187200 15.000000
R16753 n1_m1_452000_192000 n1_m4_452000_192000 15.000000
R16754 n1_m1_452000_196800 n1_m4_452000_196800 15.000000
R16755 n1_m1_452000_403200 n1_m4_452000_403200 15.000000
R16756 n1_m1_452000_408000 n1_m4_452000_408000 15.000000
R16757 n1_m1_452000_412800 n1_m4_452000_412800 15.000000
R16758 n1_m1_452000_417600 n1_m4_452000_417600 15.000000
R16759 n1_m1_452000_422400 n1_m4_452000_422400 15.000000
R16760 n1_m1_452000_427200 n1_m4_452000_427200 15.000000
R16761 n1_m1_452000_432000 n1_m4_452000_432000 15.000000
R16762 n1_m1_452000_436800 n1_m4_452000_436800 15.000000
R16763 n1_m1_452000_441600 n1_m4_452000_441600 15.000000
R16764 n1_m1_452000_446400 n1_m4_452000_446400 15.000000
R16765 n1_m1_452000_451200 n1_m4_452000_451200 15.000000
R16766 n1_m1_452000_456000 n1_m4_452000_456000 15.000000
R16767 n1_m1_452000_460800 n1_m4_452000_460800 15.000000
R16768 n1_m1_452000_465600 n1_m4_452000_465600 15.000000
R16769 n1_m1_452000_470400 n1_m4_452000_470400 15.000000
R16770 n1_m1_452000_475200 n1_m4_452000_475200 15.000000
R16771 n1_m1_452000_480000 n1_m4_452000_480000 15.000000
R16772 n1_m1_452000_484800 n1_m4_452000_484800 15.000000
R16773 n1_m1_452000_489600 n1_m4_452000_489600 15.000000
R16774 n1_m1_452000_494400 n1_m4_452000_494400 15.000000
R16775 n1_m1_480000_0 n1_m4_480000_0 15.000000
R16776 n1_m1_480000_4800 n1_m4_480000_4800 15.000000
R16777 n1_m1_480000_9600 n1_m4_480000_9600 15.000000
R16778 n1_m1_480000_14400 n1_m4_480000_14400 15.000000
R16779 n1_m1_480000_19200 n1_m4_480000_19200 15.000000
R16780 n1_m1_480000_24000 n1_m4_480000_24000 15.000000
R16781 n1_m1_480000_28800 n1_m4_480000_28800 15.000000
R16782 n1_m1_480000_33600 n1_m4_480000_33600 15.000000
R16783 n1_m1_480000_38400 n1_m4_480000_38400 15.000000
R16784 n1_m1_480000_43200 n1_m4_480000_43200 15.000000
R16785 n1_m1_480000_48000 n1_m4_480000_48000 15.000000
R16786 n1_m1_480000_52800 n1_m4_480000_52800 15.000000
R16787 n1_m1_480000_57600 n1_m4_480000_57600 15.000000
R16788 n1_m1_480000_62400 n1_m4_480000_62400 15.000000
R16789 n1_m1_480000_67200 n1_m4_480000_67200 15.000000
R16790 n1_m1_480000_72000 n1_m4_480000_72000 15.000000
R16791 n1_m1_480000_76800 n1_m4_480000_76800 15.000000
R16792 n1_m1_480000_81600 n1_m4_480000_81600 15.000000
R16793 n1_m1_480000_86400 n1_m4_480000_86400 15.000000
R16794 n1_m1_480000_91200 n1_m4_480000_91200 15.000000
R16795 n1_m1_480000_96000 n1_m4_480000_96000 15.000000
R16796 n1_m1_480000_100800 n1_m4_480000_100800 15.000000
R16797 n1_m1_480000_105600 n1_m4_480000_105600 15.000000
R16798 n1_m1_480000_110400 n1_m4_480000_110400 15.000000
R16799 n1_m1_480000_115200 n1_m4_480000_115200 15.000000
R16800 n1_m1_480000_120000 n1_m4_480000_120000 15.000000
R16801 n1_m1_480000_124800 n1_m4_480000_124800 15.000000
R16802 n1_m1_480000_129600 n1_m4_480000_129600 15.000000
R16803 n1_m1_480000_134400 n1_m4_480000_134400 15.000000
R16804 n1_m1_480000_139200 n1_m4_480000_139200 15.000000
R16805 n1_m1_480000_144000 n1_m4_480000_144000 15.000000
R16806 n1_m1_480000_148800 n1_m4_480000_148800 15.000000
R16807 n1_m1_480000_153600 n1_m4_480000_153600 15.000000
R16808 n1_m1_480000_158400 n1_m4_480000_158400 15.000000
R16809 n1_m1_480000_163200 n1_m4_480000_163200 15.000000
R16810 n1_m1_480000_168000 n1_m4_480000_168000 15.000000
R16811 n1_m1_480000_172800 n1_m4_480000_172800 15.000000
R16812 n1_m1_480000_177600 n1_m4_480000_177600 15.000000
R16813 n1_m1_480000_182400 n1_m4_480000_182400 15.000000
R16814 n1_m1_480000_187200 n1_m4_480000_187200 15.000000
R16815 n1_m1_480000_192000 n1_m4_480000_192000 15.000000
R16816 n1_m1_480000_196800 n1_m4_480000_196800 15.000000
R16817 n1_m1_480000_403200 n1_m4_480000_403200 15.000000
R16818 n1_m1_480000_408000 n1_m4_480000_408000 15.000000
R16819 n1_m1_480000_412800 n1_m4_480000_412800 15.000000
R16820 n1_m1_480000_417600 n1_m4_480000_417600 15.000000
R16821 n1_m1_480000_422400 n1_m4_480000_422400 15.000000
R16822 n1_m1_480000_427200 n1_m4_480000_427200 15.000000
R16823 n1_m1_480000_432000 n1_m4_480000_432000 15.000000
R16824 n1_m1_480000_436800 n1_m4_480000_436800 15.000000
R16825 n1_m1_480000_441600 n1_m4_480000_441600 15.000000
R16826 n1_m1_480000_446400 n1_m4_480000_446400 15.000000
R16827 n1_m1_480000_451200 n1_m4_480000_451200 15.000000
R16828 n1_m1_480000_456000 n1_m4_480000_456000 15.000000
R16829 n1_m1_480000_460800 n1_m4_480000_460800 15.000000
R16830 n1_m1_480000_465600 n1_m4_480000_465600 15.000000
R16831 n1_m1_480000_470400 n1_m4_480000_470400 15.000000
R16832 n1_m1_480000_475200 n1_m4_480000_475200 15.000000
R16833 n1_m1_480000_480000 n1_m4_480000_480000 15.000000
R16834 n1_m1_480000_484800 n1_m4_480000_484800 15.000000
R16835 n1_m1_480000_489600 n1_m4_480000_489600 15.000000
R16836 n1_m1_480000_494400 n1_m4_480000_494400 15.000000
R16837 n1_m4_4000_4000 n1_m7_4000_4000 9.000000
R16838 n1_m4_4000_84000 n1_m7_4000_84000 9.000000
R16839 n1_m4_4000_164000 n1_m7_4000_164000 9.000000
R16840 n1_m4_4000_244000 n1_m7_4000_244000 9.000000
R16841 n1_m4_4000_324000 n1_m7_4000_324000 9.000000
R16842 n1_m4_4000_404000 n1_m7_4000_404000 9.000000
R16843 n1_m4_4000_484000 n1_m7_4000_484000 9.000000
R16844 n1_m4_32000_4000 n1_m7_32000_4000 9.000000
R16845 n1_m4_32000_84000 n1_m7_32000_84000 9.000000
R16846 n1_m4_32000_164000 n1_m7_32000_164000 9.000000
R16847 n1_m4_32000_244000 n1_m7_32000_244000 9.000000
R16848 n1_m4_32000_324000 n1_m7_32000_324000 9.000000
R16849 n1_m4_32000_404000 n1_m7_32000_404000 9.000000
R16850 n1_m4_32000_484000 n1_m7_32000_484000 9.000000
R16851 n1_m4_60000_4000 n1_m7_60000_4000 9.000000
R16852 n1_m4_60000_84000 n1_m7_60000_84000 9.000000
R16853 n1_m4_60000_164000 n1_m7_60000_164000 9.000000
R16854 n1_m4_60000_244000 n1_m7_60000_244000 9.000000
R16855 n1_m4_60000_324000 n1_m7_60000_324000 9.000000
R16856 n1_m4_60000_404000 n1_m7_60000_404000 9.000000
R16857 n1_m4_60000_484000 n1_m7_60000_484000 9.000000
R16858 n1_m4_88000_4000 n1_m7_88000_4000 9.000000
R16859 n1_m4_88000_84000 n1_m7_88000_84000 9.000000
R16860 n1_m4_88000_164000 n1_m7_88000_164000 9.000000
R16861 n1_m4_88000_244000 n1_m7_88000_244000 9.000000
R16862 n1_m4_88000_324000 n1_m7_88000_324000 9.000000
R16863 n1_m4_88000_404000 n1_m7_88000_404000 9.000000
R16864 n1_m4_88000_484000 n1_m7_88000_484000 9.000000
R16865 n1_m4_116000_4000 n1_m7_116000_4000 9.000000
R16866 n1_m4_116000_84000 n1_m7_116000_84000 9.000000
R16867 n1_m4_116000_164000 n1_m7_116000_164000 9.000000
R16868 n1_m4_116000_244000 n1_m7_116000_244000 9.000000
R16869 n1_m4_116000_324000 n1_m7_116000_324000 9.000000
R16870 n1_m4_116000_404000 n1_m7_116000_404000 9.000000
R16871 n1_m4_116000_484000 n1_m7_116000_484000 9.000000
R16872 n1_m4_144000_4000 n1_m7_144000_4000 9.000000
R16873 n1_m4_144000_84000 n1_m7_144000_84000 9.000000
R16874 n1_m4_144000_164000 n1_m7_144000_164000 9.000000
R16875 n1_m4_144000_244000 n1_m7_144000_244000 9.000000
R16876 n1_m4_144000_324000 n1_m7_144000_324000 9.000000
R16877 n1_m4_144000_404000 n1_m7_144000_404000 9.000000
R16878 n1_m4_144000_484000 n1_m7_144000_484000 9.000000
R16879 n1_m4_172000_4000 n1_m7_172000_4000 9.000000
R16880 n1_m4_172000_84000 n1_m7_172000_84000 9.000000
R16881 n1_m4_172000_164000 n1_m7_172000_164000 9.000000
R16882 n1_m4_172000_244000 n1_m7_172000_244000 9.000000
R16883 n1_m4_172000_324000 n1_m7_172000_324000 9.000000
R16884 n1_m4_172000_404000 n1_m7_172000_404000 9.000000
R16885 n1_m4_172000_484000 n1_m7_172000_484000 9.000000
R16886 n1_m4_200000_4000 n1_m7_200000_4000 9.000000
R16887 n1_m4_200000_84000 n1_m7_200000_84000 9.000000
R16888 n1_m4_200000_164000 n1_m7_200000_164000 9.000000
R16889 n1_m4_200000_244000 n1_m7_200000_244000 9.000000
R16890 n1_m4_200000_324000 n1_m7_200000_324000 9.000000
R16891 n1_m4_200000_404000 n1_m7_200000_404000 9.000000
R16892 n1_m4_200000_484000 n1_m7_200000_484000 9.000000
R16893 n1_m4_228000_244000 n1_m7_228000_244000 9.000000
R16894 n1_m4_228000_324000 n1_m7_228000_324000 9.000000
R16895 n1_m4_228000_404000 n1_m7_228000_404000 9.000000
R16896 n1_m4_228000_484000 n1_m7_228000_484000 9.000000
R16897 n1_m4_256000_244000 n1_m7_256000_244000 9.000000
R16898 n1_m4_256000_324000 n1_m7_256000_324000 9.000000
R16899 n1_m4_256000_404000 n1_m7_256000_404000 9.000000
R16900 n1_m4_256000_484000 n1_m7_256000_484000 9.000000
R16901 n1_m4_284000_244000 n1_m7_284000_244000 9.000000
R16902 n1_m4_284000_324000 n1_m7_284000_324000 9.000000
R16903 n1_m4_284000_404000 n1_m7_284000_404000 9.000000
R16904 n1_m4_284000_484000 n1_m7_284000_484000 9.000000
R16905 n1_m4_312000_4000 n1_m7_312000_4000 9.000000
R16906 n1_m4_312000_84000 n1_m7_312000_84000 9.000000
R16907 n1_m4_312000_164000 n1_m7_312000_164000 9.000000
R16908 n1_m4_312000_244000 n1_m7_312000_244000 9.000000
R16909 n1_m4_312000_324000 n1_m7_312000_324000 9.000000
R16910 n1_m4_312000_404000 n1_m7_312000_404000 9.000000
R16911 n1_m4_312000_484000 n1_m7_312000_484000 9.000000
R16912 n1_m4_340000_244000 n1_m7_340000_244000 9.000000
R16913 n1_m4_340000_324000 n1_m7_340000_324000 9.000000
R16914 n1_m4_340000_404000 n1_m7_340000_404000 9.000000
R16915 n1_m4_340000_484000 n1_m7_340000_484000 9.000000
R16916 n1_m4_368000_244000 n1_m7_368000_244000 9.000000
R16917 n1_m4_368000_324000 n1_m7_368000_324000 9.000000
R16918 n1_m4_368000_404000 n1_m7_368000_404000 9.000000
R16919 n1_m4_368000_484000 n1_m7_368000_484000 9.000000
R16920 n1_m4_396000_244000 n1_m7_396000_244000 9.000000
R16921 n1_m4_396000_324000 n1_m7_396000_324000 9.000000
R16922 n1_m4_396000_404000 n1_m7_396000_404000 9.000000
R16923 n1_m4_396000_484000 n1_m7_396000_484000 9.000000
R16924 n1_m4_424000_4000 n1_m7_424000_4000 9.000000
R16925 n1_m4_424000_84000 n1_m7_424000_84000 9.000000
R16926 n1_m4_424000_164000 n1_m7_424000_164000 9.000000
R16927 n1_m4_424000_244000 n1_m7_424000_244000 9.000000
R16928 n1_m4_424000_324000 n1_m7_424000_324000 9.000000
R16929 n1_m4_424000_404000 n1_m7_424000_404000 9.000000
R16930 n1_m4_424000_484000 n1_m7_424000_484000 9.000000
R16931 n1_m4_452000_4000 n1_m7_452000_4000 9.000000
R16932 n1_m4_452000_84000 n1_m7_452000_84000 9.000000
R16933 n1_m4_452000_164000 n1_m7_452000_164000 9.000000
R16934 n1_m4_452000_404000 n1_m7_452000_404000 9.000000
R16935 n1_m4_452000_484000 n1_m7_452000_484000 9.000000
R16936 n1_m4_480000_4000 n1_m7_480000_4000 9.000000
R16937 n1_m4_480000_84000 n1_m7_480000_84000 9.000000
R16938 n1_m4_480000_164000 n1_m7_480000_164000 9.000000
R16939 n1_m4_480000_404000 n1_m7_480000_404000 9.000000
R16940 n1_m4_480000_484000 n1_m7_480000_484000 9.000000
R16941 n1_m7_4000_4000 n1_m8_4000_4000 1.000000
R16942 n1_m7_4000_84000 n1_m8_4000_84000 1.000000
R16943 n1_m7_4000_164000 n1_m8_4000_164000 1.000000
R16944 n1_m7_4000_244000 n1_m8_4000_244000 1.000000
R16945 n1_m7_4000_324000 n1_m8_4000_324000 1.000000
R16946 n1_m7_4000_404000 n1_m8_4000_404000 1.000000
R16947 n1_m7_4000_484000 n1_m8_4000_484000 1.000000
R16948 n1_m7_26400_4000 n1_m8_26400_4000 1.000000
R16949 n1_m7_26400_84000 n1_m8_26400_84000 1.000000
R16950 n1_m7_26400_164000 n1_m8_26400_164000 1.000000
R16951 n1_m7_26400_244000 n1_m8_26400_244000 1.000000
R16952 n1_m7_26400_324000 n1_m8_26400_324000 1.000000
R16953 n1_m7_26400_404000 n1_m8_26400_404000 1.000000
R16954 n1_m7_26400_484000 n1_m8_26400_484000 1.000000
R16955 n1_m7_48800_4000 n1_m8_48800_4000 1.000000
R16956 n1_m7_48800_84000 n1_m8_48800_84000 1.000000
R16957 n1_m7_48800_164000 n1_m8_48800_164000 1.000000
R16958 n1_m7_48800_244000 n1_m8_48800_244000 1.000000
R16959 n1_m7_48800_324000 n1_m8_48800_324000 1.000000
R16960 n1_m7_48800_404000 n1_m8_48800_404000 1.000000
R16961 n1_m7_48800_484000 n1_m8_48800_484000 1.000000
R16962 n1_m7_71200_4000 n1_m8_71200_4000 1.000000
R16963 n1_m7_71200_84000 n1_m8_71200_84000 1.000000
R16964 n1_m7_71200_164000 n1_m8_71200_164000 1.000000
R16965 n1_m7_71200_244000 n1_m8_71200_244000 1.000000
R16966 n1_m7_71200_324000 n1_m8_71200_324000 1.000000
R16967 n1_m7_71200_404000 n1_m8_71200_404000 1.000000
R16968 n1_m7_71200_484000 n1_m8_71200_484000 1.000000
R16969 n1_m7_93600_4000 n1_m8_93600_4000 1.000000
R16970 n1_m7_93600_84000 n1_m8_93600_84000 1.000000
R16971 n1_m7_93600_164000 n1_m8_93600_164000 1.000000
R16972 n1_m7_93600_244000 n1_m8_93600_244000 1.000000
R16973 n1_m7_93600_324000 n1_m8_93600_324000 1.000000
R16974 n1_m7_93600_404000 n1_m8_93600_404000 1.000000
R16975 n1_m7_93600_484000 n1_m8_93600_484000 1.000000
R16976 n1_m7_116000_4000 n1_m8_116000_4000 1.000000
R16977 n1_m7_116000_84000 n1_m8_116000_84000 1.000000
R16978 n1_m7_116000_164000 n1_m8_116000_164000 1.000000
R16979 n1_m7_116000_244000 n1_m8_116000_244000 1.000000
R16980 n1_m7_116000_324000 n1_m8_116000_324000 1.000000
R16981 n1_m7_116000_404000 n1_m8_116000_404000 1.000000
R16982 n1_m7_116000_484000 n1_m8_116000_484000 1.000000
R16983 n1_m7_138400_4000 n1_m8_138400_4000 1.000000
R16984 n1_m7_138400_84000 n1_m8_138400_84000 1.000000
R16985 n1_m7_138400_164000 n1_m8_138400_164000 1.000000
R16986 n1_m7_138400_244000 n1_m8_138400_244000 1.000000
R16987 n1_m7_138400_324000 n1_m8_138400_324000 1.000000
R16988 n1_m7_138400_404000 n1_m8_138400_404000 1.000000
R16989 n1_m7_138400_484000 n1_m8_138400_484000 1.000000
R16990 n1_m7_160800_4000 n1_m8_160800_4000 1.000000
R16991 n1_m7_160800_84000 n1_m8_160800_84000 1.000000
R16992 n1_m7_160800_164000 n1_m8_160800_164000 1.000000
R16993 n1_m7_160800_244000 n1_m8_160800_244000 1.000000
R16994 n1_m7_160800_324000 n1_m8_160800_324000 1.000000
R16995 n1_m7_160800_404000 n1_m8_160800_404000 1.000000
R16996 n1_m7_160800_484000 n1_m8_160800_484000 1.000000
R16997 n1_m7_183200_4000 n1_m8_183200_4000 1.000000
R16998 n1_m7_183200_84000 n1_m8_183200_84000 1.000000
R16999 n1_m7_183200_164000 n1_m8_183200_164000 1.000000
R17000 n1_m7_183200_244000 n1_m8_183200_244000 1.000000
R17001 n1_m7_183200_324000 n1_m8_183200_324000 1.000000
R17002 n1_m7_183200_404000 n1_m8_183200_404000 1.000000
R17003 n1_m7_183200_484000 n1_m8_183200_484000 1.000000
R17004 n1_m7_205600_4000 n1_m8_205600_4000 1.000000
R17005 n1_m7_205600_84000 n1_m8_205600_84000 1.000000
R17006 n1_m7_205600_164000 n1_m8_205600_164000 1.000000
R17007 n1_m7_205600_244000 n1_m8_205600_244000 1.000000
R17008 n1_m7_205600_324000 n1_m8_205600_324000 1.000000
R17009 n1_m7_205600_404000 n1_m8_205600_404000 1.000000
R17010 n1_m7_205600_484000 n1_m8_205600_484000 1.000000
R17011 n1_m7_228000_4000 n1_m8_228000_4000 1.000000
R17012 n1_m7_228000_84000 n1_m8_228000_84000 1.000000
R17013 n1_m7_228000_164000 n1_m8_228000_164000 1.000000
R17014 n1_m7_228000_244000 n1_m8_228000_244000 1.000000
R17015 n1_m7_228000_324000 n1_m8_228000_324000 1.000000
R17016 n1_m7_228000_404000 n1_m8_228000_404000 1.000000
R17017 n1_m7_228000_484000 n1_m8_228000_484000 1.000000
R17018 n1_m7_250400_4000 n1_m8_250400_4000 1.000000
R17019 n1_m7_250400_84000 n1_m8_250400_84000 1.000000
R17020 n1_m7_250400_164000 n1_m8_250400_164000 1.000000
R17021 n1_m7_250400_244000 n1_m8_250400_244000 1.000000
R17022 n1_m7_250400_324000 n1_m8_250400_324000 1.000000
R17023 n1_m7_250400_404000 n1_m8_250400_404000 1.000000
R17024 n1_m7_250400_484000 n1_m8_250400_484000 1.000000
R17025 n1_m7_272800_4000 n1_m8_272800_4000 1.000000
R17026 n1_m7_272800_84000 n1_m8_272800_84000 1.000000
R17027 n1_m7_272800_164000 n1_m8_272800_164000 1.000000
R17028 n1_m7_272800_244000 n1_m8_272800_244000 1.000000
R17029 n1_m7_272800_324000 n1_m8_272800_324000 1.000000
R17030 n1_m7_272800_404000 n1_m8_272800_404000 1.000000
R17031 n1_m7_272800_484000 n1_m8_272800_484000 1.000000
R17032 n1_m7_295200_4000 n1_m8_295200_4000 1.000000
R17033 n1_m7_295200_84000 n1_m8_295200_84000 1.000000
R17034 n1_m7_295200_164000 n1_m8_295200_164000 1.000000
R17035 n1_m7_295200_244000 n1_m8_295200_244000 1.000000
R17036 n1_m7_295200_324000 n1_m8_295200_324000 1.000000
R17037 n1_m7_295200_404000 n1_m8_295200_404000 1.000000
R17038 n1_m7_295200_484000 n1_m8_295200_484000 1.000000
R17039 n1_m7_317600_4000 n1_m8_317600_4000 1.000000
R17040 n1_m7_317600_84000 n1_m8_317600_84000 1.000000
R17041 n1_m7_317600_164000 n1_m8_317600_164000 1.000000
R17042 n1_m7_317600_244000 n1_m8_317600_244000 1.000000
R17043 n1_m7_317600_324000 n1_m8_317600_324000 1.000000
R17044 n1_m7_317600_404000 n1_m8_317600_404000 1.000000
R17045 n1_m7_317600_484000 n1_m8_317600_484000 1.000000
R17046 n1_m7_340000_4000 n1_m8_340000_4000 1.000000
R17047 n1_m7_340000_84000 n1_m8_340000_84000 1.000000
R17048 n1_m7_340000_164000 n1_m8_340000_164000 1.000000
R17049 n1_m7_340000_244000 n1_m8_340000_244000 1.000000
R17050 n1_m7_340000_324000 n1_m8_340000_324000 1.000000
R17051 n1_m7_340000_404000 n1_m8_340000_404000 1.000000
R17052 n1_m7_340000_484000 n1_m8_340000_484000 1.000000
R17053 n1_m7_362400_4000 n1_m8_362400_4000 1.000000
R17054 n1_m7_362400_84000 n1_m8_362400_84000 1.000000
R17055 n1_m7_362400_164000 n1_m8_362400_164000 1.000000
R17056 n1_m7_362400_244000 n1_m8_362400_244000 1.000000
R17057 n1_m7_362400_324000 n1_m8_362400_324000 1.000000
R17058 n1_m7_362400_404000 n1_m8_362400_404000 1.000000
R17059 n1_m7_362400_484000 n1_m8_362400_484000 1.000000
R17060 n1_m7_384800_4000 n1_m8_384800_4000 1.000000
R17061 n1_m7_384800_84000 n1_m8_384800_84000 1.000000
R17062 n1_m7_384800_164000 n1_m8_384800_164000 1.000000
R17063 n1_m7_384800_244000 n1_m8_384800_244000 1.000000
R17064 n1_m7_384800_324000 n1_m8_384800_324000 1.000000
R17065 n1_m7_384800_404000 n1_m8_384800_404000 1.000000
R17066 n1_m7_384800_484000 n1_m8_384800_484000 1.000000
R17067 n1_m7_407200_4000 n1_m8_407200_4000 1.000000
R17068 n1_m7_407200_84000 n1_m8_407200_84000 1.000000
R17069 n1_m7_407200_164000 n1_m8_407200_164000 1.000000
R17070 n1_m7_407200_244000 n1_m8_407200_244000 1.000000
R17071 n1_m7_407200_324000 n1_m8_407200_324000 1.000000
R17072 n1_m7_407200_404000 n1_m8_407200_404000 1.000000
R17073 n1_m7_407200_484000 n1_m8_407200_484000 1.000000
R17074 n1_m7_429600_4000 n1_m8_429600_4000 1.000000
R17075 n1_m7_429600_84000 n1_m8_429600_84000 1.000000
R17076 n1_m7_429600_164000 n1_m8_429600_164000 1.000000
R17077 n1_m7_429600_244000 n1_m8_429600_244000 1.000000
R17078 n1_m7_429600_324000 n1_m8_429600_324000 1.000000
R17079 n1_m7_429600_404000 n1_m8_429600_404000 1.000000
R17080 n1_m7_429600_484000 n1_m8_429600_484000 1.000000
R17081 n1_m7_452000_4000 n1_m8_452000_4000 1.000000
R17082 n1_m7_452000_84000 n1_m8_452000_84000 1.000000
R17083 n1_m7_452000_164000 n1_m8_452000_164000 1.000000
R17084 n1_m7_452000_244000 n1_m8_452000_244000 1.000000
R17085 n1_m7_452000_324000 n1_m8_452000_324000 1.000000
R17086 n1_m7_452000_404000 n1_m8_452000_404000 1.000000
R17087 n1_m7_452000_484000 n1_m8_452000_484000 1.000000
R17088 n1_m7_474400_4000 n1_m8_474400_4000 1.000000
R17089 n1_m7_474400_84000 n1_m8_474400_84000 1.000000
R17090 n1_m7_474400_164000 n1_m8_474400_164000 1.000000
R17091 n1_m7_474400_244000 n1_m8_474400_244000 1.000000
R17092 n1_m7_474400_324000 n1_m8_474400_324000 1.000000
R17093 n1_m7_474400_404000 n1_m8_474400_404000 1.000000
R17094 n1_m7_474400_484000 n1_m8_474400_484000 1.000000
R17095 n1_m7_496800_4000 n1_m8_496800_4000 1.000000
R17096 n1_m7_496800_84000 n1_m8_496800_84000 1.000000
R17097 n1_m7_496800_164000 n1_m8_496800_164000 1.000000
R17098 n1_m7_496800_244000 n1_m8_496800_244000 1.000000
R17099 n1_m7_496800_324000 n1_m8_496800_324000 1.000000
R17100 n1_m7_496800_404000 n1_m8_496800_404000 1.000000
R17101 n1_m7_496800_484000 n1_m8_496800_484000 1.000000
R17102 n1_m8_4000_4000 n1_m9_4000_4000 1.000000
R17103 n1_m8_4000_26400 n1_m9_4000_26400 1.000000
R17104 n1_m8_4000_48800 n1_m9_4000_48800 1.000000
R17105 n1_m8_4000_71200 n1_m9_4000_71200 1.000000
R17106 n1_m8_4000_93600 n1_m9_4000_93600 1.000000
R17107 n1_m8_4000_116000 n1_m9_4000_116000 1.000000
R17108 n1_m8_4000_138400 n1_m9_4000_138400 1.000000
R17109 n1_m8_4000_160800 n1_m9_4000_160800 1.000000
R17110 n1_m8_4000_183200 n1_m9_4000_183200 1.000000
R17111 n1_m8_4000_205600 n1_m9_4000_205600 1.000000
R17112 n1_m8_4000_228000 n1_m9_4000_228000 1.000000
R17113 n1_m8_4000_250400 n1_m9_4000_250400 1.000000
R17114 n1_m8_4000_272800 n1_m9_4000_272800 1.000000
R17115 n1_m8_4000_295200 n1_m9_4000_295200 1.000000
R17116 n1_m8_4000_317600 n1_m9_4000_317600 1.000000
R17117 n1_m8_4000_340000 n1_m9_4000_340000 1.000000
R17118 n1_m8_4000_362400 n1_m9_4000_362400 1.000000
R17119 n1_m8_4000_384800 n1_m9_4000_384800 1.000000
R17120 n1_m8_4000_407200 n1_m9_4000_407200 1.000000
R17121 n1_m8_4000_429600 n1_m9_4000_429600 1.000000
R17122 n1_m8_4000_452000 n1_m9_4000_452000 1.000000
R17123 n1_m8_4000_474400 n1_m9_4000_474400 1.000000
R17124 n1_m8_4000_496800 n1_m9_4000_496800 1.000000
R17125 n1_m8_26400_4000 n1_m9_26400_4000 1.000000
R17126 n1_m8_26400_26400 n1_m9_26400_26400 1.000000
R17127 n1_m8_26400_48800 n1_m9_26400_48800 1.000000
R17128 n1_m8_26400_71200 n1_m9_26400_71200 1.000000
R17129 n1_m8_26400_93600 n1_m9_26400_93600 1.000000
R17130 n1_m8_26400_116000 n1_m9_26400_116000 1.000000
R17131 n1_m8_26400_138400 n1_m9_26400_138400 1.000000
R17132 n1_m8_26400_160800 n1_m9_26400_160800 1.000000
R17133 n1_m8_26400_183200 n1_m9_26400_183200 1.000000
R17134 n1_m8_26400_205600 n1_m9_26400_205600 1.000000
R17135 n1_m8_26400_228000 n1_m9_26400_228000 1.000000
R17136 n1_m8_26400_250400 n1_m9_26400_250400 1.000000
R17137 n1_m8_26400_272800 n1_m9_26400_272800 1.000000
R17138 n1_m8_26400_295200 n1_m9_26400_295200 1.000000
R17139 n1_m8_26400_317600 n1_m9_26400_317600 1.000000
R17140 n1_m8_26400_340000 n1_m9_26400_340000 1.000000
R17141 n1_m8_26400_362400 n1_m9_26400_362400 1.000000
R17142 n1_m8_26400_384800 n1_m9_26400_384800 1.000000
R17143 n1_m8_26400_407200 n1_m9_26400_407200 1.000000
R17144 n1_m8_26400_429600 n1_m9_26400_429600 1.000000
R17145 n1_m8_26400_452000 n1_m9_26400_452000 1.000000
R17146 n1_m8_26400_474400 n1_m9_26400_474400 1.000000
R17147 n1_m8_26400_496800 n1_m9_26400_496800 1.000000
R17148 n1_m8_48800_4000 n1_m9_48800_4000 1.000000
R17149 n1_m8_48800_26400 n1_m9_48800_26400 1.000000
R17150 n1_m8_48800_48800 n1_m9_48800_48800 1.000000
R17151 n1_m8_48800_71200 n1_m9_48800_71200 1.000000
R17152 n1_m8_48800_93600 n1_m9_48800_93600 1.000000
R17153 n1_m8_48800_116000 n1_m9_48800_116000 1.000000
R17154 n1_m8_48800_138400 n1_m9_48800_138400 1.000000
R17155 n1_m8_48800_160800 n1_m9_48800_160800 1.000000
R17156 n1_m8_48800_183200 n1_m9_48800_183200 1.000000
R17157 n1_m8_48800_205600 n1_m9_48800_205600 1.000000
R17158 n1_m8_48800_228000 n1_m9_48800_228000 1.000000
R17159 n1_m8_48800_250400 n1_m9_48800_250400 1.000000
R17160 n1_m8_48800_272800 n1_m9_48800_272800 1.000000
R17161 n1_m8_48800_295200 n1_m9_48800_295200 1.000000
R17162 n1_m8_48800_317600 n1_m9_48800_317600 1.000000
R17163 n1_m8_48800_340000 n1_m9_48800_340000 1.000000
R17164 n1_m8_48800_362400 n1_m9_48800_362400 1.000000
R17165 n1_m8_48800_384800 n1_m9_48800_384800 1.000000
R17166 n1_m8_48800_407200 n1_m9_48800_407200 1.000000
R17167 n1_m8_48800_429600 n1_m9_48800_429600 1.000000
R17168 n1_m8_48800_452000 n1_m9_48800_452000 1.000000
R17169 n1_m8_48800_474400 n1_m9_48800_474400 1.000000
R17170 n1_m8_48800_496800 n1_m9_48800_496800 1.000000
R17171 n1_m8_71200_4000 n1_m9_71200_4000 1.000000
R17172 n1_m8_71200_26400 n1_m9_71200_26400 1.000000
R17173 n1_m8_71200_48800 n1_m9_71200_48800 1.000000
R17174 n1_m8_71200_71200 n1_m9_71200_71200 1.000000
R17175 n1_m8_71200_93600 n1_m9_71200_93600 1.000000
R17176 n1_m8_71200_116000 n1_m9_71200_116000 1.000000
R17177 n1_m8_71200_138400 n1_m9_71200_138400 1.000000
R17178 n1_m8_71200_160800 n1_m9_71200_160800 1.000000
R17179 n1_m8_71200_183200 n1_m9_71200_183200 1.000000
R17180 n1_m8_71200_205600 n1_m9_71200_205600 1.000000
R17181 n1_m8_71200_228000 n1_m9_71200_228000 1.000000
R17182 n1_m8_71200_250400 n1_m9_71200_250400 1.000000
R17183 n1_m8_71200_272800 n1_m9_71200_272800 1.000000
R17184 n1_m8_71200_295200 n1_m9_71200_295200 1.000000
R17185 n1_m8_71200_317600 n1_m9_71200_317600 1.000000
R17186 n1_m8_71200_340000 n1_m9_71200_340000 1.000000
R17187 n1_m8_71200_362400 n1_m9_71200_362400 1.000000
R17188 n1_m8_71200_384800 n1_m9_71200_384800 1.000000
R17189 n1_m8_71200_407200 n1_m9_71200_407200 1.000000
R17190 n1_m8_71200_429600 n1_m9_71200_429600 1.000000
R17191 n1_m8_71200_452000 n1_m9_71200_452000 1.000000
R17192 n1_m8_71200_474400 n1_m9_71200_474400 1.000000
R17193 n1_m8_71200_496800 n1_m9_71200_496800 1.000000
R17194 n1_m8_93600_4000 n1_m9_93600_4000 1.000000
R17195 n1_m8_93600_26400 n1_m9_93600_26400 1.000000
R17196 n1_m8_93600_48800 n1_m9_93600_48800 1.000000
R17197 n1_m8_93600_71200 n1_m9_93600_71200 1.000000
R17198 n1_m8_93600_93600 n1_m9_93600_93600 1.000000
R17199 n1_m8_93600_116000 n1_m9_93600_116000 1.000000
R17200 n1_m8_93600_138400 n1_m9_93600_138400 1.000000
R17201 n1_m8_93600_160800 n1_m9_93600_160800 1.000000
R17202 n1_m8_93600_183200 n1_m9_93600_183200 1.000000
R17203 n1_m8_93600_205600 n1_m9_93600_205600 1.000000
R17204 n1_m8_93600_228000 n1_m9_93600_228000 1.000000
R17205 n1_m8_93600_250400 n1_m9_93600_250400 1.000000
R17206 n1_m8_93600_272800 n1_m9_93600_272800 1.000000
R17207 n1_m8_93600_295200 n1_m9_93600_295200 1.000000
R17208 n1_m8_93600_317600 n1_m9_93600_317600 1.000000
R17209 n1_m8_93600_340000 n1_m9_93600_340000 1.000000
R17210 n1_m8_93600_362400 n1_m9_93600_362400 1.000000
R17211 n1_m8_93600_384800 n1_m9_93600_384800 1.000000
R17212 n1_m8_93600_407200 n1_m9_93600_407200 1.000000
R17213 n1_m8_93600_429600 n1_m9_93600_429600 1.000000
R17214 n1_m8_93600_452000 n1_m9_93600_452000 1.000000
R17215 n1_m8_93600_474400 n1_m9_93600_474400 1.000000
R17216 n1_m8_93600_496800 n1_m9_93600_496800 1.000000
R17217 n1_m8_116000_4000 n1_m9_116000_4000 1.000000
R17218 n1_m8_116000_26400 n1_m9_116000_26400 1.000000
R17219 n1_m8_116000_48800 n1_m9_116000_48800 1.000000
R17220 n1_m8_116000_71200 n1_m9_116000_71200 1.000000
R17221 n1_m8_116000_93600 n1_m9_116000_93600 1.000000
R17222 n1_m8_116000_116000 n1_m9_116000_116000 1.000000
R17223 n1_m8_116000_138400 n1_m9_116000_138400 1.000000
R17224 n1_m8_116000_160800 n1_m9_116000_160800 1.000000
R17225 n1_m8_116000_183200 n1_m9_116000_183200 1.000000
R17226 n1_m8_116000_205600 n1_m9_116000_205600 1.000000
R17227 n1_m8_116000_228000 n1_m9_116000_228000 1.000000
R17228 n1_m8_116000_250400 n1_m9_116000_250400 1.000000
R17229 n1_m8_116000_272800 n1_m9_116000_272800 1.000000
R17230 n1_m8_116000_295200 n1_m9_116000_295200 1.000000
R17231 n1_m8_116000_317600 n1_m9_116000_317600 1.000000
R17232 n1_m8_116000_340000 n1_m9_116000_340000 1.000000
R17233 n1_m8_116000_362400 n1_m9_116000_362400 1.000000
R17234 n1_m8_116000_384800 n1_m9_116000_384800 1.000000
R17235 n1_m8_116000_407200 n1_m9_116000_407200 1.000000
R17236 n1_m8_116000_429600 n1_m9_116000_429600 1.000000
R17237 n1_m8_116000_452000 n1_m9_116000_452000 1.000000
R17238 n1_m8_116000_474400 n1_m9_116000_474400 1.000000
R17239 n1_m8_116000_496800 n1_m9_116000_496800 1.000000
R17240 n1_m8_138400_4000 n1_m9_138400_4000 1.000000
R17241 n1_m8_138400_26400 n1_m9_138400_26400 1.000000
R17242 n1_m8_138400_48800 n1_m9_138400_48800 1.000000
R17243 n1_m8_138400_71200 n1_m9_138400_71200 1.000000
R17244 n1_m8_138400_93600 n1_m9_138400_93600 1.000000
R17245 n1_m8_138400_116000 n1_m9_138400_116000 1.000000
R17246 n1_m8_138400_138400 n1_m9_138400_138400 1.000000
R17247 n1_m8_138400_160800 n1_m9_138400_160800 1.000000
R17248 n1_m8_138400_183200 n1_m9_138400_183200 1.000000
R17249 n1_m8_138400_205600 n1_m9_138400_205600 1.000000
R17250 n1_m8_138400_228000 n1_m9_138400_228000 1.000000
R17251 n1_m8_138400_250400 n1_m9_138400_250400 1.000000
R17252 n1_m8_138400_272800 n1_m9_138400_272800 1.000000
R17253 n1_m8_138400_295200 n1_m9_138400_295200 1.000000
R17254 n1_m8_138400_317600 n1_m9_138400_317600 1.000000
R17255 n1_m8_138400_340000 n1_m9_138400_340000 1.000000
R17256 n1_m8_138400_362400 n1_m9_138400_362400 1.000000
R17257 n1_m8_138400_384800 n1_m9_138400_384800 1.000000
R17258 n1_m8_138400_407200 n1_m9_138400_407200 1.000000
R17259 n1_m8_138400_429600 n1_m9_138400_429600 1.000000
R17260 n1_m8_138400_452000 n1_m9_138400_452000 1.000000
R17261 n1_m8_138400_474400 n1_m9_138400_474400 1.000000
R17262 n1_m8_138400_496800 n1_m9_138400_496800 1.000000
R17263 n1_m8_160800_4000 n1_m9_160800_4000 1.000000
R17264 n1_m8_160800_26400 n1_m9_160800_26400 1.000000
R17265 n1_m8_160800_48800 n1_m9_160800_48800 1.000000
R17266 n1_m8_160800_71200 n1_m9_160800_71200 1.000000
R17267 n1_m8_160800_93600 n1_m9_160800_93600 1.000000
R17268 n1_m8_160800_116000 n1_m9_160800_116000 1.000000
R17269 n1_m8_160800_138400 n1_m9_160800_138400 1.000000
R17270 n1_m8_160800_160800 n1_m9_160800_160800 1.000000
R17271 n1_m8_160800_183200 n1_m9_160800_183200 1.000000
R17272 n1_m8_160800_205600 n1_m9_160800_205600 1.000000
R17273 n1_m8_160800_228000 n1_m9_160800_228000 1.000000
R17274 n1_m8_160800_250400 n1_m9_160800_250400 1.000000
R17275 n1_m8_160800_272800 n1_m9_160800_272800 1.000000
R17276 n1_m8_160800_295200 n1_m9_160800_295200 1.000000
R17277 n1_m8_160800_317600 n1_m9_160800_317600 1.000000
R17278 n1_m8_160800_340000 n1_m9_160800_340000 1.000000
R17279 n1_m8_160800_362400 n1_m9_160800_362400 1.000000
R17280 n1_m8_160800_384800 n1_m9_160800_384800 1.000000
R17281 n1_m8_160800_407200 n1_m9_160800_407200 1.000000
R17282 n1_m8_160800_429600 n1_m9_160800_429600 1.000000
R17283 n1_m8_160800_452000 n1_m9_160800_452000 1.000000
R17284 n1_m8_160800_474400 n1_m9_160800_474400 1.000000
R17285 n1_m8_160800_496800 n1_m9_160800_496800 1.000000
R17286 n1_m8_183200_4000 n1_m9_183200_4000 1.000000
R17287 n1_m8_183200_26400 n1_m9_183200_26400 1.000000
R17288 n1_m8_183200_48800 n1_m9_183200_48800 1.000000
R17289 n1_m8_183200_71200 n1_m9_183200_71200 1.000000
R17290 n1_m8_183200_93600 n1_m9_183200_93600 1.000000
R17291 n1_m8_183200_116000 n1_m9_183200_116000 1.000000
R17292 n1_m8_183200_138400 n1_m9_183200_138400 1.000000
R17293 n1_m8_183200_160800 n1_m9_183200_160800 1.000000
R17294 n1_m8_183200_183200 n1_m9_183200_183200 1.000000
R17295 n1_m8_183200_205600 n1_m9_183200_205600 1.000000
R17296 n1_m8_183200_228000 n1_m9_183200_228000 1.000000
R17297 n1_m8_183200_250400 n1_m9_183200_250400 1.000000
R17298 n1_m8_183200_272800 n1_m9_183200_272800 1.000000
R17299 n1_m8_183200_295200 n1_m9_183200_295200 1.000000
R17300 n1_m8_183200_317600 n1_m9_183200_317600 1.000000
R17301 n1_m8_183200_340000 n1_m9_183200_340000 1.000000
R17302 n1_m8_183200_362400 n1_m9_183200_362400 1.000000
R17303 n1_m8_183200_384800 n1_m9_183200_384800 1.000000
R17304 n1_m8_183200_407200 n1_m9_183200_407200 1.000000
R17305 n1_m8_183200_429600 n1_m9_183200_429600 1.000000
R17306 n1_m8_183200_452000 n1_m9_183200_452000 1.000000
R17307 n1_m8_183200_474400 n1_m9_183200_474400 1.000000
R17308 n1_m8_183200_496800 n1_m9_183200_496800 1.000000
R17309 n1_m8_205600_4000 n1_m9_205600_4000 1.000000
R17310 n1_m8_205600_26400 n1_m9_205600_26400 1.000000
R17311 n1_m8_205600_48800 n1_m9_205600_48800 1.000000
R17312 n1_m8_205600_71200 n1_m9_205600_71200 1.000000
R17313 n1_m8_205600_93600 n1_m9_205600_93600 1.000000
R17314 n1_m8_205600_116000 n1_m9_205600_116000 1.000000
R17315 n1_m8_205600_138400 n1_m9_205600_138400 1.000000
R17316 n1_m8_205600_160800 n1_m9_205600_160800 1.000000
R17317 n1_m8_205600_183200 n1_m9_205600_183200 1.000000
R17318 n1_m8_205600_205600 n1_m9_205600_205600 1.000000
R17319 n1_m8_205600_228000 n1_m9_205600_228000 1.000000
R17320 n1_m8_205600_250400 n1_m9_205600_250400 1.000000
R17321 n1_m8_205600_272800 n1_m9_205600_272800 1.000000
R17322 n1_m8_205600_295200 n1_m9_205600_295200 1.000000
R17323 n1_m8_205600_317600 n1_m9_205600_317600 1.000000
R17324 n1_m8_205600_340000 n1_m9_205600_340000 1.000000
R17325 n1_m8_205600_362400 n1_m9_205600_362400 1.000000
R17326 n1_m8_205600_384800 n1_m9_205600_384800 1.000000
R17327 n1_m8_205600_407200 n1_m9_205600_407200 1.000000
R17328 n1_m8_205600_429600 n1_m9_205600_429600 1.000000
R17329 n1_m8_205600_452000 n1_m9_205600_452000 1.000000
R17330 n1_m8_205600_474400 n1_m9_205600_474400 1.000000
R17331 n1_m8_205600_496800 n1_m9_205600_496800 1.000000
R17332 n1_m8_228000_4000 n1_m9_228000_4000 1.000000
R17333 n1_m8_228000_26400 n1_m9_228000_26400 1.000000
R17334 n1_m8_228000_48800 n1_m9_228000_48800 1.000000
R17335 n1_m8_228000_71200 n1_m9_228000_71200 1.000000
R17336 n1_m8_228000_93600 n1_m9_228000_93600 1.000000
R17337 n1_m8_228000_116000 n1_m9_228000_116000 1.000000
R17338 n1_m8_228000_138400 n1_m9_228000_138400 1.000000
R17339 n1_m8_228000_160800 n1_m9_228000_160800 1.000000
R17340 n1_m8_228000_183200 n1_m9_228000_183200 1.000000
R17341 n1_m8_228000_205600 n1_m9_228000_205600 1.000000
R17342 n1_m8_228000_228000 n1_m9_228000_228000 1.000000
R17343 n1_m8_228000_250400 n1_m9_228000_250400 1.000000
R17344 n1_m8_228000_272800 n1_m9_228000_272800 1.000000
R17345 n1_m8_228000_295200 n1_m9_228000_295200 1.000000
R17346 n1_m8_228000_317600 n1_m9_228000_317600 1.000000
R17347 n1_m8_228000_340000 n1_m9_228000_340000 1.000000
R17348 n1_m8_228000_362400 n1_m9_228000_362400 1.000000
R17349 n1_m8_228000_384800 n1_m9_228000_384800 1.000000
R17350 n1_m8_228000_407200 n1_m9_228000_407200 1.000000
R17351 n1_m8_228000_429600 n1_m9_228000_429600 1.000000
R17352 n1_m8_228000_452000 n1_m9_228000_452000 1.000000
R17353 n1_m8_228000_474400 n1_m9_228000_474400 1.000000
R17354 n1_m8_228000_496800 n1_m9_228000_496800 1.000000
R17355 n1_m8_250400_4000 n1_m9_250400_4000 1.000000
R17356 n1_m8_250400_26400 n1_m9_250400_26400 1.000000
R17357 n1_m8_250400_48800 n1_m9_250400_48800 1.000000
R17358 n1_m8_250400_71200 n1_m9_250400_71200 1.000000
R17359 n1_m8_250400_93600 n1_m9_250400_93600 1.000000
R17360 n1_m8_250400_116000 n1_m9_250400_116000 1.000000
R17361 n1_m8_250400_138400 n1_m9_250400_138400 1.000000
R17362 n1_m8_250400_160800 n1_m9_250400_160800 1.000000
R17363 n1_m8_250400_183200 n1_m9_250400_183200 1.000000
R17364 n1_m8_250400_205600 n1_m9_250400_205600 1.000000
R17365 n1_m8_250400_228000 n1_m9_250400_228000 1.000000
R17366 n1_m8_250400_250400 n1_m9_250400_250400 1.000000
R17367 n1_m8_250400_272800 n1_m9_250400_272800 1.000000
R17368 n1_m8_250400_295200 n1_m9_250400_295200 1.000000
R17369 n1_m8_250400_317600 n1_m9_250400_317600 1.000000
R17370 n1_m8_250400_340000 n1_m9_250400_340000 1.000000
R17371 n1_m8_250400_362400 n1_m9_250400_362400 1.000000
R17372 n1_m8_250400_384800 n1_m9_250400_384800 1.000000
R17373 n1_m8_250400_407200 n1_m9_250400_407200 1.000000
R17374 n1_m8_250400_429600 n1_m9_250400_429600 1.000000
R17375 n1_m8_250400_452000 n1_m9_250400_452000 1.000000
R17376 n1_m8_250400_474400 n1_m9_250400_474400 1.000000
R17377 n1_m8_250400_496800 n1_m9_250400_496800 1.000000
R17378 n1_m8_272800_4000 n1_m9_272800_4000 1.000000
R17379 n1_m8_272800_26400 n1_m9_272800_26400 1.000000
R17380 n1_m8_272800_48800 n1_m9_272800_48800 1.000000
R17381 n1_m8_272800_71200 n1_m9_272800_71200 1.000000
R17382 n1_m8_272800_93600 n1_m9_272800_93600 1.000000
R17383 n1_m8_272800_116000 n1_m9_272800_116000 1.000000
R17384 n1_m8_272800_138400 n1_m9_272800_138400 1.000000
R17385 n1_m8_272800_160800 n1_m9_272800_160800 1.000000
R17386 n1_m8_272800_183200 n1_m9_272800_183200 1.000000
R17387 n1_m8_272800_205600 n1_m9_272800_205600 1.000000
R17388 n1_m8_272800_228000 n1_m9_272800_228000 1.000000
R17389 n1_m8_272800_250400 n1_m9_272800_250400 1.000000
R17390 n1_m8_272800_272800 n1_m9_272800_272800 1.000000
R17391 n1_m8_272800_295200 n1_m9_272800_295200 1.000000
R17392 n1_m8_272800_317600 n1_m9_272800_317600 1.000000
R17393 n1_m8_272800_340000 n1_m9_272800_340000 1.000000
R17394 n1_m8_272800_362400 n1_m9_272800_362400 1.000000
R17395 n1_m8_272800_384800 n1_m9_272800_384800 1.000000
R17396 n1_m8_272800_407200 n1_m9_272800_407200 1.000000
R17397 n1_m8_272800_429600 n1_m9_272800_429600 1.000000
R17398 n1_m8_272800_452000 n1_m9_272800_452000 1.000000
R17399 n1_m8_272800_474400 n1_m9_272800_474400 1.000000
R17400 n1_m8_272800_496800 n1_m9_272800_496800 1.000000
R17401 n1_m8_295200_4000 n1_m9_295200_4000 1.000000
R17402 n1_m8_295200_26400 n1_m9_295200_26400 1.000000
R17403 n1_m8_295200_48800 n1_m9_295200_48800 1.000000
R17404 n1_m8_295200_71200 n1_m9_295200_71200 1.000000
R17405 n1_m8_295200_93600 n1_m9_295200_93600 1.000000
R17406 n1_m8_295200_116000 n1_m9_295200_116000 1.000000
R17407 n1_m8_295200_138400 n1_m9_295200_138400 1.000000
R17408 n1_m8_295200_160800 n1_m9_295200_160800 1.000000
R17409 n1_m8_295200_183200 n1_m9_295200_183200 1.000000
R17410 n1_m8_295200_205600 n1_m9_295200_205600 1.000000
R17411 n1_m8_295200_228000 n1_m9_295200_228000 1.000000
R17412 n1_m8_295200_250400 n1_m9_295200_250400 1.000000
R17413 n1_m8_295200_272800 n1_m9_295200_272800 1.000000
R17414 n1_m8_295200_295200 n1_m9_295200_295200 1.000000
R17415 n1_m8_295200_317600 n1_m9_295200_317600 1.000000
R17416 n1_m8_295200_340000 n1_m9_295200_340000 1.000000
R17417 n1_m8_295200_362400 n1_m9_295200_362400 1.000000
R17418 n1_m8_295200_384800 n1_m9_295200_384800 1.000000
R17419 n1_m8_295200_407200 n1_m9_295200_407200 1.000000
R17420 n1_m8_295200_429600 n1_m9_295200_429600 1.000000
R17421 n1_m8_295200_452000 n1_m9_295200_452000 1.000000
R17422 n1_m8_295200_474400 n1_m9_295200_474400 1.000000
R17423 n1_m8_295200_496800 n1_m9_295200_496800 1.000000
R17424 n1_m8_317600_4000 n1_m9_317600_4000 1.000000
R17425 n1_m8_317600_26400 n1_m9_317600_26400 1.000000
R17426 n1_m8_317600_48800 n1_m9_317600_48800 1.000000
R17427 n1_m8_317600_71200 n1_m9_317600_71200 1.000000
R17428 n1_m8_317600_93600 n1_m9_317600_93600 1.000000
R17429 n1_m8_317600_116000 n1_m9_317600_116000 1.000000
R17430 n1_m8_317600_138400 n1_m9_317600_138400 1.000000
R17431 n1_m8_317600_160800 n1_m9_317600_160800 1.000000
R17432 n1_m8_317600_183200 n1_m9_317600_183200 1.000000
R17433 n1_m8_317600_205600 n1_m9_317600_205600 1.000000
R17434 n1_m8_317600_228000 n1_m9_317600_228000 1.000000
R17435 n1_m8_317600_250400 n1_m9_317600_250400 1.000000
R17436 n1_m8_317600_272800 n1_m9_317600_272800 1.000000
R17437 n1_m8_317600_295200 n1_m9_317600_295200 1.000000
R17438 n1_m8_317600_317600 n1_m9_317600_317600 1.000000
R17439 n1_m8_317600_340000 n1_m9_317600_340000 1.000000
R17440 n1_m8_317600_362400 n1_m9_317600_362400 1.000000
R17441 n1_m8_317600_384800 n1_m9_317600_384800 1.000000
R17442 n1_m8_317600_407200 n1_m9_317600_407200 1.000000
R17443 n1_m8_317600_429600 n1_m9_317600_429600 1.000000
R17444 n1_m8_317600_452000 n1_m9_317600_452000 1.000000
R17445 n1_m8_317600_474400 n1_m9_317600_474400 1.000000
R17446 n1_m8_317600_496800 n1_m9_317600_496800 1.000000
R17447 n1_m8_340000_4000 n1_m9_340000_4000 1.000000
R17448 n1_m8_340000_26400 n1_m9_340000_26400 1.000000
R17449 n1_m8_340000_48800 n1_m9_340000_48800 1.000000
R17450 n1_m8_340000_71200 n1_m9_340000_71200 1.000000
R17451 n1_m8_340000_93600 n1_m9_340000_93600 1.000000
R17452 n1_m8_340000_116000 n1_m9_340000_116000 1.000000
R17453 n1_m8_340000_138400 n1_m9_340000_138400 1.000000
R17454 n1_m8_340000_160800 n1_m9_340000_160800 1.000000
R17455 n1_m8_340000_183200 n1_m9_340000_183200 1.000000
R17456 n1_m8_340000_205600 n1_m9_340000_205600 1.000000
R17457 n1_m8_340000_228000 n1_m9_340000_228000 1.000000
R17458 n1_m8_340000_250400 n1_m9_340000_250400 1.000000
R17459 n1_m8_340000_272800 n1_m9_340000_272800 1.000000
R17460 n1_m8_340000_295200 n1_m9_340000_295200 1.000000
R17461 n1_m8_340000_317600 n1_m9_340000_317600 1.000000
R17462 n1_m8_340000_340000 n1_m9_340000_340000 1.000000
R17463 n1_m8_340000_362400 n1_m9_340000_362400 1.000000
R17464 n1_m8_340000_384800 n1_m9_340000_384800 1.000000
R17465 n1_m8_340000_407200 n1_m9_340000_407200 1.000000
R17466 n1_m8_340000_429600 n1_m9_340000_429600 1.000000
R17467 n1_m8_340000_452000 n1_m9_340000_452000 1.000000
R17468 n1_m8_340000_474400 n1_m9_340000_474400 1.000000
R17469 n1_m8_340000_496800 n1_m9_340000_496800 1.000000
R17470 n1_m8_362400_4000 n1_m9_362400_4000 1.000000
R17471 n1_m8_362400_26400 n1_m9_362400_26400 1.000000
R17472 n1_m8_362400_48800 n1_m9_362400_48800 1.000000
R17473 n1_m8_362400_71200 n1_m9_362400_71200 1.000000
R17474 n1_m8_362400_93600 n1_m9_362400_93600 1.000000
R17475 n1_m8_362400_116000 n1_m9_362400_116000 1.000000
R17476 n1_m8_362400_138400 n1_m9_362400_138400 1.000000
R17477 n1_m8_362400_160800 n1_m9_362400_160800 1.000000
R17478 n1_m8_362400_183200 n1_m9_362400_183200 1.000000
R17479 n1_m8_362400_205600 n1_m9_362400_205600 1.000000
R17480 n1_m8_362400_228000 n1_m9_362400_228000 1.000000
R17481 n1_m8_362400_250400 n1_m9_362400_250400 1.000000
R17482 n1_m8_362400_272800 n1_m9_362400_272800 1.000000
R17483 n1_m8_362400_295200 n1_m9_362400_295200 1.000000
R17484 n1_m8_362400_317600 n1_m9_362400_317600 1.000000
R17485 n1_m8_362400_340000 n1_m9_362400_340000 1.000000
R17486 n1_m8_362400_362400 n1_m9_362400_362400 1.000000
R17487 n1_m8_362400_384800 n1_m9_362400_384800 1.000000
R17488 n1_m8_362400_407200 n1_m9_362400_407200 1.000000
R17489 n1_m8_362400_429600 n1_m9_362400_429600 1.000000
R17490 n1_m8_362400_452000 n1_m9_362400_452000 1.000000
R17491 n1_m8_362400_474400 n1_m9_362400_474400 1.000000
R17492 n1_m8_362400_496800 n1_m9_362400_496800 1.000000
R17493 n1_m8_384800_4000 n1_m9_384800_4000 1.000000
R17494 n1_m8_384800_26400 n1_m9_384800_26400 1.000000
R17495 n1_m8_384800_48800 n1_m9_384800_48800 1.000000
R17496 n1_m8_384800_71200 n1_m9_384800_71200 1.000000
R17497 n1_m8_384800_93600 n1_m9_384800_93600 1.000000
R17498 n1_m8_384800_116000 n1_m9_384800_116000 1.000000
R17499 n1_m8_384800_138400 n1_m9_384800_138400 1.000000
R17500 n1_m8_384800_160800 n1_m9_384800_160800 1.000000
R17501 n1_m8_384800_183200 n1_m9_384800_183200 1.000000
R17502 n1_m8_384800_205600 n1_m9_384800_205600 1.000000
R17503 n1_m8_384800_228000 n1_m9_384800_228000 1.000000
R17504 n1_m8_384800_250400 n1_m9_384800_250400 1.000000
R17505 n1_m8_384800_272800 n1_m9_384800_272800 1.000000
R17506 n1_m8_384800_295200 n1_m9_384800_295200 1.000000
R17507 n1_m8_384800_317600 n1_m9_384800_317600 1.000000
R17508 n1_m8_384800_340000 n1_m9_384800_340000 1.000000
R17509 n1_m8_384800_362400 n1_m9_384800_362400 1.000000
R17510 n1_m8_384800_384800 n1_m9_384800_384800 1.000000
R17511 n1_m8_384800_407200 n1_m9_384800_407200 1.000000
R17512 n1_m8_384800_429600 n1_m9_384800_429600 1.000000
R17513 n1_m8_384800_452000 n1_m9_384800_452000 1.000000
R17514 n1_m8_384800_474400 n1_m9_384800_474400 1.000000
R17515 n1_m8_384800_496800 n1_m9_384800_496800 1.000000
R17516 n1_m8_407200_4000 n1_m9_407200_4000 1.000000
R17517 n1_m8_407200_26400 n1_m9_407200_26400 1.000000
R17518 n1_m8_407200_48800 n1_m9_407200_48800 1.000000
R17519 n1_m8_407200_71200 n1_m9_407200_71200 1.000000
R17520 n1_m8_407200_93600 n1_m9_407200_93600 1.000000
R17521 n1_m8_407200_116000 n1_m9_407200_116000 1.000000
R17522 n1_m8_407200_138400 n1_m9_407200_138400 1.000000
R17523 n1_m8_407200_160800 n1_m9_407200_160800 1.000000
R17524 n1_m8_407200_183200 n1_m9_407200_183200 1.000000
R17525 n1_m8_407200_205600 n1_m9_407200_205600 1.000000
R17526 n1_m8_407200_228000 n1_m9_407200_228000 1.000000
R17527 n1_m8_407200_250400 n1_m9_407200_250400 1.000000
R17528 n1_m8_407200_272800 n1_m9_407200_272800 1.000000
R17529 n1_m8_407200_295200 n1_m9_407200_295200 1.000000
R17530 n1_m8_407200_317600 n1_m9_407200_317600 1.000000
R17531 n1_m8_407200_340000 n1_m9_407200_340000 1.000000
R17532 n1_m8_407200_362400 n1_m9_407200_362400 1.000000
R17533 n1_m8_407200_384800 n1_m9_407200_384800 1.000000
R17534 n1_m8_407200_407200 n1_m9_407200_407200 1.000000
R17535 n1_m8_407200_429600 n1_m9_407200_429600 1.000000
R17536 n1_m8_407200_452000 n1_m9_407200_452000 1.000000
R17537 n1_m8_407200_474400 n1_m9_407200_474400 1.000000
R17538 n1_m8_407200_496800 n1_m9_407200_496800 1.000000
R17539 n1_m8_429600_4000 n1_m9_429600_4000 1.000000
R17540 n1_m8_429600_26400 n1_m9_429600_26400 1.000000
R17541 n1_m8_429600_48800 n1_m9_429600_48800 1.000000
R17542 n1_m8_429600_71200 n1_m9_429600_71200 1.000000
R17543 n1_m8_429600_93600 n1_m9_429600_93600 1.000000
R17544 n1_m8_429600_116000 n1_m9_429600_116000 1.000000
R17545 n1_m8_429600_138400 n1_m9_429600_138400 1.000000
R17546 n1_m8_429600_160800 n1_m9_429600_160800 1.000000
R17547 n1_m8_429600_183200 n1_m9_429600_183200 1.000000
R17548 n1_m8_429600_205600 n1_m9_429600_205600 1.000000
R17549 n1_m8_429600_228000 n1_m9_429600_228000 1.000000
R17550 n1_m8_429600_250400 n1_m9_429600_250400 1.000000
R17551 n1_m8_429600_272800 n1_m9_429600_272800 1.000000
R17552 n1_m8_429600_295200 n1_m9_429600_295200 1.000000
R17553 n1_m8_429600_317600 n1_m9_429600_317600 1.000000
R17554 n1_m8_429600_340000 n1_m9_429600_340000 1.000000
R17555 n1_m8_429600_362400 n1_m9_429600_362400 1.000000
R17556 n1_m8_429600_384800 n1_m9_429600_384800 1.000000
R17557 n1_m8_429600_407200 n1_m9_429600_407200 1.000000
R17558 n1_m8_429600_429600 n1_m9_429600_429600 1.000000
R17559 n1_m8_429600_452000 n1_m9_429600_452000 1.000000
R17560 n1_m8_429600_474400 n1_m9_429600_474400 1.000000
R17561 n1_m8_429600_496800 n1_m9_429600_496800 1.000000
R17562 n1_m8_452000_4000 n1_m9_452000_4000 1.000000
R17563 n1_m8_452000_26400 n1_m9_452000_26400 1.000000
R17564 n1_m8_452000_48800 n1_m9_452000_48800 1.000000
R17565 n1_m8_452000_71200 n1_m9_452000_71200 1.000000
R17566 n1_m8_452000_93600 n1_m9_452000_93600 1.000000
R17567 n1_m8_452000_116000 n1_m9_452000_116000 1.000000
R17568 n1_m8_452000_138400 n1_m9_452000_138400 1.000000
R17569 n1_m8_452000_160800 n1_m9_452000_160800 1.000000
R17570 n1_m8_452000_183200 n1_m9_452000_183200 1.000000
R17571 n1_m8_452000_205600 n1_m9_452000_205600 1.000000
R17572 n1_m8_452000_228000 n1_m9_452000_228000 1.000000
R17573 n1_m8_452000_250400 n1_m9_452000_250400 1.000000
R17574 n1_m8_452000_272800 n1_m9_452000_272800 1.000000
R17575 n1_m8_452000_295200 n1_m9_452000_295200 1.000000
R17576 n1_m8_452000_317600 n1_m9_452000_317600 1.000000
R17577 n1_m8_452000_340000 n1_m9_452000_340000 1.000000
R17578 n1_m8_452000_362400 n1_m9_452000_362400 1.000000
R17579 n1_m8_452000_384800 n1_m9_452000_384800 1.000000
R17580 n1_m8_452000_407200 n1_m9_452000_407200 1.000000
R17581 n1_m8_452000_429600 n1_m9_452000_429600 1.000000
R17582 n1_m8_452000_452000 n1_m9_452000_452000 1.000000
R17583 n1_m8_452000_474400 n1_m9_452000_474400 1.000000
R17584 n1_m8_452000_496800 n1_m9_452000_496800 1.000000
R17585 n1_m8_474400_4000 n1_m9_474400_4000 1.000000
R17586 n1_m8_474400_26400 n1_m9_474400_26400 1.000000
R17587 n1_m8_474400_48800 n1_m9_474400_48800 1.000000
R17588 n1_m8_474400_71200 n1_m9_474400_71200 1.000000
R17589 n1_m8_474400_93600 n1_m9_474400_93600 1.000000
R17590 n1_m8_474400_116000 n1_m9_474400_116000 1.000000
R17591 n1_m8_474400_138400 n1_m9_474400_138400 1.000000
R17592 n1_m8_474400_160800 n1_m9_474400_160800 1.000000
R17593 n1_m8_474400_183200 n1_m9_474400_183200 1.000000
R17594 n1_m8_474400_205600 n1_m9_474400_205600 1.000000
R17595 n1_m8_474400_228000 n1_m9_474400_228000 1.000000
R17596 n1_m8_474400_250400 n1_m9_474400_250400 1.000000
R17597 n1_m8_474400_272800 n1_m9_474400_272800 1.000000
R17598 n1_m8_474400_295200 n1_m9_474400_295200 1.000000
R17599 n1_m8_474400_317600 n1_m9_474400_317600 1.000000
R17600 n1_m8_474400_340000 n1_m9_474400_340000 1.000000
R17601 n1_m8_474400_362400 n1_m9_474400_362400 1.000000
R17602 n1_m8_474400_384800 n1_m9_474400_384800 1.000000
R17603 n1_m8_474400_407200 n1_m9_474400_407200 1.000000
R17604 n1_m8_474400_429600 n1_m9_474400_429600 1.000000
R17605 n1_m8_474400_452000 n1_m9_474400_452000 1.000000
R17606 n1_m8_474400_474400 n1_m9_474400_474400 1.000000
R17607 n1_m8_474400_496800 n1_m9_474400_496800 1.000000
R17608 n1_m8_496800_4000 n1_m9_496800_4000 1.000000
R17609 n1_m8_496800_26400 n1_m9_496800_26400 1.000000
R17610 n1_m8_496800_48800 n1_m9_496800_48800 1.000000
R17611 n1_m8_496800_71200 n1_m9_496800_71200 1.000000
R17612 n1_m8_496800_93600 n1_m9_496800_93600 1.000000
R17613 n1_m8_496800_116000 n1_m9_496800_116000 1.000000
R17614 n1_m8_496800_138400 n1_m9_496800_138400 1.000000
R17615 n1_m8_496800_160800 n1_m9_496800_160800 1.000000
R17616 n1_m8_496800_183200 n1_m9_496800_183200 1.000000
R17617 n1_m8_496800_205600 n1_m9_496800_205600 1.000000
R17618 n1_m8_496800_228000 n1_m9_496800_228000 1.000000
R17619 n1_m8_496800_250400 n1_m9_496800_250400 1.000000
R17620 n1_m8_496800_272800 n1_m9_496800_272800 1.000000
R17621 n1_m8_496800_295200 n1_m9_496800_295200 1.000000
R17622 n1_m8_496800_317600 n1_m9_496800_317600 1.000000
R17623 n1_m8_496800_340000 n1_m9_496800_340000 1.000000
R17624 n1_m8_496800_362400 n1_m9_496800_362400 1.000000
R17625 n1_m8_496800_384800 n1_m9_496800_384800 1.000000
R17626 n1_m8_496800_407200 n1_m9_496800_407200 1.000000
R17627 n1_m8_496800_429600 n1_m9_496800_429600 1.000000
R17628 n1_m8_496800_452000 n1_m9_496800_452000 1.000000
R17629 n1_m8_496800_474400 n1_m9_496800_474400 1.000000
R17630 n1_m8_496800_496800 n1_m9_496800_496800 1.000000
V0 n1_m9_48800_48800 0 1.100000
V1 n1_m9_340000_48800 0 1.100000
V2 n1_m9_48800_340000 0 1.100000
V3 n1_m9_452000_452000 0 1.100000
I0 n1_m1_0_0 0 1.648400e-07
I1 n1_m1_0_4800 0 1.640995e-07
I2 n1_m1_0_9600 0 2.392970e-07
I3 n1_m1_0_14400 0 1.551464e-07
I4 n1_m1_0_19200 0 1.532282e-07
I5 n1_m1_0_24000 0 2.309306e-07
I6 n1_m1_0_28800 0 1.561483e-07
I7 n1_m1_0_33600 0 2.200769e-07
I8 n1_m1_0_38400 0 1.433287e-07
I9 n1_m1_0_43200 0 1.435494e-07
I10 n1_m1_0_48000 0 2.235882e-07
I11 n1_m1_0_52800 0 1.499908e-07
I12 n1_m1_0_57600 0 2.305906e-07
I13 n1_m1_0_62400 0 1.522864e-07
I14 n1_m1_0_67200 0 1.502297e-07
I15 n1_m1_0_72000 0 2.249861e-07
I16 n1_m1_0_76800 0 1.499908e-07
I17 n1_m1_0_81600 0 2.294538e-07
I18 n1_m1_0_86400 0 1.503337e-07
I19 n1_m1_0_91200 0 1.502985e-07
I20 n1_m1_0_96000 0 2.283903e-07
I21 n1_m1_0_100800 0 1.532282e-07
I22 n1_m1_0_105600 0 2.298422e-07
I23 n1_m1_0_110400 0 1.527365e-07
I24 n1_m1_0_115200 0 1.499554e-07
I25 n1_m1_0_120000 0 2.199471e-07
I26 n1_m1_0_124800 0 1.483132e-07
I27 n1_m1_0_129600 0 2.297248e-07
I28 n1_m1_0_134400 0 1.549405e-07
I29 n1_m1_0_139200 0 1.549405e-07
I30 n1_m1_0_144000 0 2.321684e-07
I31 n1_m1_0_148800 0 1.534018e-07
I32 n1_m1_0_153600 0 2.279115e-07
I33 n1_m1_0_158400 0 1.489214e-07
I34 n1_m1_0_163200 0 1.482784e-07
I35 n1_m1_0_168000 0 2.231913e-07
I36 n1_m1_0_172800 0 1.516447e-07
I37 n1_m1_0_177600 0 2.262446e-07
I38 n1_m1_0_182400 0 1.488428e-07
I39 n1_m1_0_187200 0 1.534890e-07
I40 n1_m1_0_192000 0 2.324108e-07
I41 n1_m1_0_196800 0 1.549405e-07
I42 n1_m1_0_201600 0 2.324108e-07
I43 n1_m1_0_206400 0 1.549405e-07
I44 n1_m1_0_211200 0 1.549405e-07
I45 n1_m1_0_216000 0 2.350447e-07
I46 n1_m1_0_220800 0 1.608496e-07
I47 n1_m1_0_225600 0 2.424039e-07
I48 n1_m1_0_230400 0 1.612708e-07
I49 n1_m1_0_235200 0 1.589458e-07
I50 n1_m1_0_240000 0 2.325847e-07
I51 n1_m1_0_244800 0 1.549405e-07
I52 n1_m1_0_249600 0 2.385979e-07
I53 n1_m1_0_254400 0 1.584093e-07
I54 n1_m1_0_259200 0 1.549405e-07
I55 n1_m1_0_264000 0 2.324108e-07
I56 n1_m1_0_268800 0 1.550729e-07
I57 n1_m1_0_273600 0 2.346956e-07
I58 n1_m1_0_278400 0 1.573664e-07
I59 n1_m1_0_283200 0 1.557229e-07
I60 n1_m1_0_288000 0 2.325791e-07
I61 n1_m1_0_292800 0 1.620441e-07
I62 n1_m1_0_297600 0 2.548668e-07
I63 n1_m1_0_302400 0 1.669130e-07
I64 n1_m1_0_307200 0 1.555970e-07
I65 n1_m1_0_312000 0 2.351039e-07
I66 n1_m1_0_316800 0 1.574681e-07
I67 n1_m1_0_321600 0 2.448637e-07
I68 n1_m1_0_326400 0 1.635841e-07
I69 n1_m1_0_331200 0 1.518351e-07
I70 n1_m1_0_336000 0 2.310028e-07
I71 n1_m1_0_340800 0 1.609785e-07
I72 n1_m1_0_345600 0 2.467581e-07
I73 n1_m1_0_350400 0 1.605910e-07
I74 n1_m1_0_355200 0 1.590274e-07
I75 n1_m1_0_360000 0 2.305981e-07
I76 n1_m1_0_364800 0 1.542081e-07
I77 n1_m1_0_369600 0 2.302084e-07
I78 n1_m1_0_374400 0 1.529449e-07
I79 n1_m1_0_379200 0 1.578903e-07
I80 n1_m1_0_384000 0 2.302100e-07
I81 n1_m1_0_388800 0 1.470096e-07
I82 n1_m1_0_393600 0 2.327387e-07
I83 n1_m1_0_398400 0 1.612414e-07
I84 n1_m1_0_403200 0 1.538109e-07
I85 n1_m1_0_408000 0 2.224176e-07
I86 n1_m1_0_412800 0 1.484211e-07
I87 n1_m1_0_417600 0 2.239391e-07
I88 n1_m1_0_422400 0 1.506539e-07
I89 n1_m1_0_427200 0 1.540981e-07
I90 n1_m1_0_432000 0 2.354926e-07
I91 n1_m1_0_436800 0 1.497037e-07
I92 n1_m1_0_441600 0 2.333213e-07
I93 n1_m1_0_446400 0 1.456968e-07
I94 n1_m1_0_451200 0 1.416163e-07
I95 n1_m1_0_456000 0 2.371640e-07
I96 n1_m1_0_460800 0 1.557080e-07
I97 n1_m1_0_465600 0 2.262542e-07
I98 n1_m1_0_470400 0 1.529807e-07
I99 n1_m1_0_475200 0 1.479373e-07
I100 n1_m1_0_480000 0 2.172672e-07
I101 n1_m1_0_484800 0 1.433071e-07
I102 n1_m1_0_489600 0 2.622239e-07
I103 n1_m1_0_494400 0 2.696140e-07
I104 n1_m1_4800_0 0 7.968896e-08
I105 n1_m1_4800_4800 0 7.905556e-08
I106 n1_m1_4800_9600 0 1.164763e-07
I107 n1_m1_4800_14400 0 7.561744e-08
I108 n1_m1_4800_19200 0 7.561744e-08
I109 n1_m1_4800_24000 0 1.145909e-07
I110 n1_m1_4800_28800 0 7.692703e-08
I111 n1_m1_4800_33600 0 1.151746e-07
I112 n1_m1_4800_38400 0 7.637693e-08
I113 n1_m1_4800_43200 0 7.669143e-08
I114 n1_m1_4800_48000 0 1.179329e-07
I115 n1_m1_4800_52800 0 7.894849e-08
I116 n1_m1_4800_57600 0 1.207196e-07
I117 n1_m1_4800_62400 0 8.262550e-08
I118 n1_m1_4800_67200 0 8.041000e-08
I119 n1_m1_4800_72000 0 1.199177e-07
I120 n1_m1_4800_76800 0 7.994513e-08
I121 n1_m1_4800_81600 0 1.188450e-07
I122 n1_m1_4800_86400 0 7.894849e-08
I123 n1_m1_4800_91200 0 7.800629e-08
I124 n1_m1_4800_96000 0 1.132195e-07
I125 n1_m1_4800_100800 0 7.661408e-08
I126 n1_m1_4800_105600 0 1.149211e-07
I127 n1_m1_4800_110400 0 7.594376e-08
I128 n1_m1_4800_115200 0 7.427967e-08
I129 n1_m1_4800_120000 0 1.116101e-07
I130 n1_m1_4800_124800 0 7.699200e-08
I131 n1_m1_4800_129600 0 1.174145e-07
I132 n1_m1_4800_134400 0 7.994513e-08
I133 n1_m1_4800_139200 0 7.994513e-08
I134 n1_m1_4800_144000 0 1.195872e-07
I135 n1_m1_4800_148800 0 7.784744e-08
I136 n1_m1_4800_153600 0 1.172139e-07
I137 n1_m1_4800_158400 0 7.749066e-08
I138 n1_m1_4800_163200 0 7.661408e-08
I139 n1_m1_4800_168000 0 1.164261e-07
I140 n1_m1_4800_172800 0 8.316247e-08
I141 n1_m1_4800_177600 0 1.223658e-07
I142 n1_m1_4800_182400 0 7.747025e-08
I143 n1_m1_4800_187200 0 7.921939e-08
I144 n1_m1_4800_192000 0 1.199177e-07
I145 n1_m1_4800_196800 0 7.994513e-08
I146 n1_m1_4800_201600 0 1.199177e-07
I147 n1_m1_4800_206400 0 7.994513e-08
I148 n1_m1_4800_211200 0 7.994513e-08
I149 n1_m1_4800_216000 0 1.204480e-07
I150 n1_m1_4800_220800 0 8.224960e-08
I151 n1_m1_4800_225600 0 1.249143e-07
I152 n1_m1_4800_230400 0 8.263070e-08
I153 n1_m1_4800_235200 0 8.010901e-08
I154 n1_m1_4800_240000 0 1.199177e-07
I155 n1_m1_4800_244800 0 7.994513e-08
I156 n1_m1_4800_249600 0 1.199177e-07
I157 n1_m1_4800_254400 0 7.994513e-08
I158 n1_m1_4800_259200 0 8.027134e-08
I159 n1_m1_4800_264000 0 1.214127e-07
I160 n1_m1_4800_268800 0 8.119929e-08
I161 n1_m1_4800_273600 0 1.258574e-07
I162 n1_m1_4800_278400 0 8.208841e-08
I163 n1_m1_4800_283200 0 7.960400e-08
I164 n1_m1_4800_288000 0 1.219941e-07
I165 n1_m1_4800_292800 0 8.352593e-08
I166 n1_m1_4800_297600 0 1.276196e-07
I167 n1_m1_4800_302400 0 8.461395e-08
I168 n1_m1_4800_307200 0 8.306236e-08
I169 n1_m1_4800_312000 0 1.275775e-07
I170 n1_m1_4800_316800 0 8.150795e-08
I171 n1_m1_4800_321600 0 1.210214e-07
I172 n1_m1_4800_326400 0 8.488911e-08
I173 n1_m1_4800_331200 0 8.635106e-08
I174 n1_m1_4800_336000 0 1.289872e-07
I175 n1_m1_4800_340800 0 8.351605e-08
I176 n1_m1_4800_345600 0 1.193513e-07
I177 n1_m1_4800_350400 0 7.994513e-08
I178 n1_m1_4800_355200 0 7.964278e-08
I179 n1_m1_4800_360000 0 1.166809e-07
I180 n1_m1_4800_364800 0 7.894668e-08
I181 n1_m1_4800_369600 0 1.169153e-07
I182 n1_m1_4800_374400 0 7.587632e-08
I183 n1_m1_4800_379200 0 7.729680e-08
I184 n1_m1_4800_384000 0 1.149501e-07
I185 n1_m1_4800_388800 0 7.488437e-08
I186 n1_m1_4800_393600 0 1.195752e-07
I187 n1_m1_4800_398400 0 8.289073e-08
I188 n1_m1_4800_403200 0 8.003672e-08
I189 n1_m1_4800_408000 0 1.163470e-07
I190 n1_m1_4800_412800 0 7.706478e-08
I191 n1_m1_4800_417600 0 1.178809e-07
I192 n1_m1_4800_422400 0 7.709239e-08
I193 n1_m1_4800_427200 0 7.829035e-08
I194 n1_m1_4800_432000 0 1.177055e-07
I195 n1_m1_4800_436800 0 7.492117e-08
I196 n1_m1_4800_441600 0 1.133254e-07
I197 n1_m1_4800_446400 0 7.474977e-08
I198 n1_m1_4800_451200 0 7.360524e-08
I199 n1_m1_4800_456000 0 1.117735e-07
I200 n1_m1_4800_460800 0 7.586360e-08
I201 n1_m1_4800_465600 0 1.141486e-07
I202 n1_m1_4800_470400 0 7.556775e-08
I203 n1_m1_4800_475200 0 7.455502e-08
I204 n1_m1_4800_480000 0 1.097423e-07
I205 n1_m1_4800_484800 0 6.856740e-08
I206 n1_m1_4800_489600 0 1.054479e-07
I207 n1_m1_4800_494400 0 7.896783e-08
I208 n1_m1_9600_0 0 2.345344e-07
I209 n1_m1_9600_4800 0 2.304705e-07
I210 n1_m1_9600_9600 0 3.366560e-07
I211 n1_m1_9600_14400 0 2.204712e-07
I212 n1_m1_9600_19200 0 2.204712e-07
I213 n1_m1_9600_24000 0 3.379649e-07
I214 n1_m1_9600_28800 0 2.277056e-07
I215 n1_m1_9600_33600 0 3.312811e-07
I216 n1_m1_9600_38400 0 2.247201e-07
I217 n1_m1_9600_43200 0 2.289913e-07
I218 n1_m1_9600_48000 0 3.455659e-07
I219 n1_m1_9600_52800 0 2.304643e-07
I220 n1_m1_9600_57600 0 3.479358e-07
I221 n1_m1_9600_62400 0 2.463186e-07
I222 n1_m1_9600_67200 0 2.445796e-07
I223 n1_m1_9600_72000 0 3.635678e-07
I224 n1_m1_9600_76800 0 2.377013e-07
I225 n1_m1_9600_81600 0 3.480175e-07
I226 n1_m1_9600_86400 0 2.304643e-07
I227 n1_m1_9600_91200 0 2.302132e-07
I228 n1_m1_9600_96000 0 3.443099e-07
I229 n1_m1_9600_100800 0 2.298422e-07
I230 n1_m1_9600_105600 0 3.447634e-07
I231 n1_m1_9600_110400 0 2.307815e-07
I232 n1_m1_9600_115200 0 2.331131e-07
I233 n1_m1_9600_120000 0 3.500187e-07
I234 n1_m1_9600_124800 0 2.380802e-07
I235 n1_m1_9600_129600 0 3.590860e-07
I236 n1_m1_9600_134400 0 2.398354e-07
I237 n1_m1_9600_139200 0 2.398354e-07
I238 n1_m1_9600_144000 0 3.596650e-07
I239 n1_m1_9600_148800 0 2.392764e-07
I240 n1_m1_9600_153600 0 3.536022e-07
I241 n1_m1_9600_158400 0 2.325069e-07
I242 n1_m1_9600_163200 0 2.362757e-07
I243 n1_m1_9600_168000 0 3.583188e-07
I244 n1_m1_9600_172800 0 2.448597e-07
I245 n1_m1_9600_177600 0 3.584517e-07
I246 n1_m1_9600_182400 0 2.344002e-07
I247 n1_m1_9600_187200 0 2.385063e-07
I248 n1_m1_9600_192000 0 3.611680e-07
I249 n1_m1_9600_196800 0 2.437283e-07
I250 n1_m1_9600_201600 0 3.652211e-07
I251 n1_m1_9600_206400 0 2.404099e-07
I252 n1_m1_9600_211200 0 2.398354e-07
I253 n1_m1_9600_216000 0 3.647397e-07
I254 n1_m1_9600_220800 0 2.495550e-07
I255 n1_m1_9600_225600 0 3.747428e-07
I256 n1_m1_9600_230400 0 2.486465e-07
I257 n1_m1_9600_235200 0 2.432193e-07
I258 n1_m1_9600_240000 0 3.626180e-07
I259 n1_m1_9600_244800 0 2.437283e-07
I260 n1_m1_9600_249600 0 3.607263e-07
I261 n1_m1_9600_254400 0 2.398354e-07
I262 n1_m1_9600_259200 0 2.429026e-07
I263 n1_m1_9600_264000 0 3.738097e-07
I264 n1_m1_9600_268800 0 2.493771e-07
I265 n1_m1_9600_273600 0 3.767550e-07
I266 n1_m1_9600_278400 0 2.544745e-07
I267 n1_m1_9600_283200 0 2.579555e-07
I268 n1_m1_9600_288000 0 3.857044e-07
I269 n1_m1_9600_292800 0 2.472420e-07
I270 n1_m1_9600_297600 0 3.664528e-07
I271 n1_m1_9600_302400 0 2.460355e-07
I272 n1_m1_9600_307200 0 2.536268e-07
I273 n1_m1_9600_312000 0 3.896224e-07
I274 n1_m1_9600_316800 0 2.459560e-07
I275 n1_m1_9600_321600 0 3.621341e-07
I276 n1_m1_9600_326400 0 2.491219e-07
I277 n1_m1_9600_331200 0 2.514525e-07
I278 n1_m1_9600_336000 0 3.744389e-07
I279 n1_m1_9600_340800 0 2.487934e-07
I280 n1_m1_9600_345600 0 3.624794e-07
I281 n1_m1_9600_350400 0 2.437283e-07
I282 n1_m1_9600_355200 0 2.436477e-07
I283 n1_m1_9600_360000 0 3.647299e-07
I284 n1_m1_9600_364800 0 2.434622e-07
I285 n1_m1_9600_369600 0 3.612317e-07
I286 n1_m1_9600_374400 0 2.424213e-07
I287 n1_m1_9600_379200 0 2.402428e-07
I288 n1_m1_9600_384000 0 3.506997e-07
I289 n1_m1_9600_388800 0 2.544742e-07
I290 n1_m1_9600_393600 0 4.274673e-07
I291 n1_m1_9600_398400 0 2.422399e-07
I292 n1_m1_9600_403200 0 2.338443e-07
I293 n1_m1_9600_408000 0 3.584405e-07
I294 n1_m1_9600_412800 0 2.351950e-07
I295 n1_m1_9600_417600 0 3.560231e-07
I296 n1_m1_9600_422400 0 2.363642e-07
I297 n1_m1_9600_427200 0 2.347685e-07
I298 n1_m1_9600_432000 0 3.472994e-07
I299 n1_m1_9600_436800 0 2.378468e-07
I300 n1_m1_9600_441600 0 3.409220e-07
I301 n1_m1_9600_446400 0 2.300386e-07
I302 n1_m1_9600_451200 0 2.267716e-07
I303 n1_m1_9600_456000 0 3.263756e-07
I304 n1_m1_9600_460800 0 2.228053e-07
I305 n1_m1_9600_465600 0 3.374998e-07
I306 n1_m1_9600_470400 0 2.206516e-07
I307 n1_m1_9600_475200 0 2.247264e-07
I308 n1_m1_9600_480000 0 3.421807e-07
I309 n1_m1_9600_484800 0 2.118699e-07
I310 n1_m1_9600_489600 0 3.085000e-07
I311 n1_m1_9600_494400 0 2.167033e-07
I312 n1_m1_14400_0 0 1.491480e-07
I313 n1_m1_14400_4800 0 1.487617e-07
I314 n1_m1_14400_9600 0 2.200902e-07
I315 n1_m1_14400_14400 0 1.465661e-07
I316 n1_m1_14400_19200 0 1.465661e-07
I317 n1_m1_14400_24000 0 2.213140e-07
I318 n1_m1_14400_28800 0 1.515158e-07
I319 n1_m1_14400_33600 0 2.229817e-07
I320 n1_m1_14400_38400 0 1.538048e-07
I321 n1_m1_14400_43200 0 1.568655e-07
I322 n1_m1_14400_48000 0 2.397928e-07
I323 n1_m1_14400_52800 0 1.573084e-07
I324 n1_m1_14400_57600 0 2.371532e-07
I325 n1_m1_14400_62400 0 1.690077e-07
I326 n1_m1_14400_67200 0 1.741433e-07
I327 n1_m1_14400_72000 0 2.586043e-07
I328 n1_m1_14400_76800 0 1.643985e-07
I329 n1_m1_14400_81600 0 2.384000e-07
I330 n1_m1_14400_86400 0 1.611059e-07
I331 n1_m1_14400_91200 0 1.613886e-07
I332 n1_m1_14400_96000 0 2.392726e-07
I333 n1_m1_14400_100800 0 1.573084e-07
I334 n1_m1_14400_105600 0 2.359625e-07
I335 n1_m1_14400_110400 0 1.580497e-07
I336 n1_m1_14400_115200 0 1.598903e-07
I337 n1_m1_14400_120000 0 2.430430e-07
I338 n1_m1_14400_124800 0 1.606481e-07
I339 n1_m1_14400_129600 0 2.398354e-07
I340 n1_m1_14400_134400 0 1.598903e-07
I341 n1_m1_14400_139200 0 1.598903e-07
I342 n1_m1_14400_144000 0 2.398354e-07
I343 n1_m1_14400_148800 0 1.598903e-07
I344 n1_m1_14400_153600 0 2.382956e-07
I345 n1_m1_14400_158400 0 1.691131e-07
I346 n1_m1_14400_163200 0 1.991983e-07
I347 n1_m1_14400_168000 0 2.791585e-07
I348 n1_m1_14400_172800 0 1.626945e-07
I349 n1_m1_14400_177600 0 2.361012e-07
I350 n1_m1_14400_182400 0 1.653544e-07
I351 n1_m1_14400_187200 0 1.616682e-07
I352 n1_m1_14400_192000 0 2.407738e-07
I353 n1_m1_14400_196800 0 1.624722e-07
I354 n1_m1_14400_201600 0 2.434620e-07
I355 n1_m1_14400_206400 0 1.602713e-07
I356 n1_m1_14400_211200 0 1.603941e-07
I357 n1_m1_14400_216000 0 2.468421e-07
I358 n1_m1_14400_220800 0 1.665524e-07
I359 n1_m1_14400_225600 0 2.498285e-07
I360 n1_m1_14400_230400 0 1.665524e-07
I361 n1_m1_14400_235200 0 1.651678e-07
I362 n1_m1_14400_240000 0 2.447383e-07
I363 n1_m1_14400_244800 0 1.635782e-07
I364 n1_m1_14400_249600 0 2.404809e-07
I365 n1_m1_14400_254400 0 1.598903e-07
I366 n1_m1_14400_259200 0 1.620708e-07
I367 n1_m1_14400_264000 0 2.463382e-07
I368 n1_m1_14400_268800 0 1.619571e-07
I369 n1_m1_14400_273600 0 2.348187e-07
I370 n1_m1_14400_278400 0 1.601351e-07
I371 n1_m1_14400_283200 0 1.650540e-07
I372 n1_m1_14400_288000 0 2.474211e-07
I373 n1_m1_14400_292800 0 1.647334e-07
I374 n1_m1_14400_297600 0 2.815345e-07
I375 n1_m1_14400_302400 0 2.982171e-07
I376 n1_m1_14400_307200 0 4.131015e-07
I377 n1_m1_14400_312000 0 4.097560e-07
I378 n1_m1_14400_316800 0 2.457606e-07
I379 n1_m1_14400_321600 0 3.833608e-07
I380 n1_m1_14400_326400 0 2.050659e-07
I381 n1_m1_14400_331200 0 1.727352e-07
I382 n1_m1_14400_336000 0 2.507965e-07
I383 n1_m1_14400_340800 0 1.747127e-07
I384 n1_m1_14400_345600 0 2.616554e-07
I385 n1_m1_14400_350400 0 1.712102e-07
I386 n1_m1_14400_355200 0 1.706326e-07
I387 n1_m1_14400_360000 0 2.537285e-07
I388 n1_m1_14400_364800 0 1.665524e-07
I389 n1_m1_14400_369600 0 2.467091e-07
I390 n1_m1_14400_374400 0 1.617427e-07
I391 n1_m1_14400_379200 0 1.583364e-07
I392 n1_m1_14400_384000 0 2.600351e-07
I393 n1_m1_14400_388800 0 3.597226e-07
I394 n1_m1_14400_393600 0 7.469657e-07
I395 n1_m1_14400_398400 0 3.543556e-07
I396 n1_m1_14400_403200 0 2.107847e-07
I397 n1_m1_14400_408000 0 2.459557e-07
I398 n1_m1_14400_412800 0 1.639705e-07
I399 n1_m1_14400_417600 0 2.459557e-07
I400 n1_m1_14400_422400 0 1.639705e-07
I401 n1_m1_14400_427200 0 1.605859e-07
I402 n1_m1_14400_432000 0 2.384059e-07
I403 n1_m1_14400_436800 0 1.709273e-07
I404 n1_m1_14400_441600 0 2.483311e-07
I405 n1_m1_14400_446400 0 1.630632e-07
I406 n1_m1_14400_451200 0 1.594622e-07
I407 n1_m1_14400_456000 0 2.269650e-07
I408 n1_m1_14400_460800 0 1.482655e-07
I409 n1_m1_14400_465600 0 2.245842e-07
I410 n1_m1_14400_470400 0 1.433830e-07
I411 n1_m1_14400_475200 0 1.431681e-07
I412 n1_m1_14400_480000 0 2.301593e-07
I413 n1_m1_14400_484800 0 1.493858e-07
I414 n1_m1_14400_489600 0 2.212585e-07
I415 n1_m1_14400_494400 0 1.579639e-07
I416 n1_m1_19200_0 0 1.465661e-07
I417 n1_m1_19200_4800 0 1.465661e-07
I418 n1_m1_19200_9600 0 2.198491e-07
I419 n1_m1_19200_14400 0 1.465661e-07
I420 n1_m1_19200_19200 0 1.465661e-07
I421 n1_m1_19200_24000 0 2.253629e-07
I422 n1_m1_19200_28800 0 1.526127e-07
I423 n1_m1_19200_33600 0 2.280966e-07
I424 n1_m1_19200_38400 0 1.583050e-07
I425 n1_m1_19200_43200 0 1.601110e-07
I426 n1_m1_19200_48000 0 2.475891e-07
I427 n1_m1_19200_52800 0 1.625382e-07
I428 n1_m1_19200_57600 0 2.406447e-07
I429 n1_m1_19200_62400 0 1.682447e-07
I430 n1_m1_19200_67200 0 1.751806e-07
I431 n1_m1_19200_72000 0 2.658144e-07
I432 n1_m1_19200_76800 0 1.672229e-07
I433 n1_m1_19200_81600 0 2.412659e-07
I434 n1_m1_19200_86400 0 1.637214e-07
I435 n1_m1_19200_91200 0 1.703485e-07
I436 n1_m1_19200_96000 0 2.545805e-07
I437 n1_m1_19200_100800 0 1.653660e-07
I438 n1_m1_19200_105600 0 2.409280e-07
I439 n1_m1_19200_110400 0 1.598903e-07
I440 n1_m1_19200_115200 0 1.598903e-07
I441 n1_m1_19200_120000 0 2.450728e-07
I442 n1_m1_19200_124800 0 1.611277e-07
I443 n1_m1_19200_129600 0 2.416606e-07
I444 n1_m1_19200_134400 0 1.641577e-07
I445 n1_m1_19200_139200 0 1.620926e-07
I446 n1_m1_19200_144000 0 2.398354e-07
I447 n1_m1_19200_148800 0 1.598903e-07
I448 n1_m1_19200_153600 0 2.398354e-07
I449 n1_m1_19200_158400 0 1.738671e-07
I450 n1_m1_19200_163200 0 2.254082e-07
I451 n1_m1_19200_168000 0 3.004315e-07
I452 n1_m1_19200_172800 0 1.622379e-07
I453 n1_m1_19200_177600 0 2.399426e-07
I454 n1_m1_19200_182400 0 1.666191e-07
I455 n1_m1_19200_187200 0 1.618635e-07
I456 n1_m1_19200_192000 0 2.398354e-07
I457 n1_m1_19200_196800 0 1.598903e-07
I458 n1_m1_19200_201600 0 2.398354e-07
I459 n1_m1_19200_206400 0 1.598903e-07
I460 n1_m1_19200_211200 0 1.601860e-07
I461 n1_m1_19200_216000 0 2.454120e-07
I462 n1_m1_19200_220800 0 1.665524e-07
I463 n1_m1_19200_225600 0 2.498285e-07
I464 n1_m1_19200_230400 0 1.665524e-07
I465 n1_m1_19200_235200 0 1.651678e-07
I466 n1_m1_19200_240000 0 2.417476e-07
I467 n1_m1_19200_244800 0 1.605394e-07
I468 n1_m1_19200_249600 0 2.409922e-07
I469 n1_m1_19200_254400 0 1.641577e-07
I470 n1_m1_19200_259200 0 1.663383e-07
I471 n1_m1_19200_264000 0 2.505309e-07
I472 n1_m1_19200_268800 0 1.636427e-07
I473 n1_m1_19200_273600 0 2.373471e-07
I474 n1_m1_19200_278400 0 1.586160e-07
I475 n1_m1_19200_283200 0 1.598903e-07
I476 n1_m1_19200_288000 0 2.408186e-07
I477 n1_m1_19200_292800 0 1.669938e-07
I478 n1_m1_19200_297600 0 3.131142e-07
I479 n1_m1_19200_302400 0 3.916329e-07
I480 n1_m1_19200_307200 0 5.579152e-07
I481 n1_m1_19200_312000 0 5.267585e-07
I482 n1_m1_19200_316800 0 3.498141e-07
I483 n1_m1_19200_321600 0 5.952616e-07
I484 n1_m1_19200_326400 0 2.860651e-07
I485 n1_m1_19200_331200 0 1.943751e-07
I486 n1_m1_19200_336000 0 2.665054e-07
I487 n1_m1_19200_340800 0 1.841440e-07
I488 n1_m1_19200_345600 0 2.755405e-07
I489 n1_m1_19200_350400 0 1.779323e-07
I490 n1_m1_19200_355200 0 1.737586e-07
I491 n1_m1_19200_360000 0 2.561963e-07
I492 n1_m1_19200_364800 0 1.665524e-07
I493 n1_m1_19200_369600 0 2.454805e-07
I494 n1_m1_19200_374400 0 1.627195e-07
I495 n1_m1_19200_379200 0 1.592080e-07
I496 n1_m1_19200_384000 0 2.823283e-07
I497 n1_m1_19200_388800 0 4.559409e-07
I498 n1_m1_19200_393600 0 9.681126e-07
I499 n1_m1_19200_398400 0 4.572096e-07
I500 n1_m1_19200_403200 0 2.387654e-07
I501 n1_m1_19200_408000 0 2.562298e-07
I502 n1_m1_19200_412800 0 1.711755e-07
I503 n1_m1_19200_417600 0 2.619497e-07
I504 n1_m1_19200_422400 0 1.730393e-07
I505 n1_m1_19200_427200 0 1.696033e-07
I506 n1_m1_19200_432000 0 2.533735e-07
I507 n1_m1_19200_436800 0 1.777952e-07
I508 n1_m1_19200_441600 0 3.273740e-07
I509 n1_m1_19200_446400 0 2.156884e-07
I510 n1_m1_19200_451200 0 1.817448e-07
I511 n1_m1_19200_456000 0 2.453011e-07
I512 n1_m1_19200_460800 0 1.599840e-07
I513 n1_m1_19200_465600 0 2.372285e-07
I514 n1_m1_19200_470400 0 1.465747e-07
I515 n1_m1_19200_475200 0 1.444167e-07
I516 n1_m1_19200_480000 0 2.208687e-07
I517 n1_m1_19200_484800 0 1.436978e-07
I518 n1_m1_19200_489600 0 2.175977e-07
I519 n1_m1_19200_494400 0 1.577633e-07
I520 n1_m1_24000_0 0 2.198491e-07
I521 n1_m1_24000_4800 0 2.198491e-07
I522 n1_m1_24000_9600 0 3.297737e-07
I523 n1_m1_24000_14400 0 2.207463e-07
I524 n1_m1_24000_19200 0 2.253629e-07
I525 n1_m1_24000_24000 0 3.471338e-07
I526 n1_m1_24000_28800 0 2.363461e-07
I527 n1_m1_24000_33600 0 3.492520e-07
I528 n1_m1_24000_38400 0 2.405357e-07
I529 n1_m1_24000_43200 0 2.488808e-07
I530 n1_m1_24000_48000 0 3.786742e-07
I531 n1_m1_24000_52800 0 2.513646e-07
I532 n1_m1_24000_57600 0 3.678274e-07
I533 n1_m1_24000_62400 0 2.431871e-07
I534 n1_m1_24000_67200 0 2.519872e-07
I535 n1_m1_24000_72000 0 3.886055e-07
I536 n1_m1_24000_76800 0 2.468125e-07
I537 n1_m1_24000_81600 0 3.619504e-07
I538 n1_m1_24000_86400 0 2.438659e-07
I539 n1_m1_24000_91200 0 2.570578e-07
I540 n1_m1_24000_96000 0 3.976653e-07
I541 n1_m1_24000_100800 0 2.541228e-07
I542 n1_m1_24000_105600 0 3.641294e-07
I543 n1_m1_24000_110400 0 2.398354e-07
I544 n1_m1_24000_115200 0 2.398354e-07
I545 n1_m1_24000_120000 0 3.669031e-07
I546 n1_m1_24000_124800 0 2.473085e-07
I547 n1_m1_24000_129600 0 3.666832e-07
I548 n1_m1_24000_134400 0 2.498285e-07
I549 n1_m1_24000_139200 0 2.457014e-07
I550 n1_m1_24000_144000 0 3.674527e-07
I551 n1_m1_24000_148800 0 2.417133e-07
I552 n1_m1_24000_153600 0 3.607547e-07
I553 n1_m1_24000_158400 0 2.493831e-07
I554 n1_m1_24000_163200 0 2.783391e-07
I555 n1_m1_24000_168000 0 4.042993e-07
I556 n1_m1_24000_172800 0 2.503938e-07
I557 n1_m1_24000_177600 0 3.652559e-07
I558 n1_m1_24000_182400 0 2.421548e-07
I559 n1_m1_24000_187200 0 2.403163e-07
I560 n1_m1_24000_192000 0 3.597531e-07
I561 n1_m1_24000_196800 0 2.392618e-07
I562 n1_m1_24000_201600 0 3.575558e-07
I563 n1_m1_24000_206400 0 2.385308e-07
I564 n1_m1_24000_211200 0 2.396398e-07
I565 n1_m1_24000_216000 0 3.650707e-07
I566 n1_m1_24000_220800 0 2.498285e-07
I567 n1_m1_24000_225600 0 3.747428e-07
I568 n1_m1_24000_230400 0 2.495447e-07
I569 n1_m1_24000_235200 0 2.466633e-07
I570 n1_m1_24000_240000 0 3.600528e-07
I571 n1_m1_24000_244800 0 2.398354e-07
I572 n1_m1_24000_249600 0 3.740254e-07
I573 n1_m1_24000_254400 0 2.595175e-07
I574 n1_m1_24000_259200 0 2.678017e-07
I575 n1_m1_24000_264000 0 4.286389e-07
I576 n1_m1_24000_268800 0 2.893520e-07
I577 n1_m1_24000_273600 0 4.208576e-07
I578 n1_m1_24000_278400 0 2.681245e-07
I579 n1_m1_24000_283200 0 2.515454e-07
I580 n1_m1_24000_288000 0 3.719738e-07
I581 n1_m1_24000_292800 0 2.525585e-07
I582 n1_m1_24000_297600 0 4.193935e-07
I583 n1_m1_24000_302400 0 3.714355e-07
I584 n1_m1_24000_307200 0 4.557004e-07
I585 n1_m1_24000_312000 0 5.132385e-07
I586 n1_m1_24000_316800 0 3.510412e-07
I587 n1_m1_24000_321600 0 6.257815e-07
I588 n1_m1_24000_326400 0 3.341978e-07
I589 n1_m1_24000_331200 0 2.711006e-07
I590 n1_m1_24000_336000 0 3.965062e-07
I591 n1_m1_24000_340800 0 2.714309e-07
I592 n1_m1_24000_345600 0 4.056121e-07
I593 n1_m1_24000_350400 0 2.675086e-07
I594 n1_m1_24000_355200 0 2.588124e-07
I595 n1_m1_24000_360000 0 3.767726e-07
I596 n1_m1_24000_364800 0 2.447463e-07
I597 n1_m1_24000_369600 0 3.622192e-07
I598 n1_m1_24000_374400 0 2.477273e-07
I599 n1_m1_24000_379200 0 2.484386e-07
I600 n1_m1_24000_384000 0 3.918385e-07
I601 n1_m1_24000_388800 0 3.632646e-07
I602 n1_m1_24000_393600 0 7.175945e-07
I603 n1_m1_24000_398400 0 3.733042e-07
I604 n1_m1_24000_403200 0 2.775950e-07
I605 n1_m1_24000_408000 0 3.835370e-07
I606 n1_m1_24000_412800 0 2.591896e-07
I607 n1_m1_24000_417600 0 4.009296e-07
I608 n1_m1_24000_422400 0 2.642571e-07
I609 n1_m1_24000_427200 0 2.590775e-07
I610 n1_m1_24000_432000 0 3.973666e-07
I611 n1_m1_24000_436800 0 3.925062e-07
I612 n1_m1_24000_441600 0 1.403102e-06
I613 n1_m1_24000_446400 0 1.010544e-06
I614 n1_m1_24000_451200 0 6.066429e-07
I615 n1_m1_24000_456000 0 4.765640e-07
I616 n1_m1_24000_460800 0 2.660966e-07
I617 n1_m1_24000_465600 0 3.722858e-07
I618 n1_m1_24000_470400 0 2.286179e-07
I619 n1_m1_24000_475200 0 2.212251e-07
I620 n1_m1_24000_480000 0 3.314023e-07
I621 n1_m1_24000_484800 0 2.173352e-07
I622 n1_m1_24000_489600 0 3.212480e-07
I623 n1_m1_24000_494400 0 2.270982e-07
I624 n1_m1_28800_0 0 1.477240e-07
I625 n1_m1_28800_4800 0 1.467335e-07
I626 n1_m1_28800_9600 0 2.198491e-07
I627 n1_m1_28800_14400 0 1.495975e-07
I628 n1_m1_28800_19200 0 1.536110e-07
I629 n1_m1_28800_24000 0 2.401625e-07
I630 n1_m1_28800_28800 0 1.659126e-07
I631 n1_m1_28800_33600 0 2.693297e-07
I632 n1_m1_28800_38400 0 2.177796e-07
I633 n1_m1_28800_43200 0 2.595669e-07
I634 n1_m1_28800_48000 0 3.488541e-07
I635 n1_m1_28800_52800 0 1.774744e-07
I636 n1_m1_28800_57600 0 2.575042e-07
I637 n1_m1_28800_62400 0 1.637367e-07
I638 n1_m1_28800_67200 0 1.670211e-07
I639 n1_m1_28800_72000 0 2.609925e-07
I640 n1_m1_28800_76800 0 1.687043e-07
I641 n1_m1_28800_81600 0 2.495978e-07
I642 n1_m1_28800_86400 0 1.682860e-07
I643 n1_m1_28800_91200 0 1.769577e-07
I644 n1_m1_28800_96000 0 2.688324e-07
I645 n1_m1_28800_100800 0 1.740643e-07
I646 n1_m1_28800_105600 0 2.511526e-07
I647 n1_m1_28800_110400 0 1.603378e-07
I648 n1_m1_28800_115200 0 1.619401e-07
I649 n1_m1_28800_120000 0 2.422951e-07
I650 n1_m1_28800_124800 0 1.640635e-07
I651 n1_m1_28800_129600 0 2.473522e-07
I652 n1_m1_28800_134400 0 1.649939e-07
I653 n1_m1_28800_139200 0 1.649194e-07
I654 n1_m1_28800_144000 0 2.473939e-07
I655 n1_m1_28800_148800 0 1.640853e-07
I656 n1_m1_28800_153600 0 2.432197e-07
I657 n1_m1_28800_158400 0 1.649361e-07
I658 n1_m1_28800_163200 0 1.651946e-07
I659 n1_m1_28800_168000 0 2.580087e-07
I660 n1_m1_28800_172800 0 1.815425e-07
I661 n1_m1_28800_177600 0 2.617835e-07
I662 n1_m1_28800_182400 0 1.637056e-07
I663 n1_m1_28800_187200 0 1.602298e-07
I664 n1_m1_28800_192000 0 2.409683e-07
I665 n1_m1_28800_196800 0 1.622896e-07
I666 n1_m1_28800_201600 0 2.385978e-07
I667 n1_m1_28800_206400 0 1.559422e-07
I668 n1_m1_28800_211200 0 1.596142e-07
I669 n1_m1_28800_216000 0 2.476836e-07
I670 n1_m1_28800_220800 0 1.670499e-07
I671 n1_m1_28800_225600 0 2.522993e-07
I672 n1_m1_28800_230400 0 1.669483e-07
I673 n1_m1_28800_235200 0 1.618908e-07
I674 n1_m1_28800_240000 0 2.410863e-07
I675 n1_m1_28800_244800 0 1.632983e-07
I676 n1_m1_28800_249600 0 2.581700e-07
I677 n1_m1_28800_254400 0 1.832284e-07
I678 n1_m1_28800_259200 0 1.949704e-07
I679 n1_m1_28800_264000 0 3.349583e-07
I680 n1_m1_28800_268800 0 2.391043e-07
I681 n1_m1_28800_273600 0 3.512406e-07
I682 n1_m1_28800_278400 0 2.050033e-07
I683 n1_m1_28800_283200 0 1.691246e-07
I684 n1_m1_28800_288000 0 2.521551e-07
I685 n1_m1_28800_292800 0 1.734135e-07
I686 n1_m1_28800_297600 0 2.730416e-07
I687 n1_m1_28800_302400 0 1.888610e-07
I688 n1_m1_28800_307200 0 1.863620e-07
I689 n1_m1_28800_312000 0 2.488467e-07
I690 n1_m1_28800_316800 0 1.635059e-07
I691 n1_m1_28800_321600 0 2.515421e-07
I692 n1_m1_28800_326400 0 1.717955e-07
I693 n1_m1_28800_331200 0 1.680436e-07
I694 n1_m1_28800_336000 0 2.590065e-07
I695 n1_m1_28800_340800 0 1.756912e-07
I696 n1_m1_28800_345600 0 2.562626e-07
I697 n1_m1_28800_350400 0 1.698420e-07
I698 n1_m1_28800_355200 0 1.671383e-07
I699 n1_m1_28800_360000 0 2.471524e-07
I700 n1_m1_28800_364800 0 1.597307e-07
I701 n1_m1_28800_369600 0 2.395307e-07
I702 n1_m1_28800_374400 0 1.624936e-07
I703 n1_m1_28800_379200 0 1.670639e-07
I704 n1_m1_28800_384000 0 2.478695e-07
I705 n1_m1_28800_388800 0 1.616947e-07
I706 n1_m1_28800_393600 0 2.541952e-07
I707 n1_m1_28800_398400 0 1.721857e-07
I708 n1_m1_28800_403200 0 1.699240e-07
I709 n1_m1_28800_408000 0 2.500700e-07
I710 n1_m1_28800_412800 0 1.684193e-07
I711 n1_m1_28800_417600 0 2.585336e-07
I712 n1_m1_28800_422400 0 1.717360e-07
I713 n1_m1_28800_427200 0 1.699331e-07
I714 n1_m1_28800_432000 0 2.980960e-07
I715 n1_m1_28800_436800 0 4.255279e-07
I716 n1_m1_28800_441600 0 1.574362e-06
I717 n1_m1_28800_446400 0 1.097184e-06
I718 n1_m1_28800_451200 0 6.372769e-07
I719 n1_m1_28800_456000 0 4.067890e-07
I720 n1_m1_28800_460800 0 1.847458e-07
I721 n1_m1_28800_465600 0 2.457025e-07
I722 n1_m1_28800_470400 0 1.496797e-07
I723 n1_m1_28800_475200 0 1.471720e-07
I724 n1_m1_28800_480000 0 2.288468e-07
I725 n1_m1_28800_484800 0 1.571983e-07
I726 n1_m1_28800_489600 0 2.322835e-07
I727 n1_m1_28800_494400 0 1.523917e-07
I728 n1_m1_33600_0 0 1.478134e-07
I729 n1_m1_33600_4800 0 1.467464e-07
I730 n1_m1_33600_9600 0 2.198491e-07
I731 n1_m1_33600_14400 0 1.496180e-07
I732 n1_m1_33600_19200 0 1.537001e-07
I733 n1_m1_33600_24000 0 2.415722e-07
I734 n1_m1_33600_28800 0 1.723236e-07
I735 n1_m1_33600_33600 0 3.091481e-07
I736 n1_m1_33600_38400 0 3.847931e-07
I737 n1_m1_33600_43200 0 5.664805e-07
I738 n1_m1_33600_48000 0 6.826998e-07
I739 n1_m1_33600_52800 0 1.961674e-07
I740 n1_m1_33600_57600 0 2.581817e-07
I741 n1_m1_33600_62400 0 1.675423e-07
I742 n1_m1_33600_67200 0 1.665228e-07
I743 n1_m1_33600_72000 0 2.498243e-07
I744 n1_m1_33600_76800 0 1.665707e-07
I745 n1_m1_33600_81600 0 2.498787e-07
I746 n1_m1_33600_86400 0 1.665858e-07
I747 n1_m1_33600_91200 0 1.675712e-07
I748 n1_m1_33600_96000 0 2.545603e-07
I749 n1_m1_33600_100800 0 1.819058e-07
I750 n1_m1_33600_105600 0 3.759110e-07
I751 n1_m1_33600_110400 0 1.889441e-07
I752 n1_m1_33600_115200 0 1.720983e-07
I753 n1_m1_33600_120000 0 2.525521e-07
I754 n1_m1_33600_124800 0 1.608493e-07
I755 n1_m1_33600_129600 0 2.398712e-07
I756 n1_m1_33600_134400 0 1.598903e-07
I757 n1_m1_33600_139200 0 1.598903e-07
I758 n1_m1_33600_144000 0 2.405747e-07
I759 n1_m1_33600_148800 0 1.644068e-07
I760 n1_m1_33600_153600 0 2.444955e-07
I761 n1_m1_33600_158400 0 1.599948e-07
I762 n1_m1_33600_163200 0 1.599135e-07
I763 n1_m1_33600_168000 0 2.422121e-07
I764 n1_m1_33600_172800 0 1.632932e-07
I765 n1_m1_33600_177600 0 2.438399e-07
I766 n1_m1_33600_182400 0 1.690235e-07
I767 n1_m1_33600_187200 0 1.665316e-07
I768 n1_m1_33600_192000 0 2.550399e-07
I769 n1_m1_33600_196800 0 1.745365e-07
I770 n1_m1_33600_201600 0 2.563448e-07
I771 n1_m1_33600_206400 0 1.611200e-07
I772 n1_m1_33600_211200 0 1.609410e-07
I773 n1_m1_33600_216000 0 2.495676e-07
I774 n1_m1_33600_220800 0 2.415119e-07
I775 n1_m1_33600_225600 0 7.422045e-07
I776 n1_m1_33600_230400 0 3.318892e-07
I777 n1_m1_33600_235200 0 1.793332e-07
I778 n1_m1_33600_240000 0 2.453862e-07
I779 n1_m1_33600_244800 0 1.708597e-07
I780 n1_m1_33600_249600 0 3.137279e-07
I781 n1_m1_33600_254400 0 2.341701e-07
I782 n1_m1_33600_259200 0 1.942278e-07
I783 n1_m1_33600_264000 0 2.526202e-07
I784 n1_m1_33600_268800 0 1.661844e-07
I785 n1_m1_33600_273600 0 2.508412e-07
I786 n1_m1_33600_278400 0 1.657230e-07
I787 n1_m1_33600_283200 0 1.665524e-07
I788 n1_m1_33600_288000 0 2.522834e-07
I789 n1_m1_33600_292800 0 1.727391e-07
I790 n1_m1_33600_297600 0 2.598217e-07
I791 n1_m1_33600_302400 0 1.732144e-07
I792 n1_m1_33600_307200 0 1.699023e-07
I793 n1_m1_33600_312000 0 2.573681e-07
I794 n1_m1_33600_316800 0 1.801360e-07
I795 n1_m1_33600_321600 0 2.486159e-07
I796 n1_m1_33600_326400 0 1.687324e-07
I797 n1_m1_33600_331200 0 1.673773e-07
I798 n1_m1_33600_336000 0 2.458971e-07
I799 n1_m1_33600_340800 0 1.697938e-07
I800 n1_m1_33600_345600 0 2.560329e-07
I801 n1_m1_33600_350400 0 1.694799e-07
I802 n1_m1_33600_355200 0 1.663283e-07
I803 n1_m1_33600_360000 0 2.483062e-07
I804 n1_m1_33600_364800 0 1.695853e-07
I805 n1_m1_33600_369600 0 2.444213e-07
I806 n1_m1_33600_374400 0 1.672069e-07
I807 n1_m1_33600_379200 0 1.710626e-07
I808 n1_m1_33600_384000 0 2.550609e-07
I809 n1_m1_33600_388800 0 1.674504e-07
I810 n1_m1_33600_393600 0 2.466220e-07
I811 n1_m1_33600_398400 0 1.665628e-07
I812 n1_m1_33600_403200 0 1.665971e-07
I813 n1_m1_33600_408000 0 2.500138e-07
I814 n1_m1_33600_412800 0 1.679454e-07
I815 n1_m1_33600_417600 0 2.538398e-07
I816 n1_m1_33600_422400 0 2.049528e-07
I817 n1_m1_33600_427200 0 3.736128e-07
I818 n1_m1_33600_432000 0 1.001483e-06
I819 n1_m1_33600_436800 0 7.768461e-07
I820 n1_m1_33600_441600 0 1.609357e-06
I821 n1_m1_33600_446400 0 8.889034e-07
I822 n1_m1_33600_451200 0 4.307190e-07
I823 n1_m1_33600_456000 0 2.917006e-07
I824 n1_m1_33600_460800 0 1.669871e-07
I825 n1_m1_33600_465600 0 2.384962e-07
I826 n1_m1_33600_470400 0 1.575217e-07
I827 n1_m1_33600_475200 0 1.572551e-07
I828 n1_m1_33600_480000 0 2.318436e-07
I829 n1_m1_33600_484800 0 1.496602e-07
I830 n1_m1_33600_489600 0 2.301412e-07
I831 n1_m1_33600_494400 0 1.524534e-07
I832 n1_m1_38400_0 0 1.465661e-07
I833 n1_m1_38400_4800 0 1.465661e-07
I834 n1_m1_38400_9600 0 2.199234e-07
I835 n1_m1_38400_14400 0 1.506955e-07
I836 n1_m1_38400_19200 0 1.532282e-07
I837 n1_m1_38400_24000 0 2.331598e-07
I838 n1_m1_38400_28800 0 1.620634e-07
I839 n1_m1_38400_33600 0 2.619708e-07
I840 n1_m1_38400_38400 0 2.646628e-07
I841 n1_m1_38400_43200 0 4.065553e-07
I842 n1_m1_38400_48000 0 5.138811e-07
I843 n1_m1_38400_52800 0 1.810383e-07
I844 n1_m1_38400_57600 0 2.516398e-07
I845 n1_m1_38400_62400 0 1.625184e-07
I846 n1_m1_38400_67200 0 1.620570e-07
I847 n1_m1_38400_72000 0 2.490828e-07
I848 n1_m1_38400_76800 0 1.693354e-07
I849 n1_m1_38400_81600 0 2.574438e-07
I850 n1_m1_38400_86400 0 1.716530e-07
I851 n1_m1_38400_91200 0 1.703535e-07
I852 n1_m1_38400_96000 0 3.998791e-07
I853 n1_m1_38400_100800 0 7.088669e-07
I854 n1_m1_38400_105600 0 1.153710e-06
I855 n1_m1_38400_110400 0 3.240331e-07
I856 n1_m1_38400_115200 0 1.784184e-07
I857 n1_m1_38400_120000 0 2.613207e-07
I858 n1_m1_38400_124800 0 1.661573e-07
I859 n1_m1_38400_129600 0 2.452792e-07
I860 n1_m1_38400_134400 0 1.598903e-07
I861 n1_m1_38400_139200 0 1.598903e-07
I862 n1_m1_38400_144000 0 2.460451e-07
I863 n1_m1_38400_148800 0 1.718708e-07
I864 n1_m1_38400_153600 0 2.696889e-07
I865 n1_m1_38400_158400 0 1.755088e-07
I866 n1_m1_38400_163200 0 1.633292e-07
I867 n1_m1_38400_168000 0 2.421004e-07
I868 n1_m1_38400_172800 0 1.709639e-07
I869 n1_m1_38400_177600 0 2.584771e-07
I870 n1_m1_38400_182400 0 1.648365e-07
I871 n1_m1_38400_187200 0 1.700232e-07
I872 n1_m1_38400_192000 0 2.660791e-07
I873 n1_m1_38400_196800 0 1.743154e-07
I874 n1_m1_38400_201600 0 2.459525e-07
I875 n1_m1_38400_206400 0 1.608826e-07
I876 n1_m1_38400_211200 0 1.640020e-07
I877 n1_m1_38400_216000 0 2.419099e-07
I878 n1_m1_38400_220800 0 4.517615e-07
I879 n1_m1_38400_225600 0 1.450820e-06
I880 n1_m1_38400_230400 0 6.700586e-07
I881 n1_m1_38400_235200 0 2.096450e-07
I882 n1_m1_38400_240000 0 2.533069e-07
I883 n1_m1_38400_244800 0 1.747719e-07
I884 n1_m1_38400_249600 0 5.064281e-07
I885 n1_m1_38400_254400 0 3.620602e-07
I886 n1_m1_38400_259200 0 2.432631e-07
I887 n1_m1_38400_264000 0 2.542648e-07
I888 n1_m1_38400_268800 0 1.829973e-07
I889 n1_m1_38400_273600 0 2.854896e-07
I890 n1_m1_38400_278400 0 1.690866e-07
I891 n1_m1_38400_283200 0 1.665524e-07
I892 n1_m1_38400_288000 0 2.508118e-07
I893 n1_m1_38400_292800 0 1.725790e-07
I894 n1_m1_38400_297600 0 2.598217e-07
I895 n1_m1_38400_302400 0 1.732144e-07
I896 n1_m1_38400_307200 0 1.687864e-07
I897 n1_m1_38400_312000 0 2.595361e-07
I898 n1_m1_38400_316800 0 1.780286e-07
I899 n1_m1_38400_321600 0 2.499349e-07
I900 n1_m1_38400_326400 0 1.673720e-07
I901 n1_m1_38400_331200 0 1.668338e-07
I902 n1_m1_38400_336000 0 2.542912e-07
I903 n1_m1_38400_340800 0 2.094556e-07
I904 n1_m1_38400_345600 0 3.086051e-07
I905 n1_m1_38400_350400 0 1.732653e-07
I906 n1_m1_38400_355200 0 1.667443e-07
I907 n1_m1_38400_360000 0 2.425216e-07
I908 n1_m1_38400_364800 0 1.690714e-07
I909 n1_m1_38400_369600 0 2.523414e-07
I910 n1_m1_38400_374400 0 1.737785e-07
I911 n1_m1_38400_379200 0 1.886602e-07
I912 n1_m1_38400_384000 0 2.948661e-07
I913 n1_m1_38400_388800 0 1.747688e-07
I914 n1_m1_38400_393600 0 2.447093e-07
I915 n1_m1_38400_398400 0 1.681325e-07
I916 n1_m1_38400_403200 0 1.733952e-07
I917 n1_m1_38400_408000 0 2.603925e-07
I918 n1_m1_38400_412800 0 1.675392e-07
I919 n1_m1_38400_417600 0 2.529143e-07
I920 n1_m1_38400_422400 0 2.074933e-07
I921 n1_m1_38400_427200 0 4.099388e-07
I922 n1_m1_38400_432000 0 1.152296e-06
I923 n1_m1_38400_436800 0 7.515644e-07
I924 n1_m1_38400_441600 0 9.418265e-07
I925 n1_m1_38400_446400 0 4.596863e-07
I926 n1_m1_38400_451200 0 2.706479e-07
I927 n1_m1_38400_456000 0 2.569676e-07
I928 n1_m1_38400_460800 0 1.640115e-07
I929 n1_m1_38400_465600 0 2.474183e-07
I930 n1_m1_38400_470400 0 1.737434e-07
I931 n1_m1_38400_475200 0 2.183891e-07
I932 n1_m1_38400_480000 0 2.753179e-07
I933 n1_m1_38400_484800 0 1.496812e-07
I934 n1_m1_38400_489600 0 2.231014e-07
I935 n1_m1_38400_494400 0 1.595943e-07
I936 n1_m1_43200_0 0 1.465661e-07
I937 n1_m1_43200_4800 0 1.465661e-07
I938 n1_m1_43200_9600 0 2.228704e-07
I939 n1_m1_43200_14400 0 1.526501e-07
I940 n1_m1_43200_19200 0 1.532282e-07
I941 n1_m1_43200_24000 0 2.313071e-07
I942 n1_m1_43200_28800 0 1.597881e-07
I943 n1_m1_43200_33600 0 2.423057e-07
I944 n1_m1_43200_38400 0 1.749892e-07
I945 n1_m1_43200_43200 0 2.076483e-07
I946 n1_m1_43200_48000 0 2.898082e-07
I947 n1_m1_43200_52800 0 1.633167e-07
I948 n1_m1_43200_57600 0 2.507126e-07
I949 n1_m1_43200_62400 0 1.617418e-07
I950 n1_m1_43200_67200 0 1.600655e-07
I951 n1_m1_43200_72000 0 2.445747e-07
I952 n1_m1_43200_76800 0 1.702045e-07
I953 n1_m1_43200_81600 0 2.598600e-07
I954 n1_m1_43200_86400 0 1.743492e-07
I955 n1_m1_43200_91200 0 1.884529e-07
I956 n1_m1_43200_96000 0 7.848102e-07
I957 n1_m1_43200_100800 0 1.111373e-06
I958 n1_m1_43200_105600 0 1.459407e-06
I959 n1_m1_43200_110400 0 3.174988e-07
I960 n1_m1_43200_115200 0 1.847447e-07
I961 n1_m1_43200_120000 0 2.590805e-07
I962 n1_m1_43200_124800 0 1.658690e-07
I963 n1_m1_43200_129600 0 2.470735e-07
I964 n1_m1_43200_134400 0 1.601110e-07
I965 n1_m1_43200_139200 0 1.601110e-07
I966 n1_m1_43200_144000 0 2.526380e-07
I967 n1_m1_43200_148800 0 1.784910e-07
I968 n1_m1_43200_153600 0 2.751729e-07
I969 n1_m1_43200_158400 0 1.707090e-07
I970 n1_m1_43200_163200 0 1.615888e-07
I971 n1_m1_43200_168000 0 2.423103e-07
I972 n1_m1_43200_172800 0 1.694050e-07
I973 n1_m1_43200_177600 0 2.530939e-07
I974 n1_m1_43200_182400 0 1.616694e-07
I975 n1_m1_43200_187200 0 1.705834e-07
I976 n1_m1_43200_192000 0 2.678398e-07
I977 n1_m1_43200_196800 0 1.743906e-07
I978 n1_m1_43200_201600 0 2.448698e-07
I979 n1_m1_43200_206400 0 1.689008e-07
I980 n1_m1_43200_211200 0 1.707009e-07
I981 n1_m1_43200_216000 0 2.457532e-07
I982 n1_m1_43200_220800 0 4.881855e-07
I983 n1_m1_43200_225600 0 1.584807e-06
I984 n1_m1_43200_230400 0 7.593982e-07
I985 n1_m1_43200_235200 0 2.362447e-07
I986 n1_m1_43200_240000 0 2.599555e-07
I987 n1_m1_43200_244800 0 1.795919e-07
I988 n1_m1_43200_249600 0 5.317563e-07
I989 n1_m1_43200_254400 0 3.810276e-07
I990 n1_m1_43200_259200 0 2.489592e-07
I991 n1_m1_43200_264000 0 2.726483e-07
I992 n1_m1_43200_268800 0 3.076397e-07
I993 n1_m1_43200_273600 0 4.665020e-07
I994 n1_m1_43200_278400 0 1.966714e-07
I995 n1_m1_43200_283200 0 1.665524e-07
I996 n1_m1_43200_288000 0 2.508118e-07
I997 n1_m1_43200_292800 0 1.725790e-07
I998 n1_m1_43200_297600 0 2.596874e-07
I999 n1_m1_43200_302400 0 1.729937e-07
I1000 n1_m1_43200_307200 0 1.687124e-07
I1001 n1_m1_43200_312000 0 2.534161e-07
I1002 n1_m1_43200_316800 0 1.740651e-07
I1003 n1_m1_43200_321600 0 2.536427e-07
I1004 n1_m1_43200_326400 0 1.667232e-07
I1005 n1_m1_43200_331200 0 1.676335e-07
I1006 n1_m1_43200_336000 0 3.484595e-07
I1007 n1_m1_43200_340800 0 4.471942e-07
I1008 n1_m1_43200_345600 0 4.950065e-07
I1009 n1_m1_43200_350400 0 1.782868e-07
I1010 n1_m1_43200_355200 0 1.771090e-07
I1011 n1_m1_43200_360000 0 2.498712e-07
I1012 n1_m1_43200_364800 0 1.773497e-07
I1013 n1_m1_43200_369600 0 2.711957e-07
I1014 n1_m1_43200_374400 0 1.831291e-07
I1015 n1_m1_43200_379200 0 2.070807e-07
I1016 n1_m1_43200_384000 0 3.260072e-07
I1017 n1_m1_43200_388800 0 1.803980e-07
I1018 n1_m1_43200_393600 0 2.502175e-07
I1019 n1_m1_43200_398400 0 1.685572e-07
I1020 n1_m1_43200_403200 0 1.769343e-07
I1021 n1_m1_43200_408000 0 2.667474e-07
I1022 n1_m1_43200_412800 0 1.719620e-07
I1023 n1_m1_43200_417600 0 2.562180e-07
I1024 n1_m1_43200_422400 0 1.753173e-07
I1025 n1_m1_43200_427200 0 2.224942e-07
I1026 n1_m1_43200_432000 0 4.949636e-07
I1027 n1_m1_43200_436800 0 3.245971e-07
I1028 n1_m1_43200_441600 0 3.646168e-07
I1029 n1_m1_43200_446400 0 2.072720e-07
I1030 n1_m1_43200_451200 0 1.890083e-07
I1031 n1_m1_43200_456000 0 2.567706e-07
I1032 n1_m1_43200_460800 0 1.622716e-07
I1033 n1_m1_43200_465600 0 2.462710e-07
I1034 n1_m1_43200_470400 0 1.875281e-07
I1035 n1_m1_43200_475200 0 2.824291e-07
I1036 n1_m1_43200_480000 0 3.507503e-07
I1037 n1_m1_43200_484800 0 1.565933e-07
I1038 n1_m1_43200_489600 0 2.269513e-07
I1039 n1_m1_43200_494400 0 1.662578e-07
I1040 n1_m1_48000_0 0 2.198491e-07
I1041 n1_m1_48000_4800 0 2.201993e-07
I1042 n1_m1_48000_9600 0 3.361701e-07
I1043 n1_m1_48000_14400 0 2.289350e-07
I1044 n1_m1_48000_19200 0 2.298422e-07
I1045 n1_m1_48000_24000 0 3.469607e-07
I1046 n1_m1_48000_28800 0 2.410677e-07
I1047 n1_m1_48000_33600 0 3.643997e-07
I1048 n1_m1_48000_38400 0 2.398621e-07
I1049 n1_m1_48000_43200 0 2.409516e-07
I1050 n1_m1_48000_48000 0 3.622441e-07
I1051 n1_m1_48000_52800 0 2.422089e-07
I1052 n1_m1_48000_57600 0 3.810983e-07
I1053 n1_m1_48000_62400 0 2.431470e-07
I1054 n1_m1_48000_67200 0 2.401104e-07
I1055 n1_m1_48000_72000 0 3.657330e-07
I1056 n1_m1_48000_76800 0 2.529656e-07
I1057 n1_m1_48000_81600 0 3.898269e-07
I1058 n1_m1_48000_86400 0 2.663445e-07
I1059 n1_m1_48000_91200 0 2.719220e-07
I1060 n1_m1_48000_96000 0 5.405746e-07
I1061 n1_m1_48000_100800 0 5.570929e-07
I1062 n1_m1_48000_105600 0 7.007611e-07
I1063 n1_m1_48000_110400 0 2.893001e-07
I1064 n1_m1_48000_115200 0 2.771476e-07
I1065 n1_m1_48000_120000 0 4.285848e-07
I1066 n1_m1_48000_124800 0 2.585755e-07
I1067 n1_m1_48000_129600 0 3.780584e-07
I1068 n1_m1_48000_134400 0 2.507717e-07
I1069 n1_m1_48000_139200 0 2.507717e-07
I1070 n1_m1_48000_144000 0 3.800704e-07
I1071 n1_m1_48000_148800 0 2.602969e-07
I1072 n1_m1_48000_153600 0 3.980406e-07
I1073 n1_m1_48000_158400 0 2.683637e-07
I1074 n1_m1_48000_163200 0 2.640931e-07
I1075 n1_m1_48000_168000 0 3.869672e-07
I1076 n1_m1_48000_172800 0 2.539501e-07
I1077 n1_m1_48000_177600 0 3.907581e-07
I1078 n1_m1_48000_182400 0 2.776438e-07
I1079 n1_m1_48000_187200 0 2.594679e-07
I1080 n1_m1_48000_192000 0 3.760944e-07
I1081 n1_m1_48000_196800 0 2.501053e-07
I1082 n1_m1_48000_201600 0 3.762501e-07
I1083 n1_m1_48000_206400 0 2.564904e-07
I1084 n1_m1_48000_211200 0 2.568247e-07
I1085 n1_m1_48000_216000 0 3.818824e-07
I1086 n1_m1_48000_220800 0 4.006483e-07
I1087 n1_m1_48000_225600 0 1.230521e-06
I1088 n1_m1_48000_230400 0 6.068986e-07
I1089 n1_m1_48000_235200 0 2.922285e-07
I1090 n1_m1_48000_240000 0 3.757434e-07
I1091 n1_m1_48000_244800 0 2.551253e-07
I1092 n1_m1_48000_249600 0 4.645861e-07
I1093 n1_m1_48000_254400 0 3.184803e-07
I1094 n1_m1_48000_259200 0 2.756274e-07
I1095 n1_m1_48000_264000 0 3.979793e-07
I1096 n1_m1_48000_268800 0 4.255071e-07
I1097 n1_m1_48000_273600 0 6.255111e-07
I1098 n1_m1_48000_278400 0 2.692411e-07
I1099 n1_m1_48000_283200 0 2.498285e-07
I1100 n1_m1_48000_288000 0 3.762177e-07
I1101 n1_m1_48000_292800 0 2.588685e-07
I1102 n1_m1_48000_297600 0 3.845029e-07
I1103 n1_m1_48000_302400 0 2.512265e-07
I1104 n1_m1_48000_307200 0 2.502973e-07
I1105 n1_m1_48000_312000 0 3.845202e-07
I1106 n1_m1_48000_316800 0 2.644270e-07
I1107 n1_m1_48000_321600 0 3.822140e-07
I1108 n1_m1_48000_326400 0 2.546698e-07
I1109 n1_m1_48000_331200 0 2.630158e-07
I1110 n1_m1_48000_336000 0 8.158683e-07
I1111 n1_m1_48000_340800 0 1.115797e-06
I1112 n1_m1_48000_345600 0 1.035569e-06
I1113 n1_m1_48000_350400 0 2.899290e-07
I1114 n1_m1_48000_355200 0 3.325573e-07
I1115 n1_m1_48000_360000 0 4.162726e-07
I1116 n1_m1_48000_364800 0 3.554503e-07
I1117 n1_m1_48000_369600 0 5.133667e-07
I1118 n1_m1_48000_374400 0 2.761250e-07
I1119 n1_m1_48000_379200 0 2.718483e-07
I1120 n1_m1_48000_384000 0 4.034836e-07
I1121 n1_m1_48000_388800 0 2.586848e-07
I1122 n1_m1_48000_393600 0 3.856347e-07
I1123 n1_m1_48000_398400 0 2.518761e-07
I1124 n1_m1_48000_403200 0 2.558866e-07
I1125 n1_m1_48000_408000 0 3.878277e-07
I1126 n1_m1_48000_412800 0 2.573221e-07
I1127 n1_m1_48000_417600 0 3.922041e-07
I1128 n1_m1_48000_422400 0 2.542987e-07
I1129 n1_m1_48000_427200 0 2.473615e-07
I1130 n1_m1_48000_432000 0 3.815856e-07
I1131 n1_m1_48000_436800 0 2.655021e-07
I1132 n1_m1_48000_441600 0 3.865605e-07
I1133 n1_m1_48000_446400 0 2.551230e-07
I1134 n1_m1_48000_451200 0 2.684752e-07
I1135 n1_m1_48000_456000 0 4.103499e-07
I1136 n1_m1_48000_460800 0 2.548856e-07
I1137 n1_m1_48000_465600 0 3.647918e-07
I1138 n1_m1_48000_470400 0 2.596026e-07
I1139 n1_m1_48000_475200 0 2.969946e-07
I1140 n1_m1_48000_480000 0 4.193109e-07
I1141 n1_m1_48000_484800 0 2.405450e-07
I1142 n1_m1_48000_489600 0 3.461589e-07
I1143 n1_m1_48000_494400 0 2.358654e-07
I1144 n1_m1_52800_0 0 1.484446e-07
I1145 n1_m1_52800_4800 0 1.474561e-07
I1146 n1_m1_52800_9600 0 2.232482e-07
I1147 n1_m1_52800_14400 0 1.506463e-07
I1148 n1_m1_52800_19200 0 1.532282e-07
I1149 n1_m1_52800_24000 0 2.342620e-07
I1150 n1_m1_52800_28800 0 1.616733e-07
I1151 n1_m1_52800_33600 0 2.398582e-07
I1152 n1_m1_52800_38400 0 1.598903e-07
I1153 n1_m1_52800_43200 0 1.600272e-07
I1154 n1_m1_52800_48000 0 2.437159e-07
I1155 n1_m1_52800_52800 0 1.589307e-07
I1156 n1_m1_52800_57600 0 2.362687e-07
I1157 n1_m1_52800_62400 0 1.597633e-07
I1158 n1_m1_52800_67200 0 1.622544e-07
I1159 n1_m1_52800_72000 0 2.449996e-07
I1160 n1_m1_52800_76800 0 1.646847e-07
I1161 n1_m1_52800_81600 0 2.547168e-07
I1162 n1_m1_52800_86400 0 1.742901e-07
I1163 n1_m1_52800_91200 0 1.803429e-07
I1164 n1_m1_52800_96000 0 2.627153e-07
I1165 n1_m1_52800_100800 0 1.667595e-07
I1166 n1_m1_52800_105600 0 2.890441e-07
I1167 n1_m1_52800_110400 0 1.903220e-07
I1168 n1_m1_52800_115200 0 1.942987e-07
I1169 n1_m1_52800_120000 0 3.411122e-07
I1170 n1_m1_52800_124800 0 2.071910e-07
I1171 n1_m1_52800_129600 0 2.773390e-07
I1172 n1_m1_52800_134400 0 1.745903e-07
I1173 n1_m1_52800_139200 0 1.732144e-07
I1174 n1_m1_52800_144000 0 2.598217e-07
I1175 n1_m1_52800_148800 0 1.725711e-07
I1176 n1_m1_52800_153600 0 2.717897e-07
I1177 n1_m1_52800_158400 0 2.154563e-07
I1178 n1_m1_52800_163200 0 2.540407e-07
I1179 n1_m1_52800_168000 0 3.856364e-07
I1180 n1_m1_52800_172800 0 2.135349e-07
I1181 n1_m1_52800_177600 0 2.911389e-07
I1182 n1_m1_52800_182400 0 1.991825e-07
I1183 n1_m1_52800_187200 0 2.046958e-07
I1184 n1_m1_52800_192000 0 2.530428e-07
I1185 n1_m1_52800_196800 0 1.650273e-07
I1186 n1_m1_52800_201600 0 2.588715e-07
I1187 n1_m1_52800_206400 0 1.681855e-07
I1188 n1_m1_52800_211200 0 1.714393e-07
I1189 n1_m1_52800_216000 0 3.038145e-07
I1190 n1_m1_52800_220800 0 1.975699e-07
I1191 n1_m1_52800_225600 0 2.699196e-07
I1192 n1_m1_52800_230400 0 1.750900e-07
I1193 n1_m1_52800_235200 0 1.752035e-07
I1194 n1_m1_52800_240000 0 2.592780e-07
I1195 n1_m1_52800_244800 0 1.739738e-07
I1196 n1_m1_52800_249600 0 2.734612e-07
I1197 n1_m1_52800_254400 0 1.712212e-07
I1198 n1_m1_52800_259200 0 1.673799e-07
I1199 n1_m1_52800_264000 0 2.579416e-07
I1200 n1_m1_52800_268800 0 1.828718e-07
I1201 n1_m1_52800_273600 0 2.670101e-07
I1202 n1_m1_52800_278400 0 1.700974e-07
I1203 n1_m1_52800_283200 0 1.665524e-07
I1204 n1_m1_52800_288000 0 2.508118e-07
I1205 n1_m1_52800_292800 0 1.725790e-07
I1206 n1_m1_52800_297600 0 2.557682e-07
I1207 n1_m1_52800_302400 0 1.665524e-07
I1208 n1_m1_52800_307200 0 1.665524e-07
I1209 n1_m1_52800_312000 0 2.477715e-07
I1210 n1_m1_52800_316800 0 1.681120e-07
I1211 n1_m1_52800_321600 0 2.510979e-07
I1212 n1_m1_52800_326400 0 1.703881e-07
I1213 n1_m1_52800_331200 0 1.728439e-07
I1214 n1_m1_52800_336000 0 4.937156e-07
I1215 n1_m1_52800_340800 0 7.029307e-07
I1216 n1_m1_52800_345600 0 6.772042e-07
I1217 n1_m1_52800_350400 0 2.032876e-07
I1218 n1_m1_52800_355200 0 1.900641e-07
I1219 n1_m1_52800_360000 0 3.726169e-07
I1220 n1_m1_52800_364800 0 4.515928e-07
I1221 n1_m1_52800_369600 0 4.041264e-07
I1222 n1_m1_52800_374400 0 1.724093e-07
I1223 n1_m1_52800_379200 0 1.659560e-07
I1224 n1_m1_52800_384000 0 2.437483e-07
I1225 n1_m1_52800_388800 0 1.654816e-07
I1226 n1_m1_52800_393600 0 2.596280e-07
I1227 n1_m1_52800_398400 0 1.832802e-07
I1228 n1_m1_52800_403200 0 2.151887e-07
I1229 n1_m1_52800_408000 0 3.216432e-07
I1230 n1_m1_52800_412800 0 1.699054e-07
I1231 n1_m1_52800_417600 0 2.516962e-07
I1232 n1_m1_52800_422400 0 1.674888e-07
I1233 n1_m1_52800_427200 0 1.640240e-07
I1234 n1_m1_52800_432000 0 2.523038e-07
I1235 n1_m1_52800_436800 0 1.683079e-07
I1236 n1_m1_52800_441600 0 2.590422e-07
I1237 n1_m1_52800_446400 0 1.680050e-07
I1238 n1_m1_52800_451200 0 1.710606e-07
I1239 n1_m1_52800_456000 0 2.779375e-07
I1240 n1_m1_52800_460800 0 1.805545e-07
I1241 n1_m1_52800_465600 0 2.574674e-07
I1242 n1_m1_52800_470400 0 1.702042e-07
I1243 n1_m1_52800_475200 0 1.616524e-07
I1244 n1_m1_52800_480000 0 2.375075e-07
I1245 n1_m1_52800_484800 0 1.598903e-07
I1246 n1_m1_52800_489600 0 2.331038e-07
I1247 n1_m1_52800_494400 0 1.501569e-07
I1248 n1_m1_57600_0 0 1.522138e-07
I1249 n1_m1_57600_4800 0 1.492994e-07
I1250 n1_m1_57600_9600 0 2.201027e-07
I1251 n1_m1_57600_14400 0 1.506463e-07
I1252 n1_m1_57600_19200 0 1.549677e-07
I1253 n1_m1_57600_24000 0 2.431664e-07
I1254 n1_m1_57600_28800 0 1.688263e-07
I1255 n1_m1_57600_33600 0 2.500085e-07
I1256 n1_m1_57600_38400 0 1.611827e-07
I1257 n1_m1_57600_43200 0 1.598003e-07
I1258 n1_m1_57600_48000 0 2.372860e-07
I1259 n1_m1_57600_52800 0 1.594232e-07
I1260 n1_m1_57600_57600 0 2.358771e-07
I1261 n1_m1_57600_62400 0 1.596921e-07
I1262 n1_m1_57600_67200 0 1.628223e-07
I1263 n1_m1_57600_72000 0 2.423831e-07
I1264 n1_m1_57600_76800 0 1.653254e-07
I1265 n1_m1_57600_81600 0 2.509857e-07
I1266 n1_m1_57600_86400 0 1.734939e-07
I1267 n1_m1_57600_91200 0 1.769429e-07
I1268 n1_m1_57600_96000 0 2.667641e-07
I1269 n1_m1_57600_100800 0 1.795281e-07
I1270 n1_m1_57600_105600 0 2.787244e-07
I1271 n1_m1_57600_110400 0 3.331774e-07
I1272 n1_m1_57600_115200 0 6.069993e-07
I1273 n1_m1_57600_120000 0 9.089148e-07
I1274 n1_m1_57600_124800 0 3.381055e-07
I1275 n1_m1_57600_129600 0 3.420789e-07
I1276 n1_m1_57600_134400 0 1.783176e-07
I1277 n1_m1_57600_139200 0 1.719002e-07
I1278 n1_m1_57600_144000 0 2.561326e-07
I1279 n1_m1_57600_148800 0 1.733617e-07
I1280 n1_m1_57600_153600 0 2.780827e-07
I1281 n1_m1_57600_158400 0 4.540056e-07
I1282 n1_m1_57600_163200 0 7.371240e-07
I1283 n1_m1_57600_168000 0 1.103256e-06
I1284 n1_m1_57600_172800 0 4.194951e-07
I1285 n1_m1_57600_177600 0 3.589490e-07
I1286 n1_m1_57600_182400 0 3.889652e-07
I1287 n1_m1_57600_187200 0 3.714645e-07
I1288 n1_m1_57600_192000 0 3.002539e-07
I1289 n1_m1_57600_196800 0 1.723511e-07
I1290 n1_m1_57600_201600 0 2.830958e-07
I1291 n1_m1_57600_206400 0 1.739677e-07
I1292 n1_m1_57600_211200 0 1.891838e-07
I1293 n1_m1_57600_216000 0 4.126547e-07
I1294 n1_m1_57600_220800 0 2.200913e-07
I1295 n1_m1_57600_225600 0 2.767838e-07
I1296 n1_m1_57600_230400 0 1.688470e-07
I1297 n1_m1_57600_235200 0 1.730738e-07
I1298 n1_m1_57600_240000 0 2.631629e-07
I1299 n1_m1_57600_244800 0 1.811207e-07
I1300 n1_m1_57600_249600 0 3.143698e-07
I1301 n1_m1_57600_254400 0 1.704086e-07
I1302 n1_m1_57600_259200 0 1.669061e-07
I1303 n1_m1_57600_264000 0 2.594781e-07
I1304 n1_m1_57600_268800 0 1.684541e-07
I1305 n1_m1_57600_273600 0 2.517270e-07
I1306 n1_m1_57600_278400 0 1.715425e-07
I1307 n1_m1_57600_283200 0 1.665524e-07
I1308 n1_m1_57600_288000 0 2.508118e-07
I1309 n1_m1_57600_292800 0 1.725790e-07
I1310 n1_m1_57600_297600 0 2.557682e-07
I1311 n1_m1_57600_302400 0 1.682810e-07
I1312 n1_m1_57600_307200 0 1.674630e-07
I1313 n1_m1_57600_312000 0 2.451214e-07
I1314 n1_m1_57600_316800 0 1.626059e-07
I1315 n1_m1_57600_321600 0 2.539668e-07
I1316 n1_m1_57600_326400 0 2.116276e-07
I1317 n1_m1_57600_331200 0 2.073414e-07
I1318 n1_m1_57600_336000 0 4.666245e-07
I1319 n1_m1_57600_340800 0 6.578191e-07
I1320 n1_m1_57600_345600 0 9.278120e-07
I1321 n1_m1_57600_350400 0 3.938380e-07
I1322 n1_m1_57600_355200 0 2.760780e-07
I1323 n1_m1_57600_360000 0 7.206622e-07
I1324 n1_m1_57600_364800 0 9.296388e-07
I1325 n1_m1_57600_369600 0 6.720618e-07
I1326 n1_m1_57600_374400 0 1.780063e-07
I1327 n1_m1_57600_379200 0 1.694384e-07
I1328 n1_m1_57600_384000 0 2.519662e-07
I1329 n1_m1_57600_388800 0 1.665524e-07
I1330 n1_m1_57600_393600 0 2.735022e-07
I1331 n1_m1_57600_398400 0 2.565407e-07
I1332 n1_m1_57600_403200 0 3.558809e-07
I1333 n1_m1_57600_408000 0 4.791238e-07
I1334 n1_m1_57600_412800 0 1.853042e-07
I1335 n1_m1_57600_417600 0 2.543356e-07
I1336 n1_m1_57600_422400 0 1.673741e-07
I1337 n1_m1_57600_427200 0 1.639420e-07
I1338 n1_m1_57600_432000 0 2.484151e-07
I1339 n1_m1_57600_436800 0 1.690254e-07
I1340 n1_m1_57600_441600 0 2.555871e-07
I1341 n1_m1_57600_446400 0 1.948815e-07
I1342 n1_m1_57600_451200 0 2.320106e-07
I1343 n1_m1_57600_456000 0 3.525704e-07
I1344 n1_m1_57600_460800 0 2.157482e-07
I1345 n1_m1_57600_465600 0 3.179896e-07
I1346 n1_m1_57600_470400 0 1.860831e-07
I1347 n1_m1_57600_475200 0 1.655662e-07
I1348 n1_m1_57600_480000 0 2.377752e-07
I1349 n1_m1_57600_484800 0 1.626059e-07
I1350 n1_m1_57600_489600 0 2.398926e-07
I1351 n1_m1_57600_494400 0 1.566418e-07
I1352 n1_m1_62400_0 0 1.495506e-07
I1353 n1_m1_62400_4800 0 1.518028e-07
I1354 n1_m1_62400_9600 0 2.247352e-07
I1355 n1_m1_62400_14400 0 1.600054e-07
I1356 n1_m1_62400_19200 0 1.656024e-07
I1357 n1_m1_62400_24000 0 2.440066e-07
I1358 n1_m1_62400_28800 0 1.634878e-07
I1359 n1_m1_62400_33600 0 2.563088e-07
I1360 n1_m1_62400_38400 0 1.758441e-07
I1361 n1_m1_62400_43200 0 1.720226e-07
I1362 n1_m1_62400_48000 0 2.412411e-07
I1363 n1_m1_62400_52800 0 1.602787e-07
I1364 n1_m1_62400_57600 0 2.497312e-07
I1365 n1_m1_62400_62400 0 1.627889e-07
I1366 n1_m1_62400_67200 0 1.653501e-07
I1367 n1_m1_62400_72000 0 2.480216e-07
I1368 n1_m1_62400_76800 0 1.684921e-07
I1369 n1_m1_62400_81600 0 2.591518e-07
I1370 n1_m1_62400_86400 0 1.783916e-07
I1371 n1_m1_62400_91200 0 1.806863e-07
I1372 n1_m1_62400_96000 0 2.693916e-07
I1373 n1_m1_62400_100800 0 1.790528e-07
I1374 n1_m1_62400_105600 0 3.537454e-07
I1375 n1_m1_62400_110400 0 6.926603e-07
I1376 n1_m1_62400_115200 0 1.259243e-06
I1377 n1_m1_62400_120000 0 1.711020e-06
I1378 n1_m1_62400_124800 0 3.643677e-07
I1379 n1_m1_62400_129600 0 2.804582e-07
I1380 n1_m1_62400_134400 0 1.683755e-07
I1381 n1_m1_62400_139200 0 1.639962e-07
I1382 n1_m1_62400_144000 0 2.480202e-07
I1383 n1_m1_62400_148800 0 1.743459e-07
I1384 n1_m1_62400_153600 0 2.881048e-07
I1385 n1_m1_62400_158400 0 5.900314e-07
I1386 n1_m1_62400_163200 0 1.111527e-06
I1387 n1_m1_62400_168000 0 1.993906e-06
I1388 n1_m1_62400_172800 0 1.027850e-06
I1389 n1_m1_62400_177600 0 6.581063e-07
I1390 n1_m1_62400_182400 0 4.114114e-07
I1391 n1_m1_62400_187200 0 3.629657e-07
I1392 n1_m1_62400_192000 0 3.075923e-07
I1393 n1_m1_62400_196800 0 1.779400e-07
I1394 n1_m1_62400_201600 0 2.833254e-07
I1395 n1_m1_62400_206400 0 2.046397e-07
I1396 n1_m1_62400_211200 0 3.878630e-07
I1397 n1_m1_62400_216000 0 8.798972e-07
I1398 n1_m1_62400_220800 0 3.254760e-07
I1399 n1_m1_62400_225600 0 3.041657e-07
I1400 n1_m1_62400_230400 0 1.747715e-07
I1401 n1_m1_62400_235200 0 1.729436e-07
I1402 n1_m1_62400_240000 0 2.543874e-07
I1403 n1_m1_62400_244800 0 1.717093e-07
I1404 n1_m1_62400_249600 0 2.720107e-07
I1405 n1_m1_62400_254400 0 1.723959e-07
I1406 n1_m1_62400_259200 0 1.711486e-07
I1407 n1_m1_62400_264000 0 2.583457e-07
I1408 n1_m1_62400_268800 0 1.671158e-07
I1409 n1_m1_62400_273600 0 2.578086e-07
I1410 n1_m1_62400_278400 0 1.729093e-07
I1411 n1_m1_62400_283200 0 1.693491e-07
I1412 n1_m1_62400_288000 0 2.633800e-07
I1413 n1_m1_62400_292800 0 1.736547e-07
I1414 n1_m1_62400_297600 0 2.591990e-07
I1415 n1_m1_62400_302400 0 1.764318e-07
I1416 n1_m1_62400_307200 0 1.997440e-07
I1417 n1_m1_62400_312000 0 3.270185e-07
I1418 n1_m1_62400_316800 0 1.961509e-07
I1419 n1_m1_62400_321600 0 2.665669e-07
I1420 n1_m1_62400_326400 0 1.940112e-07
I1421 n1_m1_62400_331200 0 2.774281e-07
I1422 n1_m1_62400_336000 0 7.553700e-07
I1423 n1_m1_62400_340800 0 7.236390e-07
I1424 n1_m1_62400_345600 0 7.964525e-07
I1425 n1_m1_62400_350400 0 3.040336e-07
I1426 n1_m1_62400_355200 0 3.087981e-07
I1427 n1_m1_62400_360000 0 7.569146e-07
I1428 n1_m1_62400_364800 0 8.835611e-07
I1429 n1_m1_62400_369600 0 8.032291e-07
I1430 n1_m1_62400_374400 0 1.872053e-07
I1431 n1_m1_62400_379200 0 1.725255e-07
I1432 n1_m1_62400_384000 0 2.545303e-07
I1433 n1_m1_62400_388800 0 1.665524e-07
I1434 n1_m1_62400_393600 0 2.921522e-07
I1435 n1_m1_62400_398400 0 3.179585e-07
I1436 n1_m1_62400_403200 0 3.746253e-07
I1437 n1_m1_62400_408000 0 3.800143e-07
I1438 n1_m1_62400_412800 0 1.815940e-07
I1439 n1_m1_62400_417600 0 2.533506e-07
I1440 n1_m1_62400_422400 0 1.682647e-07
I1441 n1_m1_62400_427200 0 1.677448e-07
I1442 n1_m1_62400_432000 0 2.523875e-07
I1443 n1_m1_62400_436800 0 1.811571e-07
I1444 n1_m1_62400_441600 0 3.315297e-07
I1445 n1_m1_62400_446400 0 2.062344e-07
I1446 n1_m1_62400_451200 0 2.055292e-07
I1447 n1_m1_62400_456000 0 2.923205e-07
I1448 n1_m1_62400_460800 0 2.097522e-07
I1449 n1_m1_62400_465600 0 7.636948e-07
I1450 n1_m1_62400_470400 0 3.121627e-07
I1451 n1_m1_62400_475200 0 1.697633e-07
I1452 n1_m1_62400_480000 0 2.546614e-07
I1453 n1_m1_62400_484800 0 1.621511e-07
I1454 n1_m1_62400_489600 0 2.444052e-07
I1455 n1_m1_62400_494400 0 1.659691e-07
I1456 n1_m1_67200_0 0 1.525374e-07
I1457 n1_m1_67200_4800 0 1.529892e-07
I1458 n1_m1_67200_9600 0 2.319700e-07
I1459 n1_m1_67200_14400 0 1.628275e-07
I1460 n1_m1_67200_19200 0 1.694417e-07
I1461 n1_m1_67200_24000 0 2.491215e-07
I1462 n1_m1_67200_28800 0 1.615811e-07
I1463 n1_m1_67200_33600 0 2.547810e-07
I1464 n1_m1_67200_38400 0 1.775827e-07
I1465 n1_m1_67200_43200 0 1.740894e-07
I1466 n1_m1_67200_48000 0 2.426313e-07
I1467 n1_m1_67200_52800 0 1.598903e-07
I1468 n1_m1_67200_57600 0 2.513204e-07
I1469 n1_m1_67200_62400 0 1.680592e-07
I1470 n1_m1_67200_67200 0 1.708827e-07
I1471 n1_m1_67200_72000 0 2.486423e-07
I1472 n1_m1_67200_76800 0 1.643967e-07
I1473 n1_m1_67200_81600 0 2.573762e-07
I1474 n1_m1_67200_86400 0 1.786324e-07
I1475 n1_m1_67200_91200 0 1.860646e-07
I1476 n1_m1_67200_96000 0 2.905505e-07
I1477 n1_m1_67200_100800 0 2.194581e-07
I1478 n1_m1_67200_105600 0 3.764807e-07
I1479 n1_m1_67200_110400 0 3.455230e-07
I1480 n1_m1_67200_115200 0 6.953829e-07
I1481 n1_m1_67200_120000 0 1.173336e-06
I1482 n1_m1_67200_124800 0 2.854039e-07
I1483 n1_m1_67200_129600 0 2.582863e-07
I1484 n1_m1_67200_134400 0 1.642961e-07
I1485 n1_m1_67200_139200 0 1.611527e-07
I1486 n1_m1_67200_144000 0 2.479027e-07
I1487 n1_m1_67200_148800 0 1.737203e-07
I1488 n1_m1_67200_153600 0 3.295855e-07
I1489 n1_m1_67200_158400 0 2.684185e-07
I1490 n1_m1_67200_163200 0 4.984000e-07
I1491 n1_m1_67200_168000 0 1.729252e-06
I1492 n1_m1_67200_172800 0 1.151619e-06
I1493 n1_m1_67200_177600 0 6.696525e-07
I1494 n1_m1_67200_182400 0 3.025908e-07
I1495 n1_m1_67200_187200 0 2.610992e-07
I1496 n1_m1_67200_192000 0 2.751780e-07
I1497 n1_m1_67200_196800 0 1.757110e-07
I1498 n1_m1_67200_201600 0 2.699429e-07
I1499 n1_m1_67200_206400 0 1.843029e-07
I1500 n1_m1_67200_211200 0 2.832142e-07
I1501 n1_m1_67200_216000 0 8.033308e-07
I1502 n1_m1_67200_220800 0 4.670390e-07
I1503 n1_m1_67200_225600 0 4.075316e-07
I1504 n1_m1_67200_230400 0 1.897921e-07
I1505 n1_m1_67200_235200 0 1.754409e-07
I1506 n1_m1_67200_240000 0 2.442447e-07
I1507 n1_m1_67200_244800 0 1.630629e-07
I1508 n1_m1_67200_249600 0 2.563686e-07
I1509 n1_m1_67200_254400 0 1.709509e-07
I1510 n1_m1_67200_259200 0 1.674821e-07
I1511 n1_m1_67200_264000 0 2.511643e-07
I1512 n1_m1_67200_268800 0 1.664087e-07
I1513 n1_m1_67200_273600 0 2.470501e-07
I1514 n1_m1_67200_278400 0 1.675418e-07
I1515 n1_m1_67200_283200 0 1.694685e-07
I1516 n1_m1_67200_288000 0 2.644871e-07
I1517 n1_m1_67200_292800 0 1.730673e-07
I1518 n1_m1_67200_297600 0 2.586478e-07
I1519 n1_m1_67200_302400 0 1.766726e-07
I1520 n1_m1_67200_307200 0 1.975218e-07
I1521 n1_m1_67200_312000 0 5.204242e-07
I1522 n1_m1_67200_316800 0 3.042150e-07
I1523 n1_m1_67200_321600 0 3.034611e-07
I1524 n1_m1_67200_326400 0 1.753561e-07
I1525 n1_m1_67200_331200 0 1.944446e-07
I1526 n1_m1_67200_336000 0 4.035608e-07
I1527 n1_m1_67200_340800 0 3.767328e-07
I1528 n1_m1_67200_345600 0 4.168871e-07
I1529 n1_m1_67200_350400 0 1.851202e-07
I1530 n1_m1_67200_355200 0 1.913746e-07
I1531 n1_m1_67200_360000 0 3.524155e-07
I1532 n1_m1_67200_364800 0 3.907997e-07
I1533 n1_m1_67200_369600 0 4.001774e-07
I1534 n1_m1_67200_374400 0 1.698317e-07
I1535 n1_m1_67200_379200 0 1.674821e-07
I1536 n1_m1_67200_384000 0 2.505604e-07
I1537 n1_m1_67200_388800 0 1.665524e-07
I1538 n1_m1_67200_393600 0 2.656174e-07
I1539 n1_m1_67200_398400 0 2.204025e-07
I1540 n1_m1_67200_403200 0 2.392139e-07
I1541 n1_m1_67200_408000 0 2.692793e-07
I1542 n1_m1_67200_412800 0 1.738085e-07
I1543 n1_m1_67200_417600 0 2.582219e-07
I1544 n1_m1_67200_422400 0 1.715021e-07
I1545 n1_m1_67200_427200 0 1.715021e-07
I1546 n1_m1_67200_432000 0 2.625752e-07
I1547 n1_m1_67200_436800 0 1.758313e-07
I1548 n1_m1_67200_441600 0 2.759335e-07
I1549 n1_m1_67200_446400 0 1.736947e-07
I1550 n1_m1_67200_451200 0 1.726911e-07
I1551 n1_m1_67200_456000 0 2.601396e-07
I1552 n1_m1_67200_460800 0 1.814084e-07
I1553 n1_m1_67200_465600 0 5.532778e-07
I1554 n1_m1_67200_470400 0 2.738130e-07
I1555 n1_m1_67200_475200 0 1.849948e-07
I1556 n1_m1_67200_480000 0 2.688348e-07
I1557 n1_m1_67200_484800 0 1.629394e-07
I1558 n1_m1_67200_489600 0 2.489228e-07
I1559 n1_m1_67200_494400 0 1.664605e-07
I1560 n1_m1_72000_0 0 2.298422e-07
I1561 n1_m1_72000_4800 0 2.298422e-07
I1562 n1_m1_72000_9600 0 3.452519e-07
I1563 n1_m1_72000_14400 0 2.367986e-07
I1564 n1_m1_72000_19200 0 2.448533e-07
I1565 n1_m1_72000_24000 0 3.683871e-07
I1566 n1_m1_72000_28800 0 2.415133e-07
I1567 n1_m1_72000_33600 0 3.769829e-07
I1568 n1_m1_72000_38400 0 2.595523e-07
I1569 n1_m1_72000_43200 0 2.567724e-07
I1570 n1_m1_72000_48000 0 3.632199e-07
I1571 n1_m1_72000_52800 0 2.398354e-07
I1572 n1_m1_72000_57600 0 3.749834e-07
I1573 n1_m1_72000_62400 0 2.586682e-07
I1574 n1_m1_72000_67200 0 2.596068e-07
I1575 n1_m1_72000_72000 0 3.833860e-07
I1576 n1_m1_72000_76800 0 2.444309e-07
I1577 n1_m1_72000_81600 0 3.697695e-07
I1578 n1_m1_72000_86400 0 2.571512e-07
I1579 n1_m1_72000_91200 0 2.679217e-07
I1580 n1_m1_72000_96000 0 4.188595e-07
I1581 n1_m1_72000_100800 0 2.955781e-07
I1582 n1_m1_72000_105600 0 5.114663e-07
I1583 n1_m1_72000_110400 0 2.938402e-07
I1584 n1_m1_72000_115200 0 3.986175e-07
I1585 n1_m1_72000_120000 0 6.099790e-07
I1586 n1_m1_72000_124800 0 2.718827e-07
I1587 n1_m1_72000_129600 0 3.731884e-07
I1588 n1_m1_72000_134400 0 2.494474e-07
I1589 n1_m1_72000_139200 0 2.506692e-07
I1590 n1_m1_72000_144000 0 3.804562e-07
I1591 n1_m1_72000_148800 0 2.601756e-07
I1592 n1_m1_72000_153600 0 4.089276e-07
I1593 n1_m1_72000_158400 0 3.005828e-07
I1594 n1_m1_72000_163200 0 3.731851e-07
I1595 n1_m1_72000_168000 0 8.532886e-07
I1596 n1_m1_72000_172800 0 6.668168e-07
I1597 n1_m1_72000_177600 0 7.861756e-07
I1598 n1_m1_72000_182400 0 3.252808e-07
I1599 n1_m1_72000_187200 0 2.731613e-07
I1600 n1_m1_72000_192000 0 3.795674e-07
I1601 n1_m1_72000_196800 0 2.581632e-07
I1602 n1_m1_72000_201600 0 3.953475e-07
I1603 n1_m1_72000_206400 0 2.536775e-07
I1604 n1_m1_72000_211200 0 2.751517e-07
I1605 n1_m1_72000_216000 0 6.092535e-07
I1606 n1_m1_72000_220800 0 4.458211e-07
I1607 n1_m1_72000_225600 0 4.837828e-07
I1608 n1_m1_72000_230400 0 2.671685e-07
I1609 n1_m1_72000_235200 0 2.534471e-07
I1610 n1_m1_72000_240000 0 3.800723e-07
I1611 n1_m1_72000_244800 0 2.581495e-07
I1612 n1_m1_72000_249600 0 3.744764e-07
I1613 n1_m1_72000_254400 0 2.493778e-07
I1614 n1_m1_72000_259200 0 2.474978e-07
I1615 n1_m1_72000_264000 0 3.749620e-07
I1616 n1_m1_72000_268800 0 2.526060e-07
I1617 n1_m1_72000_273600 0 3.791921e-07
I1618 n1_m1_72000_278400 0 2.516723e-07
I1619 n1_m1_72000_283200 0 2.519617e-07
I1620 n1_m1_72000_288000 0 3.869163e-07
I1621 n1_m1_72000_292800 0 2.547521e-07
I1622 n1_m1_72000_297600 0 3.811942e-07
I1623 n1_m1_72000_302400 0 2.604906e-07
I1624 n1_m1_72000_307200 0 2.776956e-07
I1625 n1_m1_72000_312000 0 5.988488e-07
I1626 n1_m1_72000_316800 0 3.685925e-07
I1627 n1_m1_72000_321600 0 4.215822e-07
I1628 n1_m1_72000_326400 0 2.542340e-07
I1629 n1_m1_72000_331200 0 2.518884e-07
I1630 n1_m1_72000_336000 0 4.013645e-07
I1631 n1_m1_72000_340800 0 2.838199e-07
I1632 n1_m1_72000_345600 0 3.959436e-07
I1633 n1_m1_72000_350400 0 2.709059e-07
I1634 n1_m1_72000_355200 0 2.889791e-07
I1635 n1_m1_72000_360000 0 3.796568e-07
I1636 n1_m1_72000_364800 0 2.789998e-07
I1637 n1_m1_72000_369600 0 3.911369e-07
I1638 n1_m1_72000_374400 0 2.522753e-07
I1639 n1_m1_72000_379200 0 2.499781e-07
I1640 n1_m1_72000_384000 0 3.747428e-07
I1641 n1_m1_72000_388800 0 2.523958e-07
I1642 n1_m1_72000_393600 0 3.830753e-07
I1643 n1_m1_72000_398400 0 2.630178e-07
I1644 n1_m1_72000_403200 0 2.619456e-07
I1645 n1_m1_72000_408000 0 3.810597e-07
I1646 n1_m1_72000_412800 0 2.585442e-07
I1647 n1_m1_72000_417600 0 3.825166e-07
I1648 n1_m1_72000_422400 0 2.506646e-07
I1649 n1_m1_72000_427200 0 2.524249e-07
I1650 n1_m1_72000_432000 0 3.872978e-07
I1651 n1_m1_72000_436800 0 2.559269e-07
I1652 n1_m1_72000_441600 0 3.792479e-07
I1653 n1_m1_72000_446400 0 2.535872e-07
I1654 n1_m1_72000_451200 0 2.515145e-07
I1655 n1_m1_72000_456000 0 3.920285e-07
I1656 n1_m1_72000_460800 0 2.656197e-07
I1657 n1_m1_72000_465600 0 4.486942e-07
I1658 n1_m1_72000_470400 0 2.918857e-07
I1659 n1_m1_72000_475200 0 2.914999e-07
I1660 n1_m1_72000_480000 0 4.058118e-07
I1661 n1_m1_72000_484800 0 2.423486e-07
I1662 n1_m1_72000_489600 0 3.573599e-07
I1663 n1_m1_72000_494400 0 2.331924e-07
I1664 n1_m1_76800_0 0 1.541669e-07
I1665 n1_m1_76800_4800 0 1.570343e-07
I1666 n1_m1_76800_9600 0 2.404576e-07
I1667 n1_m1_76800_14400 0 1.623759e-07
I1668 n1_m1_76800_19200 0 1.612030e-07
I1669 n1_m1_76800_24000 0 2.398354e-07
I1670 n1_m1_76800_28800 0 1.598903e-07
I1671 n1_m1_76800_33600 0 2.421203e-07
I1672 n1_m1_76800_38400 0 1.678500e-07
I1673 n1_m1_76800_43200 0 1.642921e-07
I1674 n1_m1_76800_48000 0 2.404670e-07
I1675 n1_m1_76800_52800 0 1.598903e-07
I1676 n1_m1_76800_57600 0 2.431626e-07
I1677 n1_m1_76800_62400 0 1.685389e-07
I1678 n1_m1_76800_67200 0 1.695623e-07
I1679 n1_m1_76800_72000 0 2.527781e-07
I1680 n1_m1_76800_76800 0 1.649023e-07
I1681 n1_m1_76800_81600 0 2.458364e-07
I1682 n1_m1_76800_86400 0 1.675946e-07
I1683 n1_m1_76800_91200 0 1.741910e-07
I1684 n1_m1_76800_96000 0 2.699828e-07
I1685 n1_m1_76800_100800 0 1.936091e-07
I1686 n1_m1_76800_105600 0 2.716690e-07
I1687 n1_m1_76800_110400 0 1.762820e-07
I1688 n1_m1_76800_115200 0 1.965389e-07
I1689 n1_m1_76800_120000 0 2.596534e-07
I1690 n1_m1_76800_124800 0 1.634013e-07
I1691 n1_m1_76800_129600 0 2.433119e-07
I1692 n1_m1_76800_134400 0 1.682171e-07
I1693 n1_m1_76800_139200 0 1.716611e-07
I1694 n1_m1_76800_144000 0 2.598217e-07
I1695 n1_m1_76800_148800 0 1.732144e-07
I1696 n1_m1_76800_153600 0 2.619997e-07
I1697 n1_m1_76800_158400 0 1.925811e-07
I1698 n1_m1_76800_163200 0 2.142351e-07
I1699 n1_m1_76800_168000 0 2.899364e-07
I1700 n1_m1_76800_172800 0 1.924690e-07
I1701 n1_m1_76800_177600 0 2.867921e-07
I1702 n1_m1_76800_182400 0 1.838211e-07
I1703 n1_m1_76800_187200 0 1.744082e-07
I1704 n1_m1_76800_192000 0 2.559202e-07
I1705 n1_m1_76800_196800 0 1.725617e-07
I1706 n1_m1_76800_201600 0 2.579226e-07
I1707 n1_m1_76800_206400 0 1.669966e-07
I1708 n1_m1_76800_211200 0 1.669241e-07
I1709 n1_m1_76800_216000 0 2.539839e-07
I1710 n1_m1_76800_220800 0 1.736545e-07
I1711 n1_m1_76800_225600 0 2.686183e-07
I1712 n1_m1_76800_230400 0 1.752234e-07
I1713 n1_m1_76800_235200 0 1.675369e-07
I1714 n1_m1_76800_240000 0 2.519605e-07
I1715 n1_m1_76800_244800 0 1.722244e-07
I1716 n1_m1_76800_249600 0 2.485475e-07
I1717 n1_m1_76800_254400 0 1.656518e-07
I1718 n1_m1_76800_259200 0 1.633322e-07
I1719 n1_m1_76800_264000 0 2.450028e-07
I1720 n1_m1_76800_268800 0 1.713608e-07
I1721 n1_m1_76800_273600 0 2.582156e-07
I1722 n1_m1_76800_278400 0 1.681540e-07
I1723 n1_m1_76800_283200 0 1.698566e-07
I1724 n1_m1_76800_288000 0 2.598217e-07
I1725 n1_m1_76800_292800 0 1.732144e-07
I1726 n1_m1_76800_297600 0 2.598217e-07
I1727 n1_m1_76800_302400 0 1.774552e-07
I1728 n1_m1_76800_307200 0 1.798765e-07
I1729 n1_m1_76800_312000 0 2.554672e-07
I1730 n1_m1_76800_316800 0 1.731409e-07
I1731 n1_m1_76800_321600 0 2.569835e-07
I1732 n1_m1_76800_326400 0 1.672323e-07
I1733 n1_m1_76800_331200 0 1.666883e-07
I1734 n1_m1_76800_336000 0 2.548784e-07
I1735 n1_m1_76800_340800 0 1.701426e-07
I1736 n1_m1_76800_345600 0 2.510494e-07
I1737 n1_m1_76800_350400 0 1.797423e-07
I1738 n1_m1_76800_355200 0 1.954006e-07
I1739 n1_m1_76800_360000 0 2.556373e-07
I1740 n1_m1_76800_364800 0 1.750976e-07
I1741 n1_m1_76800_369600 0 2.622272e-07
I1742 n1_m1_76800_374400 0 1.718834e-07
I1743 n1_m1_76800_379200 0 1.668400e-07
I1744 n1_m1_76800_384000 0 2.498285e-07
I1745 n1_m1_76800_388800 0 1.687826e-07
I1746 n1_m1_76800_393600 0 2.589306e-07
I1747 n1_m1_76800_398400 0 1.722776e-07
I1748 n1_m1_76800_403200 0 1.712259e-07
I1749 n1_m1_76800_408000 0 2.598217e-07
I1750 n1_m1_76800_412800 0 1.729636e-07
I1751 n1_m1_76800_417600 0 2.574373e-07
I1752 n1_m1_76800_422400 0 1.738566e-07
I1753 n1_m1_76800_427200 0 1.753857e-07
I1754 n1_m1_76800_432000 0 2.642764e-07
I1755 n1_m1_76800_436800 0 1.701874e-07
I1756 n1_m1_76800_441600 0 2.542372e-07
I1757 n1_m1_76800_446400 0 1.755832e-07
I1758 n1_m1_76800_451200 0 1.723583e-07
I1759 n1_m1_76800_456000 0 2.842975e-07
I1760 n1_m1_76800_460800 0 2.103182e-07
I1761 n1_m1_76800_465600 0 2.678162e-07
I1762 n1_m1_76800_470400 0 1.833691e-07
I1763 n1_m1_76800_475200 0 1.799641e-07
I1764 n1_m1_76800_480000 0 2.625808e-07
I1765 n1_m1_76800_484800 0 1.674353e-07
I1766 n1_m1_76800_489600 0 2.398107e-07
I1767 n1_m1_76800_494400 0 1.623071e-07
I1768 n1_m1_81600_0 0 2.378617e-07
I1769 n1_m1_81600_4800 0 2.484244e-07
I1770 n1_m1_81600_9600 0 4.004692e-07
I1771 n1_m1_81600_14400 0 2.681055e-07
I1772 n1_m1_81600_19200 0 2.581841e-07
I1773 n1_m1_81600_24000 0 3.715321e-07
I1774 n1_m1_81600_28800 0 2.444419e-07
I1775 n1_m1_81600_33600 0 3.589560e-07
I1776 n1_m1_81600_38400 0 2.407754e-07
I1777 n1_m1_81600_43200 0 2.393485e-07
I1778 n1_m1_81600_48000 0 3.595103e-07
I1779 n1_m1_81600_52800 0 2.398354e-07
I1780 n1_m1_81600_57600 0 3.601087e-07
I1781 n1_m1_81600_62400 0 2.432039e-07
I1782 n1_m1_81600_67200 0 2.438153e-07
I1783 n1_m1_81600_72000 0 3.657229e-07
I1784 n1_m1_81600_76800 0 2.438153e-07
I1785 n1_m1_81600_81600 0 3.744849e-07
I1786 n1_m1_81600_86400 0 2.573296e-07
I1787 n1_m1_81600_91200 0 2.623087e-07
I1788 n1_m1_81600_96000 0 4.323393e-07
I1789 n1_m1_81600_100800 0 5.606289e-07
I1790 n1_m1_81600_105600 0 1.306628e-06
I1791 n1_m1_81600_110400 0 6.009505e-07
I1792 n1_m1_81600_115200 0 2.705093e-07
I1793 n1_m1_81600_120000 0 4.291121e-07
I1794 n1_m1_81600_124800 0 2.626527e-07
I1795 n1_m1_81600_129600 0 3.722007e-07
I1796 n1_m1_81600_134400 0 2.538562e-07
I1797 n1_m1_81600_139200 0 2.592245e-07
I1798 n1_m1_81600_144000 0 3.907476e-07
I1799 n1_m1_81600_148800 0 2.664451e-07
I1800 n1_m1_81600_153600 0 4.107075e-07
I1801 n1_m1_81600_158400 0 2.737842e-07
I1802 n1_m1_81600_163200 0 2.608519e-07
I1803 n1_m1_81600_168000 0 4.107522e-07
I1804 n1_m1_81600_172800 0 2.780320e-07
I1805 n1_m1_81600_177600 0 3.969471e-07
I1806 n1_m1_81600_182400 0 2.558256e-07
I1807 n1_m1_81600_187200 0 2.587923e-07
I1808 n1_m1_81600_192000 0 3.960000e-07
I1809 n1_m1_81600_196800 0 2.563099e-07
I1810 n1_m1_81600_201600 0 3.775555e-07
I1811 n1_m1_81600_206400 0 2.526302e-07
I1812 n1_m1_81600_211200 0 2.564677e-07
I1813 n1_m1_81600_216000 0 3.773353e-07
I1814 n1_m1_81600_220800 0 2.575174e-07
I1815 n1_m1_81600_225600 0 4.005278e-07
I1816 n1_m1_81600_230400 0 2.604152e-07
I1817 n1_m1_81600_235200 0 2.575405e-07
I1818 n1_m1_81600_240000 0 3.855163e-07
I1819 n1_m1_81600_244800 0 2.590565e-07
I1820 n1_m1_81600_249600 0 3.865178e-07
I1821 n1_m1_81600_254400 0 2.560108e-07
I1822 n1_m1_81600_259200 0 2.477149e-07
I1823 n1_m1_81600_264000 0 3.639625e-07
I1824 n1_m1_81600_268800 0 2.606585e-07
I1825 n1_m1_81600_273600 0 3.803431e-07
I1826 n1_m1_81600_278400 0 2.466287e-07
I1827 n1_m1_81600_283200 0 2.512285e-07
I1828 n1_m1_81600_288000 0 3.851350e-07
I1829 n1_m1_81600_292800 0 2.586645e-07
I1830 n1_m1_81600_297600 0 3.879967e-07
I1831 n1_m1_81600_302400 0 2.604613e-07
I1832 n1_m1_81600_307200 0 2.614872e-07
I1833 n1_m1_81600_312000 0 3.864202e-07
I1834 n1_m1_81600_316800 0 2.597777e-07
I1835 n1_m1_81600_321600 0 3.865930e-07
I1836 n1_m1_81600_326400 0 2.512230e-07
I1837 n1_m1_81600_331200 0 2.507928e-07
I1838 n1_m1_81600_336000 0 3.784199e-07
I1839 n1_m1_81600_340800 0 2.557271e-07
I1840 n1_m1_81600_345600 0 3.803664e-07
I1841 n1_m1_81600_350400 0 2.449908e-07
I1842 n1_m1_81600_355200 0 2.514610e-07
I1843 n1_m1_81600_360000 0 3.786170e-07
I1844 n1_m1_81600_364800 0 2.478353e-07
I1845 n1_m1_81600_369600 0 3.780134e-07
I1846 n1_m1_81600_374400 0 2.501585e-07
I1847 n1_m1_81600_379200 0 2.456802e-07
I1848 n1_m1_81600_384000 0 3.762698e-07
I1849 n1_m1_81600_388800 0 2.509857e-07
I1850 n1_m1_81600_393600 0 3.802730e-07
I1851 n1_m1_81600_398400 0 2.590247e-07
I1852 n1_m1_81600_403200 0 2.577810e-07
I1853 n1_m1_81600_408000 0 3.870931e-07
I1854 n1_m1_81600_412800 0 2.632959e-07
I1855 n1_m1_81600_417600 0 4.016784e-07
I1856 n1_m1_81600_422400 0 2.657717e-07
I1857 n1_m1_81600_427200 0 2.654682e-07
I1858 n1_m1_81600_432000 0 4.336930e-07
I1859 n1_m1_81600_436800 0 2.962329e-07
I1860 n1_m1_81600_441600 0 3.816799e-07
I1861 n1_m1_81600_446400 0 2.591327e-07
I1862 n1_m1_81600_451200 0 2.630834e-07
I1863 n1_m1_81600_456000 0 6.341303e-07
I1864 n1_m1_81600_460800 0 5.007456e-07
I1865 n1_m1_81600_465600 0 4.263966e-07
I1866 n1_m1_81600_470400 0 4.713383e-07
I1867 n1_m1_81600_475200 0 4.796066e-07
I1868 n1_m1_81600_480000 0 4.507589e-07
I1869 n1_m1_81600_484800 0 2.441646e-07
I1870 n1_m1_81600_489600 0 3.532363e-07
I1871 n1_m1_81600_494400 0 2.511221e-07
I1872 n1_m1_86400_0 0 7.653736e-08
I1873 n1_m1_86400_4800 0 8.372769e-08
I1874 n1_m1_86400_9600 0 1.402681e-07
I1875 n1_m1_86400_14400 0 9.409873e-08
I1876 n1_m1_86400_19200 0 8.883594e-08
I1877 n1_m1_86400_24000 0 1.226644e-07
I1878 n1_m1_86400_28800 0 8.029869e-08
I1879 n1_m1_86400_33600 0 1.177755e-07
I1880 n1_m1_86400_38400 0 7.707561e-08
I1881 n1_m1_86400_43200 0 7.717069e-08
I1882 n1_m1_86400_48000 0 1.193156e-07
I1883 n1_m1_86400_52800 0 7.994513e-08
I1884 n1_m1_86400_57600 0 1.201741e-07
I1885 n1_m1_86400_62400 0 8.237385e-08
I1886 n1_m1_86400_67200 0 8.281465e-08
I1887 n1_m1_86400_72000 0 1.242220e-07
I1888 n1_m1_86400_76800 0 8.281465e-08
I1889 n1_m1_86400_81600 0 1.278874e-07
I1890 n1_m1_86400_86400 0 8.711400e-08
I1891 n1_m1_86400_91200 0 8.883233e-08
I1892 n1_m1_86400_96000 0 1.596433e-07
I1893 n1_m1_86400_100800 0 2.550580e-07
I1894 n1_m1_86400_105600 0 6.731802e-07
I1895 n1_m1_86400_110400 0 3.635362e-07
I1896 n1_m1_86400_115200 0 1.393528e-07
I1897 n1_m1_86400_120000 0 1.292770e-07
I1898 n1_m1_86400_124800 0 8.475216e-08
I1899 n1_m1_86400_129600 0 1.249143e-07
I1900 n1_m1_86400_134400 0 8.348655e-08
I1901 n1_m1_86400_139200 0 8.512637e-08
I1902 n1_m1_86400_144000 0 1.303824e-07
I1903 n1_m1_86400_148800 0 9.004704e-08
I1904 n1_m1_86400_153600 0 1.560744e-07
I1905 n1_m1_86400_158400 0 1.038711e-07
I1906 n1_m1_86400_163200 0 9.798375e-08
I1907 n1_m1_86400_168000 0 1.985705e-07
I1908 n1_m1_86400_172800 0 1.119400e-07
I1909 n1_m1_86400_177600 0 1.264285e-07
I1910 n1_m1_86400_182400 0 8.570584e-08
I1911 n1_m1_86400_187200 0 8.663710e-08
I1912 n1_m1_86400_192000 0 1.319749e-07
I1913 n1_m1_86400_196800 0 8.355699e-08
I1914 n1_m1_86400_201600 0 1.278270e-07
I1915 n1_m1_86400_206400 0 8.864220e-08
I1916 n1_m1_86400_211200 0 8.900375e-08
I1917 n1_m1_86400_216000 0 1.296165e-07
I1918 n1_m1_86400_220800 0 8.640426e-08
I1919 n1_m1_86400_225600 0 1.266914e-07
I1920 n1_m1_86400_230400 0 8.107889e-08
I1921 n1_m1_86400_235200 0 8.206094e-08
I1922 n1_m1_86400_240000 0 1.297092e-07
I1923 n1_m1_86400_244800 0 8.660722e-08
I1924 n1_m1_86400_249600 0 1.306887e-07
I1925 n1_m1_86400_254400 0 8.848010e-08
I1926 n1_m1_86400_259200 0 8.505541e-08
I1927 n1_m1_86400_264000 0 1.276425e-07
I1928 n1_m1_86400_268800 0 9.750918e-08
I1929 n1_m1_86400_273600 0 1.353410e-07
I1930 n1_m1_86400_278400 0 8.303058e-08
I1931 n1_m1_86400_283200 0 8.327618e-08
I1932 n1_m1_86400_288000 0 1.253869e-07
I1933 n1_m1_86400_292800 0 8.373771e-08
I1934 n1_m1_86400_297600 0 1.256066e-07
I1935 n1_m1_86400_302400 0 8.373771e-08
I1936 n1_m1_86400_307200 0 8.373771e-08
I1937 n1_m1_86400_312000 0 1.262721e-07
I1938 n1_m1_86400_316800 0 8.657553e-08
I1939 n1_m1_86400_321600 0 1.277134e-07
I1940 n1_m1_86400_326400 0 8.346975e-08
I1941 n1_m1_86400_331200 0 8.566744e-08
I1942 n1_m1_86400_336000 0 1.340328e-07
I1943 n1_m1_86400_340800 0 9.207101e-08
I1944 n1_m1_86400_345600 0 1.321134e-07
I1945 n1_m1_86400_350400 0 8.120753e-08
I1946 n1_m1_86400_355200 0 8.396640e-08
I1947 n1_m1_86400_360000 0 1.337274e-07
I1948 n1_m1_86400_364800 0 8.259718e-08
I1949 n1_m1_86400_369600 0 1.282994e-07
I1950 n1_m1_86400_374400 0 8.138043e-08
I1951 n1_m1_86400_379200 0 8.342305e-08
I1952 n1_m1_86400_384000 0 1.291216e-07
I1953 n1_m1_86400_388800 0 8.614569e-08
I1954 n1_m1_86400_393600 0 1.257450e-07
I1955 n1_m1_86400_398400 0 8.463083e-08
I1956 n1_m1_86400_403200 0 8.645060e-08
I1957 n1_m1_86400_408000 0 1.325057e-07
I1958 n1_m1_86400_412800 0 9.401827e-08
I1959 n1_m1_86400_417600 0 1.370032e-07
I1960 n1_m1_86400_422400 0 8.684726e-08
I1961 n1_m1_86400_427200 0 1.009508e-07
I1962 n1_m1_86400_432000 0 2.467339e-07
I1963 n1_m1_86400_436800 0 1.704249e-07
I1964 n1_m1_86400_441600 0 1.350703e-07
I1965 n1_m1_86400_446400 0 8.543667e-08
I1966 n1_m1_86400_451200 0 9.243269e-08
I1967 n1_m1_86400_456000 0 3.446925e-07
I1968 n1_m1_86400_460800 0 2.623701e-07
I1969 n1_m1_86400_465600 0 1.707633e-07
I1970 n1_m1_86400_470400 0 3.583159e-07
I1971 n1_m1_86400_475200 0 4.159813e-07
I1972 n1_m1_86400_480000 0 2.480479e-07
I1973 n1_m1_86400_484800 0 7.715346e-08
I1974 n1_m1_86400_489600 0 1.153781e-07
I1975 n1_m1_86400_494400 0 7.977476e-08
I1976 n1_m1_91200_0 0 1.481220e-07
I1977 n1_m1_91200_4800 0 1.552973e-07
I1978 n1_m1_91200_9600 0 2.641155e-07
I1979 n1_m1_91200_14400 0 1.782719e-07
I1980 n1_m1_91200_19200 0 1.662279e-07
I1981 n1_m1_91200_24000 0 2.386952e-07
I1982 n1_m1_91200_28800 0 1.537414e-07
I1983 n1_m1_91200_33600 0 2.301189e-07
I1984 n1_m1_91200_38400 0 1.532282e-07
I1985 n1_m1_91200_43200 0 1.534044e-07
I1986 n1_m1_91200_48000 0 2.367028e-07
I1987 n1_m1_91200_52800 0 1.590560e-07
I1988 n1_m1_91200_57600 0 2.425356e-07
I1989 n1_m1_91200_62400 0 1.746013e-07
I1990 n1_m1_91200_67200 0 1.717991e-07
I1991 n1_m1_91200_72000 0 2.530240e-07
I1992 n1_m1_91200_76800 0 1.764266e-07
I1993 n1_m1_91200_81600 0 3.119728e-07
I1994 n1_m1_91200_86400 0 2.042651e-07
I1995 n1_m1_91200_91200 0 1.798034e-07
I1996 n1_m1_91200_96000 0 3.971619e-07
I1997 n1_m1_91200_100800 0 5.267764e-07
I1998 n1_m1_91200_105600 0 7.621483e-07
I1999 n1_m1_91200_110400 0 3.194366e-07
I2000 n1_m1_91200_115200 0 1.816487e-07
I2001 n1_m1_91200_120000 0 2.495255e-07
I2002 n1_m1_91200_124800 0 1.679651e-07
I2003 n1_m1_91200_129600 0 2.518452e-07
I2004 n1_m1_91200_134400 0 1.685096e-07
I2005 n1_m1_91200_139200 0 1.687687e-07
I2006 n1_m1_91200_144000 0 2.586696e-07
I2007 n1_m1_91200_148800 0 1.836007e-07
I2008 n1_m1_91200_153600 0 2.850887e-07
I2009 n1_m1_91200_158400 0 1.758458e-07
I2010 n1_m1_91200_163200 0 1.709732e-07
I2011 n1_m1_91200_168000 0 2.569358e-07
I2012 n1_m1_91200_172800 0 1.788667e-07
I2013 n1_m1_91200_177600 0 2.984473e-07
I2014 n1_m1_91200_182400 0 1.887928e-07
I2015 n1_m1_91200_187200 0 1.808538e-07
I2016 n1_m1_91200_192000 0 2.678170e-07
I2017 n1_m1_91200_196800 0 1.749729e-07
I2018 n1_m1_91200_201600 0 2.606900e-07
I2019 n1_m1_91200_206400 0 1.825475e-07
I2020 n1_m1_91200_211200 0 1.895426e-07
I2021 n1_m1_91200_216000 0 3.215489e-07
I2022 n1_m1_91200_220800 0 2.712123e-07
I2023 n1_m1_91200_225600 0 3.654213e-07
I2024 n1_m1_91200_230400 0 1.717844e-07
I2025 n1_m1_91200_235200 0 1.641003e-07
I2026 n1_m1_91200_240000 0 2.594007e-07
I2027 n1_m1_91200_244800 0 1.659985e-07
I2028 n1_m1_91200_249600 0 2.457107e-07
I2029 n1_m1_91200_254400 0 1.707833e-07
I2030 n1_m1_91200_259200 0 1.704051e-07
I2031 n1_m1_91200_264000 0 3.402132e-07
I2032 n1_m1_91200_268800 0 4.613416e-07
I2033 n1_m1_91200_273600 0 6.318899e-07
I2034 n1_m1_91200_278400 0 2.134620e-07
I2035 n1_m1_91200_283200 0 1.728466e-07
I2036 n1_m1_91200_288000 0 2.549314e-07
I2037 n1_m1_91200_292800 0 1.723744e-07
I2038 n1_m1_91200_297600 0 2.592698e-07
I2039 n1_m1_91200_302400 0 1.728466e-07
I2040 n1_m1_91200_307200 0 1.704503e-07
I2041 n1_m1_91200_312000 0 2.625478e-07
I2042 n1_m1_91200_316800 0 1.755981e-07
I2043 n1_m1_91200_321600 0 2.574398e-07
I2044 n1_m1_91200_326400 0 1.678779e-07
I2045 n1_m1_91200_331200 0 1.721041e-07
I2046 n1_m1_91200_336000 0 2.723525e-07
I2047 n1_m1_91200_340800 0 1.810675e-07
I2048 n1_m1_91200_345600 0 2.461121e-07
I2049 n1_m1_91200_350400 0 1.613814e-07
I2050 n1_m1_91200_355200 0 1.634478e-07
I2051 n1_m1_91200_360000 0 2.541782e-07
I2052 n1_m1_91200_364800 0 1.602050e-07
I2053 n1_m1_91200_369600 0 2.501492e-07
I2054 n1_m1_91200_374400 0 1.641075e-07
I2055 n1_m1_91200_379200 0 1.812712e-07
I2056 n1_m1_91200_384000 0 3.407886e-07
I2057 n1_m1_91200_388800 0 2.208131e-07
I2058 n1_m1_91200_393600 0 2.756357e-07
I2059 n1_m1_91200_398400 0 1.725426e-07
I2060 n1_m1_91200_403200 0 1.744622e-07
I2061 n1_m1_91200_408000 0 3.189076e-07
I2062 n1_m1_91200_412800 0 2.586685e-07
I2063 n1_m1_91200_417600 0 3.007720e-07
I2064 n1_m1_91200_422400 0 2.183486e-07
I2065 n1_m1_91200_427200 0 4.784955e-07
I2066 n1_m1_91200_432000 0 1.347789e-06
I2067 n1_m1_91200_436800 0 7.313571e-07
I2068 n1_m1_91200_441600 0 3.645996e-07
I2069 n1_m1_91200_446400 0 1.784438e-07
I2070 n1_m1_91200_451200 0 2.477445e-07
I2071 n1_m1_91200_456000 0 9.498445e-07
I2072 n1_m1_91200_460800 0 7.124469e-07
I2073 n1_m1_91200_465600 0 5.824099e-07
I2074 n1_m1_91200_470400 0 9.872471e-07
I2075 n1_m1_91200_475200 0 1.185562e-06
I2076 n1_m1_91200_480000 0 8.969589e-07
I2077 n1_m1_91200_484800 0 1.666022e-07
I2078 n1_m1_91200_489600 0 2.450729e-07
I2079 n1_m1_91200_494400 0 1.604868e-07
I2080 n1_m1_96000_0 0 2.199196e-07
I2081 n1_m1_96000_4800 0 2.217119e-07
I2082 n1_m1_96000_9600 0 3.512383e-07
I2083 n1_m1_96000_14400 0 2.407644e-07
I2084 n1_m1_96000_19200 0 2.371919e-07
I2085 n1_m1_96000_24000 0 3.516819e-07
I2086 n1_m1_96000_28800 0 2.299671e-07
I2087 n1_m1_96000_33600 0 3.447864e-07
I2088 n1_m1_96000_38400 0 2.332514e-07
I2089 n1_m1_96000_43200 0 2.308787e-07
I2090 n1_m1_96000_48000 0 3.467296e-07
I2091 n1_m1_96000_52800 0 2.366521e-07
I2092 n1_m1_96000_57600 0 3.732709e-07
I2093 n1_m1_96000_62400 0 2.666893e-07
I2094 n1_m1_96000_67200 0 3.209154e-07
I2095 n1_m1_96000_72000 0 4.488665e-07
I2096 n1_m1_96000_76800 0 2.678675e-07
I2097 n1_m1_96000_81600 0 6.248881e-07
I2098 n1_m1_96000_86400 0 3.939500e-07
I2099 n1_m1_96000_91200 0 2.605848e-07
I2100 n1_m1_96000_96000 0 3.966770e-07
I2101 n1_m1_96000_100800 0 2.833924e-07
I2102 n1_m1_96000_105600 0 4.291543e-07
I2103 n1_m1_96000_110400 0 2.793368e-07
I2104 n1_m1_96000_115200 0 2.681088e-07
I2105 n1_m1_96000_120000 0 3.922472e-07
I2106 n1_m1_96000_124800 0 2.561383e-07
I2107 n1_m1_96000_129600 0 3.885333e-07
I2108 n1_m1_96000_134400 0 2.639775e-07
I2109 n1_m1_96000_139200 0 2.645630e-07
I2110 n1_m1_96000_144000 0 3.883005e-07
I2111 n1_m1_96000_148800 0 2.517092e-07
I2112 n1_m1_96000_153600 0 3.819580e-07
I2113 n1_m1_96000_158400 0 2.593829e-07
I2114 n1_m1_96000_163200 0 2.624490e-07
I2115 n1_m1_96000_168000 0 3.927198e-07
I2116 n1_m1_96000_172800 0 2.764854e-07
I2117 n1_m1_96000_177600 0 5.153780e-07
I2118 n1_m1_96000_182400 0 4.012963e-07
I2119 n1_m1_96000_187200 0 3.455101e-07
I2120 n1_m1_96000_192000 0 4.072805e-07
I2121 n1_m1_96000_196800 0 2.647005e-07
I2122 n1_m1_96000_201600 0 7.669570e-07
I2123 n1_m1_96000_206400 0 9.286033e-07
I2124 n1_m1_96000_211200 0 9.434296e-07
I2125 n1_m1_96000_216000 0 1.389706e-06
I2126 n1_m1_96000_220800 0 1.290752e-06
I2127 n1_m1_96000_225600 0 1.546233e-06
I2128 n1_m1_96000_230400 0 4.347109e-07
I2129 n1_m1_96000_235200 0 2.895138e-07
I2130 n1_m1_96000_240000 0 3.976735e-07
I2131 n1_m1_96000_244800 0 2.594219e-07
I2132 n1_m1_96000_249600 0 3.824987e-07
I2133 n1_m1_96000_254400 0 2.568953e-07
I2134 n1_m1_96000_259200 0 2.573191e-07
I2135 n1_m1_96000_264000 0 6.449307e-07
I2136 n1_m1_96000_268800 0 1.098186e-06
I2137 n1_m1_96000_273600 0 1.488478e-06
I2138 n1_m1_96000_278400 0 3.555350e-07
I2139 n1_m1_96000_283200 0 2.552331e-07
I2140 n1_m1_96000_288000 0 3.879856e-07
I2141 n1_m1_96000_292800 0 2.632047e-07
I2142 n1_m1_96000_297600 0 3.873138e-07
I2143 n1_m1_96000_302400 0 2.552331e-07
I2144 n1_m1_96000_307200 0 2.615106e-07
I2145 n1_m1_96000_312000 0 3.788949e-07
I2146 n1_m1_96000_316800 0 2.457717e-07
I2147 n1_m1_96000_321600 0 3.682666e-07
I2148 n1_m1_96000_326400 0 2.454701e-07
I2149 n1_m1_96000_331200 0 2.499511e-07
I2150 n1_m1_96000_336000 0 3.891860e-07
I2151 n1_m1_96000_340800 0 2.566021e-07
I2152 n1_m1_96000_345600 0 3.744873e-07
I2153 n1_m1_96000_350400 0 2.495543e-07
I2154 n1_m1_96000_355200 0 2.489964e-07
I2155 n1_m1_96000_360000 0 3.654140e-07
I2156 n1_m1_96000_364800 0 2.398354e-07
I2157 n1_m1_96000_369600 0 3.620600e-07
I2158 n1_m1_96000_374400 0 2.501641e-07
I2159 n1_m1_96000_379200 0 2.628468e-07
I2160 n1_m1_96000_384000 0 5.431418e-07
I2161 n1_m1_96000_388800 0 4.397967e-07
I2162 n1_m1_96000_393600 0 4.629586e-07
I2163 n1_m1_96000_398400 0 2.567967e-07
I2164 n1_m1_96000_403200 0 2.552350e-07
I2165 n1_m1_96000_408000 0 4.894163e-07
I2166 n1_m1_96000_412800 0 4.278220e-07
I2167 n1_m1_96000_417600 0 5.000441e-07
I2168 n1_m1_96000_422400 0 2.577338e-07
I2169 n1_m1_96000_427200 0 3.098596e-07
I2170 n1_m1_96000_432000 0 9.641946e-07
I2171 n1_m1_96000_436800 0 1.288880e-06
I2172 n1_m1_96000_441600 0 6.364404e-07
I2173 n1_m1_96000_446400 0 2.731255e-07
I2174 n1_m1_96000_451200 0 2.960316e-07
I2175 n1_m1_96000_456000 0 6.917302e-07
I2176 n1_m1_96000_460800 0 5.840451e-07
I2177 n1_m1_96000_465600 0 5.159248e-07
I2178 n1_m1_96000_470400 0 6.140892e-07
I2179 n1_m1_96000_475200 0 8.618629e-07
I2180 n1_m1_96000_480000 0 7.587231e-07
I2181 n1_m1_96000_484800 0 2.436493e-07
I2182 n1_m1_96000_489600 0 3.682955e-07
I2183 n1_m1_96000_494400 0 2.390635e-07
I2184 n1_m1_100800_0 0 1.465661e-07
I2185 n1_m1_100800_4800 0 1.475627e-07
I2186 n1_m1_100800_9600 0 2.331131e-07
I2187 n1_m1_100800_14400 0 1.598903e-07
I2188 n1_m1_100800_19200 0 1.556228e-07
I2189 n1_m1_100800_24000 0 2.298422e-07
I2190 n1_m1_100800_28800 0 1.532282e-07
I2191 n1_m1_100800_33600 0 2.334240e-07
I2192 n1_m1_100800_38400 0 1.594054e-07
I2193 n1_m1_100800_43200 0 1.582681e-07
I2194 n1_m1_100800_48000 0 2.331855e-07
I2195 n1_m1_100800_52800 0 1.598903e-07
I2196 n1_m1_100800_57600 0 2.771075e-07
I2197 n1_m1_100800_62400 0 4.451475e-07
I2198 n1_m1_100800_67200 0 7.151931e-07
I2199 n1_m1_100800_72000 0 7.572588e-07
I2200 n1_m1_100800_76800 0 2.053093e-07
I2201 n1_m1_100800_81600 0 2.838706e-07
I2202 n1_m1_100800_86400 0 1.855043e-07
I2203 n1_m1_100800_91200 0 1.657042e-07
I2204 n1_m1_100800_96000 0 2.477194e-07
I2205 n1_m1_100800_100800 0 1.670864e-07
I2206 n1_m1_100800_105600 0 2.543836e-07
I2207 n1_m1_100800_110400 0 1.751007e-07
I2208 n1_m1_100800_115200 0 1.730004e-07
I2209 n1_m1_100800_120000 0 2.525500e-07
I2210 n1_m1_100800_124800 0 1.670372e-07
I2211 n1_m1_100800_129600 0 2.543767e-07
I2212 n1_m1_100800_134400 0 1.740742e-07
I2213 n1_m1_100800_139200 0 1.741879e-07
I2214 n1_m1_100800_144000 0 2.588785e-07
I2215 n1_m1_100800_148800 0 1.672279e-07
I2216 n1_m1_100800_153600 0 2.577749e-07
I2217 n1_m1_100800_158400 0 1.798765e-07
I2218 n1_m1_100800_163200 0 1.798765e-07
I2219 n1_m1_100800_168000 0 2.669349e-07
I2220 n1_m1_100800_172800 0 1.760553e-07
I2221 n1_m1_100800_177600 0 2.877014e-07
I2222 n1_m1_100800_182400 0 2.144043e-07
I2223 n1_m1_100800_187200 0 1.902823e-07
I2224 n1_m1_100800_192000 0 2.793983e-07
I2225 n1_m1_100800_196800 0 2.163251e-07
I2226 n1_m1_100800_201600 0 6.817916e-07
I2227 n1_m1_100800_206400 0 9.150841e-07
I2228 n1_m1_100800_211200 0 9.903418e-07
I2229 n1_m1_100800_216000 0 1.153802e-06
I2230 n1_m1_100800_220800 0 6.883767e-07
I2231 n1_m1_100800_225600 0 8.368524e-07
I2232 n1_m1_100800_230400 0 2.515839e-07
I2233 n1_m1_100800_235200 0 1.872914e-07
I2234 n1_m1_100800_240000 0 2.665150e-07
I2235 n1_m1_100800_244800 0 1.814715e-07
I2236 n1_m1_100800_249600 0 2.720712e-07
I2237 n1_m1_100800_254400 0 1.762294e-07
I2238 n1_m1_100800_259200 0 1.748405e-07
I2239 n1_m1_100800_264000 0 2.524947e-07
I2240 n1_m1_100800_268800 0 2.327045e-07
I2241 n1_m1_100800_273600 0 3.636604e-07
I2242 n1_m1_100800_278400 0 1.700334e-07
I2243 n1_m1_100800_283200 0 1.665524e-07
I2244 n1_m1_100800_288000 0 2.576344e-07
I2245 n1_m1_100800_292800 0 1.781642e-07
I2246 n1_m1_100800_297600 0 2.534042e-07
I2247 n1_m1_100800_302400 0 1.617765e-07
I2248 n1_m1_100800_307200 0 1.630302e-07
I2249 n1_m1_100800_312000 0 2.428068e-07
I2250 n1_m1_100800_316800 0 1.599111e-07
I2251 n1_m1_100800_321600 0 2.398354e-07
I2252 n1_m1_100800_326400 0 1.600389e-07
I2253 n1_m1_100800_331200 0 1.637396e-07
I2254 n1_m1_100800_336000 0 2.512488e-07
I2255 n1_m1_100800_340800 0 1.694006e-07
I2256 n1_m1_100800_345600 0 2.498285e-07
I2257 n1_m1_100800_350400 0 1.665524e-07
I2258 n1_m1_100800_355200 0 1.665524e-07
I2259 n1_m1_100800_360000 0 2.488021e-07
I2260 n1_m1_100800_364800 0 1.619329e-07
I2261 n1_m1_100800_369600 0 2.410728e-07
I2262 n1_m1_100800_374400 0 1.652169e-07
I2263 n1_m1_100800_379200 0 1.638108e-07
I2264 n1_m1_100800_384000 0 2.707444e-07
I2265 n1_m1_100800_388800 0 1.920770e-07
I2266 n1_m1_100800_393600 0 2.602602e-07
I2267 n1_m1_100800_398400 0 1.693380e-07
I2268 n1_m1_100800_403200 0 1.719683e-07
I2269 n1_m1_100800_408000 0 2.615886e-07
I2270 n1_m1_100800_412800 0 1.765021e-07
I2271 n1_m1_100800_417600 0 2.612477e-07
I2272 n1_m1_100800_422400 0 1.713282e-07
I2273 n1_m1_100800_427200 0 1.742030e-07
I2274 n1_m1_100800_432000 0 3.350439e-07
I2275 n1_m1_100800_436800 0 3.829101e-07
I2276 n1_m1_100800_441600 0 3.575549e-07
I2277 n1_m1_100800_446400 0 2.570974e-07
I2278 n1_m1_100800_451200 0 1.994624e-07
I2279 n1_m1_100800_456000 0 2.888600e-07
I2280 n1_m1_100800_460800 0 2.041506e-07
I2281 n1_m1_100800_465600 0 2.581252e-07
I2282 n1_m1_100800_470400 0 2.035786e-07
I2283 n1_m1_100800_475200 0 2.196565e-07
I2284 n1_m1_100800_480000 0 2.586201e-07
I2285 n1_m1_100800_484800 0 1.552133e-07
I2286 n1_m1_100800_489600 0 2.420647e-07
I2287 n1_m1_100800_494400 0 1.561680e-07
I2288 n1_m1_105600_0 0 2.215357e-07
I2289 n1_m1_105600_4800 0 2.262193e-07
I2290 n1_m1_105600_9600 0 3.454396e-07
I2291 n1_m1_105600_14400 0 2.315479e-07
I2292 n1_m1_105600_19200 0 2.304553e-07
I2293 n1_m1_105600_24000 0 3.447634e-07
I2294 n1_m1_105600_28800 0 2.317810e-07
I2295 n1_m1_105600_33600 0 3.584371e-07
I2296 n1_m1_105600_38400 0 2.459928e-07
I2297 n1_m1_105600_43200 0 2.416344e-07
I2298 n1_m1_105600_48000 0 3.581519e-07
I2299 n1_m1_105600_52800 0 2.429806e-07
I2300 n1_m1_105600_57600 0 5.067384e-07
I2301 n1_m1_105600_62400 0 1.416636e-06
I2302 n1_m1_105600_67200 0 1.829454e-06
I2303 n1_m1_105600_72000 0 1.956564e-06
I2304 n1_m1_105600_76800 0 4.226234e-07
I2305 n1_m1_105600_81600 0 3.870621e-07
I2306 n1_m1_105600_86400 0 2.455210e-07
I2307 n1_m1_105600_91200 0 2.616063e-07
I2308 n1_m1_105600_96000 0 3.742511e-07
I2309 n1_m1_105600_100800 0 2.493456e-07
I2310 n1_m1_105600_105600 0 3.751846e-07
I2311 n1_m1_105600_110400 0 2.515342e-07
I2312 n1_m1_105600_115200 0 2.489278e-07
I2313 n1_m1_105600_120000 0 3.649002e-07
I2314 n1_m1_105600_124800 0 2.436115e-07
I2315 n1_m1_105600_129600 0 3.720535e-07
I2316 n1_m1_105600_134400 0 2.535861e-07
I2317 n1_m1_105600_139200 0 2.580959e-07
I2318 n1_m1_105600_144000 0 3.874757e-07
I2319 n1_m1_105600_148800 0 2.505733e-07
I2320 n1_m1_105600_153600 0 3.753686e-07
I2321 n1_m1_105600_158400 0 2.521621e-07
I2322 n1_m1_105600_163200 0 2.569226e-07
I2323 n1_m1_105600_168000 0 3.976200e-07
I2324 n1_m1_105600_172800 0 2.583882e-07
I2325 n1_m1_105600_177600 0 3.842516e-07
I2326 n1_m1_105600_182400 0 3.010628e-07
I2327 n1_m1_105600_187200 0 6.352988e-07
I2328 n1_m1_105600_192000 0 7.363687e-07
I2329 n1_m1_105600_196800 0 3.837736e-07
I2330 n1_m1_105600_201600 0 7.258027e-07
I2331 n1_m1_105600_206400 0 5.886131e-07
I2332 n1_m1_105600_211200 0 5.620689e-07
I2333 n1_m1_105600_216000 0 6.982251e-07
I2334 n1_m1_105600_220800 0 3.914667e-07
I2335 n1_m1_105600_225600 0 5.270696e-07
I2336 n1_m1_105600_230400 0 2.598853e-07
I2337 n1_m1_105600_235200 0 2.559897e-07
I2338 n1_m1_105600_240000 0 3.895485e-07
I2339 n1_m1_105600_244800 0 2.670858e-07
I2340 n1_m1_105600_249600 0 4.061654e-07
I2341 n1_m1_105600_254400 0 2.530832e-07
I2342 n1_m1_105600_259200 0 2.588656e-07
I2343 n1_m1_105600_264000 0 3.876825e-07
I2344 n1_m1_105600_268800 0 2.565994e-07
I2345 n1_m1_105600_273600 0 3.931569e-07
I2346 n1_m1_105600_278400 0 2.601448e-07
I2347 n1_m1_105600_283200 0 2.572601e-07
I2348 n1_m1_105600_288000 0 3.878071e-07
I2349 n1_m1_105600_292800 0 2.655206e-07
I2350 n1_m1_105600_297600 0 3.778963e-07
I2351 n1_m1_105600_302400 0 2.415611e-07
I2352 n1_m1_105600_307200 0 2.450022e-07
I2353 n1_m1_105600_312000 0 3.659906e-07
I2354 n1_m1_105600_316800 0 2.437113e-07
I2355 n1_m1_105600_321600 0 3.801369e-07
I2356 n1_m1_105600_326400 0 2.599931e-07
I2357 n1_m1_105600_331200 0 2.532362e-07
I2358 n1_m1_105600_336000 0 3.781886e-07
I2359 n1_m1_105600_340800 0 2.554556e-07
I2360 n1_m1_105600_345600 0 3.834451e-07
I2361 n1_m1_105600_350400 0 2.581160e-07
I2362 n1_m1_105600_355200 0 2.581160e-07
I2363 n1_m1_105600_360000 0 3.826642e-07
I2364 n1_m1_105600_364800 0 2.488524e-07
I2365 n1_m1_105600_369600 0 3.649209e-07
I2366 n1_m1_105600_374400 0 2.472600e-07
I2367 n1_m1_105600_379200 0 2.424039e-07
I2368 n1_m1_105600_384000 0 3.768979e-07
I2369 n1_m1_105600_388800 0 2.532599e-07
I2370 n1_m1_105600_393600 0 3.755800e-07
I2371 n1_m1_105600_398400 0 2.529388e-07
I2372 n1_m1_105600_403200 0 2.592360e-07
I2373 n1_m1_105600_408000 0 3.886409e-07
I2374 n1_m1_105600_412800 0 2.598217e-07
I2375 n1_m1_105600_417600 0 3.897325e-07
I2376 n1_m1_105600_422400 0 2.621426e-07
I2377 n1_m1_105600_427200 0 2.646577e-07
I2378 n1_m1_105600_432000 0 4.042235e-07
I2379 n1_m1_105600_436800 0 3.009935e-07
I2380 n1_m1_105600_441600 0 9.925172e-07
I2381 n1_m1_105600_446400 0 1.081450e-06
I2382 n1_m1_105600_451200 0 6.545408e-07
I2383 n1_m1_105600_456000 0 4.393667e-07
I2384 n1_m1_105600_460800 0 2.963567e-07
I2385 n1_m1_105600_465600 0 6.801963e-07
I2386 n1_m1_105600_470400 0 3.507041e-07
I2387 n1_m1_105600_475200 0 2.677432e-07
I2388 n1_m1_105600_480000 0 3.737667e-07
I2389 n1_m1_105600_484800 0 2.456916e-07
I2390 n1_m1_105600_489600 0 3.682504e-07
I2391 n1_m1_105600_494400 0 2.438426e-07
I2392 n1_m1_110400_0 0 1.465661e-07
I2393 n1_m1_110400_4800 0 1.472765e-07
I2394 n1_m1_110400_9600 0 2.276471e-07
I2395 n1_m1_110400_14400 0 1.532282e-07
I2396 n1_m1_110400_19200 0 1.532282e-07
I2397 n1_m1_110400_24000 0 2.298422e-07
I2398 n1_m1_110400_28800 0 1.543391e-07
I2399 n1_m1_110400_33600 0 2.383777e-07
I2400 n1_m1_110400_38400 0 1.634187e-07
I2401 n1_m1_110400_43200 0 1.609536e-07
I2402 n1_m1_110400_48000 0 2.398354e-07
I2403 n1_m1_110400_52800 0 1.624186e-07
I2404 n1_m1_110400_57600 0 3.008580e-07
I2405 n1_m1_110400_62400 0 6.290824e-07
I2406 n1_m1_110400_67200 0 8.968313e-07
I2407 n1_m1_110400_72000 0 8.789624e-07
I2408 n1_m1_110400_76800 0 2.164117e-07
I2409 n1_m1_110400_81600 0 2.586621e-07
I2410 n1_m1_110400_86400 0 1.628261e-07
I2411 n1_m1_110400_91200 0 1.752428e-07
I2412 n1_m1_110400_96000 0 2.503363e-07
I2413 n1_m1_110400_100800 0 1.665524e-07
I2414 n1_m1_110400_105600 0 2.498285e-07
I2415 n1_m1_110400_110400 0 1.665524e-07
I2416 n1_m1_110400_115200 0 1.665524e-07
I2417 n1_m1_110400_120000 0 2.498285e-07
I2418 n1_m1_110400_124800 0 1.662138e-07
I2419 n1_m1_110400_129600 0 2.427020e-07
I2420 n1_m1_110400_134400 0 1.620550e-07
I2421 n1_m1_110400_139200 0 1.655651e-07
I2422 n1_m1_110400_144000 0 2.539625e-07
I2423 n1_m1_110400_148800 0 1.662949e-07
I2424 n1_m1_110400_153600 0 2.482338e-07
I2425 n1_m1_110400_158400 0 1.650232e-07
I2426 n1_m1_110400_163200 0 1.649026e-07
I2427 n1_m1_110400_168000 0 2.554359e-07
I2428 n1_m1_110400_172800 0 1.726786e-07
I2429 n1_m1_110400_177600 0 3.121559e-07
I2430 n1_m1_110400_182400 0 3.934125e-07
I2431 n1_m1_110400_187200 0 1.081100e-06
I2432 n1_m1_110400_192000 0 1.565915e-06
I2433 n1_m1_110400_196800 0 7.277513e-07
I2434 n1_m1_110400_201600 0 5.519837e-07
I2435 n1_m1_110400_206400 0 1.828521e-07
I2436 n1_m1_110400_211200 0 1.851832e-07
I2437 n1_m1_110400_216000 0 3.480833e-07
I2438 n1_m1_110400_220800 0 1.939273e-07
I2439 n1_m1_110400_225600 0 2.803984e-07
I2440 n1_m1_110400_230400 0 1.749852e-07
I2441 n1_m1_110400_235200 0 1.781642e-07
I2442 n1_m1_110400_240000 0 2.553870e-07
I2443 n1_m1_110400_244800 0 1.741973e-07
I2444 n1_m1_110400_249600 0 2.589722e-07
I2445 n1_m1_110400_254400 0 1.719598e-07
I2446 n1_m1_110400_259200 0 1.886846e-07
I2447 n1_m1_110400_264000 0 2.927439e-07
I2448 n1_m1_110400_268800 0 2.190339e-07
I2449 n1_m1_110400_273600 0 3.586146e-07
I2450 n1_m1_110400_278400 0 2.060509e-07
I2451 n1_m1_110400_283200 0 1.699255e-07
I2452 n1_m1_110400_288000 0 2.479423e-07
I2453 n1_m1_110400_292800 0 1.698983e-07
I2454 n1_m1_110400_297600 0 2.490508e-07
I2455 n1_m1_110400_302400 0 1.682925e-07
I2456 n1_m1_110400_307200 0 2.001919e-07
I2457 n1_m1_110400_312000 0 3.412481e-07
I2458 n1_m1_110400_316800 0 2.275206e-07
I2459 n1_m1_110400_321600 0 3.932294e-07
I2460 n1_m1_110400_326400 0 2.594052e-07
I2461 n1_m1_110400_331200 0 1.975187e-07
I2462 n1_m1_110400_336000 0 2.555293e-07
I2463 n1_m1_110400_340800 0 1.703822e-07
I2464 n1_m1_110400_345600 0 2.598217e-07
I2465 n1_m1_110400_350400 0 1.729936e-07
I2466 n1_m1_110400_355200 0 1.715454e-07
I2467 n1_m1_110400_360000 0 2.543678e-07
I2468 n1_m1_110400_364800 0 1.654576e-07
I2469 n1_m1_110400_369600 0 2.433259e-07
I2470 n1_m1_110400_374400 0 1.666435e-07
I2471 n1_m1_110400_379200 0 1.631065e-07
I2472 n1_m1_110400_384000 0 2.544393e-07
I2473 n1_m1_110400_388800 0 1.732144e-07
I2474 n1_m1_110400_393600 0 2.514539e-07
I2475 n1_m1_110400_398400 0 1.686259e-07
I2476 n1_m1_110400_403200 0 1.709536e-07
I2477 n1_m1_110400_408000 0 2.556077e-07
I2478 n1_m1_110400_412800 0 1.732144e-07
I2479 n1_m1_110400_417600 0 2.589574e-07
I2480 n1_m1_110400_422400 0 1.690223e-07
I2481 n1_m1_110400_427200 0 1.665524e-07
I2482 n1_m1_110400_432000 0 2.570253e-07
I2483 n1_m1_110400_436800 0 1.857837e-07
I2484 n1_m1_110400_441600 0 5.840443e-07
I2485 n1_m1_110400_446400 0 7.452613e-07
I2486 n1_m1_110400_451200 0 6.138027e-07
I2487 n1_m1_110400_456000 0 3.623459e-07
I2488 n1_m1_110400_460800 0 2.098679e-07
I2489 n1_m1_110400_465600 0 4.832782e-07
I2490 n1_m1_110400_470400 0 2.184333e-07
I2491 n1_m1_110400_475200 0 1.761995e-07
I2492 n1_m1_110400_480000 0 2.511061e-07
I2493 n1_m1_110400_484800 0 1.610140e-07
I2494 n1_m1_110400_489600 0 2.300478e-07
I2495 n1_m1_110400_494400 0 1.546495e-07
I2496 n1_m1_115200_0 0 7.328303e-08
I2497 n1_m1_115200_4800 0 7.328303e-08
I2498 n1_m1_115200_9600 0 1.117577e-07
I2499 n1_m1_115200_14400 0 7.653891e-08
I2500 n1_m1_115200_19200 0 7.661408e-08
I2501 n1_m1_115200_24000 0 1.149638e-07
I2502 n1_m1_115200_28800 0 7.675820e-08
I2503 n1_m1_115200_33600 0 1.172704e-07
I2504 n1_m1_115200_38400 0 7.989897e-08
I2505 n1_m1_115200_43200 0 7.994513e-08
I2506 n1_m1_115200_48000 0 1.199177e-07
I2507 n1_m1_115200_52800 0 8.120932e-08
I2508 n1_m1_115200_57600 0 1.277442e-07
I2509 n1_m1_115200_62400 0 9.405511e-08
I2510 n1_m1_115200_67200 0 1.460094e-07
I2511 n1_m1_115200_72000 0 1.626095e-07
I2512 n1_m1_115200_76800 0 8.196516e-08
I2513 n1_m1_115200_81600 0 1.242905e-07
I2514 n1_m1_115200_86400 0 7.816025e-08
I2515 n1_m1_115200_91200 0 8.042640e-08
I2516 n1_m1_115200_96000 0 1.244942e-07
I2517 n1_m1_115200_100800 0 8.322125e-08
I2518 n1_m1_115200_105600 0 1.249143e-07
I2519 n1_m1_115200_110400 0 8.327618e-08
I2520 n1_m1_115200_115200 0 8.321502e-08
I2521 n1_m1_115200_120000 0 1.247980e-07
I2522 n1_m1_115200_124800 0 8.343412e-08
I2523 n1_m1_115200_129600 0 1.237805e-07
I2524 n1_m1_115200_134400 0 8.005069e-08
I2525 n1_m1_115200_139200 0 8.155714e-08
I2526 n1_m1_115200_144000 0 1.249143e-07
I2527 n1_m1_115200_148800 0 8.327618e-08
I2528 n1_m1_115200_153600 0 1.288874e-07
I2529 n1_m1_115200_158400 0 8.577781e-08
I2530 n1_m1_115200_163200 0 8.327618e-08
I2531 n1_m1_115200_168000 0 1.249143e-07
I2532 n1_m1_115200_172800 0 8.562758e-08
I2533 n1_m1_115200_177600 0 2.071358e-07
I2534 n1_m1_115200_182400 0 3.059297e-07
I2535 n1_m1_115200_187200 0 6.346020e-07
I2536 n1_m1_115200_192000 0 1.048831e-06
I2537 n1_m1_115200_196800 0 5.393103e-07
I2538 n1_m1_115200_201600 0 3.038691e-07
I2539 n1_m1_115200_206400 0 8.370488e-08
I2540 n1_m1_115200_211200 0 9.667062e-08
I2541 n1_m1_115200_216000 0 2.060222e-07
I2542 n1_m1_115200_220800 0 9.012217e-08
I2543 n1_m1_115200_225600 0 1.295285e-07
I2544 n1_m1_115200_230400 0 8.744144e-08
I2545 n1_m1_115200_235200 0 8.920499e-08
I2546 n1_m1_115200_240000 0 1.274161e-07
I2547 n1_m1_115200_244800 0 9.022496e-08
I2548 n1_m1_115200_249600 0 1.337898e-07
I2549 n1_m1_115200_254400 0 9.151176e-08
I2550 n1_m1_115200_259200 0 1.053280e-07
I2551 n1_m1_115200_264000 0 2.060998e-07
I2552 n1_m1_115200_268800 0 2.027899e-07
I2553 n1_m1_115200_273600 0 2.956619e-07
I2554 n1_m1_115200_278400 0 1.169980e-07
I2555 n1_m1_115200_283200 0 8.615037e-08
I2556 n1_m1_115200_288000 0 1.210263e-07
I2557 n1_m1_115200_292800 0 8.299546e-08
I2558 n1_m1_115200_297600 0 1.230056e-07
I2559 n1_m1_115200_302400 0 8.637673e-08
I2560 n1_m1_115200_307200 0 1.240731e-07
I2561 n1_m1_115200_312000 0 2.697202e-07
I2562 n1_m1_115200_316800 0 1.826194e-07
I2563 n1_m1_115200_321600 0 3.449006e-07
I2564 n1_m1_115200_326400 0 2.241726e-07
I2565 n1_m1_115200_331200 0 1.297036e-07
I2566 n1_m1_115200_336000 0 1.343664e-07
I2567 n1_m1_115200_340800 0 8.672291e-08
I2568 n1_m1_115200_345600 0 1.298912e-07
I2569 n1_m1_115200_350400 0 8.607850e-08
I2570 n1_m1_115200_355200 0 8.367618e-08
I2571 n1_m1_115200_360000 0 1.249143e-07
I2572 n1_m1_115200_364800 0 8.148086e-08
I2573 n1_m1_115200_369600 0 1.212326e-07
I2574 n1_m1_115200_374400 0 8.556042e-08
I2575 n1_m1_115200_379200 0 8.341999e-08
I2576 n1_m1_115200_384000 0 1.272888e-07
I2577 n1_m1_115200_388800 0 8.660722e-08
I2578 n1_m1_115200_393600 0 1.257270e-07
I2579 n1_m1_115200_398400 0 8.431295e-08
I2580 n1_m1_115200_403200 0 8.560846e-08
I2581 n1_m1_115200_408000 0 1.280492e-07
I2582 n1_m1_115200_412800 0 8.660722e-08
I2583 n1_m1_115200_417600 0 1.284058e-07
I2584 n1_m1_115200_422400 0 8.327618e-08
I2585 n1_m1_115200_427200 0 8.337472e-08
I2586 n1_m1_115200_432000 0 1.289376e-07
I2587 n1_m1_115200_436800 0 8.890545e-08
I2588 n1_m1_115200_441600 0 1.533490e-07
I2589 n1_m1_115200_446400 0 2.160646e-07
I2590 n1_m1_115200_451200 0 2.522607e-07
I2591 n1_m1_115200_456000 0 1.791386e-07
I2592 n1_m1_115200_460800 0 8.572923e-08
I2593 n1_m1_115200_465600 0 1.392496e-07
I2594 n1_m1_115200_470400 0 9.031753e-08
I2595 n1_m1_115200_475200 0 8.708234e-08
I2596 n1_m1_115200_480000 0 1.255530e-07
I2597 n1_m1_115200_484800 0 8.066825e-08
I2598 n1_m1_115200_489600 0 1.156778e-07
I2599 n1_m1_115200_494400 0 7.928293e-08
I2600 n1_m1_120000_0 0 1.518971e-07
I2601 n1_m1_120000_4800 0 1.511566e-07
I2602 n1_m1_120000_9600 0 2.208832e-07
I2603 n1_m1_120000_14400 0 1.507940e-07
I2604 n1_m1_120000_19200 0 1.529839e-07
I2605 n1_m1_120000_24000 0 2.307352e-07
I2606 n1_m1_120000_28800 0 1.580642e-07
I2607 n1_m1_120000_33600 0 2.307574e-07
I2608 n1_m1_120000_38400 0 1.546238e-07
I2609 n1_m1_120000_43200 0 1.549405e-07
I2610 n1_m1_120000_48000 0 2.342841e-07
I2611 n1_m1_120000_52800 0 1.626552e-07
I2612 n1_m1_120000_57600 0 2.506904e-07
I2613 n1_m1_120000_62400 0 1.757028e-07
I2614 n1_m1_120000_67200 0 1.637987e-07
I2615 n1_m1_120000_72000 0 2.418320e-07
I2616 n1_m1_120000_76800 0 1.592376e-07
I2617 n1_m1_120000_81600 0 2.429329e-07
I2618 n1_m1_120000_86400 0 1.622164e-07
I2619 n1_m1_120000_91200 0 1.603205e-07
I2620 n1_m1_120000_96000 0 2.435228e-07
I2621 n1_m1_120000_100800 0 1.664488e-07
I2622 n1_m1_120000_105600 0 2.507759e-07
I2623 n1_m1_120000_110400 0 1.655123e-07
I2624 n1_m1_120000_115200 0 1.615642e-07
I2625 n1_m1_120000_120000 0 2.421179e-07
I2626 n1_m1_120000_124800 0 1.664064e-07
I2627 n1_m1_120000_129600 0 2.506839e-07
I2628 n1_m1_120000_134400 0 1.633081e-07
I2629 n1_m1_120000_139200 0 1.629298e-07
I2630 n1_m1_120000_144000 0 2.503972e-07
I2631 n1_m1_120000_148800 0 1.713428e-07
I2632 n1_m1_120000_153600 0 2.562334e-07
I2633 n1_m1_120000_158400 0 1.675520e-07
I2634 n1_m1_120000_163200 0 1.665524e-07
I2635 n1_m1_120000_168000 0 2.545546e-07
I2636 n1_m1_120000_172800 0 1.672756e-07
I2637 n1_m1_120000_177600 0 3.095110e-07
I2638 n1_m1_120000_182400 0 4.474147e-07
I2639 n1_m1_120000_187200 0 6.827496e-07
I2640 n1_m1_120000_192000 0 7.973539e-07
I2641 n1_m1_120000_196800 0 3.256862e-07
I2642 n1_m1_120000_201600 0 3.694164e-07
I2643 n1_m1_120000_206400 0 1.842245e-07
I2644 n1_m1_120000_211200 0 1.764506e-07
I2645 n1_m1_120000_216000 0 3.125046e-07
I2646 n1_m1_120000_220800 0 2.003209e-07
I2647 n1_m1_120000_225600 0 2.792991e-07
I2648 n1_m1_120000_230400 0 1.779977e-07
I2649 n1_m1_120000_235200 0 1.810898e-07
I2650 n1_m1_120000_240000 0 2.519867e-07
I2651 n1_m1_120000_244800 0 2.296114e-07
I2652 n1_m1_120000_249600 0 6.334368e-07
I2653 n1_m1_120000_254400 0 8.952427e-07
I2654 n1_m1_120000_259200 0 1.158450e-06
I2655 n1_m1_120000_264000 0 1.904221e-06
I2656 n1_m1_120000_268800 0 1.359145e-06
I2657 n1_m1_120000_273600 0 1.690652e-06
I2658 n1_m1_120000_278400 0 5.633631e-07
I2659 n1_m1_120000_283200 0 2.766584e-07
I2660 n1_m1_120000_288000 0 3.083488e-07
I2661 n1_m1_120000_292800 0 1.818981e-07
I2662 n1_m1_120000_297600 0 2.491069e-07
I2663 n1_m1_120000_302400 0 1.669333e-07
I2664 n1_m1_120000_307200 0 1.841458e-07
I2665 n1_m1_120000_312000 0 4.483320e-07
I2666 n1_m1_120000_316800 0 3.439285e-07
I2667 n1_m1_120000_321600 0 7.896726e-07
I2668 n1_m1_120000_326400 0 5.595220e-07
I2669 n1_m1_120000_331200 0 3.408744e-07
I2670 n1_m1_120000_336000 0 2.856149e-07
I2671 n1_m1_120000_340800 0 1.715557e-07
I2672 n1_m1_120000_345600 0 2.518682e-07
I2673 n1_m1_120000_350400 0 1.664135e-07
I2674 n1_m1_120000_355200 0 1.661711e-07
I2675 n1_m1_120000_360000 0 2.494641e-07
I2676 n1_m1_120000_364800 0 1.665524e-07
I2677 n1_m1_120000_369600 0 2.463113e-07
I2678 n1_m1_120000_374400 0 1.765495e-07
I2679 n1_m1_120000_379200 0 1.726919e-07
I2680 n1_m1_120000_384000 0 2.540294e-07
I2681 n1_m1_120000_388800 0 1.819462e-07
I2682 n1_m1_120000_393600 0 2.703376e-07
I2683 n1_m1_120000_398400 0 1.749568e-07
I2684 n1_m1_120000_403200 0 1.825924e-07
I2685 n1_m1_120000_408000 0 2.803558e-07
I2686 n1_m1_120000_412800 0 1.847930e-07
I2687 n1_m1_120000_417600 0 2.609713e-07
I2688 n1_m1_120000_422400 0 1.694921e-07
I2689 n1_m1_120000_427200 0 1.708136e-07
I2690 n1_m1_120000_432000 0 2.524740e-07
I2691 n1_m1_120000_436800 0 1.690368e-07
I2692 n1_m1_120000_441600 0 2.650663e-07
I2693 n1_m1_120000_446400 0 1.732228e-07
I2694 n1_m1_120000_451200 0 1.795531e-07
I2695 n1_m1_120000_456000 0 2.607312e-07
I2696 n1_m1_120000_460800 0 1.710389e-07
I2697 n1_m1_120000_465600 0 2.631436e-07
I2698 n1_m1_120000_470400 0 1.676698e-07
I2699 n1_m1_120000_475200 0 1.669662e-07
I2700 n1_m1_120000_480000 0 2.413952e-07
I2701 n1_m1_120000_484800 0 1.686741e-07
I2702 n1_m1_120000_489600 0 2.497680e-07
I2703 n1_m1_120000_494400 0 1.622387e-07
I2704 n1_m1_124800_0 0 1.533502e-07
I2705 n1_m1_124800_4800 0 1.534669e-07
I2706 n1_m1_124800_9600 0 2.285365e-07
I2707 n1_m1_124800_14400 0 1.527486e-07
I2708 n1_m1_124800_19200 0 1.497533e-07
I2709 n1_m1_124800_24000 0 2.236207e-07
I2710 n1_m1_124800_28800 0 1.563491e-07
I2711 n1_m1_124800_33600 0 2.409108e-07
I2712 n1_m1_124800_38400 0 1.581779e-07
I2713 n1_m1_124800_43200 0 1.581936e-07
I2714 n1_m1_124800_48000 0 2.402207e-07
I2715 n1_m1_124800_52800 0 1.657845e-07
I2716 n1_m1_124800_57600 0 2.460987e-07
I2717 n1_m1_124800_62400 0 1.647077e-07
I2718 n1_m1_124800_67200 0 1.615309e-07
I2719 n1_m1_124800_72000 0 2.410131e-07
I2720 n1_m1_124800_76800 0 1.594265e-07
I2721 n1_m1_124800_81600 0 2.393936e-07
I2722 n1_m1_124800_86400 0 1.612616e-07
I2723 n1_m1_124800_91200 0 1.642344e-07
I2724 n1_m1_124800_96000 0 2.463986e-07
I2725 n1_m1_124800_100800 0 1.713909e-07
I2726 n1_m1_124800_105600 0 2.641424e-07
I2727 n1_m1_124800_110400 0 1.720966e-07
I2728 n1_m1_124800_115200 0 1.712145e-07
I2729 n1_m1_124800_120000 0 2.527538e-07
I2730 n1_m1_124800_124800 0 1.625229e-07
I2731 n1_m1_124800_129600 0 2.417731e-07
I2732 n1_m1_124800_134400 0 1.607801e-07
I2733 n1_m1_124800_139200 0 1.607342e-07
I2734 n1_m1_124800_144000 0 2.480575e-07
I2735 n1_m1_124800_148800 0 1.721860e-07
I2736 n1_m1_124800_153600 0 2.558070e-07
I2737 n1_m1_124800_158400 0 1.665524e-07
I2738 n1_m1_124800_163200 0 1.665524e-07
I2739 n1_m1_124800_168000 0 2.510101e-07
I2740 n1_m1_124800_172800 0 1.665735e-07
I2741 n1_m1_124800_177600 0 2.597057e-07
I2742 n1_m1_124800_182400 0 2.177949e-07
I2743 n1_m1_124800_187200 0 2.535220e-07
I2744 n1_m1_124800_192000 0 3.354295e-07
I2745 n1_m1_124800_196800 0 2.012107e-07
I2746 n1_m1_124800_201600 0 2.990342e-07
I2747 n1_m1_124800_206400 0 1.846131e-07
I2748 n1_m1_124800_211200 0 1.799723e-07
I2749 n1_m1_124800_216000 0 2.751698e-07
I2750 n1_m1_124800_220800 0 1.764719e-07
I2751 n1_m1_124800_225600 0 2.667808e-07
I2752 n1_m1_124800_230400 0 1.726951e-07
I2753 n1_m1_124800_235200 0 1.722796e-07
I2754 n1_m1_124800_240000 0 3.015347e-07
I2755 n1_m1_124800_244800 0 3.215005e-07
I2756 n1_m1_124800_249600 0 9.100437e-07
I2757 n1_m1_124800_254400 0 1.029992e-06
I2758 n1_m1_124800_259200 0 1.312614e-06
I2759 n1_m1_124800_264000 0 2.088930e-06
I2760 n1_m1_124800_268800 0 1.363911e-06
I2761 n1_m1_124800_273600 0 1.376315e-06
I2762 n1_m1_124800_278400 0 4.489961e-07
I2763 n1_m1_124800_283200 0 2.922693e-07
I2764 n1_m1_124800_288000 0 4.744326e-07
I2765 n1_m1_124800_292800 0 2.573794e-07
I2766 n1_m1_124800_297600 0 2.718656e-07
I2767 n1_m1_124800_302400 0 1.733539e-07
I2768 n1_m1_124800_307200 0 2.083400e-07
I2769 n1_m1_124800_312000 0 3.027684e-07
I2770 n1_m1_124800_316800 0 2.002007e-07
I2771 n1_m1_124800_321600 0 3.620883e-07
I2772 n1_m1_124800_326400 0 2.595804e-07
I2773 n1_m1_124800_331200 0 2.147900e-07
I2774 n1_m1_124800_336000 0 2.614265e-07
I2775 n1_m1_124800_340800 0 1.658613e-07
I2776 n1_m1_124800_345600 0 2.514270e-07
I2777 n1_m1_124800_350400 0 1.618284e-07
I2778 n1_m1_124800_355200 0 1.611892e-07
I2779 n1_m1_124800_360000 0 2.450436e-07
I2780 n1_m1_124800_364800 0 1.665524e-07
I2781 n1_m1_124800_369600 0 2.535533e-07
I2782 n1_m1_124800_374400 0 1.922786e-07
I2783 n1_m1_124800_379200 0 1.945470e-07
I2784 n1_m1_124800_384000 0 2.909177e-07
I2785 n1_m1_124800_388800 0 3.445454e-07
I2786 n1_m1_124800_393600 0 5.138252e-07
I2787 n1_m1_124800_398400 0 2.134865e-07
I2788 n1_m1_124800_403200 0 2.256015e-07
I2789 n1_m1_124800_408000 0 5.230953e-07
I2790 n1_m1_124800_412800 0 4.425059e-07
I2791 n1_m1_124800_417600 0 4.279728e-07
I2792 n1_m1_124800_422400 0 1.766753e-07
I2793 n1_m1_124800_427200 0 1.825648e-07
I2794 n1_m1_124800_432000 0 2.588185e-07
I2795 n1_m1_124800_436800 0 1.628998e-07
I2796 n1_m1_124800_441600 0 2.556353e-07
I2797 n1_m1_124800_446400 0 1.691614e-07
I2798 n1_m1_124800_451200 0 1.662310e-07
I2799 n1_m1_124800_456000 0 2.468177e-07
I2800 n1_m1_124800_460800 0 1.725114e-07
I2801 n1_m1_124800_465600 0 2.600489e-07
I2802 n1_m1_124800_470400 0 1.634088e-07
I2803 n1_m1_124800_475200 0 1.615322e-07
I2804 n1_m1_124800_480000 0 2.528011e-07
I2805 n1_m1_124800_484800 0 1.672293e-07
I2806 n1_m1_124800_489600 0 2.338379e-07
I2807 n1_m1_124800_494400 0 1.612193e-07
I2808 n1_m1_129600_0 0 2.321168e-07
I2809 n1_m1_129600_4800 0 2.377409e-07
I2810 n1_m1_129600_9600 0 3.545314e-07
I2811 n1_m1_129600_14400 0 2.309466e-07
I2812 n1_m1_129600_19200 0 2.252663e-07
I2813 n1_m1_129600_24000 0 3.419378e-07
I2814 n1_m1_129600_28800 0 2.324680e-07
I2815 n1_m1_129600_33600 0 3.473729e-07
I2816 n1_m1_129600_38400 0 2.353289e-07
I2817 n1_m1_129600_43200 0 2.367893e-07
I2818 n1_m1_129600_48000 0 3.616023e-07
I2819 n1_m1_129600_52800 0 2.491419e-07
I2820 n1_m1_129600_57600 0 3.862654e-07
I2821 n1_m1_129600_62400 0 2.627953e-07
I2822 n1_m1_129600_67200 0 2.628983e-07
I2823 n1_m1_129600_72000 0 3.863305e-07
I2824 n1_m1_129600_76800 0 2.451210e-07
I2825 n1_m1_129600_81600 0 3.617851e-07
I2826 n1_m1_129600_86400 0 2.509385e-07
I2827 n1_m1_129600_91200 0 2.645813e-07
I2828 n1_m1_129600_96000 0 4.663088e-07
I2829 n1_m1_129600_100800 0 3.039408e-07
I2830 n1_m1_129600_105600 0 4.237576e-07
I2831 n1_m1_129600_110400 0 2.686710e-07
I2832 n1_m1_129600_115200 0 2.686710e-07
I2833 n1_m1_129600_120000 0 4.079204e-07
I2834 n1_m1_129600_124800 0 2.534006e-07
I2835 n1_m1_129600_129600 0 3.638386e-07
I2836 n1_m1_129600_134400 0 2.425703e-07
I2837 n1_m1_129600_139200 0 2.429317e-07
I2838 n1_m1_129600_144000 0 3.700285e-07
I2839 n1_m1_129600_148800 0 2.522335e-07
I2840 n1_m1_129600_153600 0 3.829998e-07
I2841 n1_m1_129600_158400 0 2.498285e-07
I2842 n1_m1_129600_163200 0 2.498285e-07
I2843 n1_m1_129600_168000 0 3.747428e-07
I2844 n1_m1_129600_172800 0 2.498285e-07
I2845 n1_m1_129600_177600 0 3.756052e-07
I2846 n1_m1_129600_182400 0 2.512519e-07
I2847 n1_m1_129600_187200 0 2.597276e-07
I2848 n1_m1_129600_192000 0 3.968271e-07
I2849 n1_m1_129600_196800 0 2.724980e-07
I2850 n1_m1_129600_201600 0 4.157755e-07
I2851 n1_m1_129600_206400 0 2.764885e-07
I2852 n1_m1_129600_211200 0 2.732377e-07
I2853 n1_m1_129600_216000 0 4.065511e-07
I2854 n1_m1_129600_220800 0 2.752640e-07
I2855 n1_m1_129600_225600 0 4.035533e-07
I2856 n1_m1_129600_230400 0 2.555751e-07
I2857 n1_m1_129600_235200 0 2.819312e-07
I2858 n1_m1_129600_240000 0 8.018037e-07
I2859 n1_m1_129600_244800 0 9.940555e-07
I2860 n1_m1_129600_249600 0 2.614909e-06
I2861 n1_m1_129600_254400 0 1.927579e-06
I2862 n1_m1_129600_259200 0 1.895455e-06
I2863 n1_m1_129600_264000 0 2.495393e-06
I2864 n1_m1_129600_268800 0 1.295229e-06
I2865 n1_m1_129600_273600 0 1.565548e-06
I2866 n1_m1_129600_278400 0 7.367278e-07
I2867 n1_m1_129600_283200 0 4.730711e-07
I2868 n1_m1_129600_288000 0 6.577361e-07
I2869 n1_m1_129600_292800 0 3.865886e-07
I2870 n1_m1_129600_297600 0 4.608834e-07
I2871 n1_m1_129600_302400 0 2.682052e-07
I2872 n1_m1_129600_307200 0 2.679257e-07
I2873 n1_m1_129600_312000 0 3.903187e-07
I2874 n1_m1_129600_316800 0 2.503691e-07
I2875 n1_m1_129600_321600 0 3.798486e-07
I2876 n1_m1_129600_326400 0 2.599399e-07
I2877 n1_m1_129600_331200 0 2.612447e-07
I2878 n1_m1_129600_336000 0 3.755493e-07
I2879 n1_m1_129600_340800 0 2.424581e-07
I2880 n1_m1_129600_345600 0 3.622917e-07
I2881 n1_m1_129600_350400 0 2.424434e-07
I2882 n1_m1_129600_355200 0 2.438310e-07
I2883 n1_m1_129600_360000 0 3.753691e-07
I2884 n1_m1_129600_364800 0 2.498285e-07
I2885 n1_m1_129600_369600 0 4.100927e-07
I2886 n1_m1_129600_374400 0 3.864428e-07
I2887 n1_m1_129600_379200 0 2.797573e-07
I2888 n1_m1_129600_384000 0 4.483197e-07
I2889 n1_m1_129600_388800 0 1.091309e-06
I2890 n1_m1_129600_393600 0 2.232192e-06
I2891 n1_m1_129600_398400 0 7.743317e-07
I2892 n1_m1_129600_403200 0 2.905323e-07
I2893 n1_m1_129600_408000 0 1.411199e-06
I2894 n1_m1_129600_412800 0 1.652147e-06
I2895 n1_m1_129600_417600 0 1.579523e-06
I2896 n1_m1_129600_422400 0 3.825222e-07
I2897 n1_m1_129600_427200 0 2.874065e-07
I2898 n1_m1_129600_432000 0 3.835368e-07
I2899 n1_m1_129600_436800 0 2.412016e-07
I2900 n1_m1_129600_441600 0 3.658152e-07
I2901 n1_m1_129600_446400 0 2.473810e-07
I2902 n1_m1_129600_451200 0 2.448471e-07
I2903 n1_m1_129600_456000 0 3.670149e-07
I2904 n1_m1_129600_460800 0 2.552779e-07
I2905 n1_m1_129600_465600 0 3.871650e-07
I2906 n1_m1_129600_470400 0 2.525348e-07
I2907 n1_m1_129600_475200 0 2.534828e-07
I2908 n1_m1_129600_480000 0 3.773531e-07
I2909 n1_m1_129600_484800 0 2.403432e-07
I2910 n1_m1_129600_489600 0 3.496075e-07
I2911 n1_m1_129600_494400 0 2.385551e-07
I2912 n1_m1_134400_0 0 1.571967e-07
I2913 n1_m1_134400_4800 0 1.599551e-07
I2914 n1_m1_134400_9600 0 2.441069e-07
I2915 n1_m1_134400_14400 0 1.588468e-07
I2916 n1_m1_134400_19200 0 1.543197e-07
I2917 n1_m1_134400_24000 0 2.313071e-07
I2918 n1_m1_134400_28800 0 1.595987e-07
I2919 n1_m1_134400_33600 0 2.435523e-07
I2920 n1_m1_134400_38400 0 1.731567e-07
I2921 n1_m1_134400_43200 0 1.729844e-07
I2922 n1_m1_134400_48000 0 2.442914e-07
I2923 n1_m1_134400_52800 0 1.619103e-07
I2924 n1_m1_134400_57600 0 2.616372e-07
I2925 n1_m1_134400_62400 0 1.799083e-07
I2926 n1_m1_134400_67200 0 1.796826e-07
I2927 n1_m1_134400_72000 0 2.596552e-07
I2928 n1_m1_134400_76800 0 1.645382e-07
I2929 n1_m1_134400_81600 0 2.454182e-07
I2930 n1_m1_134400_86400 0 1.764684e-07
I2931 n1_m1_134400_91200 0 2.072964e-07
I2932 n1_m1_134400_96000 0 4.501540e-07
I2933 n1_m1_134400_100800 0 2.651861e-07
I2934 n1_m1_134400_105600 0 2.976215e-07
I2935 n1_m1_134400_110400 0 1.768398e-07
I2936 n1_m1_134400_115200 0 1.758824e-07
I2937 n1_m1_134400_120000 0 2.655270e-07
I2938 n1_m1_134400_124800 0 1.691366e-07
I2939 n1_m1_134400_129600 0 2.469791e-07
I2940 n1_m1_134400_134400 0 1.598903e-07
I2941 n1_m1_134400_139200 0 1.598903e-07
I2942 n1_m1_134400_144000 0 2.465777e-07
I2943 n1_m1_134400_148800 0 1.671165e-07
I2944 n1_m1_134400_153600 0 2.527878e-07
I2945 n1_m1_134400_158400 0 1.665524e-07
I2946 n1_m1_134400_163200 0 1.665524e-07
I2947 n1_m1_134400_168000 0 2.498285e-07
I2948 n1_m1_134400_172800 0 1.665524e-07
I2949 n1_m1_134400_177600 0 2.498285e-07
I2950 n1_m1_134400_182400 0 1.667196e-07
I2951 n1_m1_134400_187200 0 1.717630e-07
I2952 n1_m1_134400_192000 0 2.598217e-07
I2953 n1_m1_134400_196800 0 1.732144e-07
I2954 n1_m1_134400_201600 0 2.634455e-07
I2955 n1_m1_134400_206400 0 1.798251e-07
I2956 n1_m1_134400_211200 0 1.830178e-07
I2957 n1_m1_134400_216000 0 3.246705e-07
I2958 n1_m1_134400_220800 0 2.804320e-07
I2959 n1_m1_134400_225600 0 3.653762e-07
I2960 n1_m1_134400_230400 0 1.877195e-07
I2961 n1_m1_134400_235200 0 2.438604e-07
I2962 n1_m1_134400_240000 0 9.298540e-07
I2963 n1_m1_134400_244800 0 1.065434e-06
I2964 n1_m1_134400_249600 0 1.888577e-06
I2965 n1_m1_134400_254400 0 1.040272e-06
I2966 n1_m1_134400_259200 0 8.826772e-07
I2967 n1_m1_134400_264000 0 1.586979e-06
I2968 n1_m1_134400_268800 0 1.035305e-06
I2969 n1_m1_134400_273600 0 1.310441e-06
I2970 n1_m1_134400_278400 0 4.466694e-07
I2971 n1_m1_134400_283200 0 3.154170e-07
I2972 n1_m1_134400_288000 0 5.608458e-07
I2973 n1_m1_134400_292800 0 3.372126e-07
I2974 n1_m1_134400_297600 0 3.383326e-07
I2975 n1_m1_134400_302400 0 1.739167e-07
I2976 n1_m1_134400_307200 0 1.758417e-07
I2977 n1_m1_134400_312000 0 2.672059e-07
I2978 n1_m1_134400_316800 0 1.710606e-07
I2979 n1_m1_134400_321600 0 2.493947e-07
I2980 n1_m1_134400_326400 0 1.667597e-07
I2981 n1_m1_134400_331200 0 1.716393e-07
I2982 n1_m1_134400_336000 0 2.562410e-07
I2983 n1_m1_134400_340800 0 1.687112e-07
I2984 n1_m1_134400_345600 0 2.450661e-07
I2985 n1_m1_134400_350400 0 1.682953e-07
I2986 n1_m1_134400_355200 0 1.674091e-07
I2987 n1_m1_134400_360000 0 2.528824e-07
I2988 n1_m1_134400_364800 0 1.665524e-07
I2989 n1_m1_134400_369600 0 2.576142e-07
I2990 n1_m1_134400_374400 0 2.110661e-07
I2991 n1_m1_134400_379200 0 3.613392e-07
I2992 n1_m1_134400_384000 0 6.355006e-07
I2993 n1_m1_134400_388800 0 6.604588e-07
I2994 n1_m1_134400_393600 0 1.189508e-06
I2995 n1_m1_134400_398400 0 4.650209e-07
I2996 n1_m1_134400_403200 0 2.876683e-07
I2997 n1_m1_134400_408000 0 1.392434e-06
I2998 n1_m1_134400_412800 0 1.364331e-06
I2999 n1_m1_134400_417600 0 1.471727e-06
I3000 n1_m1_134400_422400 0 4.313010e-07
I3001 n1_m1_134400_427200 0 2.532328e-07
I3002 n1_m1_134400_432000 0 2.495726e-07
I3003 n1_m1_134400_436800 0 1.621465e-07
I3004 n1_m1_134400_441600 0 2.400641e-07
I3005 n1_m1_134400_446400 0 1.598903e-07
I3006 n1_m1_134400_451200 0 1.643985e-07
I3007 n1_m1_134400_456000 0 2.543499e-07
I3008 n1_m1_134400_460800 0 1.731962e-07
I3009 n1_m1_134400_465600 0 2.663314e-07
I3010 n1_m1_134400_470400 0 2.260459e-07
I3011 n1_m1_134400_475200 0 2.491231e-07
I3012 n1_m1_134400_480000 0 2.788935e-07
I3013 n1_m1_134400_484800 0 1.663077e-07
I3014 n1_m1_134400_489600 0 2.454271e-07
I3015 n1_m1_134400_494400 0 1.584146e-07
I3016 n1_m1_139200_0 0 1.574949e-07
I3017 n1_m1_139200_4800 0 1.605405e-07
I3018 n1_m1_139200_9600 0 2.492065e-07
I3019 n1_m1_139200_14400 0 1.624722e-07
I3020 n1_m1_139200_19200 0 1.556228e-07
I3021 n1_m1_139200_24000 0 2.305982e-07
I3022 n1_m1_139200_28800 0 1.596538e-07
I3023 n1_m1_139200_33600 0 2.645459e-07
I3024 n1_m1_139200_38400 0 1.879888e-07
I3025 n1_m1_139200_43200 0 1.815417e-07
I3026 n1_m1_139200_48000 0 2.449157e-07
I3027 n1_m1_139200_52800 0 1.570614e-07
I3028 n1_m1_139200_57600 0 2.507511e-07
I3029 n1_m1_139200_62400 0 1.669282e-07
I3030 n1_m1_139200_67200 0 1.639672e-07
I3031 n1_m1_139200_72000 0 2.450194e-07
I3032 n1_m1_139200_76800 0 1.614436e-07
I3033 n1_m1_139200_81600 0 2.487602e-07
I3034 n1_m1_139200_86400 0 1.784544e-07
I3035 n1_m1_139200_91200 0 2.038113e-07
I3036 n1_m1_139200_96000 0 3.831882e-07
I3037 n1_m1_139200_100800 0 2.346095e-07
I3038 n1_m1_139200_105600 0 2.837438e-07
I3039 n1_m1_139200_110400 0 1.722887e-07
I3040 n1_m1_139200_115200 0 1.678901e-07
I3041 n1_m1_139200_120000 0 2.478798e-07
I3042 n1_m1_139200_124800 0 1.665921e-07
I3043 n1_m1_139200_129600 0 2.483580e-07
I3044 n1_m1_139200_134400 0 1.616447e-07
I3045 n1_m1_139200_139200 0 1.598903e-07
I3046 n1_m1_139200_144000 0 2.437713e-07
I3047 n1_m1_139200_148800 0 1.662254e-07
I3048 n1_m1_139200_153600 0 2.498285e-07
I3049 n1_m1_139200_158400 0 1.665524e-07
I3050 n1_m1_139200_163200 0 1.665524e-07
I3051 n1_m1_139200_168000 0 2.498285e-07
I3052 n1_m1_139200_172800 0 1.665524e-07
I3053 n1_m1_139200_177600 0 2.498285e-07
I3054 n1_m1_139200_182400 0 1.667196e-07
I3055 n1_m1_139200_187200 0 1.717630e-07
I3056 n1_m1_139200_192000 0 2.598217e-07
I3057 n1_m1_139200_196800 0 1.732144e-07
I3058 n1_m1_139200_201600 0 2.601496e-07
I3059 n1_m1_139200_206400 0 1.761451e-07
I3060 n1_m1_139200_211200 0 1.766525e-07
I3061 n1_m1_139200_216000 0 3.504026e-07
I3062 n1_m1_139200_220800 0 3.426036e-07
I3063 n1_m1_139200_225600 0 4.276248e-07
I3064 n1_m1_139200_230400 0 1.952092e-07
I3065 n1_m1_139200_235200 0 2.716657e-07
I3066 n1_m1_139200_240000 0 1.133802e-06
I3067 n1_m1_139200_244800 0 1.231645e-06
I3068 n1_m1_139200_249600 0 1.760187e-06
I3069 n1_m1_139200_254400 0 6.590689e-07
I3070 n1_m1_139200_259200 0 5.382665e-07
I3071 n1_m1_139200_264000 0 1.649575e-06
I3072 n1_m1_139200_268800 0 1.370836e-06
I3073 n1_m1_139200_273600 0 1.894101e-06
I3074 n1_m1_139200_278400 0 6.557296e-07
I3075 n1_m1_139200_283200 0 3.030148e-07
I3076 n1_m1_139200_288000 0 5.915720e-07
I3077 n1_m1_139200_292800 0 3.439448e-07
I3078 n1_m1_139200_297600 0 3.016595e-07
I3079 n1_m1_139200_302400 0 1.645779e-07
I3080 n1_m1_139200_307200 0 1.810404e-07
I3081 n1_m1_139200_312000 0 2.793191e-07
I3082 n1_m1_139200_316800 0 1.783113e-07
I3083 n1_m1_139200_321600 0 2.547381e-07
I3084 n1_m1_139200_326400 0 1.666594e-07
I3085 n1_m1_139200_331200 0 1.694077e-07
I3086 n1_m1_139200_336000 0 2.616856e-07
I3087 n1_m1_139200_340800 0 1.744987e-07
I3088 n1_m1_139200_345600 0 2.528541e-07
I3089 n1_m1_139200_350400 0 1.691909e-07
I3090 n1_m1_139200_355200 0 1.645954e-07
I3091 n1_m1_139200_360000 0 2.494628e-07
I3092 n1_m1_139200_364800 0 1.683974e-07
I3093 n1_m1_139200_369600 0 2.997567e-07
I3094 n1_m1_139200_374400 0 3.801487e-07
I3095 n1_m1_139200_379200 0 4.900449e-07
I3096 n1_m1_139200_384000 0 6.788425e-07
I3097 n1_m1_139200_388800 0 5.121086e-07
I3098 n1_m1_139200_393600 0 8.922364e-07
I3099 n1_m1_139200_398400 0 5.188557e-07
I3100 n1_m1_139200_403200 0 5.844968e-07
I3101 n1_m1_139200_408000 0 1.663620e-06
I3102 n1_m1_139200_412800 0 1.362038e-06
I3103 n1_m1_139200_417600 0 1.253462e-06
I3104 n1_m1_139200_422400 0 3.277567e-07
I3105 n1_m1_139200_427200 0 2.225332e-07
I3106 n1_m1_139200_432000 0 2.575195e-07
I3107 n1_m1_139200_436800 0 1.683877e-07
I3108 n1_m1_139200_441600 0 2.405798e-07
I3109 n1_m1_139200_446400 0 1.598903e-07
I3110 n1_m1_139200_451200 0 1.665803e-07
I3111 n1_m1_139200_456000 0 2.634583e-07
I3112 n1_m1_139200_460800 0 1.788338e-07
I3113 n1_m1_139200_465600 0 2.614782e-07
I3114 n1_m1_139200_470400 0 2.271455e-07
I3115 n1_m1_139200_475200 0 2.609573e-07
I3116 n1_m1_139200_480000 0 2.824852e-07
I3117 n1_m1_139200_484800 0 1.679814e-07
I3118 n1_m1_139200_489600 0 2.472667e-07
I3119 n1_m1_139200_494400 0 1.534288e-07
I3120 n1_m1_144000_0 0 2.314676e-07
I3121 n1_m1_144000_4800 0 2.393137e-07
I3122 n1_m1_144000_9600 0 3.729461e-07
I3123 n1_m1_144000_14400 0 2.437082e-07
I3124 n1_m1_144000_19200 0 2.334342e-07
I3125 n1_m1_144000_24000 0 3.438685e-07
I3126 n1_m1_144000_28800 0 2.334585e-07
I3127 n1_m1_144000_33600 0 3.771965e-07
I3128 n1_m1_144000_38400 0 2.643565e-07
I3129 n1_m1_144000_43200 0 2.564905e-07
I3130 n1_m1_144000_48000 0 3.529774e-07
I3131 n1_m1_144000_52800 0 2.332769e-07
I3132 n1_m1_144000_57600 0 3.618544e-07
I3133 n1_m1_144000_62400 0 2.400961e-07
I3134 n1_m1_144000_67200 0 2.383424e-07
I3135 n1_m1_144000_72000 0 3.615656e-07
I3136 n1_m1_144000_76800 0 2.402615e-07
I3137 n1_m1_144000_81600 0 3.638166e-07
I3138 n1_m1_144000_86400 0 2.484212e-07
I3139 n1_m1_144000_91200 0 2.567882e-07
I3140 n1_m1_144000_96000 0 3.794965e-07
I3141 n1_m1_144000_100800 0 2.569958e-07
I3142 n1_m1_144000_105600 0 3.899558e-07
I3143 n1_m1_144000_110400 0 2.524167e-07
I3144 n1_m1_144000_115200 0 2.500441e-07
I3145 n1_m1_144000_120000 0 3.806847e-07
I3146 n1_m1_144000_124800 0 2.563623e-07
I3147 n1_m1_144000_129600 0 3.759004e-07
I3148 n1_m1_144000_134400 0 2.452734e-07
I3149 n1_m1_144000_139200 0 2.398354e-07
I3150 n1_m1_144000_144000 0 3.660824e-07
I3151 n1_m1_144000_148800 0 2.487025e-07
I3152 n1_m1_144000_153600 0 3.746604e-07
I3153 n1_m1_144000_158400 0 2.498285e-07
I3154 n1_m1_144000_163200 0 2.498285e-07
I3155 n1_m1_144000_168000 0 3.747428e-07
I3156 n1_m1_144000_172800 0 2.498285e-07
I3157 n1_m1_144000_177600 0 3.747428e-07
I3158 n1_m1_144000_182400 0 2.500557e-07
I3159 n1_m1_144000_187200 0 2.569068e-07
I3160 n1_m1_144000_192000 0 3.886606e-07
I3161 n1_m1_144000_196800 0 2.575509e-07
I3162 n1_m1_144000_201600 0 3.872345e-07
I3163 n1_m1_144000_206400 0 2.607648e-07
I3164 n1_m1_144000_211200 0 2.606483e-07
I3165 n1_m1_144000_216000 0 4.472714e-07
I3166 n1_m1_144000_220800 0 3.834785e-07
I3167 n1_m1_144000_225600 0 5.082511e-07
I3168 n1_m1_144000_230400 0 2.641925e-07
I3169 n1_m1_144000_235200 0 2.867684e-07
I3170 n1_m1_144000_240000 0 7.744281e-07
I3171 n1_m1_144000_244800 0 8.821368e-07
I3172 n1_m1_144000_249600 0 1.818561e-06
I3173 n1_m1_144000_254400 0 1.060026e-06
I3174 n1_m1_144000_259200 0 1.451902e-06
I3175 n1_m1_144000_264000 0 2.878094e-06
I3176 n1_m1_144000_268800 0 2.062749e-06
I3177 n1_m1_144000_273600 0 2.959014e-06
I3178 n1_m1_144000_278400 0 1.172507e-06
I3179 n1_m1_144000_283200 0 4.314266e-07
I3180 n1_m1_144000_288000 0 5.385034e-07
I3181 n1_m1_144000_292800 0 3.146367e-07
I3182 n1_m1_144000_297600 0 3.925733e-07
I3183 n1_m1_144000_302400 0 2.459371e-07
I3184 n1_m1_144000_307200 0 2.503643e-07
I3185 n1_m1_144000_312000 0 3.942613e-07
I3186 n1_m1_144000_316800 0 2.625303e-07
I3187 n1_m1_144000_321600 0 3.842255e-07
I3188 n1_m1_144000_326400 0 2.507455e-07
I3189 n1_m1_144000_331200 0 2.451232e-07
I3190 n1_m1_144000_336000 0 3.776349e-07
I3191 n1_m1_144000_340800 0 2.531435e-07
I3192 n1_m1_144000_345600 0 3.783207e-07
I3193 n1_m1_144000_350400 0 2.507476e-07
I3194 n1_m1_144000_355200 0 2.475335e-07
I3195 n1_m1_144000_360000 0 3.743740e-07
I3196 n1_m1_144000_364800 0 2.660437e-07
I3197 n1_m1_144000_369600 0 6.596819e-07
I3198 n1_m1_144000_374400 0 9.775875e-07
I3199 n1_m1_144000_379200 0 6.241051e-07
I3200 n1_m1_144000_384000 0 8.118039e-07
I3201 n1_m1_144000_388800 0 1.318203e-06
I3202 n1_m1_144000_393600 0 2.597352e-06
I3203 n1_m1_144000_398400 0 1.759153e-06
I3204 n1_m1_144000_403200 0 1.757997e-06
I3205 n1_m1_144000_408000 0 2.810572e-06
I3206 n1_m1_144000_412800 0 1.668327e-06
I3207 n1_m1_144000_417600 0 1.058254e-06
I3208 n1_m1_144000_422400 0 2.727127e-07
I3209 n1_m1_144000_427200 0 2.566131e-07
I3210 n1_m1_144000_432000 0 3.879550e-07
I3211 n1_m1_144000_436800 0 2.573127e-07
I3212 n1_m1_144000_441600 0 3.671946e-07
I3213 n1_m1_144000_446400 0 2.445399e-07
I3214 n1_m1_144000_451200 0 2.549018e-07
I3215 n1_m1_144000_456000 0 4.045644e-07
I3216 n1_m1_144000_460800 0 2.902290e-07
I3217 n1_m1_144000_465600 0 4.183537e-07
I3218 n1_m1_144000_470400 0 2.585278e-07
I3219 n1_m1_144000_475200 0 2.659159e-07
I3220 n1_m1_144000_480000 0 3.761368e-07
I3221 n1_m1_144000_484800 0 2.498285e-07
I3222 n1_m1_144000_489600 0 3.698316e-07
I3223 n1_m1_144000_494400 0 2.338307e-07
I3224 n1_m1_148800_0 0 1.489540e-07
I3225 n1_m1_148800_4800 0 1.541847e-07
I3226 n1_m1_148800_9600 0 2.431190e-07
I3227 n1_m1_148800_14400 0 1.614354e-07
I3228 n1_m1_148800_19200 0 1.552501e-07
I3229 n1_m1_148800_24000 0 2.239343e-07
I3230 n1_m1_148800_28800 0 1.527202e-07
I3231 n1_m1_148800_33600 0 2.321191e-07
I3232 n1_m1_148800_38400 0 1.550812e-07
I3233 n1_m1_148800_43200 0 1.547202e-07
I3234 n1_m1_148800_48000 0 2.314634e-07
I3235 n1_m1_148800_52800 0 1.541279e-07
I3236 n1_m1_148800_57600 0 2.362892e-07
I3237 n1_m1_148800_62400 0 1.605093e-07
I3238 n1_m1_148800_67200 0 1.657445e-07
I3239 n1_m1_148800_72000 0 2.544694e-07
I3240 n1_m1_148800_76800 0 1.642001e-07
I3241 n1_m1_148800_81600 0 2.416497e-07
I3242 n1_m1_148800_86400 0 1.600889e-07
I3243 n1_m1_148800_91200 0 1.608106e-07
I3244 n1_m1_148800_96000 0 2.428882e-07
I3245 n1_m1_148800_100800 0 1.624481e-07
I3246 n1_m1_148800_105600 0 2.494921e-07
I3247 n1_m1_148800_110400 0 1.682714e-07
I3248 n1_m1_148800_115200 0 1.747530e-07
I3249 n1_m1_148800_120000 0 2.915964e-07
I3250 n1_m1_148800_124800 0 1.793361e-07
I3251 n1_m1_148800_129600 0 2.519060e-07
I3252 n1_m1_148800_134400 0 1.635156e-07
I3253 n1_m1_148800_139200 0 1.598903e-07
I3254 n1_m1_148800_144000 0 2.405191e-07
I3255 n1_m1_148800_148800 0 1.613361e-07
I3256 n1_m1_148800_153600 0 2.484593e-07
I3257 n1_m1_148800_158400 0 1.665524e-07
I3258 n1_m1_148800_163200 0 1.665524e-07
I3259 n1_m1_148800_168000 0 2.498285e-07
I3260 n1_m1_148800_172800 0 1.665524e-07
I3261 n1_m1_148800_177600 0 2.498285e-07
I3262 n1_m1_148800_182400 0 1.665693e-07
I3263 n1_m1_148800_187200 0 1.671213e-07
I3264 n1_m1_148800_192000 0 2.539847e-07
I3265 n1_m1_148800_196800 0 1.733559e-07
I3266 n1_m1_148800_201600 0 2.664905e-07
I3267 n1_m1_148800_206400 0 1.802377e-07
I3268 n1_m1_148800_211200 0 1.794984e-07
I3269 n1_m1_148800_216000 0 2.614229e-07
I3270 n1_m1_148800_220800 0 1.769022e-07
I3271 n1_m1_148800_225600 0 2.718271e-07
I3272 n1_m1_148800_230400 0 1.823817e-07
I3273 n1_m1_148800_235200 0 1.836826e-07
I3274 n1_m1_148800_240000 0 3.104961e-07
I3275 n1_m1_148800_244800 0 2.648302e-07
I3276 n1_m1_148800_249600 0 5.644199e-07
I3277 n1_m1_148800_254400 0 7.829954e-07
I3278 n1_m1_148800_259200 0 1.324324e-06
I3279 n1_m1_148800_264000 0 1.946996e-06
I3280 n1_m1_148800_268800 0 1.132321e-06
I3281 n1_m1_148800_273600 0 1.179823e-06
I3282 n1_m1_148800_278400 0 4.110842e-07
I3283 n1_m1_148800_283200 0 2.665117e-07
I3284 n1_m1_148800_288000 0 2.631108e-07
I3285 n1_m1_148800_292800 0 1.627741e-07
I3286 n1_m1_148800_297600 0 2.533960e-07
I3287 n1_m1_148800_302400 0 1.732975e-07
I3288 n1_m1_148800_307200 0 1.822060e-07
I3289 n1_m1_148800_312000 0 2.581138e-07
I3290 n1_m1_148800_316800 0 1.751310e-07
I3291 n1_m1_148800_321600 0 2.712764e-07
I3292 n1_m1_148800_326400 0 1.747685e-07
I3293 n1_m1_148800_331200 0 1.636371e-07
I3294 n1_m1_148800_336000 0 2.418810e-07
I3295 n1_m1_148800_340800 0 1.638190e-07
I3296 n1_m1_148800_345600 0 2.586218e-07
I3297 n1_m1_148800_350400 0 1.746915e-07
I3298 n1_m1_148800_355200 0 1.692529e-07
I3299 n1_m1_148800_360000 0 2.500638e-07
I3300 n1_m1_148800_364800 0 1.737642e-07
I3301 n1_m1_148800_369600 0 4.188491e-07
I3302 n1_m1_148800_374400 0 7.245330e-07
I3303 n1_m1_148800_379200 0 9.007228e-07
I3304 n1_m1_148800_384000 0 1.574760e-06
I3305 n1_m1_148800_388800 0 1.284079e-06
I3306 n1_m1_148800_393600 0 2.130537e-06
I3307 n1_m1_148800_398400 0 1.450831e-06
I3308 n1_m1_148800_403200 0 1.416898e-06
I3309 n1_m1_148800_408000 0 1.736079e-06
I3310 n1_m1_148800_412800 0 4.759112e-07
I3311 n1_m1_148800_417600 0 3.122606e-07
I3312 n1_m1_148800_422400 0 2.041945e-07
I3313 n1_m1_148800_427200 0 1.967123e-07
I3314 n1_m1_148800_432000 0 2.496928e-07
I3315 n1_m1_148800_436800 0 1.659947e-07
I3316 n1_m1_148800_441600 0 2.493821e-07
I3317 n1_m1_148800_446400 0 1.663150e-07
I3318 n1_m1_148800_451200 0 1.670095e-07
I3319 n1_m1_148800_456000 0 2.632168e-07
I3320 n1_m1_148800_460800 0 2.042797e-07
I3321 n1_m1_148800_465600 0 4.189281e-07
I3322 n1_m1_148800_470400 0 2.190373e-07
I3323 n1_m1_148800_475200 0 1.717031e-07
I3324 n1_m1_148800_480000 0 2.478502e-07
I3325 n1_m1_148800_484800 0 1.650846e-07
I3326 n1_m1_148800_489600 0 2.473276e-07
I3327 n1_m1_148800_494400 0 1.686931e-07
I3328 n1_m1_153600_0 0 2.263908e-07
I3329 n1_m1_153600_4800 0 2.342368e-07
I3330 n1_m1_153600_9600 0 3.651198e-07
I3331 n1_m1_153600_14400 0 2.382702e-07
I3332 n1_m1_153600_19200 0 2.314795e-07
I3333 n1_m1_153600_24000 0 3.378559e-07
I3334 n1_m1_153600_28800 0 2.269351e-07
I3335 n1_m1_153600_33600 0 3.487545e-07
I3336 n1_m1_153600_38400 0 2.298422e-07
I3337 n1_m1_153600_43200 0 2.300224e-07
I3338 n1_m1_153600_48000 0 3.517793e-07
I3339 n1_m1_153600_52800 0 2.332164e-07
I3340 n1_m1_153600_57600 0 3.538334e-07
I3341 n1_m1_153600_62400 0 2.412797e-07
I3342 n1_m1_153600_67200 0 2.530265e-07
I3343 n1_m1_153600_72000 0 3.941355e-07
I3344 n1_m1_153600_76800 0 2.607158e-07
I3345 n1_m1_153600_81600 0 3.769128e-07
I3346 n1_m1_153600_86400 0 2.449313e-07
I3347 n1_m1_153600_91200 0 2.505590e-07
I3348 n1_m1_153600_96000 0 3.988083e-07
I3349 n1_m1_153600_100800 0 2.677291e-07
I3350 n1_m1_153600_105600 0 3.790378e-07
I3351 n1_m1_153600_110400 0 2.549798e-07
I3352 n1_m1_153600_115200 0 2.864113e-07
I3353 n1_m1_153600_120000 0 5.220930e-07
I3354 n1_m1_153600_124800 0 2.742829e-07
I3355 n1_m1_153600_129600 0 3.815116e-07
I3356 n1_m1_153600_134400 0 2.680593e-07
I3357 n1_m1_153600_139200 0 2.602119e-07
I3358 n1_m1_153600_144000 0 3.628167e-07
I3359 n1_m1_153600_148800 0 2.470665e-07
I3360 n1_m1_153600_153600 0 3.733683e-07
I3361 n1_m1_153600_158400 0 2.523098e-07
I3362 n1_m1_153600_163200 0 2.563946e-07
I3363 n1_m1_153600_168000 0 3.895584e-07
I3364 n1_m1_153600_172800 0 2.539373e-07
I3365 n1_m1_153600_177600 0 3.807026e-07
I3366 n1_m1_153600_182400 0 2.537020e-07
I3367 n1_m1_153600_187200 0 2.509071e-07
I3368 n1_m1_153600_192000 0 3.848911e-07
I3369 n1_m1_153600_196800 0 2.752588e-07
I3370 n1_m1_153600_201600 0 4.339389e-07
I3371 n1_m1_153600_206400 0 3.106365e-07
I3372 n1_m1_153600_211200 0 2.916627e-07
I3373 n1_m1_153600_216000 0 3.977789e-07
I3374 n1_m1_153600_220800 0 2.573398e-07
I3375 n1_m1_153600_225600 0 3.938732e-07
I3376 n1_m1_153600_230400 0 2.671040e-07
I3377 n1_m1_153600_235200 0 2.626276e-07
I3378 n1_m1_153600_240000 0 4.170735e-07
I3379 n1_m1_153600_244800 0 2.978780e-07
I3380 n1_m1_153600_249600 0 7.325695e-07
I3381 n1_m1_153600_254400 0 1.069384e-06
I3382 n1_m1_153600_259200 0 1.548417e-06
I3383 n1_m1_153600_264000 0 1.500601e-06
I3384 n1_m1_153600_268800 0 5.752190e-07
I3385 n1_m1_153600_273600 0 5.772804e-07
I3386 n1_m1_153600_278400 0 3.116330e-07
I3387 n1_m1_153600_283200 0 3.161108e-07
I3388 n1_m1_153600_288000 0 4.020089e-07
I3389 n1_m1_153600_292800 0 2.506413e-07
I3390 n1_m1_153600_297600 0 3.806862e-07
I3391 n1_m1_153600_302400 0 2.647683e-07
I3392 n1_m1_153600_307200 0 3.325566e-07
I3393 n1_m1_153600_312000 0 4.111440e-07
I3394 n1_m1_153600_316800 0 2.609155e-07
I3395 n1_m1_153600_321600 0 4.148132e-07
I3396 n1_m1_153600_326400 0 2.642741e-07
I3397 n1_m1_153600_331200 0 2.486658e-07
I3398 n1_m1_153600_336000 0 3.688520e-07
I3399 n1_m1_153600_340800 0 2.529976e-07
I3400 n1_m1_153600_345600 0 4.009192e-07
I3401 n1_m1_153600_350400 0 2.740430e-07
I3402 n1_m1_153600_355200 0 2.642155e-07
I3403 n1_m1_153600_360000 0 3.764275e-07
I3404 n1_m1_153600_364800 0 2.504946e-07
I3405 n1_m1_153600_369600 0 4.066036e-07
I3406 n1_m1_153600_374400 0 5.052649e-07
I3407 n1_m1_153600_379200 0 1.326672e-06
I3408 n1_m1_153600_384000 0 3.058059e-06
I3409 n1_m1_153600_388800 0 2.083578e-06
I3410 n1_m1_153600_393600 0 3.133857e-06
I3411 n1_m1_153600_398400 0 2.114515e-06
I3412 n1_m1_153600_403200 0 1.983510e-06
I3413 n1_m1_153600_408000 0 1.827618e-06
I3414 n1_m1_153600_412800 0 3.630177e-07
I3415 n1_m1_153600_417600 0 3.898773e-07
I3416 n1_m1_153600_422400 0 2.648858e-07
I3417 n1_m1_153600_427200 0 2.619639e-07
I3418 n1_m1_153600_432000 0 3.869452e-07
I3419 n1_m1_153600_436800 0 2.501953e-07
I3420 n1_m1_153600_441600 0 4.567169e-07
I3421 n1_m1_153600_446400 0 4.259328e-07
I3422 n1_m1_153600_451200 0 3.260928e-07
I3423 n1_m1_153600_456000 0 3.867943e-07
I3424 n1_m1_153600_460800 0 3.038298e-07
I3425 n1_m1_153600_465600 0 7.901422e-07
I3426 n1_m1_153600_470400 0 4.096954e-07
I3427 n1_m1_153600_475200 0 2.688286e-07
I3428 n1_m1_153600_480000 0 3.608909e-07
I3429 n1_m1_153600_484800 0 2.358353e-07
I3430 n1_m1_153600_489600 0 3.532730e-07
I3431 n1_m1_153600_494400 0 2.405403e-07
I3432 n1_m1_158400_0 0 1.549405e-07
I3433 n1_m1_158400_4800 0 1.601712e-07
I3434 n1_m1_158400_9600 0 2.492065e-07
I3435 n1_m1_158400_14400 0 1.624722e-07
I3436 n1_m1_158400_19200 0 1.556228e-07
I3437 n1_m1_158400_24000 0 2.298422e-07
I3438 n1_m1_158400_28800 0 1.532282e-07
I3439 n1_m1_158400_33600 0 2.298422e-07
I3440 n1_m1_158400_38400 0 1.532282e-07
I3441 n1_m1_158400_43200 0 1.532282e-07
I3442 n1_m1_158400_48000 0 2.298422e-07
I3443 n1_m1_158400_52800 0 1.532282e-07
I3444 n1_m1_158400_57600 0 2.355172e-07
I3445 n1_m1_158400_62400 0 1.573166e-07
I3446 n1_m1_158400_67200 0 1.648860e-07
I3447 n1_m1_158400_72000 0 2.622159e-07
I3448 n1_m1_158400_76800 0 1.697832e-07
I3449 n1_m1_158400_81600 0 2.446478e-07
I3450 n1_m1_158400_86400 0 1.628616e-07
I3451 n1_m1_158400_91200 0 1.660998e-07
I3452 n1_m1_158400_96000 0 2.662363e-07
I3453 n1_m1_158400_100800 0 1.830865e-07
I3454 n1_m1_158400_105600 0 2.590558e-07
I3455 n1_m1_158400_110400 0 1.752572e-07
I3456 n1_m1_158400_115200 0 2.025608e-07
I3457 n1_m1_158400_120000 0 3.495897e-07
I3458 n1_m1_158400_124800 0 2.320585e-07
I3459 n1_m1_158400_129600 0 2.651808e-07
I3460 n1_m1_158400_134400 0 1.755983e-07
I3461 n1_m1_158400_139200 0 1.747333e-07
I3462 n1_m1_158400_144000 0 2.966775e-07
I3463 n1_m1_158400_148800 0 2.195541e-07
I3464 n1_m1_158400_153600 0 2.575402e-07
I3465 n1_m1_158400_158400 0 1.707128e-07
I3466 n1_m1_158400_163200 0 1.775622e-07
I3467 n1_m1_158400_168000 0 2.706984e-07
I3468 n1_m1_158400_172800 0 1.723725e-07
I3469 n1_m1_158400_177600 0 2.567306e-07
I3470 n1_m1_158400_182400 0 1.744048e-07
I3471 n1_m1_158400_187200 0 2.085141e-07
I3472 n1_m1_158400_192000 0 2.719439e-07
I3473 n1_m1_158400_196800 0 1.815934e-07
I3474 n1_m1_158400_201600 0 2.802240e-07
I3475 n1_m1_158400_206400 0 2.150083e-07
I3476 n1_m1_158400_211200 0 2.494663e-07
I3477 n1_m1_158400_216000 0 3.297716e-07
I3478 n1_m1_158400_220800 0 1.694821e-07
I3479 n1_m1_158400_225600 0 2.609992e-07
I3480 n1_m1_158400_230400 0 1.809873e-07
I3481 n1_m1_158400_235200 0 1.949146e-07
I3482 n1_m1_158400_240000 0 4.375374e-07
I3483 n1_m1_158400_244800 0 2.888821e-07
I3484 n1_m1_158400_249600 0 4.348251e-07
I3485 n1_m1_158400_254400 0 4.795436e-07
I3486 n1_m1_158400_259200 0 4.798595e-07
I3487 n1_m1_158400_264000 0 3.780804e-07
I3488 n1_m1_158400_268800 0 1.683507e-07
I3489 n1_m1_158400_273600 0 2.498285e-07
I3490 n1_m1_158400_278400 0 1.665524e-07
I3491 n1_m1_158400_283200 0 1.706794e-07
I3492 n1_m1_158400_288000 0 2.546284e-07
I3493 n1_m1_158400_292800 0 1.640238e-07
I3494 n1_m1_158400_297600 0 2.555705e-07
I3495 n1_m1_158400_302400 0 1.732144e-07
I3496 n1_m1_158400_307200 0 1.848536e-07
I3497 n1_m1_158400_312000 0 2.532578e-07
I3498 n1_m1_158400_316800 0 1.671218e-07
I3499 n1_m1_158400_321600 0 2.534673e-07
I3500 n1_m1_158400_326400 0 1.638190e-07
I3501 n1_m1_158400_331200 0 1.604202e-07
I3502 n1_m1_158400_336000 0 2.448386e-07
I3503 n1_m1_158400_340800 0 1.688463e-07
I3504 n1_m1_158400_345600 0 2.502170e-07
I3505 n1_m1_158400_350400 0 1.726255e-07
I3506 n1_m1_158400_355200 0 1.723516e-07
I3507 n1_m1_158400_360000 0 2.505844e-07
I3508 n1_m1_158400_364800 0 1.665524e-07
I3509 n1_m1_158400_369600 0 2.594828e-07
I3510 n1_m1_158400_374400 0 2.403910e-07
I3511 n1_m1_158400_379200 0 6.495377e-07
I3512 n1_m1_158400_384000 0 2.020506e-06
I3513 n1_m1_158400_388800 0 1.086672e-06
I3514 n1_m1_158400_393600 0 1.180917e-06
I3515 n1_m1_158400_398400 0 9.306709e-07
I3516 n1_m1_158400_403200 0 1.023820e-06
I3517 n1_m1_158400_408000 0 7.451778e-07
I3518 n1_m1_158400_412800 0 1.952952e-07
I3519 n1_m1_158400_417600 0 2.607046e-07
I3520 n1_m1_158400_422400 0 1.798765e-07
I3521 n1_m1_158400_427200 0 1.807193e-07
I3522 n1_m1_158400_432000 0 3.010378e-07
I3523 n1_m1_158400_436800 0 1.800232e-07
I3524 n1_m1_158400_441600 0 3.521390e-07
I3525 n1_m1_158400_446400 0 4.008933e-07
I3526 n1_m1_158400_451200 0 2.742540e-07
I3527 n1_m1_158400_456000 0 2.518485e-07
I3528 n1_m1_158400_460800 0 1.788825e-07
I3529 n1_m1_158400_465600 0 3.115666e-07
I3530 n1_m1_158400_470400 0 1.811394e-07
I3531 n1_m1_158400_475200 0 1.646648e-07
I3532 n1_m1_158400_480000 0 2.393456e-07
I3533 n1_m1_158400_484800 0 1.584285e-07
I3534 n1_m1_158400_489600 0 2.391197e-07
I3535 n1_m1_158400_494400 0 1.549405e-07
I3536 n1_m1_163200_0 0 1.538230e-07
I3537 n1_m1_163200_4800 0 1.562905e-07
I3538 n1_m1_163200_9600 0 2.426848e-07
I3539 n1_m1_163200_14400 0 1.581244e-07
I3540 n1_m1_163200_19200 0 1.540600e-07
I3541 n1_m1_163200_24000 0 2.298422e-07
I3542 n1_m1_163200_28800 0 1.532282e-07
I3543 n1_m1_163200_33600 0 2.298422e-07
I3544 n1_m1_163200_38400 0 1.532282e-07
I3545 n1_m1_163200_43200 0 1.532282e-07
I3546 n1_m1_163200_48000 0 2.298422e-07
I3547 n1_m1_163200_52800 0 1.532282e-07
I3548 n1_m1_163200_57600 0 2.352937e-07
I3549 n1_m1_163200_62400 0 1.544909e-07
I3550 n1_m1_163200_67200 0 1.562740e-07
I3551 n1_m1_163200_72000 0 2.456519e-07
I3552 n1_m1_163200_76800 0 1.595981e-07
I3553 n1_m1_163200_81600 0 2.340689e-07
I3554 n1_m1_163200_86400 0 1.595891e-07
I3555 n1_m1_163200_91200 0 1.603573e-07
I3556 n1_m1_163200_96000 0 2.523887e-07
I3557 n1_m1_163200_100800 0 1.755288e-07
I3558 n1_m1_163200_105600 0 2.604142e-07
I3559 n1_m1_163200_110400 0 1.757920e-07
I3560 n1_m1_163200_115200 0 1.872097e-07
I3561 n1_m1_163200_120000 0 2.909356e-07
I3562 n1_m1_163200_124800 0 2.054027e-07
I3563 n1_m1_163200_129600 0 2.683159e-07
I3564 n1_m1_163200_134400 0 1.772813e-07
I3565 n1_m1_163200_139200 0 1.762972e-07
I3566 n1_m1_163200_144000 0 3.295480e-07
I3567 n1_m1_163200_148800 0 2.353089e-07
I3568 n1_m1_163200_153600 0 2.596313e-07
I3569 n1_m1_163200_158400 0 1.723454e-07
I3570 n1_m1_163200_163200 0 1.747248e-07
I3571 n1_m1_163200_168000 0 2.627704e-07
I3572 n1_m1_163200_172800 0 1.716553e-07
I3573 n1_m1_163200_177600 0 2.515936e-07
I3574 n1_m1_163200_182400 0 1.697820e-07
I3575 n1_m1_163200_187200 0 1.962220e-07
I3576 n1_m1_163200_192000 0 2.685268e-07
I3577 n1_m1_163200_196800 0 1.732144e-07
I3578 n1_m1_163200_201600 0 2.644824e-07
I3579 n1_m1_163200_206400 0 1.889296e-07
I3580 n1_m1_163200_211200 0 2.276481e-07
I3581 n1_m1_163200_216000 0 3.212553e-07
I3582 n1_m1_163200_220800 0 1.713940e-07
I3583 n1_m1_163200_225600 0 2.527633e-07
I3584 n1_m1_163200_230400 0 1.727196e-07
I3585 n1_m1_163200_235200 0 2.197910e-07
I3586 n1_m1_163200_240000 0 6.073350e-07
I3587 n1_m1_163200_244800 0 3.216660e-07
I3588 n1_m1_163200_249600 0 3.513833e-07
I3589 n1_m1_163200_254400 0 2.540195e-07
I3590 n1_m1_163200_259200 0 2.367938e-07
I3591 n1_m1_163200_264000 0 2.760182e-07
I3592 n1_m1_163200_268800 0 1.741304e-07
I3593 n1_m1_163200_273600 0 2.551585e-07
I3594 n1_m1_163200_278400 0 1.645182e-07
I3595 n1_m1_163200_283200 0 1.688132e-07
I3596 n1_m1_163200_288000 0 2.595982e-07
I3597 n1_m1_163200_292800 0 1.647655e-07
I3598 n1_m1_163200_297600 0 2.475257e-07
I3599 n1_m1_163200_302400 0 1.716342e-07
I3600 n1_m1_163200_307200 0 1.703247e-07
I3601 n1_m1_163200_312000 0 2.441383e-07
I3602 n1_m1_163200_316800 0 1.664788e-07
I3603 n1_m1_163200_321600 0 2.497148e-07
I3604 n1_m1_163200_326400 0 1.613952e-07
I3605 n1_m1_163200_331200 0 1.600867e-07
I3606 n1_m1_163200_336000 0 2.488677e-07
I3607 n1_m1_163200_340800 0 1.678366e-07
I3608 n1_m1_163200_345600 0 2.462773e-07
I3609 n1_m1_163200_350400 0 1.685391e-07
I3610 n1_m1_163200_355200 0 1.685669e-07
I3611 n1_m1_163200_360000 0 2.500911e-07
I3612 n1_m1_163200_364800 0 1.690405e-07
I3613 n1_m1_163200_369600 0 2.644887e-07
I3614 n1_m1_163200_374400 0 2.500648e-07
I3615 n1_m1_163200_379200 0 6.896818e-07
I3616 n1_m1_163200_384000 0 1.979104e-06
I3617 n1_m1_163200_388800 0 9.842460e-07
I3618 n1_m1_163200_393600 0 5.910870e-07
I3619 n1_m1_163200_398400 0 4.152692e-07
I3620 n1_m1_163200_403200 0 5.899657e-07
I3621 n1_m1_163200_408000 0 4.716423e-07
I3622 n1_m1_163200_412800 0 1.811892e-07
I3623 n1_m1_163200_417600 0 2.581640e-07
I3624 n1_m1_163200_422400 0 1.711810e-07
I3625 n1_m1_163200_427200 0 1.745656e-07
I3626 n1_m1_163200_432000 0 3.109439e-07
I3627 n1_m1_163200_436800 0 1.854530e-07
I3628 n1_m1_163200_441600 0 2.842640e-07
I3629 n1_m1_163200_446400 0 2.890441e-07
I3630 n1_m1_163200_451200 0 2.368219e-07
I3631 n1_m1_163200_456000 0 2.596607e-07
I3632 n1_m1_163200_460800 0 1.660501e-07
I3633 n1_m1_163200_465600 0 2.466246e-07
I3634 n1_m1_163200_470400 0 1.592357e-07
I3635 n1_m1_163200_475200 0 1.562415e-07
I3636 n1_m1_163200_480000 0 2.406866e-07
I3637 n1_m1_163200_484800 0 1.642380e-07
I3638 n1_m1_163200_489600 0 2.420051e-07
I3639 n1_m1_163200_494400 0 1.581708e-07
I3640 n1_m1_168000_0 0 2.239980e-07
I3641 n1_m1_168000_4800 0 2.304922e-07
I3642 n1_m1_168000_9600 0 3.588200e-07
I3643 n1_m1_168000_14400 0 2.337151e-07
I3644 n1_m1_168000_19200 0 2.298422e-07
I3645 n1_m1_168000_24000 0 3.355705e-07
I3646 n1_m1_168000_28800 0 2.238163e-07
I3647 n1_m1_168000_33600 0 3.446923e-07
I3648 n1_m1_168000_38400 0 2.298422e-07
I3649 n1_m1_168000_43200 0 2.298422e-07
I3650 n1_m1_168000_48000 0 3.447634e-07
I3651 n1_m1_168000_52800 0 2.298422e-07
I3652 n1_m1_168000_57600 0 3.536434e-07
I3653 n1_m1_168000_62400 0 2.378794e-07
I3654 n1_m1_168000_67200 0 2.366632e-07
I3655 n1_m1_168000_72000 0 3.539204e-07
I3656 n1_m1_168000_76800 0 2.308033e-07
I3657 n1_m1_168000_81600 0 3.478575e-07
I3658 n1_m1_168000_86400 0 2.407242e-07
I3659 n1_m1_168000_91200 0 2.459834e-07
I3660 n1_m1_168000_96000 0 3.685471e-07
I3661 n1_m1_168000_100800 0 2.504506e-07
I3662 n1_m1_168000_105600 0 3.756759e-07
I3663 n1_m1_168000_110400 0 2.528880e-07
I3664 n1_m1_168000_115200 0 2.605582e-07
I3665 n1_m1_168000_120000 0 4.333803e-07
I3666 n1_m1_168000_124800 0 6.829266e-07
I3667 n1_m1_168000_129600 0 9.174763e-07
I3668 n1_m1_168000_134400 0 6.232689e-07
I3669 n1_m1_168000_139200 0 5.892807e-07
I3670 n1_m1_168000_144000 0 6.893868e-07
I3671 n1_m1_168000_148800 0 3.766748e-07
I3672 n1_m1_168000_153600 0 4.176572e-07
I3673 n1_m1_168000_158400 0 2.613267e-07
I3674 n1_m1_168000_163200 0 2.593623e-07
I3675 n1_m1_168000_168000 0 3.799643e-07
I3676 n1_m1_168000_172800 0 2.495576e-07
I3677 n1_m1_168000_177600 0 3.677868e-07
I3678 n1_m1_168000_182400 0 2.496240e-07
I3679 n1_m1_168000_187200 0 2.544987e-07
I3680 n1_m1_168000_192000 0 3.888695e-07
I3681 n1_m1_168000_196800 0 2.592324e-07
I3682 n1_m1_168000_201600 0 5.226650e-07
I3683 n1_m1_168000_206400 0 3.098956e-07
I3684 n1_m1_168000_211200 0 3.006638e-07
I3685 n1_m1_168000_216000 0 4.444533e-07
I3686 n1_m1_168000_220800 0 2.758861e-07
I3687 n1_m1_168000_225600 0 3.915138e-07
I3688 n1_m1_168000_230400 0 2.648283e-07
I3689 n1_m1_168000_235200 0 4.266387e-07
I3690 n1_m1_168000_240000 0 1.375084e-06
I3691 n1_m1_168000_244800 0 6.567427e-07
I3692 n1_m1_168000_249600 0 4.643503e-07
I3693 n1_m1_168000_254400 0 2.568544e-07
I3694 n1_m1_168000_259200 0 2.654636e-07
I3695 n1_m1_168000_264000 0 4.381529e-07
I3696 n1_m1_168000_268800 0 2.783844e-07
I3697 n1_m1_168000_273600 0 3.953519e-07
I3698 n1_m1_168000_278400 0 2.665574e-07
I3699 n1_m1_168000_283200 0 2.721985e-07
I3700 n1_m1_168000_288000 0 3.922232e-07
I3701 n1_m1_168000_292800 0 2.510143e-07
I3702 n1_m1_168000_297600 0 3.761282e-07
I3703 n1_m1_168000_302400 0 2.586376e-07
I3704 n1_m1_168000_307200 0 2.526750e-07
I3705 n1_m1_168000_312000 0 3.745234e-07
I3706 n1_m1_168000_316800 0 2.572140e-07
I3707 n1_m1_168000_321600 0 3.733920e-07
I3708 n1_m1_168000_326400 0 2.405607e-07
I3709 n1_m1_168000_331200 0 2.461312e-07
I3710 n1_m1_168000_336000 0 3.745557e-07
I3711 n1_m1_168000_340800 0 2.461661e-07
I3712 n1_m1_168000_345600 0 3.625326e-07
I3713 n1_m1_168000_350400 0 2.487150e-07
I3714 n1_m1_168000_355200 0 2.500235e-07
I3715 n1_m1_168000_360000 0 3.802911e-07
I3716 n1_m1_168000_364800 0 2.589119e-07
I3717 n1_m1_168000_369600 0 4.311841e-07
I3718 n1_m1_168000_374400 0 5.077601e-07
I3719 n1_m1_168000_379200 0 1.073474e-06
I3720 n1_m1_168000_384000 0 3.014906e-06
I3721 n1_m1_168000_388800 0 1.973494e-06
I3722 n1_m1_168000_393600 0 1.561473e-06
I3723 n1_m1_168000_398400 0 3.467803e-07
I3724 n1_m1_168000_403200 0 4.188084e-07
I3725 n1_m1_168000_408000 0 4.541299e-07
I3726 n1_m1_168000_412800 0 2.686049e-07
I3727 n1_m1_168000_417600 0 3.904669e-07
I3728 n1_m1_168000_422400 0 2.620887e-07
I3729 n1_m1_168000_427200 0 2.733547e-07
I3730 n1_m1_168000_432000 0 4.608355e-07
I3731 n1_m1_168000_436800 0 2.734368e-07
I3732 n1_m1_168000_441600 0 3.810701e-07
I3733 n1_m1_168000_446400 0 3.081084e-07
I3734 n1_m1_168000_451200 0 2.961814e-07
I3735 n1_m1_168000_456000 0 3.948653e-07
I3736 n1_m1_168000_460800 0 2.532046e-07
I3737 n1_m1_168000_465600 0 3.597040e-07
I3738 n1_m1_168000_470400 0 2.381760e-07
I3739 n1_m1_168000_475200 0 2.381430e-07
I3740 n1_m1_168000_480000 0 3.684913e-07
I3741 n1_m1_168000_484800 0 2.450539e-07
I3742 n1_m1_168000_489600 0 3.594157e-07
I3743 n1_m1_168000_494400 0 2.351093e-07
I3744 n1_m1_172800_0 0 7.413921e-08
I3745 n1_m1_172800_4800 0 7.675455e-08
I3746 n1_m1_172800_9600 0 1.196067e-07
I3747 n1_m1_172800_14400 0 7.790503e-08
I3748 n1_m1_172800_19200 0 7.661408e-08
I3749 n1_m1_172800_24000 0 1.128965e-07
I3750 n1_m1_172800_28800 0 7.528694e-08
I3751 n1_m1_172800_33600 0 1.149055e-07
I3752 n1_m1_172800_38400 0 7.661408e-08
I3753 n1_m1_172800_43200 0 7.661408e-08
I3754 n1_m1_172800_48000 0 1.149211e-07
I3755 n1_m1_172800_52800 0 7.661408e-08
I3756 n1_m1_172800_57600 0 1.178016e-07
I3757 n1_m1_172800_62400 0 7.841291e-08
I3758 n1_m1_172800_67200 0 7.685585e-08
I3759 n1_m1_172800_72000 0 1.149211e-07
I3760 n1_m1_172800_76800 0 7.749044e-08
I3761 n1_m1_172800_81600 0 1.191837e-07
I3762 n1_m1_172800_86400 0 8.027039e-08
I3763 n1_m1_172800_91200 0 8.222711e-08
I3764 n1_m1_172800_96000 0 1.237853e-07
I3765 n1_m1_172800_100800 0 7.994513e-08
I3766 n1_m1_172800_105600 0 1.199177e-07
I3767 n1_m1_172800_110400 0 7.994513e-08
I3768 n1_m1_172800_115200 0 8.204543e-08
I3769 n1_m1_172800_120000 0 1.663190e-07
I3770 n1_m1_172800_124800 0 4.064919e-07
I3771 n1_m1_172800_129600 0 3.633242e-07
I3772 n1_m1_172800_134400 0 1.452113e-07
I3773 n1_m1_172800_139200 0 1.669828e-07
I3774 n1_m1_172800_144000 0 2.262367e-07
I3775 n1_m1_172800_148800 0 1.264128e-07
I3776 n1_m1_172800_153600 0 1.554568e-07
I3777 n1_m1_172800_158400 0 9.113885e-08
I3778 n1_m1_172800_163200 0 8.663380e-08
I3779 n1_m1_172800_168000 0 1.254247e-07
I3780 n1_m1_172800_172800 0 8.286047e-08
I3781 n1_m1_172800_177600 0 1.223223e-07
I3782 n1_m1_172800_182400 0 8.181038e-08
I3783 n1_m1_172800_187200 0 8.665833e-08
I3784 n1_m1_172800_192000 0 1.304887e-07
I3785 n1_m1_172800_196800 0 9.510657e-08
I3786 n1_m1_172800_201600 0 3.832424e-07
I3787 n1_m1_172800_206400 0 2.438987e-07
I3788 n1_m1_172800_211200 0 1.891342e-07
I3789 n1_m1_172800_216000 0 2.162224e-07
I3790 n1_m1_172800_220800 0 1.050792e-07
I3791 n1_m1_172800_225600 0 1.364172e-07
I3792 n1_m1_172800_230400 0 9.427675e-08
I3793 n1_m1_172800_235200 0 1.585044e-07
I3794 n1_m1_172800_240000 0 4.731498e-07
I3795 n1_m1_172800_244800 0 2.389296e-07
I3796 n1_m1_172800_249600 0 1.653517e-07
I3797 n1_m1_172800_254400 0 8.884788e-08
I3798 n1_m1_172800_259200 0 8.778508e-08
I3799 n1_m1_172800_264000 0 1.321257e-07
I3800 n1_m1_172800_268800 0 8.402246e-08
I3801 n1_m1_172800_273600 0 1.292153e-07
I3802 n1_m1_172800_278400 0 1.011521e-07
I3803 n1_m1_172800_283200 0 1.020951e-07
I3804 n1_m1_172800_288000 0 1.314961e-07
I3805 n1_m1_172800_292800 0 8.714568e-08
I3806 n1_m1_172800_297600 0 1.336638e-07
I3807 n1_m1_172800_302400 0 8.613411e-08
I3808 n1_m1_172800_307200 0 8.381226e-08
I3809 n1_m1_172800_312000 0 1.237800e-07
I3810 n1_m1_172800_316800 0 8.415242e-08
I3811 n1_m1_172800_321600 0 1.211944e-07
I3812 n1_m1_172800_326400 0 8.009856e-08
I3813 n1_m1_172800_331200 0 8.383047e-08
I3814 n1_m1_172800_336000 0 1.254611e-07
I3815 n1_m1_172800_340800 0 8.059036e-08
I3816 n1_m1_172800_345600 0 1.211639e-07
I3817 n1_m1_172800_350400 0 8.280461e-08
I3818 n1_m1_172800_355200 0 8.370761e-08
I3819 n1_m1_172800_360000 0 1.295329e-07
I3820 n1_m1_172800_364800 0 8.660722e-08
I3821 n1_m1_172800_369600 0 1.442436e-07
I3822 n1_m1_172800_374400 0 2.204294e-07
I3823 n1_m1_172800_379200 0 5.461356e-07
I3824 n1_m1_172800_384000 0 1.041751e-06
I3825 n1_m1_172800_388800 0 7.166507e-07
I3826 n1_m1_172800_393600 0 7.451707e-07
I3827 n1_m1_172800_398400 0 1.557948e-07
I3828 n1_m1_172800_403200 0 8.773764e-08
I3829 n1_m1_172800_408000 0 1.320178e-07
I3830 n1_m1_172800_412800 0 8.647400e-08
I3831 n1_m1_172800_417600 0 1.285508e-07
I3832 n1_m1_172800_422400 0 9.236832e-08
I3833 n1_m1_172800_427200 0 1.020550e-07
I3834 n1_m1_172800_432000 0 1.488922e-07
I3835 n1_m1_172800_436800 0 1.072452e-07
I3836 n1_m1_172800_441600 0 1.417485e-07
I3837 n1_m1_172800_446400 0 9.650634e-08
I3838 n1_m1_172800_451200 0 8.875613e-08
I3839 n1_m1_172800_456000 0 1.263476e-07
I3840 n1_m1_172800_460800 0 8.491227e-08
I3841 n1_m1_172800_465600 0 1.199177e-07
I3842 n1_m1_172800_470400 0 7.994513e-08
I3843 n1_m1_172800_475200 0 7.986327e-08
I3844 n1_m1_172800_480000 0 1.178263e-07
I3845 n1_m1_172800_484800 0 7.762639e-08
I3846 n1_m1_172800_489600 0 1.180649e-07
I3847 n1_m1_172800_494400 0 7.994513e-08
I3848 n1_m1_177600_0 0 2.274409e-07
I3849 n1_m1_177600_4800 0 2.352870e-07
I3850 n1_m1_177600_9600 0 3.663550e-07
I3851 n1_m1_177600_14400 0 2.387384e-07
I3852 n1_m1_177600_19200 0 2.316478e-07
I3853 n1_m1_177600_24000 0 3.447399e-07
I3854 n1_m1_177600_28800 0 2.298269e-07
I3855 n1_m1_177600_33600 0 3.447632e-07
I3856 n1_m1_177600_38400 0 2.298422e-07
I3857 n1_m1_177600_43200 0 2.298422e-07
I3858 n1_m1_177600_48000 0 3.447634e-07
I3859 n1_m1_177600_52800 0 2.298422e-07
I3860 n1_m1_177600_57600 0 3.529489e-07
I3861 n1_m1_177600_62400 0 2.314545e-07
I3862 n1_m1_177600_67200 0 2.299273e-07
I3863 n1_m1_177600_72000 0 3.475874e-07
I3864 n1_m1_177600_76800 0 2.432336e-07
I3865 n1_m1_177600_81600 0 3.741500e-07
I3866 n1_m1_177600_86400 0 2.443460e-07
I3867 n1_m1_177600_91200 0 2.442009e-07
I3868 n1_m1_177600_96000 0 3.750759e-07
I3869 n1_m1_177600_100800 0 2.398881e-07
I3870 n1_m1_177600_105600 0 3.662039e-07
I3871 n1_m1_177600_110400 0 2.435423e-07
I3872 n1_m1_177600_115200 0 2.461867e-07
I3873 n1_m1_177600_120000 0 4.727087e-07
I3874 n1_m1_177600_124800 0 6.492782e-07
I3875 n1_m1_177600_129600 0 6.525100e-07
I3876 n1_m1_177600_134400 0 3.677634e-07
I3877 n1_m1_177600_139200 0 3.491621e-07
I3878 n1_m1_177600_144000 0 4.672804e-07
I3879 n1_m1_177600_148800 0 3.536998e-07
I3880 n1_m1_177600_153600 0 4.932455e-07
I3881 n1_m1_177600_158400 0 2.938020e-07
I3882 n1_m1_177600_163200 0 2.650507e-07
I3883 n1_m1_177600_168000 0 3.778567e-07
I3884 n1_m1_177600_172800 0 2.498225e-07
I3885 n1_m1_177600_177600 0 3.746591e-07
I3886 n1_m1_177600_182400 0 2.465853e-07
I3887 n1_m1_177600_187200 0 2.601453e-07
I3888 n1_m1_177600_192000 0 4.086213e-07
I3889 n1_m1_177600_196800 0 3.927840e-07
I3890 n1_m1_177600_201600 0 1.812951e-06
I3891 n1_m1_177600_206400 0 1.278054e-06
I3892 n1_m1_177600_211200 0 8.360538e-07
I3893 n1_m1_177600_216000 0 7.189118e-07
I3894 n1_m1_177600_220800 0 3.135771e-07
I3895 n1_m1_177600_225600 0 3.912656e-07
I3896 n1_m1_177600_230400 0 2.479729e-07
I3897 n1_m1_177600_235200 0 2.910240e-07
I3898 n1_m1_177600_240000 0 6.841468e-07
I3899 n1_m1_177600_244800 0 3.604793e-07
I3900 n1_m1_177600_249600 0 4.244074e-07
I3901 n1_m1_177600_254400 0 2.666857e-07
I3902 n1_m1_177600_259200 0 2.582440e-07
I3903 n1_m1_177600_264000 0 4.259062e-07
I3904 n1_m1_177600_268800 0 4.218245e-07
I3905 n1_m1_177600_273600 0 6.333996e-07
I3906 n1_m1_177600_278400 0 3.774397e-07
I3907 n1_m1_177600_283200 0 4.675908e-07
I3908 n1_m1_177600_288000 0 7.979326e-07
I3909 n1_m1_177600_292800 0 3.334115e-07
I3910 n1_m1_177600_297600 0 3.907130e-07
I3911 n1_m1_177600_302400 0 2.630606e-07
I3912 n1_m1_177600_307200 0 2.515433e-07
I3913 n1_m1_177600_312000 0 3.636386e-07
I3914 n1_m1_177600_316800 0 2.473709e-07
I3915 n1_m1_177600_321600 0 3.600207e-07
I3916 n1_m1_177600_326400 0 2.455190e-07
I3917 n1_m1_177600_331200 0 2.864727e-07
I3918 n1_m1_177600_336000 0 4.420076e-07
I3919 n1_m1_177600_340800 0 2.526258e-07
I3920 n1_m1_177600_345600 0 3.734595e-07
I3921 n1_m1_177600_350400 0 2.491250e-07
I3922 n1_m1_177600_355200 0 2.511228e-07
I3923 n1_m1_177600_360000 0 3.885987e-07
I3924 n1_m1_177600_364800 0 2.597796e-07
I3925 n1_m1_177600_369600 0 4.071423e-07
I3926 n1_m1_177600_374400 0 6.351371e-07
I3927 n1_m1_177600_379200 0 1.829359e-06
I3928 n1_m1_177600_384000 0 3.111468e-06
I3929 n1_m1_177600_388800 0 2.116397e-06
I3930 n1_m1_177600_393600 0 2.308244e-06
I3931 n1_m1_177600_398400 0 6.346122e-07
I3932 n1_m1_177600_403200 0 2.680969e-07
I3933 n1_m1_177600_408000 0 4.090306e-07
I3934 n1_m1_177600_412800 0 3.030164e-07
I3935 n1_m1_177600_417600 0 4.399633e-07
I3936 n1_m1_177600_422400 0 3.549419e-07
I3937 n1_m1_177600_427200 0 4.088542e-07
I3938 n1_m1_177600_432000 0 5.281325e-07
I3939 n1_m1_177600_436800 0 4.414638e-07
I3940 n1_m1_177600_441600 0 4.833745e-07
I3941 n1_m1_177600_446400 0 2.866501e-07
I3942 n1_m1_177600_451200 0 2.560938e-07
I3943 n1_m1_177600_456000 0 3.709836e-07
I3944 n1_m1_177600_460800 0 2.548198e-07
I3945 n1_m1_177600_465600 0 3.599848e-07
I3946 n1_m1_177600_470400 0 2.441699e-07
I3947 n1_m1_177600_475200 0 2.493413e-07
I3948 n1_m1_177600_480000 0 3.674686e-07
I3949 n1_m1_177600_484800 0 2.379722e-07
I3950 n1_m1_177600_489600 0 3.569602e-07
I3951 n1_m1_177600_494400 0 2.397618e-07
I3952 n1_m1_182400_0 0 1.548975e-07
I3953 n1_m1_182400_4800 0 1.600219e-07
I3954 n1_m1_182400_9600 0 2.489556e-07
I3955 n1_m1_182400_14400 0 1.624073e-07
I3956 n1_m1_182400_19200 0 1.557299e-07
I3957 n1_m1_182400_24000 0 2.298977e-07
I3958 n1_m1_182400_28800 0 1.532282e-07
I3959 n1_m1_182400_33600 0 2.298422e-07
I3960 n1_m1_182400_38400 0 1.532282e-07
I3961 n1_m1_182400_43200 0 1.532282e-07
I3962 n1_m1_182400_48000 0 2.298422e-07
I3963 n1_m1_182400_52800 0 1.532282e-07
I3964 n1_m1_182400_57600 0 2.355991e-07
I3965 n1_m1_182400_62400 0 1.584153e-07
I3966 n1_m1_182400_67200 0 1.587790e-07
I3967 n1_m1_182400_72000 0 2.478519e-07
I3968 n1_m1_182400_76800 0 1.774284e-07
I3969 n1_m1_182400_81600 0 2.731266e-07
I3970 n1_m1_182400_86400 0 1.712345e-07
I3971 n1_m1_182400_91200 0 1.659987e-07
I3972 n1_m1_182400_96000 0 2.464814e-07
I3973 n1_m1_182400_100800 0 1.636058e-07
I3974 n1_m1_182400_105600 0 2.617477e-07
I3975 n1_m1_182400_110400 0 1.732136e-07
I3976 n1_m1_182400_115200 0 1.677091e-07
I3977 n1_m1_182400_120000 0 3.231688e-07
I3978 n1_m1_182400_124800 0 6.755164e-07
I3979 n1_m1_182400_129600 0 1.055573e-06
I3980 n1_m1_182400_134400 0 5.459899e-07
I3981 n1_m1_182400_139200 0 4.334301e-07
I3982 n1_m1_182400_144000 0 8.441140e-07
I3983 n1_m1_182400_148800 0 6.346377e-07
I3984 n1_m1_182400_153600 0 5.420623e-07
I3985 n1_m1_182400_158400 0 2.166378e-07
I3986 n1_m1_182400_163200 0 1.795626e-07
I3987 n1_m1_182400_168000 0 2.474269e-07
I3988 n1_m1_182400_172800 0 1.666351e-07
I3989 n1_m1_182400_177600 0 2.501322e-07
I3990 n1_m1_182400_182400 0 1.710571e-07
I3991 n1_m1_182400_187200 0 1.911750e-07
I3992 n1_m1_182400_192000 0 2.739784e-07
I3993 n1_m1_182400_196800 0 2.473640e-07
I3994 n1_m1_182400_201600 0 1.306272e-06
I3995 n1_m1_182400_206400 0 1.027738e-06
I3996 n1_m1_182400_211200 0 7.054738e-07
I3997 n1_m1_182400_216000 0 5.635978e-07
I3998 n1_m1_182400_220800 0 1.969647e-07
I3999 n1_m1_182400_225600 0 2.635936e-07
I4000 n1_m1_182400_230400 0 1.732210e-07
I4001 n1_m1_182400_235200 0 1.668523e-07
I4002 n1_m1_182400_240000 0 2.651625e-07
I4003 n1_m1_182400_244800 0 1.808614e-07
I4004 n1_m1_182400_249600 0 2.568493e-07
I4005 n1_m1_182400_254400 0 1.682147e-07
I4006 n1_m1_182400_259200 0 1.746873e-07
I4007 n1_m1_182400_264000 0 5.602831e-07
I4008 n1_m1_182400_268800 0 7.206127e-07
I4009 n1_m1_182400_273600 0 9.063448e-07
I4010 n1_m1_182400_278400 0 4.538656e-07
I4011 n1_m1_182400_283200 0 7.623262e-07
I4012 n1_m1_182400_288000 0 1.427446e-06
I4013 n1_m1_182400_292800 0 4.207931e-07
I4014 n1_m1_182400_297600 0 2.676777e-07
I4015 n1_m1_182400_302400 0 1.803323e-07
I4016 n1_m1_182400_307200 0 1.682513e-07
I4017 n1_m1_182400_312000 0 2.427405e-07
I4018 n1_m1_182400_316800 0 1.709545e-07
I4019 n1_m1_182400_321600 0 2.513180e-07
I4020 n1_m1_182400_326400 0 1.826799e-07
I4021 n1_m1_182400_331200 0 3.055562e-07
I4022 n1_m1_182400_336000 0 4.989877e-07
I4023 n1_m1_182400_340800 0 2.234975e-07
I4024 n1_m1_182400_345600 0 2.537533e-07
I4025 n1_m1_182400_350400 0 1.665760e-07
I4026 n1_m1_182400_355200 0 1.674152e-07
I4027 n1_m1_182400_360000 0 2.590658e-07
I4028 n1_m1_182400_364800 0 1.703818e-07
I4029 n1_m1_182400_369600 0 2.537685e-07
I4030 n1_m1_182400_374400 0 3.843844e-07
I4031 n1_m1_182400_379200 0 1.210588e-06
I4032 n1_m1_182400_384000 0 2.135786e-06
I4033 n1_m1_182400_388800 0 1.354935e-06
I4034 n1_m1_182400_393600 0 9.430915e-07
I4035 n1_m1_182400_398400 0 2.330719e-07
I4036 n1_m1_182400_403200 0 1.793144e-07
I4037 n1_m1_182400_408000 0 3.247294e-07
I4038 n1_m1_182400_412800 0 3.364397e-07
I4039 n1_m1_182400_417600 0 5.940423e-07
I4040 n1_m1_182400_422400 0 5.662244e-07
I4041 n1_m1_182400_427200 0 7.422780e-07
I4042 n1_m1_182400_432000 0 1.060581e-06
I4043 n1_m1_182400_436800 0 3.974068e-07
I4044 n1_m1_182400_441600 0 3.165362e-07
I4045 n1_m1_182400_446400 0 1.774764e-07
I4046 n1_m1_182400_451200 0 1.649828e-07
I4047 n1_m1_182400_456000 0 2.577864e-07
I4048 n1_m1_182400_460800 0 1.775409e-07
I4049 n1_m1_182400_465600 0 2.481487e-07
I4050 n1_m1_182400_470400 0 1.809180e-07
I4051 n1_m1_182400_475200 0 2.223155e-07
I4052 n1_m1_182400_480000 0 3.313553e-07
I4053 n1_m1_182400_484800 0 1.758009e-07
I4054 n1_m1_182400_489600 0 2.383540e-07
I4055 n1_m1_182400_494400 0 1.551077e-07
I4056 n1_m1_187200_0 0 1.534074e-07
I4057 n1_m1_187200_4800 0 1.554923e-07
I4058 n1_m1_187200_9600 0 2.413905e-07
I4059 n1_m1_187200_14400 0 1.604528e-07
I4060 n1_m1_187200_19200 0 1.589605e-07
I4061 n1_m1_187200_24000 0 2.318162e-07
I4062 n1_m1_187200_28800 0 1.532342e-07
I4063 n1_m1_187200_33600 0 2.298422e-07
I4064 n1_m1_187200_38400 0 1.532282e-07
I4065 n1_m1_187200_43200 0 1.532282e-07
I4066 n1_m1_187200_48000 0 2.298422e-07
I4067 n1_m1_187200_52800 0 1.532282e-07
I4068 n1_m1_187200_57600 0 2.313964e-07
I4069 n1_m1_187200_62400 0 1.549405e-07
I4070 n1_m1_187200_67200 0 1.556925e-07
I4071 n1_m1_187200_72000 0 2.471127e-07
I4072 n1_m1_187200_76800 0 1.799969e-07
I4073 n1_m1_187200_81600 0 2.767563e-07
I4074 n1_m1_187200_86400 0 1.726078e-07
I4075 n1_m1_187200_91200 0 1.667647e-07
I4076 n1_m1_187200_96000 0 2.491986e-07
I4077 n1_m1_187200_100800 0 1.664023e-07
I4078 n1_m1_187200_105600 0 2.538310e-07
I4079 n1_m1_187200_110400 0 1.703039e-07
I4080 n1_m1_187200_115200 0 1.722206e-07
I4081 n1_m1_187200_120000 0 2.914447e-07
I4082 n1_m1_187200_124800 0 4.768738e-07
I4083 n1_m1_187200_129600 0 1.636213e-06
I4084 n1_m1_187200_134400 0 1.214400e-06
I4085 n1_m1_187200_139200 0 9.836719e-07
I4086 n1_m1_187200_144000 0 1.028357e-06
I4087 n1_m1_187200_148800 0 5.603261e-07
I4088 n1_m1_187200_153600 0 5.006702e-07
I4089 n1_m1_187200_158400 0 1.964968e-07
I4090 n1_m1_187200_163200 0 1.784380e-07
I4091 n1_m1_187200_168000 0 2.567220e-07
I4092 n1_m1_187200_172800 0 1.717382e-07
I4093 n1_m1_187200_177600 0 2.576087e-07
I4094 n1_m1_187200_182400 0 1.695763e-07
I4095 n1_m1_187200_187200 0 1.777685e-07
I4096 n1_m1_187200_192000 0 2.687180e-07
I4097 n1_m1_187200_196800 0 2.741803e-07
I4098 n1_m1_187200_201600 0 9.846346e-07
I4099 n1_m1_187200_206400 0 7.423231e-07
I4100 n1_m1_187200_211200 0 6.427818e-07
I4101 n1_m1_187200_216000 0 5.949142e-07
I4102 n1_m1_187200_220800 0 2.296470e-07
I4103 n1_m1_187200_225600 0 2.718039e-07
I4104 n1_m1_187200_230400 0 1.731443e-07
I4105 n1_m1_187200_235200 0 1.675012e-07
I4106 n1_m1_187200_240000 0 2.578492e-07
I4107 n1_m1_187200_244800 0 1.761174e-07
I4108 n1_m1_187200_249600 0 2.587331e-07
I4109 n1_m1_187200_254400 0 1.702040e-07
I4110 n1_m1_187200_259200 0 1.716929e-07
I4111 n1_m1_187200_264000 0 5.118368e-07
I4112 n1_m1_187200_268800 0 6.854932e-07
I4113 n1_m1_187200_273600 0 8.891080e-07
I4114 n1_m1_187200_278400 0 3.403230e-07
I4115 n1_m1_187200_283200 0 3.602084e-07
I4116 n1_m1_187200_288000 0 6.453655e-07
I4117 n1_m1_187200_292800 0 2.634921e-07
I4118 n1_m1_187200_297600 0 2.612909e-07
I4119 n1_m1_187200_302400 0 1.698517e-07
I4120 n1_m1_187200_307200 0 1.670478e-07
I4121 n1_m1_187200_312000 0 2.483246e-07
I4122 n1_m1_187200_316800 0 1.667542e-07
I4123 n1_m1_187200_321600 0 2.474137e-07
I4124 n1_m1_187200_326400 0 1.752667e-07
I4125 n1_m1_187200_331200 0 2.097790e-07
I4126 n1_m1_187200_336000 0 3.315110e-07
I4127 n1_m1_187200_340800 0 1.908823e-07
I4128 n1_m1_187200_345600 0 2.579674e-07
I4129 n1_m1_187200_350400 0 1.675139e-07
I4130 n1_m1_187200_355200 0 1.676423e-07
I4131 n1_m1_187200_360000 0 2.590954e-07
I4132 n1_m1_187200_364800 0 1.723838e-07
I4133 n1_m1_187200_369600 0 2.540675e-07
I4134 n1_m1_187200_374400 0 2.571306e-07
I4135 n1_m1_187200_379200 0 6.951418e-07
I4136 n1_m1_187200_384000 0 1.867896e-06
I4137 n1_m1_187200_388800 0 1.258241e-06
I4138 n1_m1_187200_393600 0 7.986792e-07
I4139 n1_m1_187200_398400 0 1.761070e-07
I4140 n1_m1_187200_403200 0 1.975107e-07
I4141 n1_m1_187200_408000 0 3.187899e-07
I4142 n1_m1_187200_412800 0 3.062658e-07
I4143 n1_m1_187200_417600 0 6.102019e-07
I4144 n1_m1_187200_422400 0 3.951321e-07
I4145 n1_m1_187200_427200 0 4.573782e-07
I4146 n1_m1_187200_432000 0 7.810545e-07
I4147 n1_m1_187200_436800 0 3.839430e-07
I4148 n1_m1_187200_441600 0 3.239159e-07
I4149 n1_m1_187200_446400 0 1.709442e-07
I4150 n1_m1_187200_451200 0 1.749333e-07
I4151 n1_m1_187200_456000 0 2.916322e-07
I4152 n1_m1_187200_460800 0 1.836886e-07
I4153 n1_m1_187200_465600 0 2.546294e-07
I4154 n1_m1_187200_470400 0 1.751138e-07
I4155 n1_m1_187200_475200 0 1.938701e-07
I4156 n1_m1_187200_480000 0 3.463678e-07
I4157 n1_m1_187200_484800 0 2.054405e-07
I4158 n1_m1_187200_489600 0 2.527683e-07
I4159 n1_m1_187200_494400 0 1.638432e-07
I4160 n1_m1_192000_0 0 2.234265e-07
I4161 n1_m1_192000_4800 0 2.304095e-07
I4162 n1_m1_192000_9600 0 3.588200e-07
I4163 n1_m1_192000_14400 0 2.398354e-07
I4164 n1_m1_192000_19200 0 2.398354e-07
I4165 n1_m1_192000_24000 0 3.562675e-07
I4166 n1_m1_192000_28800 0 2.300417e-07
I4167 n1_m1_192000_33600 0 3.447634e-07
I4168 n1_m1_192000_38400 0 2.298422e-07
I4169 n1_m1_192000_43200 0 2.298422e-07
I4170 n1_m1_192000_48000 0 3.447634e-07
I4171 n1_m1_192000_52800 0 2.298422e-07
I4172 n1_m1_192000_57600 0 3.528174e-07
I4173 n1_m1_192000_62400 0 2.402766e-07
I4174 n1_m1_192000_67200 0 2.386905e-07
I4175 n1_m1_192000_72000 0 3.589262e-07
I4176 n1_m1_192000_76800 0 2.508526e-07
I4177 n1_m1_192000_81600 0 3.875970e-07
I4178 n1_m1_192000_86400 0 2.503834e-07
I4179 n1_m1_192000_91200 0 2.470294e-07
I4180 n1_m1_192000_96000 0 3.870845e-07
I4181 n1_m1_192000_100800 0 2.584638e-07
I4182 n1_m1_192000_105600 0 3.876957e-07
I4183 n1_m1_192000_110400 0 2.581584e-07
I4184 n1_m1_192000_115200 0 2.574003e-07
I4185 n1_m1_192000_120000 0 4.114076e-07
I4186 n1_m1_192000_124800 0 5.664766e-07
I4187 n1_m1_192000_129600 0 2.407835e-06
I4188 n1_m1_192000_134400 0 2.056362e-06
I4189 n1_m1_192000_139200 0 1.746243e-06
I4190 n1_m1_192000_144000 0 1.484300e-06
I4191 n1_m1_192000_148800 0 5.030859e-07
I4192 n1_m1_192000_153600 0 5.124262e-07
I4193 n1_m1_192000_158400 0 3.046511e-07
I4194 n1_m1_192000_163200 0 2.697645e-07
I4195 n1_m1_192000_168000 0 3.897325e-07
I4196 n1_m1_192000_172800 0 2.592406e-07
I4197 n1_m1_192000_177600 0 3.880139e-07
I4198 n1_m1_192000_182400 0 2.653502e-07
I4199 n1_m1_192000_187200 0 2.648151e-07
I4200 n1_m1_192000_192000 0 4.035213e-07
I4201 n1_m1_192000_196800 0 6.487107e-07
I4202 n1_m1_192000_201600 0 2.112167e-06
I4203 n1_m1_192000_206400 0 1.236238e-06
I4204 n1_m1_192000_211200 0 8.835551e-07
I4205 n1_m1_192000_216000 0 7.527869e-07
I4206 n1_m1_192000_220800 0 3.033535e-07
I4207 n1_m1_192000_225600 0 3.986399e-07
I4208 n1_m1_192000_230400 0 2.595586e-07
I4209 n1_m1_192000_235200 0 2.585306e-07
I4210 n1_m1_192000_240000 0 3.886473e-07
I4211 n1_m1_192000_244800 0 2.580567e-07
I4212 n1_m1_192000_249600 0 3.897836e-07
I4213 n1_m1_192000_254400 0 2.599776e-07
I4214 n1_m1_192000_259200 0 2.547676e-07
I4215 n1_m1_192000_264000 0 5.114992e-07
I4216 n1_m1_192000_268800 0 6.176872e-07
I4217 n1_m1_192000_273600 0 8.203162e-07
I4218 n1_m1_192000_278400 0 3.212146e-07
I4219 n1_m1_192000_283200 0 2.716914e-07
I4220 n1_m1_192000_288000 0 4.207992e-07
I4221 n1_m1_192000_292800 0 2.716295e-07
I4222 n1_m1_192000_297600 0 3.861831e-07
I4223 n1_m1_192000_302400 0 2.522499e-07
I4224 n1_m1_192000_307200 0 2.506405e-07
I4225 n1_m1_192000_312000 0 3.747428e-07
I4226 n1_m1_192000_316800 0 2.494945e-07
I4227 n1_m1_192000_321600 0 3.739127e-07
I4228 n1_m1_192000_326400 0 2.575642e-07
I4229 n1_m1_192000_331200 0 2.598830e-07
I4230 n1_m1_192000_336000 0 3.915007e-07
I4231 n1_m1_192000_340800 0 2.616088e-07
I4232 n1_m1_192000_345600 0 3.929813e-07
I4233 n1_m1_192000_350400 0 2.589988e-07
I4234 n1_m1_192000_355200 0 2.586397e-07
I4235 n1_m1_192000_360000 0 3.895785e-07
I4236 n1_m1_192000_364800 0 2.598217e-07
I4237 n1_m1_192000_369600 0 3.839586e-07
I4238 n1_m1_192000_374400 0 2.710074e-07
I4239 n1_m1_192000_379200 0 3.603437e-07
I4240 n1_m1_192000_384000 0 1.073210e-06
I4241 n1_m1_192000_388800 0 1.062912e-06
I4242 n1_m1_192000_393600 0 8.769303e-07
I4243 n1_m1_192000_398400 0 2.768117e-07
I4244 n1_m1_192000_403200 0 2.646240e-07
I4245 n1_m1_192000_408000 0 4.008727e-07
I4246 n1_m1_192000_412800 0 3.519477e-07
I4247 n1_m1_192000_417600 0 7.379256e-07
I4248 n1_m1_192000_422400 0 3.829866e-07
I4249 n1_m1_192000_427200 0 3.348833e-07
I4250 n1_m1_192000_432000 0 5.005094e-07
I4251 n1_m1_192000_436800 0 3.271304e-07
I4252 n1_m1_192000_441600 0 4.232435e-07
I4253 n1_m1_192000_446400 0 2.740280e-07
I4254 n1_m1_192000_451200 0 3.095737e-07
I4255 n1_m1_192000_456000 0 5.017652e-07
I4256 n1_m1_192000_460800 0 3.022947e-07
I4257 n1_m1_192000_465600 0 4.057353e-07
I4258 n1_m1_192000_470400 0 2.594836e-07
I4259 n1_m1_192000_475200 0 2.600450e-07
I4260 n1_m1_192000_480000 0 4.144831e-07
I4261 n1_m1_192000_484800 0 2.695301e-07
I4262 n1_m1_192000_489600 0 3.806374e-07
I4263 n1_m1_192000_494400 0 2.562443e-07
I4264 n1_m1_196800_0 0 1.502166e-07
I4265 n1_m1_196800_4800 0 1.533991e-07
I4266 n1_m1_196800_9600 0 2.370683e-07
I4267 n1_m1_196800_14400 0 1.598903e-07
I4268 n1_m1_196800_19200 0 1.598903e-07
I4269 n1_m1_196800_24000 0 2.383705e-07
I4270 n1_m1_196800_28800 0 1.539923e-07
I4271 n1_m1_196800_33600 0 2.337317e-07
I4272 n1_m1_196800_38400 0 1.558368e-07
I4273 n1_m1_196800_43200 0 1.558368e-07
I4274 n1_m1_196800_48000 0 2.337552e-07
I4275 n1_m1_196800_52800 0 1.558368e-07
I4276 n1_m1_196800_57600 0 2.377965e-07
I4277 n1_m1_196800_62400 0 1.629019e-07
I4278 n1_m1_196800_67200 0 1.599798e-07
I4279 n1_m1_196800_72000 0 2.363721e-07
I4280 n1_m1_196800_76800 0 1.613203e-07
I4281 n1_m1_196800_81600 0 2.509188e-07
I4282 n1_m1_196800_86400 0 1.691610e-07
I4283 n1_m1_196800_91200 0 1.705055e-07
I4284 n1_m1_196800_96000 0 2.616637e-07
I4285 n1_m1_196800_100800 0 1.750845e-07
I4286 n1_m1_196800_105600 0 2.637346e-07
I4287 n1_m1_196800_110400 0 1.746592e-07
I4288 n1_m1_196800_115200 0 1.709472e-07
I4289 n1_m1_196800_120000 0 2.571601e-07
I4290 n1_m1_196800_124800 0 1.908204e-07
I4291 n1_m1_196800_129600 0 7.865591e-07
I4292 n1_m1_196800_134400 0 8.989630e-07
I4293 n1_m1_196800_139200 0 7.251200e-07
I4294 n1_m1_196800_144000 0 5.783138e-07
I4295 n1_m1_196800_148800 0 3.004752e-07
I4296 n1_m1_196800_153600 0 4.006761e-07
I4297 n1_m1_196800_158400 0 2.191876e-07
I4298 n1_m1_196800_163200 0 1.871872e-07
I4299 n1_m1_196800_168000 0 2.639782e-07
I4300 n1_m1_196800_172800 0 1.716603e-07
I4301 n1_m1_196800_177600 0 2.569989e-07
I4302 n1_m1_196800_182400 0 1.876420e-07
I4303 n1_m1_196800_187200 0 2.106074e-07
I4304 n1_m1_196800_192000 0 3.197231e-07
I4305 n1_m1_196800_196800 0 5.831363e-07
I4306 n1_m1_196800_201600 0 1.727164e-06
I4307 n1_m1_196800_206400 0 9.401535e-07
I4308 n1_m1_196800_211200 0 6.084008e-07
I4309 n1_m1_196800_216000 0 4.737891e-07
I4310 n1_m1_196800_220800 0 1.801976e-07
I4311 n1_m1_196800_225600 0 2.614903e-07
I4312 n1_m1_196800_230400 0 1.732144e-07
I4313 n1_m1_196800_235200 0 1.732144e-07
I4314 n1_m1_196800_240000 0 2.598217e-07
I4315 n1_m1_196800_244800 0 1.683583e-07
I4316 n1_m1_196800_249600 0 2.702946e-07
I4317 n1_m1_196800_254400 0 2.101327e-07
I4318 n1_m1_196800_259200 0 2.022162e-07
I4319 n1_m1_196800_264000 0 2.691246e-07
I4320 n1_m1_196800_268800 0 2.085939e-07
I4321 n1_m1_196800_273600 0 3.017313e-07
I4322 n1_m1_196800_278400 0 1.801370e-07
I4323 n1_m1_196800_283200 0 1.745292e-07
I4324 n1_m1_196800_288000 0 2.598217e-07
I4325 n1_m1_196800_292800 0 1.736361e-07
I4326 n1_m1_196800_297600 0 2.651097e-07
I4327 n1_m1_196800_302400 0 1.767712e-07
I4328 n1_m1_196800_307200 0 1.713951e-07
I4329 n1_m1_196800_312000 0 2.506300e-07
I4330 n1_m1_196800_316800 0 1.671940e-07
I4331 n1_m1_196800_321600 0 2.538107e-07
I4332 n1_m1_196800_326400 0 1.722988e-07
I4333 n1_m1_196800_331200 0 1.732144e-07
I4334 n1_m1_196800_336000 0 2.598217e-07
I4335 n1_m1_196800_340800 0 1.759034e-07
I4336 n1_m1_196800_345600 0 2.694038e-07
I4337 n1_m1_196800_350400 0 1.760957e-07
I4338 n1_m1_196800_355200 0 1.735471e-07
I4339 n1_m1_196800_360000 0 2.584021e-07
I4340 n1_m1_196800_364800 0 1.706058e-07
I4341 n1_m1_196800_369600 0 2.578990e-07
I4342 n1_m1_196800_374400 0 1.796096e-07
I4343 n1_m1_196800_379200 0 1.859134e-07
I4344 n1_m1_196800_384000 0 3.007191e-07
I4345 n1_m1_196800_388800 0 2.527285e-07
I4346 n1_m1_196800_393600 0 3.057354e-07
I4347 n1_m1_196800_398400 0 2.001129e-07
I4348 n1_m1_196800_403200 0 1.748686e-07
I4349 n1_m1_196800_408000 0 2.599511e-07
I4350 n1_m1_196800_412800 0 1.830554e-07
I4351 n1_m1_196800_417600 0 3.103170e-07
I4352 n1_m1_196800_422400 0 1.806279e-07
I4353 n1_m1_196800_427200 0 1.798765e-07
I4354 n1_m1_196800_432000 0 2.564098e-07
I4355 n1_m1_196800_436800 0 1.704823e-07
I4356 n1_m1_196800_441600 0 2.768356e-07
I4357 n1_m1_196800_446400 0 1.875968e-07
I4358 n1_m1_196800_451200 0 1.776564e-07
I4359 n1_m1_196800_456000 0 2.594666e-07
I4360 n1_m1_196800_460800 0 1.769824e-07
I4361 n1_m1_196800_465600 0 2.675291e-07
I4362 n1_m1_196800_470400 0 1.710288e-07
I4363 n1_m1_196800_475200 0 1.675942e-07
I4364 n1_m1_196800_480000 0 2.535605e-07
I4365 n1_m1_196800_484800 0 1.654680e-07
I4366 n1_m1_196800_489600 0 2.466313e-07
I4367 n1_m1_196800_494400 0 1.688934e-07
I4368 n1_m1_201600_0 0 1.532282e-07
I4369 n1_m1_201600_4800 0 1.532282e-07
I4370 n1_m1_201600_9600 0 2.304715e-07
I4371 n1_m1_201600_14400 0 1.543051e-07
I4372 n1_m1_201600_19200 0 1.543051e-07
I4373 n1_m1_201600_24000 0 2.312208e-07
I4374 n1_m1_201600_28800 0 1.548115e-07
I4375 n1_m1_201600_33600 0 2.397752e-07
I4376 n1_m1_201600_38400 0 1.598903e-07
I4377 n1_m1_201600_43200 0 1.598903e-07
I4378 n1_m1_201600_48000 0 2.398354e-07
I4379 n1_m1_201600_52800 0 1.598903e-07
I4380 n1_m1_201600_57600 0 2.393931e-07
I4381 n1_m1_201600_62400 0 1.562127e-07
I4382 n1_m1_201600_67200 0 1.591995e-07
I4383 n1_m1_201600_72000 0 2.398354e-07
I4384 n1_m1_201600_76800 0 1.631940e-07
I4385 n1_m1_201600_81600 0 2.515781e-07
I4386 n1_m1_201600_86400 0 1.723554e-07
I4387 n1_m1_201600_91200 0 1.746521e-07
I4388 n1_m1_201600_96000 0 2.735727e-07
I4389 n1_m1_201600_100800 0 1.867033e-07
I4390 n1_m1_201600_105600 0 2.906963e-07
I4391 n1_m1_201600_110400 0 1.979213e-07
I4392 n1_m1_201600_115200 0 1.883112e-07
I4393 n1_m1_201600_120000 0 2.750882e-07
I4394 n1_m1_201600_124800 0 1.825933e-07
I4395 n1_m1_201600_129600 0 3.364967e-07
I4396 n1_m1_201600_134400 0 4.628125e-07
I4397 n1_m1_201600_139200 0 5.905981e-07
I4398 n1_m1_201600_144000 0 7.269421e-07
I4399 n1_m1_201600_148800 0 3.344014e-07
I4400 n1_m1_201600_153600 0 3.905061e-07
I4401 n1_m1_201600_158400 0 2.733739e-07
I4402 n1_m1_201600_163200 0 2.523278e-07
I4403 n1_m1_201600_168000 0 3.950780e-07
I4404 n1_m1_201600_172800 0 2.109524e-07
I4405 n1_m1_201600_177600 0 2.736971e-07
I4406 n1_m1_201600_182400 0 2.373397e-07
I4407 n1_m1_201600_187200 0 3.900337e-07
I4408 n1_m1_201600_192000 0 5.164314e-07
I4409 n1_m1_201600_196800 0 3.894220e-07
I4410 n1_m1_201600_201600 0 9.504802e-07
I4411 n1_m1_201600_206400 0 5.193741e-07
I4412 n1_m1_201600_211200 0 4.135408e-07
I4413 n1_m1_201600_216000 0 3.702567e-07
I4414 n1_m1_201600_220800 0 1.733711e-07
I4415 n1_m1_201600_225600 0 2.517055e-07
I4416 n1_m1_201600_230400 0 1.676293e-07
I4417 n1_m1_201600_235200 0 1.676293e-07
I4418 n1_m1_201600_240000 0 2.553580e-07
I4419 n1_m1_201600_244800 0 1.724295e-07
I4420 n1_m1_201600_249600 0 2.817512e-07
I4421 n1_m1_201600_254400 0 2.468360e-07
I4422 n1_m1_201600_259200 0 2.459531e-07
I4423 n1_m1_201600_264000 0 2.697624e-07
I4424 n1_m1_201600_268800 0 1.733420e-07
I4425 n1_m1_201600_273600 0 2.682260e-07
I4426 n1_m1_201600_278400 0 1.789438e-07
I4427 n1_m1_201600_283200 0 1.756165e-07
I4428 n1_m1_201600_288000 0 2.588685e-07
I4429 n1_m1_201600_292800 0 1.744560e-07
I4430 n1_m1_201600_297600 0 2.793954e-07
I4431 n1_m1_201600_302400 0 1.870167e-07
I4432 n1_m1_201600_307200 0 1.808206e-07
I4433 n1_m1_201600_312000 0 2.550340e-07
I4434 n1_m1_201600_316800 0 1.743430e-07
I4435 n1_m1_201600_321600 0 2.690464e-07
I4436 n1_m1_201600_326400 0 1.746197e-07
I4437 n1_m1_201600_331200 0 1.732144e-07
I4438 n1_m1_201600_336000 0 2.598217e-07
I4439 n1_m1_201600_340800 0 1.733926e-07
I4440 n1_m1_201600_345600 0 2.615779e-07
I4441 n1_m1_201600_350400 0 1.778445e-07
I4442 n1_m1_201600_355200 0 1.732595e-07
I4443 n1_m1_201600_360000 0 2.514915e-07
I4444 n1_m1_201600_364800 0 1.665524e-07
I4445 n1_m1_201600_369600 0 2.522214e-07
I4446 n1_m1_201600_374400 0 1.777971e-07
I4447 n1_m1_201600_379200 0 1.826785e-07
I4448 n1_m1_201600_384000 0 2.801317e-07
I4449 n1_m1_201600_388800 0 1.920050e-07
I4450 n1_m1_201600_393600 0 5.393712e-07
I4451 n1_m1_201600_398400 0 7.351065e-07
I4452 n1_m1_201600_403200 0 6.838010e-07
I4453 n1_m1_201600_408000 0 4.935922e-07
I4454 n1_m1_201600_412800 0 1.844081e-07
I4455 n1_m1_201600_417600 0 2.722915e-07
I4456 n1_m1_201600_422400 0 1.780456e-07
I4457 n1_m1_201600_427200 0 1.764139e-07
I4458 n1_m1_201600_432000 0 2.563236e-07
I4459 n1_m1_201600_436800 0 1.921587e-07
I4460 n1_m1_201600_441600 0 4.615470e-07
I4461 n1_m1_201600_446400 0 3.459482e-07
I4462 n1_m1_201600_451200 0 2.409470e-07
I4463 n1_m1_201600_456000 0 2.668072e-07
I4464 n1_m1_201600_460800 0 1.739319e-07
I4465 n1_m1_201600_465600 0 2.635587e-07
I4466 n1_m1_201600_470400 0 1.679011e-07
I4467 n1_m1_201600_475200 0 1.673755e-07
I4468 n1_m1_201600_480000 0 2.589197e-07
I4469 n1_m1_201600_484800 0 1.701110e-07
I4470 n1_m1_201600_489600 0 2.424580e-07
I4471 n1_m1_201600_494400 0 1.600549e-07
I4472 n1_m1_206400_0 0 1.537699e-07
I4473 n1_m1_206400_4800 0 1.533065e-07
I4474 n1_m1_206400_9600 0 2.298422e-07
I4475 n1_m1_206400_14400 0 1.532282e-07
I4476 n1_m1_206400_19200 0 1.532282e-07
I4477 n1_m1_206400_24000 0 2.300026e-07
I4478 n1_m1_206400_28800 0 1.553284e-07
I4479 n1_m1_206400_33600 0 2.397818e-07
I4480 n1_m1_206400_38400 0 1.598903e-07
I4481 n1_m1_206400_43200 0 1.598903e-07
I4482 n1_m1_206400_48000 0 2.398354e-07
I4483 n1_m1_206400_52800 0 1.598903e-07
I4484 n1_m1_206400_57600 0 2.397475e-07
I4485 n1_m1_206400_62400 0 1.591597e-07
I4486 n1_m1_206400_67200 0 1.597530e-07
I4487 n1_m1_206400_72000 0 2.402146e-07
I4488 n1_m1_206400_76800 0 1.611584e-07
I4489 n1_m1_206400_81600 0 2.489401e-07
I4490 n1_m1_206400_86400 0 1.718519e-07
I4491 n1_m1_206400_91200 0 1.862793e-07
I4492 n1_m1_206400_96000 0 3.131164e-07
I4493 n1_m1_206400_100800 0 2.181605e-07
I4494 n1_m1_206400_105600 0 3.344849e-07
I4495 n1_m1_206400_110400 0 2.004575e-07
I4496 n1_m1_206400_115200 0 1.859208e-07
I4497 n1_m1_206400_120000 0 2.667089e-07
I4498 n1_m1_206400_124800 0 1.774484e-07
I4499 n1_m1_206400_129600 0 3.159013e-07
I4500 n1_m1_206400_134400 0 4.873393e-07
I4501 n1_m1_206400_139200 0 7.359065e-07
I4502 n1_m1_206400_144000 0 1.057772e-06
I4503 n1_m1_206400_148800 0 4.889749e-07
I4504 n1_m1_206400_153600 0 5.179093e-07
I4505 n1_m1_206400_158400 0 3.632089e-07
I4506 n1_m1_206400_163200 0 3.345374e-07
I4507 n1_m1_206400_168000 0 5.216050e-07
I4508 n1_m1_206400_172800 0 2.619110e-07
I4509 n1_m1_206400_177600 0 2.791338e-07
I4510 n1_m1_206400_182400 0 2.546569e-07
I4511 n1_m1_206400_187200 0 5.544844e-07
I4512 n1_m1_206400_192000 0 7.001721e-07
I4513 n1_m1_206400_196800 0 2.833280e-07
I4514 n1_m1_206400_201600 0 5.248450e-07
I4515 n1_m1_206400_206400 0 2.871568e-07
I4516 n1_m1_206400_211200 0 2.835568e-07
I4517 n1_m1_206400_216000 0 2.992300e-07
I4518 n1_m1_206400_220800 0 1.763224e-07
I4519 n1_m1_206400_225600 0 2.532598e-07
I4520 n1_m1_206400_230400 0 1.672814e-07
I4521 n1_m1_206400_235200 0 1.672814e-07
I4522 n1_m1_206400_240000 0 2.550800e-07
I4523 n1_m1_206400_244800 0 1.732144e-07
I4524 n1_m1_206400_249600 0 2.576929e-07
I4525 n1_m1_206400_254400 0 1.856401e-07
I4526 n1_m1_206400_259200 0 1.875344e-07
I4527 n1_m1_206400_264000 0 2.521612e-07
I4528 n1_m1_206400_268800 0 1.630445e-07
I4529 n1_m1_206400_273600 0 2.539721e-07
I4530 n1_m1_206400_278400 0 1.711528e-07
I4531 n1_m1_206400_283200 0 1.680312e-07
I4532 n1_m1_206400_288000 0 2.513034e-07
I4533 n1_m1_206400_292800 0 1.686536e-07
I4534 n1_m1_206400_297600 0 2.647252e-07
I4535 n1_m1_206400_302400 0 1.802231e-07
I4536 n1_m1_206400_307200 0 1.799618e-07
I4537 n1_m1_206400_312000 0 2.576539e-07
I4538 n1_m1_206400_316800 0 1.818422e-07
I4539 n1_m1_206400_321600 0 2.824530e-07
I4540 n1_m1_206400_326400 0 1.770381e-07
I4541 n1_m1_206400_331200 0 1.733689e-07
I4542 n1_m1_206400_336000 0 2.600954e-07
I4543 n1_m1_206400_340800 0 1.713572e-07
I4544 n1_m1_206400_345600 0 2.567682e-07
I4545 n1_m1_206400_350400 0 1.744867e-07
I4546 n1_m1_206400_355200 0 1.725699e-07
I4547 n1_m1_206400_360000 0 2.505844e-07
I4548 n1_m1_206400_364800 0 1.665524e-07
I4549 n1_m1_206400_369600 0 2.537542e-07
I4550 n1_m1_206400_374400 0 1.819494e-07
I4551 n1_m1_206400_379200 0 2.022602e-07
I4552 n1_m1_206400_384000 0 3.577330e-07
I4553 n1_m1_206400_388800 0 2.124697e-07
I4554 n1_m1_206400_393600 0 7.311172e-07
I4555 n1_m1_206400_398400 0 1.189285e-06
I4556 n1_m1_206400_403200 0 1.258697e-06
I4557 n1_m1_206400_408000 0 1.265967e-06
I4558 n1_m1_206400_412800 0 2.685049e-07
I4559 n1_m1_206400_417600 0 2.665701e-07
I4560 n1_m1_206400_422400 0 1.688981e-07
I4561 n1_m1_206400_427200 0 1.709044e-07
I4562 n1_m1_206400_432000 0 2.679773e-07
I4563 n1_m1_206400_436800 0 1.878840e-07
I4564 n1_m1_206400_441600 0 4.663543e-07
I4565 n1_m1_206400_446400 0 4.139343e-07
I4566 n1_m1_206400_451200 0 3.460479e-07
I4567 n1_m1_206400_456000 0 3.163092e-07
I4568 n1_m1_206400_460800 0 1.733604e-07
I4569 n1_m1_206400_465600 0 2.555815e-07
I4570 n1_m1_206400_470400 0 1.669524e-07
I4571 n1_m1_206400_475200 0 1.711152e-07
I4572 n1_m1_206400_480000 0 2.733980e-07
I4573 n1_m1_206400_484800 0 1.766559e-07
I4574 n1_m1_206400_489600 0 2.382598e-07
I4575 n1_m1_206400_494400 0 1.547531e-07
I4576 n1_m1_211200_0 0 1.577284e-07
I4577 n1_m1_211200_4800 0 1.544596e-07
I4578 n1_m1_211200_9600 0 2.299191e-07
I4579 n1_m1_211200_14400 0 1.532282e-07
I4580 n1_m1_211200_19200 0 1.532282e-07
I4581 n1_m1_211200_24000 0 2.311115e-07
I4582 n1_m1_211200_28800 0 1.590755e-07
I4583 n1_m1_211200_33600 0 2.398273e-07
I4584 n1_m1_211200_38400 0 1.598903e-07
I4585 n1_m1_211200_43200 0 1.598903e-07
I4586 n1_m1_211200_48000 0 2.398354e-07
I4587 n1_m1_211200_52800 0 1.598903e-07
I4588 n1_m1_211200_57600 0 2.398354e-07
I4589 n1_m1_211200_62400 0 1.598903e-07
I4590 n1_m1_211200_67200 0 1.598903e-07
I4591 n1_m1_211200_72000 0 2.428375e-07
I4592 n1_m1_211200_76800 0 1.661137e-07
I4593 n1_m1_211200_81600 0 2.648753e-07
I4594 n1_m1_211200_86400 0 2.121328e-07
I4595 n1_m1_211200_91200 0 2.888208e-07
I4596 n1_m1_211200_96000 0 5.909959e-07
I4597 n1_m1_211200_100800 0 3.832913e-07
I4598 n1_m1_211200_105600 0 5.197461e-07
I4599 n1_m1_211200_110400 0 2.735823e-07
I4600 n1_m1_211200_115200 0 2.036825e-07
I4601 n1_m1_211200_120000 0 2.717681e-07
I4602 n1_m1_211200_124800 0 1.921971e-07
I4603 n1_m1_211200_129600 0 3.071160e-07
I4604 n1_m1_211200_134400 0 3.541067e-07
I4605 n1_m1_211200_139200 0 4.526742e-07
I4606 n1_m1_211200_144000 0 6.568961e-07
I4607 n1_m1_211200_148800 0 3.911042e-07
I4608 n1_m1_211200_153600 0 5.962573e-07
I4609 n1_m1_211200_158400 0 4.776284e-07
I4610 n1_m1_211200_163200 0 4.184453e-07
I4611 n1_m1_211200_168000 0 5.723555e-07
I4612 n1_m1_211200_172800 0 2.500989e-07
I4613 n1_m1_211200_177600 0 2.709671e-07
I4614 n1_m1_211200_182400 0 2.452287e-07
I4615 n1_m1_211200_187200 0 5.790909e-07
I4616 n1_m1_211200_192000 0 6.192369e-07
I4617 n1_m1_211200_196800 0 2.581406e-07
I4618 n1_m1_211200_201600 0 5.621087e-07
I4619 n1_m1_211200_206400 0 2.575463e-07
I4620 n1_m1_211200_211200 0 2.427742e-07
I4621 n1_m1_211200_216000 0 2.936276e-07
I4622 n1_m1_211200_220800 0 1.823776e-07
I4623 n1_m1_211200_225600 0 2.635070e-07
I4624 n1_m1_211200_230400 0 1.750598e-07
I4625 n1_m1_211200_235200 0 1.758446e-07
I4626 n1_m1_211200_240000 0 2.605125e-07
I4627 n1_m1_211200_244800 0 1.732144e-07
I4628 n1_m1_211200_249600 0 2.525406e-07
I4629 n1_m1_211200_254400 0 1.659810e-07
I4630 n1_m1_211200_259200 0 1.644266e-07
I4631 n1_m1_211200_264000 0 2.508751e-07
I4632 n1_m1_211200_268800 0 1.665542e-07
I4633 n1_m1_211200_273600 0 2.513065e-07
I4634 n1_m1_211200_278400 0 1.670786e-07
I4635 n1_m1_211200_283200 0 1.661377e-07
I4636 n1_m1_211200_288000 0 2.498285e-07
I4637 n1_m1_211200_292800 0 1.665632e-07
I4638 n1_m1_211200_297600 0 2.509653e-07
I4639 n1_m1_211200_302400 0 1.720060e-07
I4640 n1_m1_211200_307200 0 1.779408e-07
I4641 n1_m1_211200_312000 0 2.638976e-07
I4642 n1_m1_211200_316800 0 1.938323e-07
I4643 n1_m1_211200_321600 0 3.181267e-07
I4644 n1_m1_211200_326400 0 1.847970e-07
I4645 n1_m1_211200_331200 0 1.744373e-07
I4646 n1_m1_211200_336000 0 2.619892e-07
I4647 n1_m1_211200_340800 0 1.739682e-07
I4648 n1_m1_211200_345600 0 2.566211e-07
I4649 n1_m1_211200_350400 0 1.775982e-07
I4650 n1_m1_211200_355200 0 1.736989e-07
I4651 n1_m1_211200_360000 0 2.506777e-07
I4652 n1_m1_211200_364800 0 1.670232e-07
I4653 n1_m1_211200_369600 0 2.621777e-07
I4654 n1_m1_211200_374400 0 1.897565e-07
I4655 n1_m1_211200_379200 0 2.166705e-07
I4656 n1_m1_211200_384000 0 5.208701e-07
I4657 n1_m1_211200_388800 0 3.246742e-07
I4658 n1_m1_211200_393600 0 7.029732e-07
I4659 n1_m1_211200_398400 0 1.241584e-06
I4660 n1_m1_211200_403200 0 1.421009e-06
I4661 n1_m1_211200_408000 0 1.670218e-06
I4662 n1_m1_211200_412800 0 3.366254e-07
I4663 n1_m1_211200_417600 0 2.907197e-07
I4664 n1_m1_211200_422400 0 1.880180e-07
I4665 n1_m1_211200_427200 0 1.748072e-07
I4666 n1_m1_211200_432000 0 2.951672e-07
I4667 n1_m1_211200_436800 0 1.921739e-07
I4668 n1_m1_211200_441600 0 3.443747e-07
I4669 n1_m1_211200_446400 0 2.850659e-07
I4670 n1_m1_211200_451200 0 2.616452e-07
I4671 n1_m1_211200_456000 0 2.934118e-07
I4672 n1_m1_211200_460800 0 1.720302e-07
I4673 n1_m1_211200_465600 0 2.516695e-07
I4674 n1_m1_211200_470400 0 1.661550e-07
I4675 n1_m1_211200_475200 0 1.677297e-07
I4676 n1_m1_211200_480000 0 2.675178e-07
I4677 n1_m1_211200_484800 0 1.740353e-07
I4678 n1_m1_211200_489600 0 2.374160e-07
I4679 n1_m1_211200_494400 0 1.575170e-07
I4680 n1_m1_216000_0 0 2.334518e-07
I4681 n1_m1_216000_4800 0 2.343534e-07
I4682 n1_m1_216000_9600 0 3.452911e-07
I4683 n1_m1_216000_14400 0 2.298422e-07
I4684 n1_m1_216000_19200 0 2.298422e-07
I4685 n1_m1_216000_24000 0 3.495447e-07
I4686 n1_m1_216000_28800 0 2.362233e-07
I4687 n1_m1_216000_33600 0 3.544354e-07
I4688 n1_m1_216000_38400 0 2.362903e-07
I4689 n1_m1_216000_43200 0 2.364078e-07
I4690 n1_m1_216000_48000 0 3.602549e-07
I4691 n1_m1_216000_52800 0 2.447259e-07
I4692 n1_m1_216000_57600 0 3.697548e-07
I4693 n1_m1_216000_62400 0 2.412912e-07
I4694 n1_m1_216000_67200 0 2.433022e-07
I4695 n1_m1_216000_72000 0 3.714532e-07
I4696 n1_m1_216000_76800 0 2.587571e-07
I4697 n1_m1_216000_81600 0 5.090739e-07
I4698 n1_m1_216000_86400 0 5.080752e-07
I4699 n1_m1_216000_91200 0 7.814405e-07
I4700 n1_m1_216000_96000 0 1.685158e-06
I4701 n1_m1_216000_100800 0 1.113405e-06
I4702 n1_m1_216000_105600 0 1.377022e-06
I4703 n1_m1_216000_110400 0 6.221090e-07
I4704 n1_m1_216000_115200 0 4.297829e-07
I4705 n1_m1_216000_120000 0 5.402193e-07
I4706 n1_m1_216000_124800 0 3.408519e-07
I4707 n1_m1_216000_129600 0 4.996246e-07
I4708 n1_m1_216000_134400 0 3.711554e-07
I4709 n1_m1_216000_139200 0 4.332046e-07
I4710 n1_m1_216000_144000 0 9.926109e-07
I4711 n1_m1_216000_148800 0 8.105764e-07
I4712 n1_m1_216000_153600 0 1.125911e-06
I4713 n1_m1_216000_158400 0 7.740451e-07
I4714 n1_m1_216000_163200 0 7.439008e-07
I4715 n1_m1_216000_168000 0 1.020355e-06
I4716 n1_m1_216000_172800 0 3.311774e-07
I4717 n1_m1_216000_177600 0 3.969847e-07
I4718 n1_m1_216000_182400 0 3.103404e-07
I4719 n1_m1_216000_187200 0 6.124579e-07
I4720 n1_m1_216000_192000 0 6.387138e-07
I4721 n1_m1_216000_196800 0 4.632957e-07
I4722 n1_m1_216000_201600 0 1.017371e-06
I4723 n1_m1_216000_206400 0 4.182093e-07
I4724 n1_m1_216000_211200 0 3.213039e-07
I4725 n1_m1_216000_216000 0 4.383350e-07
I4726 n1_m1_216000_220800 0 3.060356e-07
I4727 n1_m1_216000_225600 0 4.721321e-07
I4728 n1_m1_216000_230400 0 2.853095e-07
I4729 n1_m1_216000_235200 0 2.909177e-07
I4730 n1_m1_216000_240000 0 4.050290e-07
I4731 n1_m1_216000_244800 0 2.624057e-07
I4732 n1_m1_216000_249600 0 3.880916e-07
I4733 n1_m1_216000_254400 0 2.503837e-07
I4734 n1_m1_216000_259200 0 2.473410e-07
I4735 n1_m1_216000_264000 0 3.804126e-07
I4736 n1_m1_216000_268800 0 2.548435e-07
I4737 n1_m1_216000_273600 0 3.847799e-07
I4738 n1_m1_216000_278400 0 2.504195e-07
I4739 n1_m1_216000_283200 0 2.434347e-07
I4740 n1_m1_216000_288000 0 3.730557e-07
I4741 n1_m1_216000_292800 0 2.494879e-07
I4742 n1_m1_216000_297600 0 3.751926e-07
I4743 n1_m1_216000_302400 0 2.574781e-07
I4744 n1_m1_216000_307200 0 2.641074e-07
I4745 n1_m1_216000_312000 0 3.904760e-07
I4746 n1_m1_216000_316800 0 2.847845e-07
I4747 n1_m1_216000_321600 0 4.825518e-07
I4748 n1_m1_216000_326400 0 3.150220e-07
I4749 n1_m1_216000_331200 0 3.244690e-07
I4750 n1_m1_216000_336000 0 4.746376e-07
I4751 n1_m1_216000_340800 0 2.807762e-07
I4752 n1_m1_216000_345600 0 4.044582e-07
I4753 n1_m1_216000_350400 0 3.046489e-07
I4754 n1_m1_216000_355200 0 2.698774e-07
I4755 n1_m1_216000_360000 0 3.803761e-07
I4756 n1_m1_216000_364800 0 2.621821e-07
I4757 n1_m1_216000_369600 0 4.475872e-07
I4758 n1_m1_216000_374400 0 5.086179e-07
I4759 n1_m1_216000_379200 0 6.583597e-07
I4760 n1_m1_216000_384000 0 1.741006e-06
I4761 n1_m1_216000_388800 0 1.027912e-06
I4762 n1_m1_216000_393600 0 1.149525e-06
I4763 n1_m1_216000_398400 0 1.401371e-06
I4764 n1_m1_216000_403200 0 1.719616e-06
I4765 n1_m1_216000_408000 0 1.911218e-06
I4766 n1_m1_216000_412800 0 3.943117e-07
I4767 n1_m1_216000_417600 0 5.932858e-07
I4768 n1_m1_216000_422400 0 4.594332e-07
I4769 n1_m1_216000_427200 0 3.823942e-07
I4770 n1_m1_216000_432000 0 6.498013e-07
I4771 n1_m1_216000_436800 0 4.585166e-07
I4772 n1_m1_216000_441600 0 5.001506e-07
I4773 n1_m1_216000_446400 0 2.751866e-07
I4774 n1_m1_216000_451200 0 2.695827e-07
I4775 n1_m1_216000_456000 0 3.936213e-07
I4776 n1_m1_216000_460800 0 2.587357e-07
I4777 n1_m1_216000_465600 0 3.829599e-07
I4778 n1_m1_216000_470400 0 2.468720e-07
I4779 n1_m1_216000_475200 0 2.488546e-07
I4780 n1_m1_216000_480000 0 3.795819e-07
I4781 n1_m1_216000_484800 0 2.481670e-07
I4782 n1_m1_216000_489600 0 3.544222e-07
I4783 n1_m1_216000_494400 0 2.355442e-07
I4784 n1_m1_220800_0 0 1.482784e-07
I4785 n1_m1_220800_4800 0 1.525125e-07
I4786 n1_m1_220800_9600 0 2.298422e-07
I4787 n1_m1_220800_14400 0 1.532282e-07
I4788 n1_m1_220800_19200 0 1.556190e-07
I4789 n1_m1_220800_24000 0 2.382205e-07
I4790 n1_m1_220800_28800 0 1.561551e-07
I4791 n1_m1_220800_33600 0 2.298760e-07
I4792 n1_m1_220800_38400 0 1.532994e-07
I4793 n1_m1_220800_43200 0 1.562219e-07
I4794 n1_m1_220800_48000 0 2.415617e-07
I4795 n1_m1_220800_52800 0 1.690807e-07
I4796 n1_m1_220800_57600 0 2.586311e-07
I4797 n1_m1_220800_62400 0 1.626260e-07
I4798 n1_m1_220800_67200 0 1.655283e-07
I4799 n1_m1_220800_72000 0 2.472016e-07
I4800 n1_m1_220800_76800 0 1.696842e-07
I4801 n1_m1_220800_81600 0 3.262158e-07
I4802 n1_m1_220800_86400 0 2.909256e-07
I4803 n1_m1_220800_91200 0 4.117017e-07
I4804 n1_m1_220800_96000 0 8.403003e-07
I4805 n1_m1_220800_100800 0 6.104919e-07
I4806 n1_m1_220800_105600 0 7.251631e-07
I4807 n1_m1_220800_110400 0 2.934750e-07
I4808 n1_m1_220800_115200 0 2.228719e-07
I4809 n1_m1_220800_120000 0 3.883274e-07
I4810 n1_m1_220800_124800 0 2.475776e-07
I4811 n1_m1_220800_129600 0 3.461094e-07
I4812 n1_m1_220800_134400 0 2.182688e-07
I4813 n1_m1_220800_139200 0 3.277023e-07
I4814 n1_m1_220800_144000 0 1.207489e-06
I4815 n1_m1_220800_148800 0 1.015353e-06
I4816 n1_m1_220800_153600 0 1.038129e-06
I4817 n1_m1_220800_158400 0 4.597136e-07
I4818 n1_m1_220800_163200 0 5.334366e-07
I4819 n1_m1_220800_168000 0 8.337610e-07
I4820 n1_m1_220800_172800 0 2.040037e-07
I4821 n1_m1_220800_177600 0 2.670445e-07
I4822 n1_m1_220800_182400 0 1.775157e-07
I4823 n1_m1_220800_187200 0 2.175449e-07
I4824 n1_m1_220800_192000 0 4.076595e-07
I4825 n1_m1_220800_196800 0 3.925048e-07
I4826 n1_m1_220800_201600 0 5.968150e-07
I4827 n1_m1_220800_206400 0 2.394349e-07
I4828 n1_m1_220800_211200 0 1.876536e-07
I4829 n1_m1_220800_216000 0 2.684243e-07
I4830 n1_m1_220800_220800 0 2.115725e-07
I4831 n1_m1_220800_225600 0 3.272597e-07
I4832 n1_m1_220800_230400 0 1.806690e-07
I4833 n1_m1_220800_235200 0 1.852516e-07
I4834 n1_m1_220800_240000 0 2.676186e-07
I4835 n1_m1_220800_244800 0 1.753500e-07
I4836 n1_m1_220800_249600 0 2.605541e-07
I4837 n1_m1_220800_254400 0 1.712212e-07
I4838 n1_m1_220800_259200 0 1.653307e-07
I4839 n1_m1_220800_264000 0 2.419091e-07
I4840 n1_m1_220800_268800 0 1.622934e-07
I4841 n1_m1_220800_273600 0 2.455183e-07
I4842 n1_m1_220800_278400 0 1.630082e-07
I4843 n1_m1_220800_283200 0 1.617415e-07
I4844 n1_m1_220800_288000 0 2.489851e-07
I4845 n1_m1_220800_292800 0 1.704023e-07
I4846 n1_m1_220800_297600 0 2.595834e-07
I4847 n1_m1_220800_302400 0 1.732144e-07
I4848 n1_m1_220800_307200 0 1.732144e-07
I4849 n1_m1_220800_312000 0 2.518753e-07
I4850 n1_m1_220800_316800 0 1.672730e-07
I4851 n1_m1_220800_321600 0 2.625882e-07
I4852 n1_m1_220800_326400 0 2.283630e-07
I4853 n1_m1_220800_331200 0 2.872752e-07
I4854 n1_m1_220800_336000 0 4.440810e-07
I4855 n1_m1_220800_340800 0 2.618585e-07
I4856 n1_m1_220800_345600 0 3.167344e-07
I4857 n1_m1_220800_350400 0 2.068187e-07
I4858 n1_m1_220800_355200 0 1.780649e-07
I4859 n1_m1_220800_360000 0 2.589480e-07
I4860 n1_m1_220800_364800 0 1.778208e-07
I4861 n1_m1_220800_369600 0 3.013547e-07
I4862 n1_m1_220800_374400 0 4.425815e-07
I4863 n1_m1_220800_379200 0 8.513155e-07
I4864 n1_m1_220800_384000 0 1.859158e-06
I4865 n1_m1_220800_388800 0 6.012376e-07
I4866 n1_m1_220800_393600 0 3.515049e-07
I4867 n1_m1_220800_398400 0 3.109913e-07
I4868 n1_m1_220800_403200 0 4.776673e-07
I4869 n1_m1_220800_408000 0 5.943011e-07
I4870 n1_m1_220800_412800 0 1.891427e-07
I4871 n1_m1_220800_417600 0 2.983152e-07
I4872 n1_m1_220800_422400 0 2.709920e-07
I4873 n1_m1_220800_427200 0 2.980621e-07
I4874 n1_m1_220800_432000 0 5.800334e-07
I4875 n1_m1_220800_436800 0 4.374200e-07
I4876 n1_m1_220800_441600 0 4.280979e-07
I4877 n1_m1_220800_446400 0 1.832227e-07
I4878 n1_m1_220800_451200 0 1.769468e-07
I4879 n1_m1_220800_456000 0 2.600353e-07
I4880 n1_m1_220800_460800 0 1.687625e-07
I4881 n1_m1_220800_465600 0 2.498285e-07
I4882 n1_m1_220800_470400 0 1.665524e-07
I4883 n1_m1_220800_475200 0 1.664023e-07
I4884 n1_m1_220800_480000 0 2.459958e-07
I4885 n1_m1_220800_484800 0 1.620712e-07
I4886 n1_m1_220800_489600 0 2.359981e-07
I4887 n1_m1_220800_494400 0 1.539812e-07
I4888 n1_m1_225600_0 0 1.511906e-07
I4889 n1_m1_225600_4800 0 1.529335e-07
I4890 n1_m1_225600_9600 0 2.298422e-07
I4891 n1_m1_225600_14400 0 1.532282e-07
I4892 n1_m1_225600_19200 0 1.574956e-07
I4893 n1_m1_225600_24000 0 2.398354e-07
I4894 n1_m1_225600_28800 0 1.592487e-07
I4895 n1_m1_225600_33600 0 2.357465e-07
I4896 n1_m1_225600_38400 0 1.572001e-07
I4897 n1_m1_225600_43200 0 1.592762e-07
I4898 n1_m1_225600_48000 0 2.407991e-07
I4899 n1_m1_225600_52800 0 1.651611e-07
I4900 n1_m1_225600_57600 0 2.531018e-07
I4901 n1_m1_225600_62400 0 1.624292e-07
I4902 n1_m1_225600_67200 0 1.677522e-07
I4903 n1_m1_225600_72000 0 2.452405e-07
I4904 n1_m1_225600_76800 0 1.649355e-07
I4905 n1_m1_225600_81600 0 2.911717e-07
I4906 n1_m1_225600_86400 0 3.212413e-07
I4907 n1_m1_225600_91200 0 2.136036e-07
I4908 n1_m1_225600_96000 0 3.486628e-07
I4909 n1_m1_225600_100800 0 2.610769e-07
I4910 n1_m1_225600_105600 0 3.589036e-07
I4911 n1_m1_225600_110400 0 1.963134e-07
I4912 n1_m1_225600_115200 0 1.874032e-07
I4913 n1_m1_225600_120000 0 3.217831e-07
I4914 n1_m1_225600_124800 0 2.397124e-07
I4915 n1_m1_225600_129600 0 3.247320e-07
I4916 n1_m1_225600_134400 0 1.867155e-07
I4917 n1_m1_225600_139200 0 2.398252e-07
I4918 n1_m1_225600_144000 0 8.986987e-07
I4919 n1_m1_225600_148800 0 8.258259e-07
I4920 n1_m1_225600_153600 0 8.615743e-07
I4921 n1_m1_225600_158400 0 3.904561e-07
I4922 n1_m1_225600_163200 0 3.513182e-07
I4923 n1_m1_225600_168000 0 4.917666e-07
I4924 n1_m1_225600_172800 0 1.866872e-07
I4925 n1_m1_225600_177600 0 2.590796e-07
I4926 n1_m1_225600_182400 0 1.796749e-07
I4927 n1_m1_225600_187200 0 1.767485e-07
I4928 n1_m1_225600_192000 0 3.511728e-07
I4929 n1_m1_225600_196800 0 3.123894e-07
I4930 n1_m1_225600_201600 0 4.355222e-07
I4931 n1_m1_225600_206400 0 2.097832e-07
I4932 n1_m1_225600_211200 0 1.856548e-07
I4933 n1_m1_225600_216000 0 2.656510e-07
I4934 n1_m1_225600_220800 0 1.835648e-07
I4935 n1_m1_225600_225600 0 2.772385e-07
I4936 n1_m1_225600_230400 0 1.786698e-07
I4937 n1_m1_225600_235200 0 1.948644e-07
I4938 n1_m1_225600_240000 0 2.717830e-07
I4939 n1_m1_225600_244800 0 1.732144e-07
I4940 n1_m1_225600_249600 0 2.636587e-07
I4941 n1_m1_225600_254400 0 1.723939e-07
I4942 n1_m1_225600_259200 0 1.682915e-07
I4943 n1_m1_225600_264000 0 2.454670e-07
I4944 n1_m1_225600_268800 0 1.605947e-07
I4945 n1_m1_225600_273600 0 2.398354e-07
I4946 n1_m1_225600_278400 0 1.617242e-07
I4947 n1_m1_225600_283200 0 1.651701e-07
I4948 n1_m1_225600_288000 0 2.508118e-07
I4949 n1_m1_225600_292800 0 1.725790e-07
I4950 n1_m1_225600_297600 0 2.598217e-07
I4951 n1_m1_225600_302400 0 1.732144e-07
I4952 n1_m1_225600_307200 0 1.706092e-07
I4953 n1_m1_225600_312000 0 2.553463e-07
I4954 n1_m1_225600_316800 0 1.695078e-07
I4955 n1_m1_225600_321600 0 2.553735e-07
I4956 n1_m1_225600_326400 0 1.957774e-07
I4957 n1_m1_225600_331200 0 2.436534e-07
I4958 n1_m1_225600_336000 0 4.402657e-07
I4959 n1_m1_225600_340800 0 3.087617e-07
I4960 n1_m1_225600_345600 0 3.508372e-07
I4961 n1_m1_225600_350400 0 1.755533e-07
I4962 n1_m1_225600_355200 0 1.832340e-07
I4963 n1_m1_225600_360000 0 3.512845e-07
I4964 n1_m1_225600_364800 0 2.241229e-07
I4965 n1_m1_225600_369600 0 2.896860e-07
I4966 n1_m1_225600_374400 0 3.220637e-07
I4967 n1_m1_225600_379200 0 7.665825e-07
I4968 n1_m1_225600_384000 0 1.666281e-06
I4969 n1_m1_225600_388800 0 4.881065e-07
I4970 n1_m1_225600_393600 0 3.535937e-07
I4971 n1_m1_225600_398400 0 2.025368e-07
I4972 n1_m1_225600_403200 0 2.123378e-07
I4973 n1_m1_225600_408000 0 3.034339e-07
I4974 n1_m1_225600_412800 0 1.753684e-07
I4975 n1_m1_225600_417600 0 2.739367e-07
I4976 n1_m1_225600_422400 0 2.047930e-07
I4977 n1_m1_225600_427200 0 2.267060e-07
I4978 n1_m1_225600_432000 0 4.363081e-07
I4979 n1_m1_225600_436800 0 4.388307e-07
I4980 n1_m1_225600_441600 0 4.584058e-07
I4981 n1_m1_225600_446400 0 1.945380e-07
I4982 n1_m1_225600_451200 0 1.811437e-07
I4983 n1_m1_225600_456000 0 2.649254e-07
I4984 n1_m1_225600_460800 0 1.705055e-07
I4985 n1_m1_225600_465600 0 2.557080e-07
I4986 n1_m1_225600_470400 0 1.704720e-07
I4987 n1_m1_225600_475200 0 1.704720e-07
I4988 n1_m1_225600_480000 0 2.557080e-07
I4989 n1_m1_225600_484800 0 1.660736e-07
I4990 n1_m1_225600_489600 0 2.331268e-07
I4991 n1_m1_225600_494400 0 1.503160e-07
I4992 n1_m1_230400_0 0 1.522690e-07
I4993 n1_m1_230400_4800 0 1.530895e-07
I4994 n1_m1_230400_9600 0 2.305966e-07
I4995 n1_m1_230400_14400 0 1.575506e-07
I4996 n1_m1_230400_19200 0 1.597388e-07
I4997 n1_m1_230400_24000 0 2.398354e-07
I4998 n1_m1_230400_28800 0 1.613502e-07
I4999 n1_m1_230400_33600 0 2.491087e-07
I5000 n1_m1_230400_38400 0 1.613752e-07
I5001 n1_m1_230400_43200 0 1.598903e-07
I5002 n1_m1_230400_48000 0 2.398354e-07
I5003 n1_m1_230400_52800 0 1.600502e-07
I5004 n1_m1_230400_57600 0 2.444801e-07
I5005 n1_m1_230400_62400 0 1.628721e-07
I5006 n1_m1_230400_67200 0 1.753856e-07
I5007 n1_m1_230400_72000 0 2.642680e-07
I5008 n1_m1_230400_76800 0 1.856839e-07
I5009 n1_m1_230400_81600 0 4.892428e-07
I5010 n1_m1_230400_86400 0 7.382254e-07
I5011 n1_m1_230400_91200 0 2.926075e-07
I5012 n1_m1_230400_96000 0 2.963678e-07
I5013 n1_m1_230400_100800 0 1.900781e-07
I5014 n1_m1_230400_105600 0 3.038682e-07
I5015 n1_m1_230400_110400 0 2.160116e-07
I5016 n1_m1_230400_115200 0 2.049991e-07
I5017 n1_m1_230400_120000 0 2.855025e-07
I5018 n1_m1_230400_124800 0 2.593832e-07
I5019 n1_m1_230400_129600 0 3.495206e-07
I5020 n1_m1_230400_134400 0 1.968549e-07
I5021 n1_m1_230400_139200 0 1.729393e-07
I5022 n1_m1_230400_144000 0 2.991992e-07
I5023 n1_m1_230400_148800 0 2.553578e-07
I5024 n1_m1_230400_153600 0 2.860198e-07
I5025 n1_m1_230400_158400 0 1.860713e-07
I5026 n1_m1_230400_163200 0 1.864475e-07
I5027 n1_m1_230400_168000 0 3.052987e-07
I5028 n1_m1_230400_172800 0 2.636566e-07
I5029 n1_m1_230400_177600 0 2.896651e-07
I5030 n1_m1_230400_182400 0 1.797110e-07
I5031 n1_m1_230400_187200 0 1.823281e-07
I5032 n1_m1_230400_192000 0 3.543873e-07
I5033 n1_m1_230400_196800 0 2.435777e-07
I5034 n1_m1_230400_201600 0 3.033651e-07
I5035 n1_m1_230400_206400 0 1.831753e-07
I5036 n1_m1_230400_211200 0 1.833373e-07
I5037 n1_m1_230400_216000 0 2.655785e-07
I5038 n1_m1_230400_220800 0 1.735300e-07
I5039 n1_m1_230400_225600 0 2.637106e-07
I5040 n1_m1_230400_230400 0 1.993443e-07
I5041 n1_m1_230400_235200 0 2.711187e-07
I5042 n1_m1_230400_240000 0 3.199267e-07
I5043 n1_m1_230400_244800 0 1.741554e-07
I5044 n1_m1_230400_249600 0 2.667441e-07
I5045 n1_m1_230400_254400 0 1.766832e-07
I5046 n1_m1_230400_259200 0 1.730765e-07
I5047 n1_m1_230400_264000 0 2.577455e-07
I5048 n1_m1_230400_268800 0 1.667136e-07
I5049 n1_m1_230400_273600 0 2.425918e-07
I5050 n1_m1_230400_278400 0 1.636942e-07
I5051 n1_m1_230400_283200 0 1.665524e-07
I5052 n1_m1_230400_288000 0 2.562818e-07
I5053 n1_m1_230400_292800 0 1.731743e-07
I5054 n1_m1_230400_297600 0 2.598217e-07
I5055 n1_m1_230400_302400 0 1.732144e-07
I5056 n1_m1_230400_307200 0 1.729344e-07
I5057 n1_m1_230400_312000 0 2.808754e-07
I5058 n1_m1_230400_316800 0 1.854027e-07
I5059 n1_m1_230400_321600 0 2.660390e-07
I5060 n1_m1_230400_326400 0 1.743781e-07
I5061 n1_m1_230400_331200 0 1.800330e-07
I5062 n1_m1_230400_336000 0 2.839205e-07
I5063 n1_m1_230400_340800 0 1.904942e-07
I5064 n1_m1_230400_345600 0 2.818834e-07
I5065 n1_m1_230400_350400 0 1.815590e-07
I5066 n1_m1_230400_355200 0 2.306391e-07
I5067 n1_m1_230400_360000 0 9.644736e-07
I5068 n1_m1_230400_364800 0 7.953536e-07
I5069 n1_m1_230400_369600 0 4.956561e-07
I5070 n1_m1_230400_374400 0 2.467897e-07
I5071 n1_m1_230400_379200 0 5.947356e-07
I5072 n1_m1_230400_384000 0 1.020628e-06
I5073 n1_m1_230400_388800 0 2.785774e-07
I5074 n1_m1_230400_393600 0 2.720497e-07
I5075 n1_m1_230400_398400 0 1.730541e-07
I5076 n1_m1_230400_403200 0 1.729575e-07
I5077 n1_m1_230400_408000 0 3.647600e-07
I5078 n1_m1_230400_412800 0 2.620831e-07
I5079 n1_m1_230400_417600 0 2.769078e-07
I5080 n1_m1_230400_422400 0 1.735875e-07
I5081 n1_m1_230400_427200 0 2.103410e-07
I5082 n1_m1_230400_432000 0 3.676186e-07
I5083 n1_m1_230400_436800 0 2.333956e-07
I5084 n1_m1_230400_441600 0 2.857547e-07
I5085 n1_m1_230400_446400 0 1.760834e-07
I5086 n1_m1_230400_451200 0 1.771216e-07
I5087 n1_m1_230400_456000 0 2.759114e-07
I5088 n1_m1_230400_460800 0 1.869759e-07
I5089 n1_m1_230400_465600 0 2.698052e-07
I5090 n1_m1_230400_470400 0 1.734463e-07
I5091 n1_m1_230400_475200 0 1.781707e-07
I5092 n1_m1_230400_480000 0 2.667641e-07
I5093 n1_m1_230400_484800 0 1.702701e-07
I5094 n1_m1_230400_489600 0 2.363034e-07
I5095 n1_m1_230400_494400 0 1.482784e-07
I5096 n1_m1_235200_0 0 1.495506e-07
I5097 n1_m1_235200_4800 0 1.526964e-07
I5098 n1_m1_235200_9600 0 2.335436e-07
I5099 n1_m1_235200_14400 0 1.597632e-07
I5100 n1_m1_235200_19200 0 1.598903e-07
I5101 n1_m1_235200_24000 0 2.398354e-07
I5102 n1_m1_235200_28800 0 1.614488e-07
I5103 n1_m1_235200_33600 0 2.497349e-07
I5104 n1_m1_235200_38400 0 1.614755e-07
I5105 n1_m1_235200_43200 0 1.598903e-07
I5106 n1_m1_235200_48000 0 2.398354e-07
I5107 n1_m1_235200_52800 0 1.604157e-07
I5108 n1_m1_235200_57600 0 2.410475e-07
I5109 n1_m1_235200_62400 0 1.635480e-07
I5110 n1_m1_235200_67200 0 1.786103e-07
I5111 n1_m1_235200_72000 0 2.584696e-07
I5112 n1_m1_235200_76800 0 1.799048e-07
I5113 n1_m1_235200_81600 0 4.986170e-07
I5114 n1_m1_235200_86400 0 7.506925e-07
I5115 n1_m1_235200_91200 0 3.355736e-07
I5116 n1_m1_235200_96000 0 2.794427e-07
I5117 n1_m1_235200_100800 0 1.791475e-07
I5118 n1_m1_235200_105600 0 2.925339e-07
I5119 n1_m1_235200_110400 0 2.500680e-07
I5120 n1_m1_235200_115200 0 2.697259e-07
I5121 n1_m1_235200_120000 0 3.693955e-07
I5122 n1_m1_235200_124800 0 3.284100e-07
I5123 n1_m1_235200_129600 0 4.846247e-07
I5124 n1_m1_235200_134400 0 3.082605e-07
I5125 n1_m1_235200_139200 0 2.189491e-07
I5126 n1_m1_235200_144000 0 2.769293e-07
I5127 n1_m1_235200_148800 0 2.137667e-07
I5128 n1_m1_235200_153600 0 2.689434e-07
I5129 n1_m1_235200_158400 0 1.995465e-07
I5130 n1_m1_235200_163200 0 2.211902e-07
I5131 n1_m1_235200_168000 0 4.009321e-07
I5132 n1_m1_235200_172800 0 3.809101e-07
I5133 n1_m1_235200_177600 0 5.876852e-07
I5134 n1_m1_235200_182400 0 3.786421e-07
I5135 n1_m1_235200_187200 0 2.613629e-07
I5136 n1_m1_235200_192000 0 4.079565e-07
I5137 n1_m1_235200_196800 0 3.330485e-07
I5138 n1_m1_235200_201600 0 4.503292e-07
I5139 n1_m1_235200_206400 0 2.135279e-07
I5140 n1_m1_235200_211200 0 1.774004e-07
I5141 n1_m1_235200_216000 0 2.527117e-07
I5142 n1_m1_235200_220800 0 1.704684e-07
I5143 n1_m1_235200_225600 0 2.611539e-07
I5144 n1_m1_235200_230400 0 2.001505e-07
I5145 n1_m1_235200_235200 0 2.695220e-07
I5146 n1_m1_235200_240000 0 3.057782e-07
I5147 n1_m1_235200_244800 0 1.774563e-07
I5148 n1_m1_235200_249600 0 2.635457e-07
I5149 n1_m1_235200_254400 0 1.744145e-07
I5150 n1_m1_235200_259200 0 1.727613e-07
I5151 n1_m1_235200_264000 0 2.534899e-07
I5152 n1_m1_235200_268800 0 1.665859e-07
I5153 n1_m1_235200_273600 0 2.487823e-07
I5154 n1_m1_235200_278400 0 1.656412e-07
I5155 n1_m1_235200_283200 0 1.665524e-07
I5156 n1_m1_235200_288000 0 2.566512e-07
I5157 n1_m1_235200_292800 0 1.732144e-07
I5158 n1_m1_235200_297600 0 2.606641e-07
I5159 n1_m1_235200_302400 0 1.745990e-07
I5160 n1_m1_235200_307200 0 1.736788e-07
I5161 n1_m1_235200_312000 0 2.786302e-07
I5162 n1_m1_235200_316800 0 1.877652e-07
I5163 n1_m1_235200_321600 0 2.731043e-07
I5164 n1_m1_235200_326400 0 1.746556e-07
I5165 n1_m1_235200_331200 0 1.734876e-07
I5166 n1_m1_235200_336000 0 2.617799e-07
I5167 n1_m1_235200_340800 0 1.919168e-07
I5168 n1_m1_235200_345600 0 3.169335e-07
I5169 n1_m1_235200_350400 0 1.907155e-07
I5170 n1_m1_235200_355200 0 2.418335e-07
I5171 n1_m1_235200_360000 0 9.958572e-07
I5172 n1_m1_235200_364800 0 8.436522e-07
I5173 n1_m1_235200_369600 0 5.774671e-07
I5174 n1_m1_235200_374400 0 2.236394e-07
I5175 n1_m1_235200_379200 0 3.949240e-07
I5176 n1_m1_235200_384000 0 6.112295e-07
I5177 n1_m1_235200_388800 0 2.861842e-07
I5178 n1_m1_235200_393600 0 3.053041e-07
I5179 n1_m1_235200_398400 0 1.852498e-07
I5180 n1_m1_235200_403200 0 1.893356e-07
I5181 n1_m1_235200_408000 0 3.656534e-07
I5182 n1_m1_235200_412800 0 2.216963e-07
I5183 n1_m1_235200_417600 0 2.643702e-07
I5184 n1_m1_235200_422400 0 1.743315e-07
I5185 n1_m1_235200_427200 0 1.874186e-07
I5186 n1_m1_235200_432000 0 2.780975e-07
I5187 n1_m1_235200_436800 0 1.766118e-07
I5188 n1_m1_235200_441600 0 2.577278e-07
I5189 n1_m1_235200_446400 0 1.715903e-07
I5190 n1_m1_235200_451200 0 1.734362e-07
I5191 n1_m1_235200_456000 0 2.706955e-07
I5192 n1_m1_235200_460800 0 1.904030e-07
I5193 n1_m1_235200_465600 0 2.730684e-07
I5194 n1_m1_235200_470400 0 1.734105e-07
I5195 n1_m1_235200_475200 0 1.774057e-07
I5196 n1_m1_235200_480000 0 2.656926e-07
I5197 n1_m1_235200_484800 0 1.698697e-07
I5198 n1_m1_235200_489600 0 2.359164e-07
I5199 n1_m1_235200_494400 0 1.493071e-07
I5200 n1_m1_240000_0 0 2.296683e-07
I5201 n1_m1_240000_4800 0 2.305155e-07
I5202 n1_m1_240000_9600 0 3.544419e-07
I5203 n1_m1_240000_14400 0 2.398354e-07
I5204 n1_m1_240000_19200 0 2.398354e-07
I5205 n1_m1_240000_24000 0 3.597531e-07
I5206 n1_m1_240000_28800 0 2.410809e-07
I5207 n1_m1_240000_33600 0 3.676647e-07
I5208 n1_m1_240000_38400 0 2.411023e-07
I5209 n1_m1_240000_43200 0 2.398354e-07
I5210 n1_m1_240000_48000 0 3.597531e-07
I5211 n1_m1_240000_52800 0 2.435391e-07
I5212 n1_m1_240000_57600 0 3.706436e-07
I5213 n1_m1_240000_62400 0 2.543966e-07
I5214 n1_m1_240000_67200 0 2.653936e-07
I5215 n1_m1_240000_72000 0 3.798548e-07
I5216 n1_m1_240000_76800 0 2.526798e-07
I5217 n1_m1_240000_81600 0 4.499432e-07
I5218 n1_m1_240000_86400 0 5.163851e-07
I5219 n1_m1_240000_91200 0 2.953773e-07
I5220 n1_m1_240000_96000 0 3.911817e-07
I5221 n1_m1_240000_100800 0 2.600558e-07
I5222 n1_m1_240000_105600 0 4.605702e-07
I5223 n1_m1_240000_110400 0 5.075844e-07
I5224 n1_m1_240000_115200 0 6.461497e-07
I5225 n1_m1_240000_120000 0 9.821699e-07
I5226 n1_m1_240000_124800 0 5.319102e-07
I5227 n1_m1_240000_129600 0 6.855650e-07
I5228 n1_m1_240000_134400 0 4.511778e-07
I5229 n1_m1_240000_139200 0 3.465334e-07
I5230 n1_m1_240000_144000 0 3.958944e-07
I5231 n1_m1_240000_148800 0 2.657383e-07
I5232 n1_m1_240000_153600 0 4.178464e-07
I5233 n1_m1_240000_158400 0 4.522713e-07
I5234 n1_m1_240000_163200 0 9.197281e-07
I5235 n1_m1_240000_168000 0 1.929667e-06
I5236 n1_m1_240000_172800 0 1.431980e-06
I5237 n1_m1_240000_177600 0 2.364652e-06
I5238 n1_m1_240000_182400 0 1.590865e-06
I5239 n1_m1_240000_187200 0 9.469645e-07
I5240 n1_m1_240000_192000 0 7.403287e-07
I5241 n1_m1_240000_196800 0 3.744165e-07
I5242 n1_m1_240000_201600 0 5.684989e-07
I5243 n1_m1_240000_206400 0 2.978539e-07
I5244 n1_m1_240000_211200 0 2.737353e-07
I5245 n1_m1_240000_216000 0 4.323060e-07
I5246 n1_m1_240000_220800 0 2.554271e-07
I5247 n1_m1_240000_225600 0 3.915285e-07
I5248 n1_m1_240000_230400 0 2.806859e-07
I5249 n1_m1_240000_235200 0 3.144457e-07
I5250 n1_m1_240000_240000 0 3.948977e-07
I5251 n1_m1_240000_244800 0 2.678635e-07
I5252 n1_m1_240000_249600 0 4.609335e-07
I5253 n1_m1_240000_254400 0 2.811454e-07
I5254 n1_m1_240000_259200 0 2.612963e-07
I5255 n1_m1_240000_264000 0 3.776078e-07
I5256 n1_m1_240000_268800 0 2.463597e-07
I5257 n1_m1_240000_273600 0 3.717309e-07
I5258 n1_m1_240000_278400 0 2.471199e-07
I5259 n1_m1_240000_283200 0 2.498285e-07
I5260 n1_m1_240000_288000 0 3.849767e-07
I5261 n1_m1_240000_292800 0 2.598217e-07
I5262 n1_m1_240000_297600 0 3.956702e-07
I5263 n1_m1_240000_302400 0 2.695807e-07
I5264 n1_m1_240000_307200 0 2.661974e-07
I5265 n1_m1_240000_312000 0 3.875186e-07
I5266 n1_m1_240000_316800 0 2.616670e-07
I5267 n1_m1_240000_321600 0 3.978006e-07
I5268 n1_m1_240000_326400 0 2.610245e-07
I5269 n1_m1_240000_331200 0 2.602436e-07
I5270 n1_m1_240000_336000 0 4.144806e-07
I5271 n1_m1_240000_340800 0 4.934161e-07
I5272 n1_m1_240000_345600 0 1.183594e-06
I5273 n1_m1_240000_350400 0 6.922478e-07
I5274 n1_m1_240000_355200 0 5.133981e-07
I5275 n1_m1_240000_360000 0 7.369641e-07
I5276 n1_m1_240000_364800 0 5.352502e-07
I5277 n1_m1_240000_369600 0 6.532570e-07
I5278 n1_m1_240000_374400 0 3.400477e-07
I5279 n1_m1_240000_379200 0 4.021804e-07
I5280 n1_m1_240000_384000 0 5.481494e-07
I5281 n1_m1_240000_388800 0 6.159263e-07
I5282 n1_m1_240000_393600 0 6.265969e-07
I5283 n1_m1_240000_398400 0 2.974240e-07
I5284 n1_m1_240000_403200 0 2.741074e-07
I5285 n1_m1_240000_408000 0 4.028987e-07
I5286 n1_m1_240000_412800 0 2.711467e-07
I5287 n1_m1_240000_417600 0 3.998136e-07
I5288 n1_m1_240000_422400 0 2.717950e-07
I5289 n1_m1_240000_427200 0 2.701850e-07
I5290 n1_m1_240000_432000 0 3.885056e-07
I5291 n1_m1_240000_436800 0 2.594254e-07
I5292 n1_m1_240000_441600 0 3.895872e-07
I5293 n1_m1_240000_446400 0 2.597394e-07
I5294 n1_m1_240000_451200 0 2.598217e-07
I5295 n1_m1_240000_456000 0 3.962588e-07
I5296 n1_m1_240000_460800 0 2.668946e-07
I5297 n1_m1_240000_465600 0 3.976214e-07
I5298 n1_m1_240000_470400 0 2.596569e-07
I5299 n1_m1_240000_475200 0 2.562997e-07
I5300 n1_m1_240000_480000 0 3.829897e-07
I5301 n1_m1_240000_484800 0 2.488833e-07
I5302 n1_m1_240000_489600 0 3.548332e-07
I5303 n1_m1_240000_494400 0 2.343371e-07
I5304 n1_m1_244800_0 0 1.532282e-07
I5305 n1_m1_244800_4800 0 1.542248e-07
I5306 n1_m1_244800_9600 0 2.392133e-07
I5307 n1_m1_244800_14400 0 1.598903e-07
I5308 n1_m1_244800_19200 0 1.598903e-07
I5309 n1_m1_244800_24000 0 2.444428e-07
I5310 n1_m1_244800_28800 0 1.600024e-07
I5311 n1_m1_244800_33600 0 2.398354e-07
I5312 n1_m1_244800_38400 0 1.598903e-07
I5313 n1_m1_244800_43200 0 1.598903e-07
I5314 n1_m1_244800_48000 0 2.415418e-07
I5315 n1_m1_244800_52800 0 1.654318e-07
I5316 n1_m1_244800_57600 0 2.499899e-07
I5317 n1_m1_244800_62400 0 1.687699e-07
I5318 n1_m1_244800_67200 0 1.767308e-07
I5319 n1_m1_244800_72000 0 2.798548e-07
I5320 n1_m1_244800_76800 0 1.740705e-07
I5321 n1_m1_244800_81600 0 2.586404e-07
I5322 n1_m1_244800_86400 0 1.694814e-07
I5323 n1_m1_244800_91200 0 1.729463e-07
I5324 n1_m1_244800_96000 0 2.598217e-07
I5325 n1_m1_244800_100800 0 1.697333e-07
I5326 n1_m1_244800_105600 0 2.710245e-07
I5327 n1_m1_244800_110400 0 2.187758e-07
I5328 n1_m1_244800_115200 0 2.522146e-07
I5329 n1_m1_244800_120000 0 4.071545e-07
I5330 n1_m1_244800_124800 0 2.535446e-07
I5331 n1_m1_244800_129600 0 2.876595e-07
I5332 n1_m1_244800_134400 0 1.847193e-07
I5333 n1_m1_244800_139200 0 1.818966e-07
I5334 n1_m1_244800_144000 0 2.567314e-07
I5335 n1_m1_244800_148800 0 1.746259e-07
I5336 n1_m1_244800_153600 0 3.537842e-07
I5337 n1_m1_244800_158400 0 4.271652e-07
I5338 n1_m1_244800_163200 0 8.793998e-07
I5339 n1_m1_244800_168000 0 1.781646e-06
I5340 n1_m1_244800_172800 0 1.151590e-06
I5341 n1_m1_244800_177600 0 1.891032e-06
I5342 n1_m1_244800_182400 0 1.231915e-06
I5343 n1_m1_244800_187200 0 7.124243e-07
I5344 n1_m1_244800_192000 0 3.865124e-07
I5345 n1_m1_244800_196800 0 1.728685e-07
I5346 n1_m1_244800_201600 0 2.942221e-07
I5347 n1_m1_244800_206400 0 1.748228e-07
I5348 n1_m1_244800_211200 0 1.729762e-07
I5349 n1_m1_244800_216000 0 2.768825e-07
I5350 n1_m1_244800_220800 0 1.751408e-07
I5351 n1_m1_244800_225600 0 2.683031e-07
I5352 n1_m1_244800_230400 0 1.878341e-07
I5353 n1_m1_244800_235200 0 1.958462e-07
I5354 n1_m1_244800_240000 0 2.595996e-07
I5355 n1_m1_244800_244800 0 2.107546e-07
I5356 n1_m1_244800_249600 0 4.945018e-07
I5357 n1_m1_244800_254400 0 2.719297e-07
I5358 n1_m1_244800_259200 0 1.988854e-07
I5359 n1_m1_244800_264000 0 2.571387e-07
I5360 n1_m1_244800_268800 0 1.652106e-07
I5361 n1_m1_244800_273600 0 2.516649e-07
I5362 n1_m1_244800_278400 0 1.691364e-07
I5363 n1_m1_244800_283200 0 1.665524e-07
I5364 n1_m1_244800_288000 0 2.523947e-07
I5365 n1_m1_244800_292800 0 1.735362e-07
I5366 n1_m1_244800_297600 0 2.678097e-07
I5367 n1_m1_244800_302400 0 1.829677e-07
I5368 n1_m1_244800_307200 0 1.847326e-07
I5369 n1_m1_244800_312000 0 2.558329e-07
I5370 n1_m1_244800_316800 0 1.683384e-07
I5371 n1_m1_244800_321600 0 2.525375e-07
I5372 n1_m1_244800_326400 0 1.685095e-07
I5373 n1_m1_244800_331200 0 1.730071e-07
I5374 n1_m1_244800_336000 0 3.069452e-07
I5375 n1_m1_244800_340800 0 5.201905e-07
I5376 n1_m1_244800_345600 0 1.611039e-06
I5377 n1_m1_244800_350400 0 1.119277e-06
I5378 n1_m1_244800_355200 0 7.475761e-07
I5379 n1_m1_244800_360000 0 3.964574e-07
I5380 n1_m1_244800_364800 0 2.271325e-07
I5381 n1_m1_244800_369600 0 3.692252e-07
I5382 n1_m1_244800_374400 0 3.315573e-07
I5383 n1_m1_244800_379200 0 4.155923e-07
I5384 n1_m1_244800_384000 0 3.610549e-07
I5385 n1_m1_244800_388800 0 5.258681e-07
I5386 n1_m1_244800_393600 0 6.564404e-07
I5387 n1_m1_244800_398400 0 3.203747e-07
I5388 n1_m1_244800_403200 0 2.121671e-07
I5389 n1_m1_244800_408000 0 2.647964e-07
I5390 n1_m1_244800_412800 0 1.790331e-07
I5391 n1_m1_244800_417600 0 2.684367e-07
I5392 n1_m1_244800_422400 0 1.736292e-07
I5393 n1_m1_244800_427200 0 1.717139e-07
I5394 n1_m1_244800_432000 0 2.617675e-07
I5395 n1_m1_244800_436800 0 1.698790e-07
I5396 n1_m1_244800_441600 0 2.594560e-07
I5397 n1_m1_244800_446400 0 1.732144e-07
I5398 n1_m1_244800_451200 0 1.699283e-07
I5399 n1_m1_244800_456000 0 2.525375e-07
I5400 n1_m1_244800_460800 0 1.695821e-07
I5401 n1_m1_244800_465600 0 2.560577e-07
I5402 n1_m1_244800_470400 0 1.682913e-07
I5403 n1_m1_244800_475200 0 1.666754e-07
I5404 n1_m1_244800_480000 0 2.434756e-07
I5405 n1_m1_244800_484800 0 1.609456e-07
I5406 n1_m1_244800_489600 0 2.398354e-07
I5407 n1_m1_244800_494400 0 1.598903e-07
I5408 n1_m1_249600_0 0 2.381699e-07
I5409 n1_m1_249600_4800 0 2.396648e-07
I5410 n1_m1_249600_9600 0 3.713114e-07
I5411 n1_m1_249600_14400 0 2.481630e-07
I5412 n1_m1_249600_19200 0 2.481630e-07
I5413 n1_m1_249600_24000 0 3.738247e-07
I5414 n1_m1_249600_28800 0 2.493046e-07
I5415 n1_m1_249600_33600 0 3.708881e-07
I5416 n1_m1_249600_38400 0 2.443939e-07
I5417 n1_m1_249600_43200 0 2.454096e-07
I5418 n1_m1_249600_48000 0 3.762063e-07
I5419 n1_m1_249600_52800 0 2.563502e-07
I5420 n1_m1_249600_57600 0 3.799224e-07
I5421 n1_m1_249600_62400 0 2.496108e-07
I5422 n1_m1_249600_67200 0 2.587897e-07
I5423 n1_m1_249600_72000 0 4.046756e-07
I5424 n1_m1_249600_76800 0 2.579755e-07
I5425 n1_m1_249600_81600 0 3.904623e-07
I5426 n1_m1_249600_86400 0 2.636721e-07
I5427 n1_m1_249600_91200 0 2.549797e-07
I5428 n1_m1_249600_96000 0 4.027926e-07
I5429 n1_m1_249600_100800 0 2.820125e-07
I5430 n1_m1_249600_105600 0 4.163155e-07
I5431 n1_m1_249600_110400 0 2.686096e-07
I5432 n1_m1_249600_115200 0 2.664779e-07
I5433 n1_m1_249600_120000 0 4.267520e-07
I5434 n1_m1_249600_124800 0 2.838517e-07
I5435 n1_m1_249600_129600 0 3.983009e-07
I5436 n1_m1_249600_134400 0 2.649721e-07
I5437 n1_m1_249600_139200 0 2.565787e-07
I5438 n1_m1_249600_144000 0 3.787979e-07
I5439 n1_m1_249600_148800 0 2.619103e-07
I5440 n1_m1_249600_153600 0 4.561799e-07
I5441 n1_m1_249600_158400 0 3.972302e-07
I5442 n1_m1_249600_163200 0 5.339406e-07
I5443 n1_m1_249600_168000 0 9.441373e-07
I5444 n1_m1_249600_172800 0 6.330468e-07
I5445 n1_m1_249600_177600 0 1.036233e-06
I5446 n1_m1_249600_182400 0 6.823744e-07
I5447 n1_m1_249600_187200 0 4.324044e-07
I5448 n1_m1_249600_192000 0 4.041040e-07
I5449 n1_m1_249600_196800 0 2.554925e-07
I5450 n1_m1_249600_201600 0 4.053539e-07
I5451 n1_m1_249600_206400 0 2.597434e-07
I5452 n1_m1_249600_211200 0 2.585667e-07
I5453 n1_m1_249600_216000 0 3.891275e-07
I5454 n1_m1_249600_220800 0 2.542331e-07
I5455 n1_m1_249600_225600 0 3.827477e-07
I5456 n1_m1_249600_230400 0 2.599436e-07
I5457 n1_m1_249600_235200 0 2.886448e-07
I5458 n1_m1_249600_240000 0 6.951179e-07
I5459 n1_m1_249600_244800 0 7.756927e-07
I5460 n1_m1_249600_249600 0 8.011116e-07
I5461 n1_m1_249600_254400 0 3.900869e-07
I5462 n1_m1_249600_259200 0 3.034831e-07
I5463 n1_m1_249600_264000 0 3.916276e-07
I5464 n1_m1_249600_268800 0 2.504964e-07
I5465 n1_m1_249600_273600 0 3.667732e-07
I5466 n1_m1_249600_278400 0 2.472445e-07
I5467 n1_m1_249600_283200 0 2.507243e-07
I5468 n1_m1_249600_288000 0 3.843764e-07
I5469 n1_m1_249600_292800 0 2.596401e-07
I5470 n1_m1_249600_297600 0 3.985680e-07
I5471 n1_m1_249600_302400 0 3.659616e-07
I5472 n1_m1_249600_307200 0 5.086611e-07
I5473 n1_m1_249600_312000 0 6.085488e-07
I5474 n1_m1_249600_316800 0 2.855913e-07
I5475 n1_m1_249600_321600 0 4.047113e-07
I5476 n1_m1_249600_326400 0 3.422205e-07
I5477 n1_m1_249600_331200 0 5.432716e-07
I5478 n1_m1_249600_336000 0 9.456789e-07
I5479 n1_m1_249600_340800 0 5.692714e-07
I5480 n1_m1_249600_345600 0 1.590009e-06
I5481 n1_m1_249600_350400 0 1.531633e-06
I5482 n1_m1_249600_355200 0 1.264764e-06
I5483 n1_m1_249600_360000 0 7.537614e-07
I5484 n1_m1_249600_364800 0 3.460146e-07
I5485 n1_m1_249600_369600 0 5.689741e-07
I5486 n1_m1_249600_374400 0 3.682647e-07
I5487 n1_m1_249600_379200 0 3.833586e-07
I5488 n1_m1_249600_384000 0 4.959579e-07
I5489 n1_m1_249600_388800 0 6.283900e-07
I5490 n1_m1_249600_393600 0 1.580274e-06
I5491 n1_m1_249600_398400 0 1.103674e-06
I5492 n1_m1_249600_403200 0 8.500958e-07
I5493 n1_m1_249600_408000 0 6.794438e-07
I5494 n1_m1_249600_412800 0 2.784398e-07
I5495 n1_m1_249600_417600 0 4.256138e-07
I5496 n1_m1_249600_422400 0 2.855100e-07
I5497 n1_m1_249600_427200 0 2.584126e-07
I5498 n1_m1_249600_432000 0 4.264003e-07
I5499 n1_m1_249600_436800 0 2.577859e-07
I5500 n1_m1_249600_441600 0 6.050759e-07
I5501 n1_m1_249600_446400 0 5.440113e-07
I5502 n1_m1_249600_451200 0 3.720907e-07
I5503 n1_m1_249600_456000 0 3.889000e-07
I5504 n1_m1_249600_460800 0 2.473516e-07
I5505 n1_m1_249600_465600 0 3.919016e-07
I5506 n1_m1_249600_470400 0 2.596321e-07
I5507 n1_m1_249600_475200 0 2.613111e-07
I5508 n1_m1_249600_480000 0 3.840186e-07
I5509 n1_m1_249600_484800 0 2.419460e-07
I5510 n1_m1_249600_489600 0 3.604537e-07
I5511 n1_m1_249600_494400 0 2.446808e-07
I5512 n1_m1_254400_0 0 7.994513e-08
I5513 n1_m1_254400_4800 0 8.042243e-08
I5514 n1_m1_254400_9600 0 1.244056e-07
I5515 n1_m1_254400_14400 0 8.322174e-08
I5516 n1_m1_254400_19200 0 8.327618e-08
I5517 n1_m1_254400_24000 0 1.250784e-07
I5518 n1_m1_254400_28800 0 8.263739e-08
I5519 n1_m1_254400_33600 0 1.225778e-07
I5520 n1_m1_254400_38400 0 8.824597e-08
I5521 n1_m1_254400_43200 0 8.968744e-08
I5522 n1_m1_254400_48000 0 1.292286e-07
I5523 n1_m1_254400_52800 0 8.324233e-08
I5524 n1_m1_254400_57600 0 1.275781e-07
I5525 n1_m1_254400_62400 0 8.170577e-08
I5526 n1_m1_254400_67200 0 8.407015e-08
I5527 n1_m1_254400_72000 0 1.340688e-07
I5528 n1_m1_254400_76800 0 8.812575e-08
I5529 n1_m1_254400_81600 0 1.332532e-07
I5530 n1_m1_254400_86400 0 8.908468e-08
I5531 n1_m1_254400_91200 0 8.613177e-08
I5532 n1_m1_254400_96000 0 1.295546e-07
I5533 n1_m1_254400_100800 0 1.263536e-07
I5534 n1_m1_254400_105600 0 1.922384e-07
I5535 n1_m1_254400_110400 0 9.816007e-08
I5536 n1_m1_254400_115200 0 8.702100e-08
I5537 n1_m1_254400_120000 0 1.328081e-07
I5538 n1_m1_254400_124800 0 8.462799e-08
I5539 n1_m1_254400_129600 0 1.264295e-07
I5540 n1_m1_254400_134400 0 8.501242e-08
I5541 n1_m1_254400_139200 0 8.334415e-08
I5542 n1_m1_254400_144000 0 1.288057e-07
I5543 n1_m1_254400_148800 0 8.997079e-08
I5544 n1_m1_254400_153600 0 1.353145e-07
I5545 n1_m1_254400_158400 0 8.646676e-08
I5546 n1_m1_254400_163200 0 8.655843e-08
I5547 n1_m1_254400_168000 0 1.298791e-07
I5548 n1_m1_254400_172800 0 8.646915e-08
I5549 n1_m1_254400_177600 0 1.298413e-07
I5550 n1_m1_254400_182400 0 8.897774e-08
I5551 n1_m1_254400_187200 0 8.717193e-08
I5552 n1_m1_254400_192000 0 1.267528e-07
I5553 n1_m1_254400_196800 0 8.652176e-08
I5554 n1_m1_254400_201600 0 1.294773e-07
I5555 n1_m1_254400_206400 0 8.411162e-08
I5556 n1_m1_254400_211200 0 8.696780e-08
I5557 n1_m1_254400_216000 0 1.358175e-07
I5558 n1_m1_254400_220800 0 8.699477e-08
I5559 n1_m1_254400_225600 0 1.298158e-07
I5560 n1_m1_254400_230400 0 9.079454e-08
I5561 n1_m1_254400_235200 0 1.329292e-07
I5562 n1_m1_254400_240000 0 4.517534e-07
I5563 n1_m1_254400_244800 0 4.612245e-07
I5564 n1_m1_254400_249600 0 2.566792e-07
I5565 n1_m1_254400_254400 0 9.969629e-08
I5566 n1_m1_254400_259200 0 9.089977e-08
I5567 n1_m1_254400_264000 0 1.270614e-07
I5568 n1_m1_254400_268800 0 8.327618e-08
I5569 n1_m1_254400_273600 0 1.249143e-07
I5570 n1_m1_254400_278400 0 8.334190e-08
I5571 n1_m1_254400_283200 0 8.499912e-08
I5572 n1_m1_254400_288000 0 1.299108e-07
I5573 n1_m1_254400_292800 0 8.606877e-08
I5574 n1_m1_254400_297600 0 1.271264e-07
I5575 n1_m1_254400_302400 0 1.069551e-07
I5576 n1_m1_254400_307200 0 1.487160e-07
I5577 n1_m1_254400_312000 0 3.842980e-07
I5578 n1_m1_254400_316800 0 1.294470e-07
I5579 n1_m1_254400_321600 0 1.353509e-07
I5580 n1_m1_254400_326400 0 2.190740e-07
I5581 n1_m1_254400_331200 0 4.277433e-07
I5582 n1_m1_254400_336000 0 6.533289e-07
I5583 n1_m1_254400_340800 0 2.195830e-07
I5584 n1_m1_254400_345600 0 1.604820e-07
I5585 n1_m1_254400_350400 0 2.212326e-07
I5586 n1_m1_254400_355200 0 3.457272e-07
I5587 n1_m1_254400_360000 0 3.615665e-07
I5588 n1_m1_254400_364800 0 1.093641e-07
I5589 n1_m1_254400_369600 0 1.352240e-07
I5590 n1_m1_254400_374400 0 8.783952e-08
I5591 n1_m1_254400_379200 0 1.174993e-07
I5592 n1_m1_254400_384000 0 2.374737e-07
I5593 n1_m1_254400_388800 0 1.032033e-07
I5594 n1_m1_254400_393600 0 2.598805e-07
I5595 n1_m1_254400_398400 0 4.313573e-07
I5596 n1_m1_254400_403200 0 5.386821e-07
I5597 n1_m1_254400_408000 0 4.560602e-07
I5598 n1_m1_254400_412800 0 1.145553e-07
I5599 n1_m1_254400_417600 0 1.347083e-07
I5600 n1_m1_254400_422400 0 9.267087e-08
I5601 n1_m1_254400_427200 0 9.247786e-08
I5602 n1_m1_254400_432000 0 2.061938e-07
I5603 n1_m1_254400_436800 0 9.868571e-08
I5604 n1_m1_254400_441600 0 1.362280e-07
I5605 n1_m1_254400_446400 0 1.418227e-07
I5606 n1_m1_254400_451200 0 1.767096e-07
I5607 n1_m1_254400_456000 0 1.663215e-07
I5608 n1_m1_254400_460800 0 8.111556e-08
I5609 n1_m1_254400_465600 0 1.277626e-07
I5610 n1_m1_254400_470400 0 8.905387e-08
I5611 n1_m1_254400_475200 0 9.242153e-08
I5612 n1_m1_254400_480000 0 1.372951e-07
I5613 n1_m1_254400_484800 0 8.383804e-08
I5614 n1_m1_254400_489600 0 1.199026e-07
I5615 n1_m1_254400_494400 0 7.984077e-08
I5616 n1_m1_259200_0 0 1.598903e-07
I5617 n1_m1_259200_4800 0 1.598903e-07
I5618 n1_m1_259200_9600 0 2.398354e-07
I5619 n1_m1_259200_14400 0 1.639705e-07
I5620 n1_m1_259200_19200 0 1.665524e-07
I5621 n1_m1_259200_24000 0 2.576143e-07
I5622 n1_m1_259200_28800 0 1.721661e-07
I5623 n1_m1_259200_33600 0 2.531514e-07
I5624 n1_m1_259200_38400 0 1.704864e-07
I5625 n1_m1_259200_43200 0 1.708854e-07
I5626 n1_m1_259200_48000 0 2.499604e-07
I5627 n1_m1_259200_52800 0 1.676530e-07
I5628 n1_m1_259200_57600 0 2.662581e-07
I5629 n1_m1_259200_62400 0 1.853966e-07
I5630 n1_m1_259200_67200 0 1.966089e-07
I5631 n1_m1_259200_72000 0 2.661197e-07
I5632 n1_m1_259200_76800 0 1.746860e-07
I5633 n1_m1_259200_81600 0 2.545500e-07
I5634 n1_m1_259200_86400 0 1.706690e-07
I5635 n1_m1_259200_91200 0 1.965088e-07
I5636 n1_m1_259200_96000 0 3.073850e-07
I5637 n1_m1_259200_100800 0 2.060071e-07
I5638 n1_m1_259200_105600 0 4.011174e-07
I5639 n1_m1_259200_110400 0 2.597075e-07
I5640 n1_m1_259200_115200 0 3.033390e-07
I5641 n1_m1_259200_120000 0 4.637544e-07
I5642 n1_m1_259200_124800 0 2.298746e-07
I5643 n1_m1_259200_129600 0 2.872702e-07
I5644 n1_m1_259200_134400 0 1.721001e-07
I5645 n1_m1_259200_139200 0 1.741375e-07
I5646 n1_m1_259200_144000 0 2.657460e-07
I5647 n1_m1_259200_148800 0 1.733173e-07
I5648 n1_m1_259200_153600 0 2.540686e-07
I5649 n1_m1_259200_158400 0 1.679141e-07
I5650 n1_m1_259200_163200 0 1.716576e-07
I5651 n1_m1_259200_168000 0 2.588093e-07
I5652 n1_m1_259200_172800 0 1.688094e-07
I5653 n1_m1_259200_177600 0 2.564785e-07
I5654 n1_m1_259200_182400 0 1.732144e-07
I5655 n1_m1_259200_187200 0 1.729536e-07
I5656 n1_m1_259200_192000 0 2.511864e-07
I5657 n1_m1_259200_196800 0 1.691610e-07
I5658 n1_m1_259200_201600 0 2.557001e-07
I5659 n1_m1_259200_206400 0 1.692234e-07
I5660 n1_m1_259200_211200 0 1.731695e-07
I5661 n1_m1_259200_216000 0 2.755475e-07
I5662 n1_m1_259200_220800 0 1.843575e-07
I5663 n1_m1_259200_225600 0 2.535181e-07
I5664 n1_m1_259200_230400 0 1.669749e-07
I5665 n1_m1_259200_235200 0 1.700102e-07
I5666 n1_m1_259200_240000 0 3.005464e-07
I5667 n1_m1_259200_244800 0 2.585733e-07
I5668 n1_m1_259200_249600 0 2.882819e-07
I5669 n1_m1_259200_254400 0 1.732144e-07
I5670 n1_m1_259200_259200 0 1.732144e-07
I5671 n1_m1_259200_264000 0 2.541228e-07
I5672 n1_m1_259200_268800 0 1.663838e-07
I5673 n1_m1_259200_273600 0 2.478778e-07
I5674 n1_m1_259200_278400 0 1.686491e-07
I5675 n1_m1_259200_283200 0 1.721154e-07
I5676 n1_m1_259200_288000 0 2.594998e-07
I5677 n1_m1_259200_292800 0 1.705174e-07
I5678 n1_m1_259200_297600 0 2.501930e-07
I5679 n1_m1_259200_302400 0 1.736458e-07
I5680 n1_m1_259200_307200 0 1.896107e-07
I5681 n1_m1_259200_312000 0 2.780346e-07
I5682 n1_m1_259200_316800 0 1.910801e-07
I5683 n1_m1_259200_321600 0 3.431866e-07
I5684 n1_m1_259200_326400 0 2.214309e-07
I5685 n1_m1_259200_331200 0 3.383571e-07
I5686 n1_m1_259200_336000 0 5.100508e-07
I5687 n1_m1_259200_340800 0 2.040190e-07
I5688 n1_m1_259200_345600 0 2.693998e-07
I5689 n1_m1_259200_350400 0 2.247620e-07
I5690 n1_m1_259200_355200 0 3.349812e-07
I5691 n1_m1_259200_360000 0 3.623551e-07
I5692 n1_m1_259200_364800 0 1.766429e-07
I5693 n1_m1_259200_369600 0 2.775515e-07
I5694 n1_m1_259200_374400 0 1.887437e-07
I5695 n1_m1_259200_379200 0 1.759889e-07
I5696 n1_m1_259200_384000 0 2.934702e-07
I5697 n1_m1_259200_388800 0 1.910514e-07
I5698 n1_m1_259200_393600 0 3.588746e-07
I5699 n1_m1_259200_398400 0 6.781711e-07
I5700 n1_m1_259200_403200 0 1.136949e-06
I5701 n1_m1_259200_408000 0 1.430894e-06
I5702 n1_m1_259200_412800 0 3.616168e-07
I5703 n1_m1_259200_417600 0 3.939879e-07
I5704 n1_m1_259200_422400 0 2.641877e-07
I5705 n1_m1_259200_427200 0 2.209869e-07
I5706 n1_m1_259200_432000 0 4.147516e-07
I5707 n1_m1_259200_436800 0 1.892026e-07
I5708 n1_m1_259200_441600 0 2.565550e-07
I5709 n1_m1_259200_446400 0 3.094473e-07
I5710 n1_m1_259200_451200 0 5.040852e-07
I5711 n1_m1_259200_456000 0 5.304134e-07
I5712 n1_m1_259200_460800 0 2.108009e-07
I5713 n1_m1_259200_465600 0 2.705770e-07
I5714 n1_m1_259200_470400 0 1.663794e-07
I5715 n1_m1_259200_475200 0 1.740117e-07
I5716 n1_m1_259200_480000 0 2.685151e-07
I5717 n1_m1_259200_484800 0 1.676761e-07
I5718 n1_m1_259200_489600 0 2.393539e-07
I5719 n1_m1_259200_494400 0 1.565606e-07
I5720 n1_m1_264000_0 0 2.356013e-07
I5721 n1_m1_264000_4800 0 2.392232e-07
I5722 n1_m1_264000_9600 0 3.599993e-07
I5723 n1_m1_264000_14400 0 2.463771e-07
I5724 n1_m1_264000_19200 0 2.536305e-07
I5725 n1_m1_264000_24000 0 3.883097e-07
I5726 n1_m1_264000_28800 0 2.609577e-07
I5727 n1_m1_264000_33600 0 4.239433e-07
I5728 n1_m1_264000_38400 0 3.699440e-07
I5729 n1_m1_264000_43200 0 3.674946e-07
I5730 n1_m1_264000_48000 0 4.285401e-07
I5731 n1_m1_264000_52800 0 2.598217e-07
I5732 n1_m1_264000_57600 0 3.950495e-07
I5733 n1_m1_264000_62400 0 2.729778e-07
I5734 n1_m1_264000_67200 0 2.833238e-07
I5735 n1_m1_264000_72000 0 3.875609e-07
I5736 n1_m1_264000_76800 0 2.580313e-07
I5737 n1_m1_264000_81600 0 3.850784e-07
I5738 n1_m1_264000_86400 0 2.694605e-07
I5739 n1_m1_264000_91200 0 3.456300e-07
I5740 n1_m1_264000_96000 0 7.208195e-07
I5741 n1_m1_264000_100800 0 9.615458e-07
I5742 n1_m1_264000_105600 0 1.946304e-06
I5743 n1_m1_264000_110400 0 1.139416e-06
I5744 n1_m1_264000_115200 0 1.130832e-06
I5745 n1_m1_264000_120000 0 1.762069e-06
I5746 n1_m1_264000_124800 0 6.587940e-07
I5747 n1_m1_264000_129600 0 6.205884e-07
I5748 n1_m1_264000_134400 0 3.124323e-07
I5749 n1_m1_264000_139200 0 3.165317e-07
I5750 n1_m1_264000_144000 0 4.663512e-07
I5751 n1_m1_264000_148800 0 2.668901e-07
I5752 n1_m1_264000_153600 0 3.760767e-07
I5753 n1_m1_264000_158400 0 2.527734e-07
I5754 n1_m1_264000_163200 0 2.545442e-07
I5755 n1_m1_264000_168000 0 3.817211e-07
I5756 n1_m1_264000_172800 0 2.541300e-07
I5757 n1_m1_264000_177600 0 3.811842e-07
I5758 n1_m1_264000_182400 0 2.542658e-07
I5759 n1_m1_264000_187200 0 2.581887e-07
I5760 n1_m1_264000_192000 0 3.770859e-07
I5761 n1_m1_264000_196800 0 2.644139e-07
I5762 n1_m1_264000_201600 0 5.180564e-07
I5763 n1_m1_264000_206400 0 3.759820e-07
I5764 n1_m1_264000_211200 0 3.170124e-07
I5765 n1_m1_264000_216000 0 4.085811e-07
I5766 n1_m1_264000_220800 0 2.525090e-07
I5767 n1_m1_264000_225600 0 3.768132e-07
I5768 n1_m1_264000_230400 0 2.666839e-07
I5769 n1_m1_264000_235200 0 2.987567e-07
I5770 n1_m1_264000_240000 0 4.555046e-07
I5771 n1_m1_264000_244800 0 2.746946e-07
I5772 n1_m1_264000_249600 0 3.924326e-07
I5773 n1_m1_264000_254400 0 2.598217e-07
I5774 n1_m1_264000_259200 0 2.598217e-07
I5775 n1_m1_264000_264000 0 3.853648e-07
I5776 n1_m1_264000_268800 0 2.500044e-07
I5777 n1_m1_264000_273600 0 3.658031e-07
I5778 n1_m1_264000_278400 0 2.498285e-07
I5779 n1_m1_264000_283200 0 2.519584e-07
I5780 n1_m1_264000_288000 0 3.856077e-07
I5781 n1_m1_264000_292800 0 2.511629e-07
I5782 n1_m1_264000_297600 0 3.753749e-07
I5783 n1_m1_264000_302400 0 2.563428e-07
I5784 n1_m1_264000_307200 0 2.598217e-07
I5785 n1_m1_264000_312000 0 4.485789e-07
I5786 n1_m1_264000_316800 0 2.980434e-07
I5787 n1_m1_264000_321600 0 5.359016e-07
I5788 n1_m1_264000_326400 0 2.690296e-07
I5789 n1_m1_264000_331200 0 2.588785e-07
I5790 n1_m1_264000_336000 0 4.514552e-07
I5791 n1_m1_264000_340800 0 2.696623e-07
I5792 n1_m1_264000_345600 0 4.144382e-07
I5793 n1_m1_264000_350400 0 3.093349e-07
I5794 n1_m1_264000_355200 0 3.159874e-07
I5795 n1_m1_264000_360000 0 6.002374e-07
I5796 n1_m1_264000_364800 0 4.028201e-07
I5797 n1_m1_264000_369600 0 4.228606e-07
I5798 n1_m1_264000_374400 0 2.821794e-07
I5799 n1_m1_264000_379200 0 3.774210e-07
I5800 n1_m1_264000_384000 0 9.649214e-07
I5801 n1_m1_264000_388800 0 5.003186e-07
I5802 n1_m1_264000_393600 0 4.920286e-07
I5803 n1_m1_264000_398400 0 5.089944e-07
I5804 n1_m1_264000_403200 0 1.029685e-06
I5805 n1_m1_264000_408000 0 1.713596e-06
I5806 n1_m1_264000_412800 0 4.919140e-07
I5807 n1_m1_264000_417600 0 7.508080e-07
I5808 n1_m1_264000_422400 0 4.731658e-07
I5809 n1_m1_264000_427200 0 3.034702e-07
I5810 n1_m1_264000_432000 0 3.893488e-07
I5811 n1_m1_264000_436800 0 2.653779e-07
I5812 n1_m1_264000_441600 0 3.883822e-07
I5813 n1_m1_264000_446400 0 5.748413e-07
I5814 n1_m1_264000_451200 0 1.281172e-06
I5815 n1_m1_264000_456000 0 2.086603e-06
I5816 n1_m1_264000_460800 0 8.678959e-07
I5817 n1_m1_264000_465600 0 5.268398e-07
I5818 n1_m1_264000_470400 0 2.792837e-07
I5819 n1_m1_264000_475200 0 2.586740e-07
I5820 n1_m1_264000_480000 0 3.868620e-07
I5821 n1_m1_264000_484800 0 2.481840e-07
I5822 n1_m1_264000_489600 0 3.597078e-07
I5823 n1_m1_264000_494400 0 2.395223e-07
I5824 n1_m1_268800_0 0 1.554556e-07
I5825 n1_m1_268800_4800 0 1.597666e-07
I5826 n1_m1_268800_9600 0 2.442247e-07
I5827 n1_m1_268800_14400 0 1.696349e-07
I5828 n1_m1_268800_19200 0 1.727841e-07
I5829 n1_m1_268800_24000 0 2.598217e-07
I5830 n1_m1_268800_28800 0 1.722161e-07
I5831 n1_m1_268800_33600 0 3.941187e-07
I5832 n1_m1_268800_38400 0 5.920097e-07
I5833 n1_m1_268800_43200 0 6.345464e-07
I5834 n1_m1_268800_48000 0 5.127479e-07
I5835 n1_m1_268800_52800 0 1.758424e-07
I5836 n1_m1_268800_57600 0 2.689790e-07
I5837 n1_m1_268800_62400 0 1.715453e-07
I5838 n1_m1_268800_67200 0 1.728352e-07
I5839 n1_m1_268800_72000 0 2.699676e-07
I5840 n1_m1_268800_76800 0 1.751568e-07
I5841 n1_m1_268800_81600 0 2.741418e-07
I5842 n1_m1_268800_86400 0 2.106202e-07
I5843 n1_m1_268800_91200 0 2.162788e-07
I5844 n1_m1_268800_96000 0 5.602301e-07
I5845 n1_m1_268800_100800 0 7.729932e-07
I5846 n1_m1_268800_105600 0 1.618821e-06
I5847 n1_m1_268800_110400 0 9.724802e-07
I5848 n1_m1_268800_115200 0 8.263313e-07
I5849 n1_m1_268800_120000 0 1.146123e-06
I5850 n1_m1_268800_124800 0 3.720315e-07
I5851 n1_m1_268800_129600 0 3.215629e-07
I5852 n1_m1_268800_134400 0 1.885000e-07
I5853 n1_m1_268800_139200 0 1.920870e-07
I5854 n1_m1_268800_144000 0 2.884450e-07
I5855 n1_m1_268800_148800 0 1.750534e-07
I5856 n1_m1_268800_153600 0 2.512426e-07
I5857 n1_m1_268800_158400 0 1.704801e-07
I5858 n1_m1_268800_163200 0 1.725322e-07
I5859 n1_m1_268800_168000 0 2.570720e-07
I5860 n1_m1_268800_172800 0 1.670283e-07
I5861 n1_m1_268800_177600 0 2.502184e-07
I5862 n1_m1_268800_182400 0 1.672088e-07
I5863 n1_m1_268800_187200 0 1.712518e-07
I5864 n1_m1_268800_192000 0 2.575933e-07
I5865 n1_m1_268800_196800 0 2.362554e-07
I5866 n1_m1_268800_201600 0 6.432706e-07
I5867 n1_m1_268800_206400 0 4.907119e-07
I5868 n1_m1_268800_211200 0 3.737418e-07
I5869 n1_m1_268800_216000 0 3.633572e-07
I5870 n1_m1_268800_220800 0 1.763705e-07
I5871 n1_m1_268800_225600 0 2.526010e-07
I5872 n1_m1_268800_230400 0 1.707698e-07
I5873 n1_m1_268800_235200 0 1.776357e-07
I5874 n1_m1_268800_240000 0 2.679230e-07
I5875 n1_m1_268800_244800 0 1.730563e-07
I5876 n1_m1_268800_249600 0 2.643727e-07
I5877 n1_m1_268800_254400 0 1.732144e-07
I5878 n1_m1_268800_259200 0 1.730459e-07
I5879 n1_m1_268800_264000 0 2.547393e-07
I5880 n1_m1_268800_268800 0 1.662923e-07
I5881 n1_m1_268800_273600 0 2.443295e-07
I5882 n1_m1_268800_278400 0 1.665524e-07
I5883 n1_m1_268800_283200 0 1.668078e-07
I5884 n1_m1_268800_288000 0 2.567196e-07
I5885 n1_m1_268800_292800 0 1.721313e-07
I5886 n1_m1_268800_297600 0 2.580257e-07
I5887 n1_m1_268800_302400 0 1.727793e-07
I5888 n1_m1_268800_307200 0 1.728721e-07
I5889 n1_m1_268800_312000 0 2.719839e-07
I5890 n1_m1_268800_316800 0 1.695272e-07
I5891 n1_m1_268800_321600 0 2.587131e-07
I5892 n1_m1_268800_326400 0 1.729483e-07
I5893 n1_m1_268800_331200 0 1.825255e-07
I5894 n1_m1_268800_336000 0 2.897978e-07
I5895 n1_m1_268800_340800 0 1.812278e-07
I5896 n1_m1_268800_345600 0 2.665494e-07
I5897 n1_m1_268800_350400 0 1.779694e-07
I5898 n1_m1_268800_355200 0 2.007055e-07
I5899 n1_m1_268800_360000 0 3.478105e-07
I5900 n1_m1_268800_364800 0 2.563847e-07
I5901 n1_m1_268800_369600 0 3.101761e-07
I5902 n1_m1_268800_374400 0 2.166332e-07
I5903 n1_m1_268800_379200 0 4.810888e-07
I5904 n1_m1_268800_384000 0 1.229171e-06
I5905 n1_m1_268800_388800 0 6.381554e-07
I5906 n1_m1_268800_393600 0 4.850503e-07
I5907 n1_m1_268800_398400 0 1.944892e-07
I5908 n1_m1_268800_403200 0 2.504184e-07
I5909 n1_m1_268800_408000 0 4.081374e-07
I5910 n1_m1_268800_412800 0 1.940445e-07
I5911 n1_m1_268800_417600 0 3.273619e-07
I5912 n1_m1_268800_422400 0 2.234470e-07
I5913 n1_m1_268800_427200 0 1.845498e-07
I5914 n1_m1_268800_432000 0 2.612205e-07
I5915 n1_m1_268800_436800 0 1.853318e-07
I5916 n1_m1_268800_441600 0 2.674434e-07
I5917 n1_m1_268800_446400 0 2.489913e-07
I5918 n1_m1_268800_451200 0 6.520534e-07
I5919 n1_m1_268800_456000 0 1.722731e-06
I5920 n1_m1_268800_460800 0 1.105888e-06
I5921 n1_m1_268800_465600 0 7.562358e-07
I5922 n1_m1_268800_470400 0 2.691187e-07
I5923 n1_m1_268800_475200 0 1.965215e-07
I5924 n1_m1_268800_480000 0 2.594365e-07
I5925 n1_m1_268800_484800 0 1.642982e-07
I5926 n1_m1_268800_489600 0 2.391040e-07
I5927 n1_m1_268800_494400 0 1.556977e-07
I5928 n1_m1_273600_0 0 2.442300e-07
I5929 n1_m1_273600_4800 0 2.519109e-07
I5930 n1_m1_273600_9600 0 3.923429e-07
I5931 n1_m1_273600_14400 0 2.652534e-07
I5932 n1_m1_273600_19200 0 2.638044e-07
I5933 n1_m1_273600_24000 0 3.907032e-07
I5934 n1_m1_273600_28800 0 2.581693e-07
I5935 n1_m1_273600_33600 0 5.251897e-07
I5936 n1_m1_273600_38400 0 7.640028e-07
I5937 n1_m1_273600_43200 0 9.105369e-07
I5938 n1_m1_273600_48000 0 9.689196e-07
I5939 n1_m1_273600_52800 0 3.577025e-07
I5940 n1_m1_273600_57600 0 4.293242e-07
I5941 n1_m1_273600_62400 0 2.716605e-07
I5942 n1_m1_273600_67200 0 2.583837e-07
I5943 n1_m1_273600_72000 0 4.242640e-07
I5944 n1_m1_273600_76800 0 2.646971e-07
I5945 n1_m1_273600_81600 0 8.529799e-07
I5946 n1_m1_273600_86400 0 1.050126e-06
I5947 n1_m1_273600_91200 0 8.558994e-07
I5948 n1_m1_273600_96000 0 1.167482e-06
I5949 n1_m1_273600_100800 0 5.821622e-07
I5950 n1_m1_273600_105600 0 9.734495e-07
I5951 n1_m1_273600_110400 0 7.485862e-07
I5952 n1_m1_273600_115200 0 5.830590e-07
I5953 n1_m1_273600_120000 0 7.123106e-07
I5954 n1_m1_273600_124800 0 3.147544e-07
I5955 n1_m1_273600_129600 0 4.004929e-07
I5956 n1_m1_273600_134400 0 2.681202e-07
I5957 n1_m1_273600_139200 0 2.788039e-07
I5958 n1_m1_273600_144000 0 4.392398e-07
I5959 n1_m1_273600_148800 0 2.800537e-07
I5960 n1_m1_273600_153600 0 3.971391e-07
I5961 n1_m1_273600_158400 0 2.631291e-07
I5962 n1_m1_273600_163200 0 2.657814e-07
I5963 n1_m1_273600_168000 0 3.907242e-07
I5964 n1_m1_273600_172800 0 2.544270e-07
I5965 n1_m1_273600_177600 0 3.792545e-07
I5966 n1_m1_273600_182400 0 2.557399e-07
I5967 n1_m1_273600_187200 0 2.547012e-07
I5968 n1_m1_273600_192000 0 4.491629e-07
I5969 n1_m1_273600_196800 0 5.312510e-07
I5970 n1_m1_273600_201600 0 1.222242e-06
I5971 n1_m1_273600_206400 0 7.567205e-07
I5972 n1_m1_273600_211200 0 4.822654e-07
I5973 n1_m1_273600_216000 0 4.534493e-07
I5974 n1_m1_273600_220800 0 2.607924e-07
I5975 n1_m1_273600_225600 0 3.873577e-07
I5976 n1_m1_273600_230400 0 2.679144e-07
I5977 n1_m1_273600_235200 0 2.731946e-07
I5978 n1_m1_273600_240000 0 4.124708e-07
I5979 n1_m1_273600_244800 0 2.852856e-07
I5980 n1_m1_273600_249600 0 3.971925e-07
I5981 n1_m1_273600_254400 0 2.568920e-07
I5982 n1_m1_273600_259200 0 2.549413e-07
I5983 n1_m1_273600_264000 0 3.731334e-07
I5984 n1_m1_273600_268800 0 2.492167e-07
I5985 n1_m1_273600_273600 0 3.750439e-07
I5986 n1_m1_273600_278400 0 2.527582e-07
I5987 n1_m1_273600_283200 0 2.557142e-07
I5988 n1_m1_273600_288000 0 3.922076e-07
I5989 n1_m1_273600_292800 0 2.627514e-07
I5990 n1_m1_273600_297600 0 3.923445e-07
I5991 n1_m1_273600_302400 0 2.579568e-07
I5992 n1_m1_273600_307200 0 2.529307e-07
I5993 n1_m1_273600_312000 0 3.930323e-07
I5994 n1_m1_273600_316800 0 2.544329e-07
I5995 n1_m1_273600_321600 0 4.480215e-07
I5996 n1_m1_273600_326400 0 2.735292e-07
I5997 n1_m1_273600_331200 0 2.590786e-07
I5998 n1_m1_273600_336000 0 3.980502e-07
I5999 n1_m1_273600_340800 0 2.647266e-07
I6000 n1_m1_273600_345600 0 4.129758e-07
I6001 n1_m1_273600_350400 0 2.801184e-07
I6002 n1_m1_273600_355200 0 2.650941e-07
I6003 n1_m1_273600_360000 0 5.350836e-07
I6004 n1_m1_273600_364800 0 6.335704e-07
I6005 n1_m1_273600_369600 0 7.437029e-07
I6006 n1_m1_273600_374400 0 3.189198e-07
I6007 n1_m1_273600_379200 0 5.369648e-07
I6008 n1_m1_273600_384000 0 1.320173e-06
I6009 n1_m1_273600_388800 0 8.803117e-07
I6010 n1_m1_273600_393600 0 8.438189e-07
I6011 n1_m1_273600_398400 0 2.885643e-07
I6012 n1_m1_273600_403200 0 2.551903e-07
I6013 n1_m1_273600_408000 0 4.867769e-07
I6014 n1_m1_273600_412800 0 4.151614e-07
I6015 n1_m1_273600_417600 0 4.821882e-07
I6016 n1_m1_273600_422400 0 2.743181e-07
I6017 n1_m1_273600_427200 0 2.703400e-07
I6018 n1_m1_273600_432000 0 4.069954e-07
I6019 n1_m1_273600_436800 0 2.791109e-07
I6020 n1_m1_273600_441600 0 4.052432e-07
I6021 n1_m1_273600_446400 0 2.879911e-07
I6022 n1_m1_273600_451200 0 4.281738e-07
I6023 n1_m1_273600_456000 0 1.888862e-06
I6024 n1_m1_273600_460800 0 1.775876e-06
I6025 n1_m1_273600_465600 0 1.216186e-06
I6026 n1_m1_273600_470400 0 3.628759e-07
I6027 n1_m1_273600_475200 0 2.819394e-07
I6028 n1_m1_273600_480000 0 3.908710e-07
I6029 n1_m1_273600_484800 0 2.557820e-07
I6030 n1_m1_273600_489600 0 3.602692e-07
I6031 n1_m1_273600_494400 0 2.308789e-07
I6032 n1_m1_278400_0 0 1.612295e-07
I6033 n1_m1_278400_4800 0 1.654118e-07
I6034 n1_m1_278400_9600 0 2.696494e-07
I6035 n1_m1_278400_14400 0 1.865386e-07
I6036 n1_m1_278400_19200 0 1.782779e-07
I6037 n1_m1_278400_24000 0 2.570061e-07
I6038 n1_m1_278400_28800 0 1.738716e-07
I6039 n1_m1_278400_33600 0 2.676545e-07
I6040 n1_m1_278400_38400 0 2.140674e-07
I6041 n1_m1_278400_43200 0 2.785694e-07
I6042 n1_m1_278400_48000 0 4.688263e-07
I6043 n1_m1_278400_52800 0 2.618434e-07
I6044 n1_m1_278400_57600 0 2.873549e-07
I6045 n1_m1_278400_62400 0 1.882417e-07
I6046 n1_m1_278400_67200 0 1.746191e-07
I6047 n1_m1_278400_72000 0 2.756160e-07
I6048 n1_m1_278400_76800 0 1.826106e-07
I6049 n1_m1_278400_81600 0 8.242788e-07
I6050 n1_m1_278400_86400 0 1.092518e-06
I6051 n1_m1_278400_91200 0 1.024612e-06
I6052 n1_m1_278400_96000 0 8.201158e-07
I6053 n1_m1_278400_100800 0 3.204023e-07
I6054 n1_m1_278400_105600 0 3.216622e-07
I6055 n1_m1_278400_110400 0 2.216374e-07
I6056 n1_m1_278400_115200 0 1.745243e-07
I6057 n1_m1_278400_120000 0 2.958194e-07
I6058 n1_m1_278400_124800 0 1.901001e-07
I6059 n1_m1_278400_129600 0 2.760066e-07
I6060 n1_m1_278400_134400 0 1.881546e-07
I6061 n1_m1_278400_139200 0 1.969461e-07
I6062 n1_m1_278400_144000 0 3.124994e-07
I6063 n1_m1_278400_148800 0 2.000188e-07
I6064 n1_m1_278400_153600 0 2.734871e-07
I6065 n1_m1_278400_158400 0 1.732144e-07
I6066 n1_m1_278400_163200 0 1.732144e-07
I6067 n1_m1_278400_168000 0 2.553405e-07
I6068 n1_m1_278400_172800 0 1.666129e-07
I6069 n1_m1_278400_177600 0 2.498285e-07
I6070 n1_m1_278400_182400 0 1.666413e-07
I6071 n1_m1_278400_187200 0 1.697247e-07
I6072 n1_m1_278400_192000 0 3.528569e-07
I6073 n1_m1_278400_196800 0 5.745466e-07
I6074 n1_m1_278400_201600 0 1.245626e-06
I6075 n1_m1_278400_206400 0 5.346599e-07
I6076 n1_m1_278400_211200 0 2.262676e-07
I6077 n1_m1_278400_216000 0 2.553891e-07
I6078 n1_m1_278400_220800 0 1.732144e-07
I6079 n1_m1_278400_225600 0 2.655144e-07
I6080 n1_m1_278400_230400 0 1.869251e-07
I6081 n1_m1_278400_235200 0 1.891046e-07
I6082 n1_m1_278400_240000 0 2.746366e-07
I6083 n1_m1_278400_244800 0 1.794485e-07
I6084 n1_m1_278400_249600 0 2.634704e-07
I6085 n1_m1_278400_254400 0 1.687368e-07
I6086 n1_m1_278400_259200 0 1.665524e-07
I6087 n1_m1_278400_264000 0 2.470202e-07
I6088 n1_m1_278400_268800 0 1.661562e-07
I6089 n1_m1_278400_273600 0 2.555466e-07
I6090 n1_m1_278400_278400 0 1.746728e-07
I6091 n1_m1_278400_283200 0 1.778774e-07
I6092 n1_m1_278400_288000 0 2.910640e-07
I6093 n1_m1_278400_292800 0 2.101578e-07
I6094 n1_m1_278400_297600 0 2.874959e-07
I6095 n1_m1_278400_302400 0 1.732236e-07
I6096 n1_m1_278400_307200 0 1.675976e-07
I6097 n1_m1_278400_312000 0 2.739841e-07
I6098 n1_m1_278400_316800 0 1.699043e-07
I6099 n1_m1_278400_321600 0 2.547702e-07
I6100 n1_m1_278400_326400 0 1.674502e-07
I6101 n1_m1_278400_331200 0 1.694895e-07
I6102 n1_m1_278400_336000 0 2.683534e-07
I6103 n1_m1_278400_340800 0 1.760121e-07
I6104 n1_m1_278400_345600 0 2.615090e-07
I6105 n1_m1_278400_350400 0 1.763195e-07
I6106 n1_m1_278400_355200 0 1.723537e-07
I6107 n1_m1_278400_360000 0 4.435087e-07
I6108 n1_m1_278400_364800 0 4.892308e-07
I6109 n1_m1_278400_369600 0 3.890139e-07
I6110 n1_m1_278400_374400 0 1.721829e-07
I6111 n1_m1_278400_379200 0 1.889736e-07
I6112 n1_m1_278400_384000 0 4.367102e-07
I6113 n1_m1_278400_388800 0 4.650464e-07
I6114 n1_m1_278400_393600 0 4.065864e-07
I6115 n1_m1_278400_398400 0 1.757118e-07
I6116 n1_m1_278400_403200 0 1.865712e-07
I6117 n1_m1_278400_408000 0 5.741110e-07
I6118 n1_m1_278400_412800 0 6.309881e-07
I6119 n1_m1_278400_417600 0 5.022561e-07
I6120 n1_m1_278400_422400 0 1.767595e-07
I6121 n1_m1_278400_427200 0 1.783431e-07
I6122 n1_m1_278400_432000 0 2.666862e-07
I6123 n1_m1_278400_436800 0 1.779201e-07
I6124 n1_m1_278400_441600 0 2.495492e-07
I6125 n1_m1_278400_446400 0 1.987011e-07
I6126 n1_m1_278400_451200 0 2.332536e-07
I6127 n1_m1_278400_456000 0 8.565196e-07
I6128 n1_m1_278400_460800 0 7.334003e-07
I6129 n1_m1_278400_465600 0 3.828771e-07
I6130 n1_m1_278400_470400 0 1.822932e-07
I6131 n1_m1_278400_475200 0 1.795366e-07
I6132 n1_m1_278400_480000 0 2.667567e-07
I6133 n1_m1_278400_484800 0 1.719188e-07
I6134 n1_m1_278400_489600 0 2.447972e-07
I6135 n1_m1_278400_494400 0 1.549405e-07
I6136 n1_m1_283200_0 0 7.741006e-08
I6137 n1_m1_283200_4800 0 7.854778e-08
I6138 n1_m1_283200_9600 0 1.307057e-07
I6139 n1_m1_283200_14400 0 9.167737e-08
I6140 n1_m1_283200_19200 0 8.629588e-08
I6141 n1_m1_283200_24000 0 1.254717e-07
I6142 n1_m1_283200_28800 0 8.653196e-08
I6143 n1_m1_283200_33600 0 1.317871e-07
I6144 n1_m1_283200_38400 0 8.665558e-08
I6145 n1_m1_283200_43200 0 8.876906e-08
I6146 n1_m1_283200_48000 0 1.412817e-07
I6147 n1_m1_283200_52800 0 9.308421e-08
I6148 n1_m1_283200_57600 0 1.333572e-07
I6149 n1_m1_283200_62400 0 9.372736e-08
I6150 n1_m1_283200_67200 0 8.935404e-08
I6151 n1_m1_283200_72000 0 1.338833e-07
I6152 n1_m1_283200_76800 0 9.228134e-08
I6153 n1_m1_283200_81600 0 3.252856e-07
I6154 n1_m1_283200_86400 0 4.482022e-07
I6155 n1_m1_283200_91200 0 4.646528e-07
I6156 n1_m1_283200_96000 0 3.147993e-07
I6157 n1_m1_283200_100800 0 1.252682e-07
I6158 n1_m1_283200_105600 0 1.432355e-07
I6159 n1_m1_283200_110400 0 9.817322e-08
I6160 n1_m1_283200_115200 0 8.933239e-08
I6161 n1_m1_283200_120000 0 1.560390e-07
I6162 n1_m1_283200_124800 0 9.747776e-08
I6163 n1_m1_283200_129600 0 1.387100e-07
I6164 n1_m1_283200_134400 0 9.247334e-08
I6165 n1_m1_283200_139200 0 9.247334e-08
I6166 n1_m1_283200_144000 0 1.360317e-07
I6167 n1_m1_283200_148800 0 8.922301e-08
I6168 n1_m1_283200_153600 0 1.326763e-07
I6169 n1_m1_283200_158400 0 8.690611e-08
I6170 n1_m1_283200_163200 0 8.660722e-08
I6171 n1_m1_283200_168000 0 1.259778e-07
I6172 n1_m1_283200_172800 0 8.327618e-08
I6173 n1_m1_283200_177600 0 1.243141e-07
I6174 n1_m1_283200_182400 0 8.252016e-08
I6175 n1_m1_283200_187200 0 8.388691e-08
I6176 n1_m1_283200_192000 0 1.873848e-07
I6177 n1_m1_283200_196800 0 3.661364e-07
I6178 n1_m1_283200_201600 0 8.225525e-07
I6179 n1_m1_283200_206400 0 3.090035e-07
I6180 n1_m1_283200_211200 0 1.159256e-07
I6181 n1_m1_283200_216000 0 1.288334e-07
I6182 n1_m1_283200_220800 0 8.660722e-08
I6183 n1_m1_283200_225600 0 1.296432e-07
I6184 n1_m1_283200_230400 0 8.973131e-08
I6185 n1_m1_283200_235200 0 9.359315e-08
I6186 n1_m1_283200_240000 0 1.412831e-07
I6187 n1_m1_283200_244800 0 9.189315e-08
I6188 n1_m1_283200_249600 0 1.336600e-07
I6189 n1_m1_283200_254400 0 8.584874e-08
I6190 n1_m1_283200_259200 0 8.407215e-08
I6191 n1_m1_283200_264000 0 1.254273e-07
I6192 n1_m1_283200_268800 0 8.347216e-08
I6193 n1_m1_283200_273600 0 1.282969e-07
I6194 n1_m1_283200_278400 0 8.736975e-08
I6195 n1_m1_283200_283200 0 9.079444e-08
I6196 n1_m1_283200_288000 0 1.543767e-07
I6197 n1_m1_283200_292800 0 1.153621e-07
I6198 n1_m1_283200_297600 0 1.517514e-07
I6199 n1_m1_283200_302400 0 8.823261e-08
I6200 n1_m1_283200_307200 0 8.412629e-08
I6201 n1_m1_283200_312000 0 1.288874e-07
I6202 n1_m1_283200_316800 0 8.641143e-08
I6203 n1_m1_283200_321600 0 1.267825e-07
I6204 n1_m1_283200_326400 0 8.337985e-08
I6205 n1_m1_283200_331200 0 8.590155e-08
I6206 n1_m1_283200_336000 0 1.299108e-07
I6207 n1_m1_283200_340800 0 8.660722e-08
I6208 n1_m1_283200_345600 0 1.275488e-07
I6209 n1_m1_283200_350400 0 8.436485e-08
I6210 n1_m1_283200_355200 0 8.714684e-08
I6211 n1_m1_283200_360000 0 1.460458e-07
I6212 n1_m1_283200_364800 0 9.968598e-08
I6213 n1_m1_283200_369600 0 1.377575e-07
I6214 n1_m1_283200_374400 0 8.779611e-08
I6215 n1_m1_283200_379200 0 9.299658e-08
I6216 n1_m1_283200_384000 0 1.913802e-07
I6217 n1_m1_283200_388800 0 2.908547e-07
I6218 n1_m1_283200_393600 0 2.544819e-07
I6219 n1_m1_283200_398400 0 8.858559e-08
I6220 n1_m1_283200_403200 0 9.852208e-08
I6221 n1_m1_283200_408000 0 3.479854e-07
I6222 n1_m1_283200_412800 0 4.168929e-07
I6223 n1_m1_283200_417600 0 3.457290e-07
I6224 n1_m1_283200_422400 0 1.040243e-07
I6225 n1_m1_283200_427200 0 9.299862e-08
I6226 n1_m1_283200_432000 0 1.336247e-07
I6227 n1_m1_283200_436800 0 8.967075e-08
I6228 n1_m1_283200_441600 0 1.273050e-07
I6229 n1_m1_283200_446400 0 8.374073e-08
I6230 n1_m1_283200_451200 0 8.814137e-08
I6231 n1_m1_283200_456000 0 2.451766e-07
I6232 n1_m1_283200_460800 0 1.708079e-07
I6233 n1_m1_283200_465600 0 1.360594e-07
I6234 n1_m1_283200_470400 0 8.867906e-08
I6235 n1_m1_283200_475200 0 9.115559e-08
I6236 n1_m1_283200_480000 0 1.349342e-07
I6237 n1_m1_283200_484800 0 8.363069e-08
I6238 n1_m1_283200_489600 0 1.206127e-07
I6239 n1_m1_283200_494400 0 7.806164e-08
I6240 n1_m1_288000_0 0 1.633151e-07
I6241 n1_m1_288000_4800 0 1.595444e-07
I6242 n1_m1_288000_9600 0 2.432540e-07
I6243 n1_m1_288000_14400 0 1.678836e-07
I6244 n1_m1_288000_19200 0 1.677977e-07
I6245 n1_m1_288000_24000 0 2.513034e-07
I6246 n1_m1_288000_28800 0 1.686341e-07
I6247 n1_m1_288000_33600 0 2.546318e-07
I6248 n1_m1_288000_38400 0 1.717083e-07
I6249 n1_m1_288000_43200 0 1.693645e-07
I6250 n1_m1_288000_48000 0 2.520691e-07
I6251 n1_m1_288000_52800 0 1.698890e-07
I6252 n1_m1_288000_57600 0 2.764620e-07
I6253 n1_m1_288000_62400 0 2.989088e-07
I6254 n1_m1_288000_67200 0 4.555642e-07
I6255 n1_m1_288000_72000 0 7.289858e-07
I6256 n1_m1_288000_76800 0 2.576634e-07
I6257 n1_m1_288000_81600 0 3.005574e-07
I6258 n1_m1_288000_86400 0 2.781926e-07
I6259 n1_m1_288000_91200 0 2.371455e-07
I6260 n1_m1_288000_96000 0 2.911339e-07
I6261 n1_m1_288000_100800 0 1.752787e-07
I6262 n1_m1_288000_105600 0 3.141352e-07
I6263 n1_m1_288000_110400 0 2.990092e-07
I6264 n1_m1_288000_115200 0 2.281200e-07
I6265 n1_m1_288000_120000 0 2.774239e-07
I6266 n1_m1_288000_124800 0 1.771489e-07
I6267 n1_m1_288000_129600 0 2.636217e-07
I6268 n1_m1_288000_134400 0 1.776203e-07
I6269 n1_m1_288000_139200 0 1.773222e-07
I6270 n1_m1_288000_144000 0 2.707067e-07
I6271 n1_m1_288000_148800 0 1.802046e-07
I6272 n1_m1_288000_153600 0 2.794668e-07
I6273 n1_m1_288000_158400 0 1.896730e-07
I6274 n1_m1_288000_163200 0 1.821918e-07
I6275 n1_m1_288000_168000 0 2.609897e-07
I6276 n1_m1_288000_172800 0 1.676369e-07
I6277 n1_m1_288000_177600 0 2.470762e-07
I6278 n1_m1_288000_182400 0 1.659683e-07
I6279 n1_m1_288000_187200 0 1.786837e-07
I6280 n1_m1_288000_192000 0 4.271885e-07
I6281 n1_m1_288000_196800 0 5.377807e-07
I6282 n1_m1_288000_201600 0 8.032250e-07
I6283 n1_m1_288000_206400 0 2.596265e-07
I6284 n1_m1_288000_211200 0 1.813426e-07
I6285 n1_m1_288000_216000 0 2.661746e-07
I6286 n1_m1_288000_220800 0 1.677138e-07
I6287 n1_m1_288000_225600 0 2.513260e-07
I6288 n1_m1_288000_230400 0 1.730756e-07
I6289 n1_m1_288000_235200 0 1.756296e-07
I6290 n1_m1_288000_240000 0 2.652799e-07
I6291 n1_m1_288000_244800 0 1.734121e-07
I6292 n1_m1_288000_249600 0 2.584799e-07
I6293 n1_m1_288000_254400 0 1.694515e-07
I6294 n1_m1_288000_259200 0 1.725530e-07
I6295 n1_m1_288000_264000 0 2.588849e-07
I6296 n1_m1_288000_268800 0 1.684252e-07
I6297 n1_m1_288000_273600 0 2.513034e-07
I6298 n1_m1_288000_278400 0 1.711127e-07
I6299 n1_m1_288000_283200 0 1.755426e-07
I6300 n1_m1_288000_288000 0 2.634597e-07
I6301 n1_m1_288000_292800 0 1.746075e-07
I6302 n1_m1_288000_297600 0 2.601704e-07
I6303 n1_m1_288000_302400 0 1.688813e-07
I6304 n1_m1_288000_307200 0 1.665524e-07
I6305 n1_m1_288000_312000 0 2.506982e-07
I6306 n1_m1_288000_316800 0 1.671021e-07
I6307 n1_m1_288000_321600 0 2.498285e-07
I6308 n1_m1_288000_326400 0 1.665750e-07
I6309 n1_m1_288000_331200 0 1.671270e-07
I6310 n1_m1_288000_336000 0 2.527808e-07
I6311 n1_m1_288000_340800 0 1.746258e-07
I6312 n1_m1_288000_345600 0 2.626345e-07
I6313 n1_m1_288000_350400 0 1.732144e-07
I6314 n1_m1_288000_355200 0 1.734033e-07
I6315 n1_m1_288000_360000 0 2.618435e-07
I6316 n1_m1_288000_364800 0 1.742554e-07
I6317 n1_m1_288000_369600 0 2.536315e-07
I6318 n1_m1_288000_374400 0 1.704746e-07
I6319 n1_m1_288000_379200 0 1.808930e-07
I6320 n1_m1_288000_384000 0 2.868952e-07
I6321 n1_m1_288000_388800 0 3.717600e-07
I6322 n1_m1_288000_393600 0 4.359925e-07
I6323 n1_m1_288000_398400 0 1.672331e-07
I6324 n1_m1_288000_403200 0 1.689121e-07
I6325 n1_m1_288000_408000 0 3.431135e-07
I6326 n1_m1_288000_412800 0 3.673078e-07
I6327 n1_m1_288000_417600 0 4.285995e-07
I6328 n1_m1_288000_422400 0 2.025855e-07
I6329 n1_m1_288000_427200 0 2.042414e-07
I6330 n1_m1_288000_432000 0 3.689363e-07
I6331 n1_m1_288000_436800 0 3.686221e-07
I6332 n1_m1_288000_441600 0 3.952258e-07
I6333 n1_m1_288000_446400 0 1.846270e-07
I6334 n1_m1_288000_451200 0 1.648929e-07
I6335 n1_m1_288000_456000 0 2.816517e-07
I6336 n1_m1_288000_460800 0 2.009567e-07
I6337 n1_m1_288000_465600 0 2.531033e-07
I6338 n1_m1_288000_470400 0 1.957222e-07
I6339 n1_m1_288000_475200 0 2.308708e-07
I6340 n1_m1_288000_480000 0 3.176688e-07
I6341 n1_m1_288000_484800 0 1.706178e-07
I6342 n1_m1_288000_489600 0 2.368274e-07
I6343 n1_m1_288000_494400 0 1.625845e-07
I6344 n1_m1_292800_0 0 1.577364e-07
I6345 n1_m1_292800_4800 0 1.536635e-07
I6346 n1_m1_292800_9600 0 2.381094e-07
I6347 n1_m1_292800_14400 0 1.702434e-07
I6348 n1_m1_292800_19200 0 1.725790e-07
I6349 n1_m1_292800_24000 0 2.578467e-07
I6350 n1_m1_292800_28800 0 1.712929e-07
I6351 n1_m1_292800_33600 0 2.503885e-07
I6352 n1_m1_292800_38400 0 1.716171e-07
I6353 n1_m1_292800_43200 0 1.725216e-07
I6354 n1_m1_292800_48000 0 2.510932e-07
I6355 n1_m1_292800_52800 0 1.667935e-07
I6356 n1_m1_292800_57600 0 2.837317e-07
I6357 n1_m1_292800_62400 0 4.270176e-07
I6358 n1_m1_292800_67200 0 7.534439e-07
I6359 n1_m1_292800_72000 0 1.298429e-06
I6360 n1_m1_292800_76800 0 4.212643e-07
I6361 n1_m1_292800_81600 0 2.768258e-07
I6362 n1_m1_292800_86400 0 1.845297e-07
I6363 n1_m1_292800_91200 0 1.719276e-07
I6364 n1_m1_292800_96000 0 2.618182e-07
I6365 n1_m1_292800_100800 0 1.724424e-07
I6366 n1_m1_292800_105600 0 4.128605e-07
I6367 n1_m1_292800_110400 0 5.015134e-07
I6368 n1_m1_292800_115200 0 3.833150e-07
I6369 n1_m1_292800_120000 0 3.223129e-07
I6370 n1_m1_292800_124800 0 1.795669e-07
I6371 n1_m1_292800_129600 0 2.630603e-07
I6372 n1_m1_292800_134400 0 1.785100e-07
I6373 n1_m1_292800_139200 0 1.789929e-07
I6374 n1_m1_292800_144000 0 2.749766e-07
I6375 n1_m1_292800_148800 0 1.857940e-07
I6376 n1_m1_292800_153600 0 2.943725e-07
I6377 n1_m1_292800_158400 0 1.984890e-07
I6378 n1_m1_292800_163200 0 1.860637e-07
I6379 n1_m1_292800_168000 0 2.677678e-07
I6380 n1_m1_292800_172800 0 1.726743e-07
I6381 n1_m1_292800_177600 0 2.592084e-07
I6382 n1_m1_292800_182400 0 1.736917e-07
I6383 n1_m1_292800_187200 0 1.818459e-07
I6384 n1_m1_292800_192000 0 3.881184e-07
I6385 n1_m1_292800_196800 0 3.335604e-07
I6386 n1_m1_292800_201600 0 3.848489e-07
I6387 n1_m1_292800_206400 0 1.816328e-07
I6388 n1_m1_292800_211200 0 1.701181e-07
I6389 n1_m1_292800_216000 0 2.605434e-07
I6390 n1_m1_292800_220800 0 1.708829e-07
I6391 n1_m1_292800_225600 0 2.530845e-07
I6392 n1_m1_292800_230400 0 1.740786e-07
I6393 n1_m1_292800_235200 0 1.754473e-07
I6394 n1_m1_292800_240000 0 2.635379e-07
I6395 n1_m1_292800_244800 0 1.745833e-07
I6396 n1_m1_292800_249600 0 2.599186e-07
I6397 n1_m1_292800_254400 0 1.709660e-07
I6398 n1_m1_292800_259200 0 1.688079e-07
I6399 n1_m1_292800_264000 0 2.590873e-07
I6400 n1_m1_292800_268800 0 1.727765e-07
I6401 n1_m1_292800_273600 0 2.607790e-07
I6402 n1_m1_292800_278400 0 1.872196e-07
I6403 n1_m1_292800_283200 0 1.976824e-07
I6404 n1_m1_292800_288000 0 2.758842e-07
I6405 n1_m1_292800_292800 0 1.729178e-07
I6406 n1_m1_292800_297600 0 2.512718e-07
I6407 n1_m1_292800_302400 0 1.667833e-07
I6408 n1_m1_292800_307200 0 1.665524e-07
I6409 n1_m1_292800_312000 0 2.487938e-07
I6410 n1_m1_292800_316800 0 1.662756e-07
I6411 n1_m1_292800_321600 0 2.490349e-07
I6412 n1_m1_292800_326400 0 1.665524e-07
I6413 n1_m1_292800_331200 0 1.665524e-07
I6414 n1_m1_292800_336000 0 2.500671e-07
I6415 n1_m1_292800_340800 0 1.698767e-07
I6416 n1_m1_292800_345600 0 2.601828e-07
I6417 n1_m1_292800_350400 0 1.732144e-07
I6418 n1_m1_292800_355200 0 1.732144e-07
I6419 n1_m1_292800_360000 0 2.598217e-07
I6420 n1_m1_292800_364800 0 1.732144e-07
I6421 n1_m1_292800_369600 0 2.547951e-07
I6422 n1_m1_292800_374400 0 1.768338e-07
I6423 n1_m1_292800_379200 0 1.859691e-07
I6424 n1_m1_292800_384000 0 2.514282e-07
I6425 n1_m1_292800_388800 0 1.970337e-07
I6426 n1_m1_292800_393600 0 2.895867e-07
I6427 n1_m1_292800_398400 0 1.687062e-07
I6428 n1_m1_292800_403200 0 1.724311e-07
I6429 n1_m1_292800_408000 0 2.687706e-07
I6430 n1_m1_292800_412800 0 1.886045e-07
I6431 n1_m1_292800_417600 0 2.710456e-07
I6432 n1_m1_292800_422400 0 1.806869e-07
I6433 n1_m1_292800_427200 0 2.584033e-07
I6434 n1_m1_292800_432000 0 6.838291e-07
I6435 n1_m1_292800_436800 0 5.646811e-07
I6436 n1_m1_292800_441600 0 4.102039e-07
I6437 n1_m1_292800_446400 0 1.665814e-07
I6438 n1_m1_292800_451200 0 1.684577e-07
I6439 n1_m1_292800_456000 0 3.840755e-07
I6440 n1_m1_292800_460800 0 2.649617e-07
I6441 n1_m1_292800_465600 0 2.717442e-07
I6442 n1_m1_292800_470400 0 2.282429e-07
I6443 n1_m1_292800_475200 0 3.308666e-07
I6444 n1_m1_292800_480000 0 4.718144e-07
I6445 n1_m1_292800_484800 0 1.996512e-07
I6446 n1_m1_292800_489600 0 2.364999e-07
I6447 n1_m1_292800_494400 0 1.535356e-07
I6448 n1_m1_297600_0 0 2.278155e-07
I6449 n1_m1_297600_4800 0 2.228784e-07
I6450 n1_m1_297600_9600 0 3.555596e-07
I6451 n1_m1_297600_14400 0 2.534663e-07
I6452 n1_m1_297600_19200 0 2.531717e-07
I6453 n1_m1_297600_24000 0 3.789704e-07
I6454 n1_m1_297600_28800 0 2.612255e-07
I6455 n1_m1_297600_33600 0 3.839750e-07
I6456 n1_m1_297600_38400 0 2.623844e-07
I6457 n1_m1_297600_43200 0 2.605324e-07
I6458 n1_m1_297600_48000 0 3.806449e-07
I6459 n1_m1_297600_52800 0 2.498285e-07
I6460 n1_m1_297600_57600 0 4.057070e-07
I6461 n1_m1_297600_62400 0 5.181865e-07
I6462 n1_m1_297600_67200 0 1.007422e-06
I6463 n1_m1_297600_72000 0 1.924701e-06
I6464 n1_m1_297600_76800 0 6.742289e-07
I6465 n1_m1_297600_81600 0 4.358419e-07
I6466 n1_m1_297600_86400 0 2.745406e-07
I6467 n1_m1_297600_91200 0 2.626715e-07
I6468 n1_m1_297600_96000 0 3.980238e-07
I6469 n1_m1_297600_100800 0 2.530463e-07
I6470 n1_m1_297600_105600 0 5.114835e-07
I6471 n1_m1_297600_110400 0 6.735571e-07
I6472 n1_m1_297600_115200 0 6.005744e-07
I6473 n1_m1_297600_120000 0 5.107545e-07
I6474 n1_m1_297600_124800 0 2.649391e-07
I6475 n1_m1_297600_129600 0 3.900573e-07
I6476 n1_m1_297600_134400 0 2.603635e-07
I6477 n1_m1_297600_139200 0 2.629757e-07
I6478 n1_m1_297600_144000 0 3.999545e-07
I6479 n1_m1_297600_148800 0 2.711537e-07
I6480 n1_m1_297600_153600 0 4.091672e-07
I6481 n1_m1_297600_158400 0 2.696857e-07
I6482 n1_m1_297600_163200 0 2.603233e-07
I6483 n1_m1_297600_168000 0 3.845156e-07
I6484 n1_m1_297600_172800 0 2.567501e-07
I6485 n1_m1_297600_177600 0 3.938352e-07
I6486 n1_m1_297600_182400 0 2.686855e-07
I6487 n1_m1_297600_187200 0 2.811267e-07
I6488 n1_m1_297600_192000 0 4.589018e-07
I6489 n1_m1_297600_196800 0 3.028836e-07
I6490 n1_m1_297600_201600 0 4.008076e-07
I6491 n1_m1_297600_206400 0 2.604459e-07
I6492 n1_m1_297600_211200 0 2.624307e-07
I6493 n1_m1_297600_216000 0 3.973384e-07
I6494 n1_m1_297600_220800 0 2.707520e-07
I6495 n1_m1_297600_225600 0 3.990180e-07
I6496 n1_m1_297600_230400 0 2.745258e-07
I6497 n1_m1_297600_235200 0 2.839977e-07
I6498 n1_m1_297600_240000 0 4.360421e-07
I6499 n1_m1_297600_244800 0 2.780862e-07
I6500 n1_m1_297600_249600 0 3.931087e-07
I6501 n1_m1_297600_254400 0 2.568318e-07
I6502 n1_m1_297600_259200 0 2.500059e-07
I6503 n1_m1_297600_264000 0 3.806858e-07
I6504 n1_m1_297600_268800 0 2.631488e-07
I6505 n1_m1_297600_273600 0 4.197104e-07
I6506 n1_m1_297600_278400 0 3.601393e-07
I6507 n1_m1_297600_283200 0 3.968710e-07
I6508 n1_m1_297600_288000 0 4.602799e-07
I6509 n1_m1_297600_292800 0 2.641144e-07
I6510 n1_m1_297600_297600 0 3.791694e-07
I6511 n1_m1_297600_302400 0 2.498285e-07
I6512 n1_m1_297600_307200 0 2.498285e-07
I6513 n1_m1_297600_312000 0 3.695563e-07
I6514 n1_m1_297600_316800 0 2.474440e-07
I6515 n1_m1_297600_321600 0 3.647538e-07
I6516 n1_m1_297600_326400 0 2.489128e-07
I6517 n1_m1_297600_331200 0 2.498285e-07
I6518 n1_m1_297600_336000 0 3.747428e-07
I6519 n1_m1_297600_340800 0 2.522259e-07
I6520 n1_m1_297600_345600 0 3.840634e-07
I6521 n1_m1_297600_350400 0 2.592478e-07
I6522 n1_m1_297600_355200 0 2.598217e-07
I6523 n1_m1_297600_360000 0 3.897325e-07
I6524 n1_m1_297600_364800 0 2.598217e-07
I6525 n1_m1_297600_369600 0 3.894867e-07
I6526 n1_m1_297600_374400 0 2.693654e-07
I6527 n1_m1_297600_379200 0 2.945420e-07
I6528 n1_m1_297600_384000 0 3.990778e-07
I6529 n1_m1_297600_388800 0 2.599956e-07
I6530 n1_m1_297600_393600 0 4.130978e-07
I6531 n1_m1_297600_398400 0 3.102587e-07
I6532 n1_m1_297600_403200 0 3.057432e-07
I6533 n1_m1_297600_408000 0 3.995609e-07
I6534 n1_m1_297600_412800 0 2.621249e-07
I6535 n1_m1_297600_417600 0 4.069009e-07
I6536 n1_m1_297600_422400 0 2.599576e-07
I6537 n1_m1_297600_427200 0 2.662652e-07
I6538 n1_m1_297600_432000 0 5.989174e-07
I6539 n1_m1_297600_436800 0 5.810345e-07
I6540 n1_m1_297600_441600 0 4.702424e-07
I6541 n1_m1_297600_446400 0 2.475909e-07
I6542 n1_m1_297600_451200 0 2.519277e-07
I6543 n1_m1_297600_456000 0 7.114540e-07
I6544 n1_m1_297600_460800 0 7.137067e-07
I6545 n1_m1_297600_465600 0 6.670486e-07
I6546 n1_m1_297600_470400 0 2.801667e-07
I6547 n1_m1_297600_475200 0 3.381689e-07
I6548 n1_m1_297600_480000 0 4.921031e-07
I6549 n1_m1_297600_484800 0 2.547916e-07
I6550 n1_m1_297600_489600 0 3.520496e-07
I6551 n1_m1_297600_494400 0 2.328968e-07
I6552 n1_m1_302400_0 0 1.526058e-07
I6553 n1_m1_302400_4800 0 1.520636e-07
I6554 n1_m1_302400_9600 0 2.408891e-07
I6555 n1_m1_302400_14400 0 1.665524e-07
I6556 n1_m1_302400_19200 0 1.650013e-07
I6557 n1_m1_302400_24000 0 3.059359e-07
I6558 n1_m1_302400_28800 0 2.933105e-07
I6559 n1_m1_302400_33600 0 3.228047e-07
I6560 n1_m1_302400_38400 0 1.837858e-07
I6561 n1_m1_302400_43200 0 1.745656e-07
I6562 n1_m1_302400_48000 0 2.549898e-07
I6563 n1_m1_302400_52800 0 1.707931e-07
I6564 n1_m1_302400_57600 0 2.606598e-07
I6565 n1_m1_302400_62400 0 2.076989e-07
I6566 n1_m1_302400_67200 0 3.270360e-07
I6567 n1_m1_302400_72000 0 6.713883e-07
I6568 n1_m1_302400_76800 0 2.765018e-07
I6569 n1_m1_302400_81600 0 2.644772e-07
I6570 n1_m1_302400_86400 0 1.791670e-07
I6571 n1_m1_302400_91200 0 1.688537e-07
I6572 n1_m1_302400_96000 0 2.531157e-07
I6573 n1_m1_302400_100800 0 1.745187e-07
I6574 n1_m1_302400_105600 0 3.008759e-07
I6575 n1_m1_302400_110400 0 2.907375e-07
I6576 n1_m1_302400_115200 0 2.739309e-07
I6577 n1_m1_302400_120000 0 3.391310e-07
I6578 n1_m1_302400_124800 0 1.819908e-07
I6579 n1_m1_302400_129600 0 2.598217e-07
I6580 n1_m1_302400_134400 0 1.732144e-07
I6581 n1_m1_302400_139200 0 1.732144e-07
I6582 n1_m1_302400_144000 0 2.598217e-07
I6583 n1_m1_302400_148800 0 1.732144e-07
I6584 n1_m1_302400_153600 0 2.623508e-07
I6585 n1_m1_302400_158400 0 1.748068e-07
I6586 n1_m1_302400_163200 0 1.716342e-07
I6587 n1_m1_302400_168000 0 2.511825e-07
I6588 n1_m1_302400_172800 0 1.681510e-07
I6589 n1_m1_302400_177600 0 2.598752e-07
I6590 n1_m1_302400_182400 0 1.785594e-07
I6591 n1_m1_302400_187200 0 1.869810e-07
I6592 n1_m1_302400_192000 0 2.810186e-07
I6593 n1_m1_302400_196800 0 1.804017e-07
I6594 n1_m1_302400_201600 0 2.622827e-07
I6595 n1_m1_302400_206400 0 1.739435e-07
I6596 n1_m1_302400_211200 0 1.786879e-07
I6597 n1_m1_302400_216000 0 2.690490e-07
I6598 n1_m1_302400_220800 0 1.785655e-07
I6599 n1_m1_302400_225600 0 2.646510e-07
I6600 n1_m1_302400_230400 0 1.831675e-07
I6601 n1_m1_302400_235200 0 1.905201e-07
I6602 n1_m1_302400_240000 0 3.026898e-07
I6603 n1_m1_302400_244800 0 2.012300e-07
I6604 n1_m1_302400_249600 0 2.663333e-07
I6605 n1_m1_302400_254400 0 1.724900e-07
I6606 n1_m1_302400_259200 0 1.707931e-07
I6607 n1_m1_302400_264000 0 2.564959e-07
I6608 n1_m1_302400_268800 0 1.752805e-07
I6609 n1_m1_302400_273600 0 2.776673e-07
I6610 n1_m1_302400_278400 0 2.199041e-07
I6611 n1_m1_302400_283200 0 2.320854e-07
I6612 n1_m1_302400_288000 0 2.901456e-07
I6613 n1_m1_302400_292800 0 1.754253e-07
I6614 n1_m1_302400_297600 0 2.525291e-07
I6615 n1_m1_302400_302400 0 1.665524e-07
I6616 n1_m1_302400_307200 0 1.665524e-07
I6617 n1_m1_302400_312000 0 2.498285e-07
I6618 n1_m1_302400_316800 0 1.659567e-07
I6619 n1_m1_302400_321600 0 2.430743e-07
I6620 n1_m1_302400_326400 0 1.650474e-07
I6621 n1_m1_302400_331200 0 1.665524e-07
I6622 n1_m1_302400_336000 0 2.498285e-07
I6623 n1_m1_302400_340800 0 1.665524e-07
I6624 n1_m1_302400_345600 0 2.544553e-07
I6625 n1_m1_302400_350400 0 1.765120e-07
I6626 n1_m1_302400_355200 0 1.769059e-07
I6627 n1_m1_302400_360000 0 2.603028e-07
I6628 n1_m1_302400_364800 0 1.732144e-07
I6629 n1_m1_302400_369600 0 2.624631e-07
I6630 n1_m1_302400_374400 0 1.672966e-07
I6631 n1_m1_302400_379200 0 1.694600e-07
I6632 n1_m1_302400_384000 0 2.680652e-07
I6633 n1_m1_302400_388800 0 1.717979e-07
I6634 n1_m1_302400_393600 0 3.225531e-07
I6635 n1_m1_302400_398400 0 4.194704e-07
I6636 n1_m1_302400_403200 0 4.282920e-07
I6637 n1_m1_302400_408000 0 3.223057e-07
I6638 n1_m1_302400_412800 0 1.732718e-07
I6639 n1_m1_302400_417600 0 2.526570e-07
I6640 n1_m1_302400_422400 0 1.653903e-07
I6641 n1_m1_302400_427200 0 1.662854e-07
I6642 n1_m1_302400_432000 0 2.686184e-07
I6643 n1_m1_302400_436800 0 1.828661e-07
I6644 n1_m1_302400_441600 0 2.573682e-07
I6645 n1_m1_302400_446400 0 1.743945e-07
I6646 n1_m1_302400_451200 0 1.721641e-07
I6647 n1_m1_302400_456000 0 3.785255e-07
I6648 n1_m1_302400_460800 0 4.695941e-07
I6649 n1_m1_302400_465600 0 5.578545e-07
I6650 n1_m1_302400_470400 0 1.930367e-07
I6651 n1_m1_302400_475200 0 1.749002e-07
I6652 n1_m1_302400_480000 0 2.446198e-07
I6653 n1_m1_302400_484800 0 1.588838e-07
I6654 n1_m1_302400_489600 0 2.467533e-07
I6655 n1_m1_302400_494400 0 1.701707e-07
I6656 n1_m1_307200_0 0 1.532282e-07
I6657 n1_m1_307200_4800 0 1.542248e-07
I6658 n1_m1_307200_9600 0 2.431062e-07
I6659 n1_m1_307200_14400 0 1.665524e-07
I6660 n1_m1_307200_19200 0 1.722252e-07
I6661 n1_m1_307200_24000 0 5.248967e-07
I6662 n1_m1_307200_28800 0 5.388970e-07
I6663 n1_m1_307200_33600 0 4.564421e-07
I6664 n1_m1_307200_38400 0 1.921990e-07
I6665 n1_m1_307200_43200 0 1.702040e-07
I6666 n1_m1_307200_48000 0 2.526384e-07
I6667 n1_m1_307200_52800 0 1.748950e-07
I6668 n1_m1_307200_57600 0 2.803782e-07
I6669 n1_m1_307200_62400 0 2.659649e-07
I6670 n1_m1_307200_67200 0 2.154474e-07
I6671 n1_m1_307200_72000 0 3.406670e-07
I6672 n1_m1_307200_76800 0 1.943750e-07
I6673 n1_m1_307200_81600 0 2.649756e-07
I6674 n1_m1_307200_86400 0 1.772201e-07
I6675 n1_m1_307200_91200 0 1.766669e-07
I6676 n1_m1_307200_96000 0 2.902059e-07
I6677 n1_m1_307200_100800 0 1.716417e-07
I6678 n1_m1_307200_105600 0 6.267199e-07
I6679 n1_m1_307200_110400 0 9.392143e-07
I6680 n1_m1_307200_115200 0 8.897366e-07
I6681 n1_m1_307200_120000 0 7.300140e-07
I6682 n1_m1_307200_124800 0 2.039989e-07
I6683 n1_m1_307200_129600 0 2.645698e-07
I6684 n1_m1_307200_134400 0 1.732144e-07
I6685 n1_m1_307200_139200 0 1.732144e-07
I6686 n1_m1_307200_144000 0 2.598217e-07
I6687 n1_m1_307200_148800 0 1.732144e-07
I6688 n1_m1_307200_153600 0 2.796397e-07
I6689 n1_m1_307200_158400 0 1.912230e-07
I6690 n1_m1_307200_163200 0 1.791807e-07
I6691 n1_m1_307200_168000 0 2.585976e-07
I6692 n1_m1_307200_172800 0 1.715165e-07
I6693 n1_m1_307200_177600 0 2.598885e-07
I6694 n1_m1_307200_182400 0 1.784986e-07
I6695 n1_m1_307200_187200 0 1.849138e-07
I6696 n1_m1_307200_192000 0 2.732564e-07
I6697 n1_m1_307200_196800 0 1.798765e-07
I6698 n1_m1_307200_201600 0 2.591931e-07
I6699 n1_m1_307200_206400 0 1.657410e-07
I6700 n1_m1_307200_211200 0 1.712246e-07
I6701 n1_m1_307200_216000 0 2.664004e-07
I6702 n1_m1_307200_220800 0 1.717161e-07
I6703 n1_m1_307200_225600 0 2.584004e-07
I6704 n1_m1_307200_230400 0 1.765982e-07
I6705 n1_m1_307200_235200 0 1.831675e-07
I6706 n1_m1_307200_240000 0 2.891594e-07
I6707 n1_m1_307200_244800 0 1.944412e-07
I6708 n1_m1_307200_249600 0 2.648283e-07
I6709 n1_m1_307200_254400 0 1.732144e-07
I6710 n1_m1_307200_259200 0 1.732144e-07
I6711 n1_m1_307200_264000 0 2.598217e-07
I6712 n1_m1_307200_268800 0 1.730448e-07
I6713 n1_m1_307200_273600 0 2.568942e-07
I6714 n1_m1_307200_278400 0 1.814356e-07
I6715 n1_m1_307200_283200 0 1.866525e-07
I6716 n1_m1_307200_288000 0 2.643159e-07
I6717 n1_m1_307200_292800 0 1.690607e-07
I6718 n1_m1_307200_297600 0 2.500102e-07
I6719 n1_m1_307200_302400 0 1.665524e-07
I6720 n1_m1_307200_307200 0 1.665524e-07
I6721 n1_m1_307200_312000 0 2.498285e-07
I6722 n1_m1_307200_316800 0 1.665524e-07
I6723 n1_m1_307200_321600 0 2.480864e-07
I6724 n1_m1_307200_326400 0 1.627578e-07
I6725 n1_m1_307200_331200 0 1.656143e-07
I6726 n1_m1_307200_336000 0 2.498285e-07
I6727 n1_m1_307200_340800 0 1.683396e-07
I6728 n1_m1_307200_345600 0 2.633534e-07
I6729 n1_m1_307200_350400 0 1.828502e-07
I6730 n1_m1_307200_355200 0 1.795783e-07
I6731 n1_m1_307200_360000 0 2.605775e-07
I6732 n1_m1_307200_364800 0 1.732144e-07
I6733 n1_m1_307200_369600 0 2.671452e-07
I6734 n1_m1_307200_374400 0 1.767382e-07
I6735 n1_m1_307200_379200 0 1.668907e-07
I6736 n1_m1_307200_384000 0 2.611552e-07
I6737 n1_m1_307200_388800 0 1.688568e-07
I6738 n1_m1_307200_393600 0 4.324342e-07
I6739 n1_m1_307200_398400 0 7.704017e-07
I6740 n1_m1_307200_403200 0 7.615308e-07
I6741 n1_m1_307200_408000 0 3.825149e-07
I6742 n1_m1_307200_412800 0 1.780380e-07
I6743 n1_m1_307200_417600 0 2.568272e-07
I6744 n1_m1_307200_422400 0 1.709804e-07
I6745 n1_m1_307200_427200 0 1.676162e-07
I6746 n1_m1_307200_432000 0 2.541500e-07
I6747 n1_m1_307200_436800 0 1.735350e-07
I6748 n1_m1_307200_441600 0 2.518816e-07
I6749 n1_m1_307200_446400 0 1.731074e-07
I6750 n1_m1_307200_451200 0 1.769332e-07
I6751 n1_m1_307200_456000 0 3.214150e-07
I6752 n1_m1_307200_460800 0 2.886228e-07
I6753 n1_m1_307200_465600 0 4.062049e-07
I6754 n1_m1_307200_470400 0 2.026395e-07
I6755 n1_m1_307200_475200 0 1.752746e-07
I6756 n1_m1_307200_480000 0 2.423905e-07
I6757 n1_m1_307200_484800 0 1.598903e-07
I6758 n1_m1_307200_489600 0 2.393976e-07
I6759 n1_m1_307200_494400 0 1.566405e-07
I6760 n1_m1_312000_0 0 2.382061e-07
I6761 n1_m1_312000_4800 0 2.325466e-07
I6762 n1_m1_312000_9600 0 3.646594e-07
I6763 n1_m1_312000_14400 0 2.498285e-07
I6764 n1_m1_312000_19200 0 2.565511e-07
I6765 n1_m1_312000_24000 0 6.462193e-07
I6766 n1_m1_312000_28800 0 6.745887e-07
I6767 n1_m1_312000_33600 0 7.747899e-07
I6768 n1_m1_312000_38400 0 3.024120e-07
I6769 n1_m1_312000_43200 0 2.531532e-07
I6770 n1_m1_312000_48000 0 3.760050e-07
I6771 n1_m1_312000_52800 0 2.541972e-07
I6772 n1_m1_312000_57600 0 3.981661e-07
I6773 n1_m1_312000_62400 0 3.752634e-07
I6774 n1_m1_312000_67200 0 3.435463e-07
I6775 n1_m1_312000_72000 0 4.182426e-07
I6776 n1_m1_312000_76800 0 2.601261e-07
I6777 n1_m1_312000_81600 0 3.915492e-07
I6778 n1_m1_312000_86400 0 2.613361e-07
I6779 n1_m1_312000_91200 0 2.573738e-07
I6780 n1_m1_312000_96000 0 4.337359e-07
I6781 n1_m1_312000_100800 0 3.395997e-07
I6782 n1_m1_312000_105600 0 1.898136e-06
I6783 n1_m1_312000_110400 0 2.020386e-06
I6784 n1_m1_312000_115200 0 1.759320e-06
I6785 n1_m1_312000_120000 0 1.692638e-06
I6786 n1_m1_312000_124800 0 3.993954e-07
I6787 n1_m1_312000_129600 0 3.921925e-07
I6788 n1_m1_312000_134400 0 2.627395e-07
I6789 n1_m1_312000_139200 0 2.700684e-07
I6790 n1_m1_312000_144000 0 4.215758e-07
I6791 n1_m1_312000_148800 0 3.079559e-07
I6792 n1_m1_312000_153600 0 4.972536e-07
I6793 n1_m1_312000_158400 0 3.228680e-07
I6794 n1_m1_312000_163200 0 2.937683e-07
I6795 n1_m1_312000_168000 0 4.129984e-07
I6796 n1_m1_312000_172800 0 2.678773e-07
I6797 n1_m1_312000_177600 0 3.956830e-07
I6798 n1_m1_312000_182400 0 2.616058e-07
I6799 n1_m1_312000_187200 0 2.683957e-07
I6800 n1_m1_312000_192000 0 4.033833e-07
I6801 n1_m1_312000_196800 0 2.673083e-07
I6802 n1_m1_312000_201600 0 3.839997e-07
I6803 n1_m1_312000_206400 0 2.527402e-07
I6804 n1_m1_312000_211200 0 2.678997e-07
I6805 n1_m1_312000_216000 0 4.197350e-07
I6806 n1_m1_312000_220800 0 2.650762e-07
I6807 n1_m1_312000_225600 0 3.959133e-07
I6808 n1_m1_312000_230400 0 2.534789e-07
I6809 n1_m1_312000_235200 0 2.592942e-07
I6810 n1_m1_312000_240000 0 4.324997e-07
I6811 n1_m1_312000_244800 0 3.020318e-07
I6812 n1_m1_312000_249600 0 4.052823e-07
I6813 n1_m1_312000_254400 0 3.254416e-07
I6814 n1_m1_312000_259200 0 4.042083e-07
I6815 n1_m1_312000_264000 0 4.995985e-07
I6816 n1_m1_312000_268800 0 2.650561e-07
I6817 n1_m1_312000_273600 0 3.872574e-07
I6818 n1_m1_312000_278400 0 2.634080e-07
I6819 n1_m1_312000_283200 0 2.632162e-07
I6820 n1_m1_312000_288000 0 3.835983e-07
I6821 n1_m1_312000_292800 0 2.572572e-07
I6822 n1_m1_312000_297600 0 3.805756e-07
I6823 n1_m1_312000_302400 0 2.498285e-07
I6824 n1_m1_312000_307200 0 2.668471e-07
I6825 n1_m1_312000_312000 0 3.764588e-07
I6826 n1_m1_312000_316800 0 2.560713e-07
I6827 n1_m1_312000_321600 0 3.733617e-07
I6828 n1_m1_312000_326400 0 2.405607e-07
I6829 n1_m1_312000_331200 0 2.467829e-07
I6830 n1_m1_312000_336000 0 3.783572e-07
I6831 n1_m1_312000_340800 0 2.465259e-07
I6832 n1_m1_312000_345600 0 3.980019e-07
I6833 n1_m1_312000_350400 0 3.449013e-07
I6834 n1_m1_312000_355200 0 3.275758e-07
I6835 n1_m1_312000_360000 0 3.937794e-07
I6836 n1_m1_312000_364800 0 2.518753e-07
I6837 n1_m1_312000_369600 0 3.889026e-07
I6838 n1_m1_312000_374400 0 2.611146e-07
I6839 n1_m1_312000_379200 0 2.586319e-07
I6840 n1_m1_312000_384000 0 3.955817e-07
I6841 n1_m1_312000_388800 0 2.492192e-07
I6842 n1_m1_312000_393600 0 5.365905e-07
I6843 n1_m1_312000_398400 0 1.003283e-06
I6844 n1_m1_312000_403200 0 1.301958e-06
I6845 n1_m1_312000_408000 0 8.441915e-07
I6846 n1_m1_312000_412800 0 2.618889e-07
I6847 n1_m1_312000_417600 0 3.955400e-07
I6848 n1_m1_312000_422400 0 2.563272e-07
I6849 n1_m1_312000_427200 0 2.612493e-07
I6850 n1_m1_312000_432000 0 3.833406e-07
I6851 n1_m1_312000_436800 0 2.591556e-07
I6852 n1_m1_312000_441600 0 3.977446e-07
I6853 n1_m1_312000_446400 0 2.662079e-07
I6854 n1_m1_312000_451200 0 2.617311e-07
I6855 n1_m1_312000_456000 0 4.046458e-07
I6856 n1_m1_312000_460800 0 2.768905e-07
I6857 n1_m1_312000_465600 0 4.141881e-07
I6858 n1_m1_312000_470400 0 2.661309e-07
I6859 n1_m1_312000_475200 0 2.585123e-07
I6860 n1_m1_312000_480000 0 3.775573e-07
I6861 n1_m1_312000_484800 0 2.435759e-07
I6862 n1_m1_312000_489600 0 3.494142e-07
I6863 n1_m1_312000_494400 0 2.235656e-07
I6864 n1_m1_316800_0 0 1.484424e-07
I6865 n1_m1_316800_4800 0 1.535328e-07
I6866 n1_m1_316800_9600 0 2.440638e-07
I6867 n1_m1_316800_14400 0 1.681911e-07
I6868 n1_m1_316800_19200 0 1.671885e-07
I6869 n1_m1_316800_24000 0 2.653591e-07
I6870 n1_m1_316800_28800 0 2.073682e-07
I6871 n1_m1_316800_33600 0 2.832040e-07
I6872 n1_m1_316800_38400 0 1.694025e-07
I6873 n1_m1_316800_43200 0 1.666396e-07
I6874 n1_m1_316800_48000 0 2.536822e-07
I6875 n1_m1_316800_52800 0 1.731409e-07
I6876 n1_m1_316800_57600 0 2.602522e-07
I6877 n1_m1_316800_62400 0 1.782492e-07
I6878 n1_m1_316800_67200 0 1.778270e-07
I6879 n1_m1_316800_72000 0 2.539389e-07
I6880 n1_m1_316800_76800 0 1.673663e-07
I6881 n1_m1_316800_81600 0 2.561261e-07
I6882 n1_m1_316800_86400 0 1.764764e-07
I6883 n1_m1_316800_91200 0 1.809793e-07
I6884 n1_m1_316800_96000 0 3.174222e-07
I6885 n1_m1_316800_100800 0 2.702930e-07
I6886 n1_m1_316800_105600 0 1.286679e-06
I6887 n1_m1_316800_110400 0 1.232028e-06
I6888 n1_m1_316800_115200 0 9.582665e-07
I6889 n1_m1_316800_120000 0 6.319161e-07
I6890 n1_m1_316800_124800 0 2.009276e-07
I6891 n1_m1_316800_129600 0 2.609528e-07
I6892 n1_m1_316800_134400 0 1.732480e-07
I6893 n1_m1_316800_139200 0 1.757190e-07
I6894 n1_m1_316800_144000 0 2.685159e-07
I6895 n1_m1_316800_148800 0 1.846041e-07
I6896 n1_m1_316800_153600 0 2.772361e-07
I6897 n1_m1_316800_158400 0 1.847353e-07
I6898 n1_m1_316800_163200 0 1.861452e-07
I6899 n1_m1_316800_168000 0 2.739705e-07
I6900 n1_m1_316800_172800 0 1.815166e-07
I6901 n1_m1_316800_177600 0 2.672496e-07
I6902 n1_m1_316800_182400 0 1.748139e-07
I6903 n1_m1_316800_187200 0 1.736290e-07
I6904 n1_m1_316800_192000 0 2.623267e-07
I6905 n1_m1_316800_196800 0 1.798477e-07
I6906 n1_m1_316800_201600 0 2.657130e-07
I6907 n1_m1_316800_206400 0 1.823883e-07
I6908 n1_m1_316800_211200 0 2.038645e-07
I6909 n1_m1_316800_216000 0 3.332887e-07
I6910 n1_m1_316800_220800 0 1.765656e-07
I6911 n1_m1_316800_225600 0 2.600707e-07
I6912 n1_m1_316800_230400 0 1.679375e-07
I6913 n1_m1_316800_235200 0 1.794966e-07
I6914 n1_m1_316800_240000 0 3.777136e-07
I6915 n1_m1_316800_244800 0 3.169183e-07
I6916 n1_m1_316800_249600 0 3.396250e-07
I6917 n1_m1_316800_254400 0 2.715060e-07
I6918 n1_m1_316800_259200 0 3.113417e-07
I6919 n1_m1_316800_264000 0 3.795883e-07
I6920 n1_m1_316800_268800 0 1.876421e-07
I6921 n1_m1_316800_273600 0 2.604640e-07
I6922 n1_m1_316800_278400 0 1.739259e-07
I6923 n1_m1_316800_283200 0 1.797938e-07
I6924 n1_m1_316800_288000 0 2.685300e-07
I6925 n1_m1_316800_292800 0 1.713970e-07
I6926 n1_m1_316800_297600 0 2.502967e-07
I6927 n1_m1_316800_302400 0 1.675955e-07
I6928 n1_m1_316800_307200 0 1.672975e-07
I6929 n1_m1_316800_312000 0 2.466840e-07
I6930 n1_m1_316800_316800 0 1.661846e-07
I6931 n1_m1_316800_321600 0 2.448420e-07
I6932 n1_m1_316800_326400 0 1.614803e-07
I6933 n1_m1_316800_331200 0 1.602987e-07
I6934 n1_m1_316800_336000 0 2.400139e-07
I6935 n1_m1_316800_340800 0 1.599341e-07
I6936 n1_m1_316800_345600 0 2.552575e-07
I6937 n1_m1_316800_350400 0 1.981338e-07
I6938 n1_m1_316800_355200 0 1.982888e-07
I6939 n1_m1_316800_360000 0 2.603513e-07
I6940 n1_m1_316800_364800 0 1.681911e-07
I6941 n1_m1_316800_369600 0 2.565906e-07
I6942 n1_m1_316800_374400 0 1.670030e-07
I6943 n1_m1_316800_379200 0 1.680507e-07
I6944 n1_m1_316800_384000 0 2.632140e-07
I6945 n1_m1_316800_388800 0 1.743876e-07
I6946 n1_m1_316800_393600 0 2.926618e-07
I6947 n1_m1_316800_398400 0 3.415696e-07
I6948 n1_m1_316800_403200 0 4.351743e-07
I6949 n1_m1_316800_408000 0 4.204716e-07
I6950 n1_m1_316800_412800 0 1.884494e-07
I6951 n1_m1_316800_417600 0 2.752203e-07
I6952 n1_m1_316800_422400 0 1.694324e-07
I6953 n1_m1_316800_427200 0 1.734659e-07
I6954 n1_m1_316800_432000 0 2.680386e-07
I6955 n1_m1_316800_436800 0 1.689991e-07
I6956 n1_m1_316800_441600 0 2.525475e-07
I6957 n1_m1_316800_446400 0 1.683641e-07
I6958 n1_m1_316800_451200 0 1.682885e-07
I6959 n1_m1_316800_456000 0 2.579707e-07
I6960 n1_m1_316800_460800 0 1.740787e-07
I6961 n1_m1_316800_465600 0 2.555963e-07
I6962 n1_m1_316800_470400 0 1.602213e-07
I6963 n1_m1_316800_475200 0 1.637149e-07
I6964 n1_m1_316800_480000 0 2.409768e-07
I6965 n1_m1_316800_484800 0 1.592521e-07
I6966 n1_m1_316800_489600 0 2.324524e-07
I6967 n1_m1_316800_494400 0 1.519559e-07
I6968 n1_m1_321600_0 0 2.261945e-07
I6969 n1_m1_321600_4800 0 2.315532e-07
I6970 n1_m1_321600_9600 0 3.774894e-07
I6971 n1_m1_321600_14400 0 2.647915e-07
I6972 n1_m1_321600_19200 0 2.552068e-07
I6973 n1_m1_321600_24000 0 3.758223e-07
I6974 n1_m1_321600_28800 0 2.534762e-07
I6975 n1_m1_321600_33600 0 3.748972e-07
I6976 n1_m1_321600_38400 0 2.537295e-07
I6977 n1_m1_321600_43200 0 2.550747e-07
I6978 n1_m1_321600_48000 0 3.887023e-07
I6979 n1_m1_321600_52800 0 2.598648e-07
I6980 n1_m1_321600_57600 0 3.905333e-07
I6981 n1_m1_321600_62400 0 2.636392e-07
I6982 n1_m1_321600_67200 0 2.604333e-07
I6983 n1_m1_321600_72000 0 3.922058e-07
I6984 n1_m1_321600_76800 0 2.594380e-07
I6985 n1_m1_321600_81600 0 3.770672e-07
I6986 n1_m1_321600_86400 0 2.518185e-07
I6987 n1_m1_321600_91200 0 2.623330e-07
I6988 n1_m1_321600_96000 0 4.010381e-07
I6989 n1_m1_321600_100800 0 3.031036e-07
I6990 n1_m1_321600_105600 0 1.421761e-06
I6991 n1_m1_321600_110400 0 1.276942e-06
I6992 n1_m1_321600_115200 0 1.036295e-06
I6993 n1_m1_321600_120000 0 9.435947e-07
I6994 n1_m1_321600_124800 0 3.026686e-07
I6995 n1_m1_321600_129600 0 3.914287e-07
I6996 n1_m1_321600_134400 0 2.598217e-07
I6997 n1_m1_321600_139200 0 2.598217e-07
I6998 n1_m1_321600_144000 0 3.912462e-07
I6999 n1_m1_321600_148800 0 2.688130e-07
I7000 n1_m1_321600_153600 0 4.017942e-07
I7001 n1_m1_321600_158400 0 2.680423e-07
I7002 n1_m1_321600_163200 0 2.763759e-07
I7003 n1_m1_321600_168000 0 4.197119e-07
I7004 n1_m1_321600_172800 0 2.797534e-07
I7005 n1_m1_321600_177600 0 4.118661e-07
I7006 n1_m1_321600_182400 0 2.656762e-07
I7007 n1_m1_321600_187200 0 2.608666e-07
I7008 n1_m1_321600_192000 0 3.915169e-07
I7009 n1_m1_321600_196800 0 2.666773e-07
I7010 n1_m1_321600_201600 0 4.060726e-07
I7011 n1_m1_321600_206400 0 2.905905e-07
I7012 n1_m1_321600_211200 0 3.568497e-07
I7013 n1_m1_321600_216000 0 5.770069e-07
I7014 n1_m1_321600_220800 0 3.155846e-07
I7015 n1_m1_321600_225600 0 4.110324e-07
I7016 n1_m1_321600_230400 0 2.508887e-07
I7017 n1_m1_321600_235200 0 2.540835e-07
I7018 n1_m1_321600_240000 0 4.562374e-07
I7019 n1_m1_321600_244800 0 3.619894e-07
I7020 n1_m1_321600_249600 0 4.728600e-07
I7021 n1_m1_321600_254400 0 3.251238e-07
I7022 n1_m1_321600_259200 0 3.300692e-07
I7023 n1_m1_321600_264000 0 4.732015e-07
I7024 n1_m1_321600_268800 0 2.787723e-07
I7025 n1_m1_321600_273600 0 3.877879e-07
I7026 n1_m1_321600_278400 0 2.501477e-07
I7027 n1_m1_321600_283200 0 2.526075e-07
I7028 n1_m1_321600_288000 0 3.813994e-07
I7029 n1_m1_321600_292800 0 2.504364e-07
I7030 n1_m1_321600_297600 0 3.780522e-07
I7031 n1_m1_321600_302400 0 2.579235e-07
I7032 n1_m1_321600_307200 0 2.564447e-07
I7033 n1_m1_321600_312000 0 3.905111e-07
I7034 n1_m1_321600_316800 0 2.474499e-07
I7035 n1_m1_321600_321600 0 3.711725e-07
I7036 n1_m1_321600_326400 0 2.545753e-07
I7037 n1_m1_321600_331200 0 2.468114e-07
I7038 n1_m1_321600_336000 0 3.646817e-07
I7039 n1_m1_321600_340800 0 2.479965e-07
I7040 n1_m1_321600_345600 0 3.833435e-07
I7041 n1_m1_321600_350400 0 2.768810e-07
I7042 n1_m1_321600_355200 0 2.777788e-07
I7043 n1_m1_321600_360000 0 3.962693e-07
I7044 n1_m1_321600_364800 0 2.597566e-07
I7045 n1_m1_321600_369600 0 3.867827e-07
I7046 n1_m1_321600_374400 0 2.476100e-07
I7047 n1_m1_321600_379200 0 2.575642e-07
I7048 n1_m1_321600_384000 0 4.006635e-07
I7049 n1_m1_321600_388800 0 2.575108e-07
I7050 n1_m1_321600_393600 0 3.791896e-07
I7051 n1_m1_321600_398400 0 2.629208e-07
I7052 n1_m1_321600_403200 0 3.458461e-07
I7053 n1_m1_321600_408000 0 5.468103e-07
I7054 n1_m1_321600_412800 0 2.908944e-07
I7055 n1_m1_321600_417600 0 3.922061e-07
I7056 n1_m1_321600_422400 0 2.529561e-07
I7057 n1_m1_321600_427200 0 2.600574e-07
I7058 n1_m1_321600_432000 0 4.044421e-07
I7059 n1_m1_321600_436800 0 2.561543e-07
I7060 n1_m1_321600_441600 0 3.851289e-07
I7061 n1_m1_321600_446400 0 2.596680e-07
I7062 n1_m1_321600_451200 0 2.631480e-07
I7063 n1_m1_321600_456000 0 3.877760e-07
I7064 n1_m1_321600_460800 0 2.449902e-07
I7065 n1_m1_321600_465600 0 3.671642e-07
I7066 n1_m1_321600_470400 0 2.448052e-07
I7067 n1_m1_321600_475200 0 2.448052e-07
I7068 n1_m1_321600_480000 0 3.652818e-07
I7069 n1_m1_321600_484800 0 2.356816e-07
I7070 n1_m1_321600_489600 0 3.437020e-07
I7071 n1_m1_321600_494400 0 2.225021e-07
I7072 n1_m1_326400_0 0 1.534355e-07
I7073 n1_m1_326400_4800 0 1.546263e-07
I7074 n1_m1_326400_9600 0 2.491355e-07
I7075 n1_m1_326400_14400 0 1.749734e-07
I7076 n1_m1_326400_19200 0 1.699026e-07
I7077 n1_m1_326400_24000 0 2.502083e-07
I7078 n1_m1_326400_28800 0 1.667597e-07
I7079 n1_m1_326400_33600 0 2.538505e-07
I7080 n1_m1_326400_38400 0 1.730104e-07
I7081 n1_m1_326400_43200 0 1.732609e-07
I7082 n1_m1_326400_48000 0 2.600403e-07
I7083 n1_m1_326400_52800 0 1.773676e-07
I7084 n1_m1_326400_57600 0 2.869782e-07
I7085 n1_m1_326400_62400 0 1.861165e-07
I7086 n1_m1_326400_67200 0 1.711668e-07
I7087 n1_m1_326400_72000 0 2.554778e-07
I7088 n1_m1_326400_76800 0 1.766078e-07
I7089 n1_m1_326400_81600 0 2.602630e-07
I7090 n1_m1_326400_86400 0 1.727673e-07
I7091 n1_m1_326400_91200 0 1.767556e-07
I7092 n1_m1_326400_96000 0 2.591148e-07
I7093 n1_m1_326400_100800 0 2.222513e-07
I7094 n1_m1_326400_105600 0 7.546296e-07
I7095 n1_m1_326400_110400 0 4.488543e-07
I7096 n1_m1_326400_115200 0 4.439350e-07
I7097 n1_m1_326400_120000 0 6.280698e-07
I7098 n1_m1_326400_124800 0 2.051406e-07
I7099 n1_m1_326400_129600 0 2.600801e-07
I7100 n1_m1_326400_134400 0 1.732144e-07
I7101 n1_m1_326400_139200 0 1.732144e-07
I7102 n1_m1_326400_144000 0 2.650735e-07
I7103 n1_m1_326400_148800 0 1.797029e-07
I7104 n1_m1_326400_153600 0 2.699385e-07
I7105 n1_m1_326400_158400 0 1.831750e-07
I7106 n1_m1_326400_163200 0 1.860158e-07
I7107 n1_m1_326400_168000 0 2.795631e-07
I7108 n1_m1_326400_172800 0 1.839060e-07
I7109 n1_m1_326400_177600 0 2.630047e-07
I7110 n1_m1_326400_182400 0 1.696838e-07
I7111 n1_m1_326400_187200 0 1.720909e-07
I7112 n1_m1_326400_192000 0 2.598217e-07
I7113 n1_m1_326400_196800 0 1.738037e-07
I7114 n1_m1_326400_201600 0 2.669184e-07
I7115 n1_m1_326400_206400 0 1.839295e-07
I7116 n1_m1_326400_211200 0 1.968395e-07
I7117 n1_m1_326400_216000 0 3.039548e-07
I7118 n1_m1_326400_220800 0 1.969580e-07
I7119 n1_m1_326400_225600 0 2.737907e-07
I7120 n1_m1_326400_230400 0 1.720187e-07
I7121 n1_m1_326400_235200 0 1.739154e-07
I7122 n1_m1_326400_240000 0 2.947710e-07
I7123 n1_m1_326400_244800 0 2.050106e-07
I7124 n1_m1_326400_249600 0 2.753457e-07
I7125 n1_m1_326400_254400 0 1.730788e-07
I7126 n1_m1_326400_259200 0 1.687573e-07
I7127 n1_m1_326400_264000 0 2.600809e-07
I7128 n1_m1_326400_268800 0 1.748736e-07
I7129 n1_m1_326400_273600 0 2.571413e-07
I7130 n1_m1_326400_278400 0 1.805444e-07
I7131 n1_m1_326400_283200 0 1.816254e-07
I7132 n1_m1_326400_288000 0 2.505897e-07
I7133 n1_m1_326400_292800 0 1.728178e-07
I7134 n1_m1_326400_297600 0 2.633631e-07
I7135 n1_m1_326400_302400 0 1.680573e-07
I7136 n1_m1_326400_307200 0 1.680573e-07
I7137 n1_m1_326400_312000 0 2.518358e-07
I7138 n1_m1_326400_316800 0 1.613690e-07
I7139 n1_m1_326400_321600 0 2.464539e-07
I7140 n1_m1_326400_326400 0 1.715340e-07
I7141 n1_m1_326400_331200 0 1.678078e-07
I7142 n1_m1_326400_336000 0 2.508576e-07
I7143 n1_m1_326400_340800 0 1.723997e-07
I7144 n1_m1_326400_345600 0 2.594626e-07
I7145 n1_m1_326400_350400 0 1.798400e-07
I7146 n1_m1_326400_355200 0 1.807988e-07
I7147 n1_m1_326400_360000 0 2.661385e-07
I7148 n1_m1_326400_364800 0 1.702631e-07
I7149 n1_m1_326400_369600 0 2.505334e-07
I7150 n1_m1_326400_374400 0 1.625938e-07
I7151 n1_m1_326400_379200 0 1.693984e-07
I7152 n1_m1_326400_384000 0 2.624160e-07
I7153 n1_m1_326400_388800 0 1.760493e-07
I7154 n1_m1_326400_393600 0 2.704322e-07
I7155 n1_m1_326400_398400 0 1.750185e-07
I7156 n1_m1_326400_403200 0 2.160228e-07
I7157 n1_m1_326400_408000 0 4.585899e-07
I7158 n1_m1_326400_412800 0 4.169176e-07
I7159 n1_m1_326400_417600 0 3.362440e-07
I7160 n1_m1_326400_422400 0 1.845233e-07
I7161 n1_m1_326400_427200 0 1.731558e-07
I7162 n1_m1_326400_432000 0 2.624014e-07
I7163 n1_m1_326400_436800 0 1.817488e-07
I7164 n1_m1_326400_441600 0 2.546255e-07
I7165 n1_m1_326400_446400 0 1.664637e-07
I7166 n1_m1_326400_451200 0 1.725656e-07
I7167 n1_m1_326400_456000 0 2.645853e-07
I7168 n1_m1_326400_460800 0 1.679570e-07
I7169 n1_m1_326400_465600 0 2.414528e-07
I7170 n1_m1_326400_470400 0 1.613952e-07
I7171 n1_m1_326400_475200 0 1.613846e-07
I7172 n1_m1_326400_480000 0 2.412383e-07
I7173 n1_m1_326400_484800 0 1.569999e-07
I7174 n1_m1_326400_489600 0 2.296806e-07
I7175 n1_m1_326400_494400 0 1.521100e-07
I7176 n1_m1_331200_0 0 1.587025e-07
I7177 n1_m1_331200_4800 0 1.587674e-07
I7178 n1_m1_331200_9600 0 2.482646e-07
I7179 n1_m1_331200_14400 0 1.818395e-07
I7180 n1_m1_331200_19200 0 1.813016e-07
I7181 n1_m1_331200_24000 0 2.601950e-07
I7182 n1_m1_331200_28800 0 1.721745e-07
I7183 n1_m1_331200_33600 0 2.599091e-07
I7184 n1_m1_331200_38400 0 1.775598e-07
I7185 n1_m1_331200_43200 0 1.747010e-07
I7186 n1_m1_331200_48000 0 2.684182e-07
I7187 n1_m1_331200_52800 0 2.420428e-07
I7188 n1_m1_331200_57600 0 5.850932e-07
I7189 n1_m1_331200_62400 0 3.543053e-07
I7190 n1_m1_331200_67200 0 2.164942e-07
I7191 n1_m1_331200_72000 0 2.534556e-07
I7192 n1_m1_331200_76800 0 1.738521e-07
I7193 n1_m1_331200_81600 0 2.592882e-07
I7194 n1_m1_331200_86400 0 1.697811e-07
I7195 n1_m1_331200_91200 0 1.729301e-07
I7196 n1_m1_331200_96000 0 2.630692e-07
I7197 n1_m1_331200_100800 0 2.998369e-07
I7198 n1_m1_331200_105600 0 7.467943e-07
I7199 n1_m1_331200_110400 0 2.917704e-07
I7200 n1_m1_331200_115200 0 2.735464e-07
I7201 n1_m1_331200_120000 0 4.296931e-07
I7202 n1_m1_331200_124800 0 1.813448e-07
I7203 n1_m1_331200_129600 0 2.598217e-07
I7204 n1_m1_331200_134400 0 1.732144e-07
I7205 n1_m1_331200_139200 0 1.732144e-07
I7206 n1_m1_331200_144000 0 2.619507e-07
I7207 n1_m1_331200_148800 0 1.790736e-07
I7208 n1_m1_331200_153600 0 2.724948e-07
I7209 n1_m1_331200_158400 0 1.857077e-07
I7210 n1_m1_331200_163200 0 1.860412e-07
I7211 n1_m1_331200_168000 0 2.730607e-07
I7212 n1_m1_331200_172800 0 1.791218e-07
I7213 n1_m1_331200_177600 0 2.558703e-07
I7214 n1_m1_331200_182400 0 1.670469e-07
I7215 n1_m1_331200_187200 0 1.717512e-07
I7216 n1_m1_331200_192000 0 2.594315e-07
I7217 n1_m1_331200_196800 0 1.730313e-07
I7218 n1_m1_331200_201600 0 2.613965e-07
I7219 n1_m1_331200_206400 0 1.750483e-07
I7220 n1_m1_331200_211200 0 1.758889e-07
I7221 n1_m1_331200_216000 0 2.640557e-07
I7222 n1_m1_331200_220800 0 1.760371e-07
I7223 n1_m1_331200_225600 0 2.613224e-07
I7224 n1_m1_331200_230400 0 1.683851e-07
I7225 n1_m1_331200_235200 0 1.696416e-07
I7226 n1_m1_331200_240000 0 2.689283e-07
I7227 n1_m1_331200_244800 0 1.775100e-07
I7228 n1_m1_331200_249600 0 3.039116e-07
I7229 n1_m1_331200_254400 0 1.813865e-07
I7230 n1_m1_331200_259200 0 1.722081e-07
I7231 n1_m1_331200_264000 0 2.589119e-07
I7232 n1_m1_331200_268800 0 1.732377e-07
I7233 n1_m1_331200_273600 0 2.574260e-07
I7234 n1_m1_331200_278400 0 1.731505e-07
I7235 n1_m1_331200_283200 0 1.770474e-07
I7236 n1_m1_331200_288000 0 2.647710e-07
I7237 n1_m1_331200_292800 0 1.745536e-07
I7238 n1_m1_331200_297600 0 2.578604e-07
I7239 n1_m1_331200_302400 0 1.667440e-07
I7240 n1_m1_331200_307200 0 1.666533e-07
I7241 n1_m1_331200_312000 0 2.448749e-07
I7242 n1_m1_331200_316800 0 1.686205e-07
I7243 n1_m1_331200_321600 0 2.552543e-07
I7244 n1_m1_331200_326400 0 1.636998e-07
I7245 n1_m1_331200_331200 0 1.657526e-07
I7246 n1_m1_331200_336000 0 2.506374e-07
I7247 n1_m1_331200_340800 0 1.679637e-07
I7248 n1_m1_331200_345600 0 2.520887e-07
I7249 n1_m1_331200_350400 0 1.691752e-07
I7250 n1_m1_331200_355200 0 1.700941e-07
I7251 n1_m1_331200_360000 0 2.611561e-07
I7252 n1_m1_331200_364800 0 1.700038e-07
I7253 n1_m1_331200_369600 0 2.489281e-07
I7254 n1_m1_331200_374400 0 1.792114e-07
I7255 n1_m1_331200_379200 0 1.700458e-07
I7256 n1_m1_331200_384000 0 2.585790e-07
I7257 n1_m1_331200_388800 0 1.782163e-07
I7258 n1_m1_331200_393600 0 2.692905e-07
I7259 n1_m1_331200_398400 0 1.720930e-07
I7260 n1_m1_331200_403200 0 1.782088e-07
I7261 n1_m1_331200_408000 0 5.565050e-07
I7262 n1_m1_331200_412800 0 8.383265e-07
I7263 n1_m1_331200_417600 0 6.886854e-07
I7264 n1_m1_331200_422400 0 2.251820e-07
I7265 n1_m1_331200_427200 0 1.735613e-07
I7266 n1_m1_331200_432000 0 3.805249e-07
I7267 n1_m1_331200_436800 0 4.524165e-07
I7268 n1_m1_331200_441600 0 4.211524e-07
I7269 n1_m1_331200_446400 0 1.703650e-07
I7270 n1_m1_331200_451200 0 1.711579e-07
I7271 n1_m1_331200_456000 0 2.674408e-07
I7272 n1_m1_331200_460800 0 1.774614e-07
I7273 n1_m1_331200_465600 0 2.515026e-07
I7274 n1_m1_331200_470400 0 1.604923e-07
I7275 n1_m1_331200_475200 0 1.602234e-07
I7276 n1_m1_331200_480000 0 2.338692e-07
I7277 n1_m1_331200_484800 0 1.545297e-07
I7278 n1_m1_331200_489600 0 2.299773e-07
I7279 n1_m1_331200_494400 0 1.530045e-07
I7280 n1_m1_336000_0 0 2.419207e-07
I7281 n1_m1_336000_4800 0 2.392948e-07
I7282 n1_m1_336000_9600 0 3.900212e-07
I7283 n1_m1_336000_14400 0 3.343120e-07
I7284 n1_m1_336000_19200 0 3.220108e-07
I7285 n1_m1_336000_24000 0 4.087196e-07
I7286 n1_m1_336000_28800 0 2.819673e-07
I7287 n1_m1_336000_33600 0 5.095942e-07
I7288 n1_m1_336000_38400 0 3.149501e-07
I7289 n1_m1_336000_43200 0 2.822893e-07
I7290 n1_m1_336000_48000 0 5.376423e-07
I7291 n1_m1_336000_52800 0 7.590709e-07
I7292 n1_m1_336000_57600 0 1.942597e-06
I7293 n1_m1_336000_62400 0 1.193855e-06
I7294 n1_m1_336000_67200 0 6.807653e-07
I7295 n1_m1_336000_72000 0 4.388242e-07
I7296 n1_m1_336000_76800 0 2.572734e-07
I7297 n1_m1_336000_81600 0 3.916796e-07
I7298 n1_m1_336000_86400 0 2.769787e-07
I7299 n1_m1_336000_91200 0 2.952516e-07
I7300 n1_m1_336000_96000 0 4.173227e-07
I7301 n1_m1_336000_100800 0 3.332039e-07
I7302 n1_m1_336000_105600 0 6.891258e-07
I7303 n1_m1_336000_110400 0 3.131776e-07
I7304 n1_m1_336000_115200 0 3.021558e-07
I7305 n1_m1_336000_120000 0 4.743402e-07
I7306 n1_m1_336000_124800 0 2.603112e-07
I7307 n1_m1_336000_129600 0 3.897325e-07
I7308 n1_m1_336000_134400 0 2.598217e-07
I7309 n1_m1_336000_139200 0 2.598217e-07
I7310 n1_m1_336000_144000 0 3.899190e-07
I7311 n1_m1_336000_148800 0 2.610057e-07
I7312 n1_m1_336000_153600 0 3.961769e-07
I7313 n1_m1_336000_158400 0 2.686309e-07
I7314 n1_m1_336000_163200 0 2.646018e-07
I7315 n1_m1_336000_168000 0 3.921298e-07
I7316 n1_m1_336000_172800 0 2.608232e-07
I7317 n1_m1_336000_177600 0 3.840878e-07
I7318 n1_m1_336000_182400 0 2.524554e-07
I7319 n1_m1_336000_187200 0 2.559911e-07
I7320 n1_m1_336000_192000 0 3.779777e-07
I7321 n1_m1_336000_196800 0 2.545432e-07
I7322 n1_m1_336000_201600 0 3.977111e-07
I7323 n1_m1_336000_206400 0 2.678215e-07
I7324 n1_m1_336000_211200 0 2.628388e-07
I7325 n1_m1_336000_216000 0 3.887002e-07
I7326 n1_m1_336000_220800 0 2.587216e-07
I7327 n1_m1_336000_225600 0 3.883861e-07
I7328 n1_m1_336000_230400 0 2.542583e-07
I7329 n1_m1_336000_235200 0 2.719411e-07
I7330 n1_m1_336000_240000 0 5.012931e-07
I7331 n1_m1_336000_244800 0 3.535623e-07
I7332 n1_m1_336000_249600 0 5.652492e-07
I7333 n1_m1_336000_254400 0 3.059120e-07
I7334 n1_m1_336000_259200 0 2.714934e-07
I7335 n1_m1_336000_264000 0 3.898907e-07
I7336 n1_m1_336000_268800 0 2.631246e-07
I7337 n1_m1_336000_273600 0 4.221963e-07
I7338 n1_m1_336000_278400 0 3.059229e-07
I7339 n1_m1_336000_283200 0 5.087401e-07
I7340 n1_m1_336000_288000 0 1.109869e-06
I7341 n1_m1_336000_292800 0 3.919693e-07
I7342 n1_m1_336000_297600 0 3.884024e-07
I7343 n1_m1_336000_302400 0 2.619465e-07
I7344 n1_m1_336000_307200 0 2.552545e-07
I7345 n1_m1_336000_312000 0 3.929616e-07
I7346 n1_m1_336000_316800 0 3.733878e-07
I7347 n1_m1_336000_321600 0 5.029251e-07
I7348 n1_m1_336000_326400 0 2.430469e-07
I7349 n1_m1_336000_331200 0 2.501882e-07
I7350 n1_m1_336000_336000 0 3.879137e-07
I7351 n1_m1_336000_340800 0 2.508382e-07
I7352 n1_m1_336000_345600 0 3.761644e-07
I7353 n1_m1_336000_350400 0 2.501174e-07
I7354 n1_m1_336000_355200 0 2.554011e-07
I7355 n1_m1_336000_360000 0 4.303976e-07
I7356 n1_m1_336000_364800 0 2.971782e-07
I7357 n1_m1_336000_369600 0 4.171510e-07
I7358 n1_m1_336000_374400 0 3.350742e-07
I7359 n1_m1_336000_379200 0 4.863509e-07
I7360 n1_m1_336000_384000 0 1.216991e-06
I7361 n1_m1_336000_388800 0 6.923975e-07
I7362 n1_m1_336000_393600 0 5.073579e-07
I7363 n1_m1_336000_398400 0 2.536348e-07
I7364 n1_m1_336000_403200 0 2.617836e-07
I7365 n1_m1_336000_408000 0 9.900962e-07
I7366 n1_m1_336000_412800 0 1.554396e-06
I7367 n1_m1_336000_417600 0 1.220356e-06
I7368 n1_m1_336000_422400 0 3.585306e-07
I7369 n1_m1_336000_427200 0 2.900544e-07
I7370 n1_m1_336000_432000 0 8.956863e-07
I7371 n1_m1_336000_436800 0 8.627712e-07
I7372 n1_m1_336000_441600 0 7.443002e-07
I7373 n1_m1_336000_446400 0 2.661534e-07
I7374 n1_m1_336000_451200 0 2.577781e-07
I7375 n1_m1_336000_456000 0 3.997081e-07
I7376 n1_m1_336000_460800 0 2.599221e-07
I7377 n1_m1_336000_465600 0 4.178081e-07
I7378 n1_m1_336000_470400 0 2.932087e-07
I7379 n1_m1_336000_475200 0 2.772778e-07
I7380 n1_m1_336000_480000 0 3.839433e-07
I7381 n1_m1_336000_484800 0 2.450489e-07
I7382 n1_m1_336000_489600 0 3.465646e-07
I7383 n1_m1_336000_494400 0 2.227537e-07
I7384 n1_m1_340800_0 0 7.824909e-08
I7385 n1_m1_340800_4800 0 7.767803e-08
I7386 n1_m1_340800_9600 0 1.266302e-07
I7387 n1_m1_340800_14400 0 9.713906e-08
I7388 n1_m1_340800_19200 0 9.372218e-08
I7389 n1_m1_340800_24000 0 1.278395e-07
I7390 n1_m1_340800_28800 0 9.200079e-08
I7391 n1_m1_340800_33600 0 2.100232e-07
I7392 n1_m1_340800_38400 0 1.790200e-07
I7393 n1_m1_340800_43200 0 1.512286e-07
I7394 n1_m1_340800_48000 0 1.815683e-07
I7395 n1_m1_340800_52800 0 1.945638e-07
I7396 n1_m1_340800_57600 0 4.834272e-07
I7397 n1_m1_340800_62400 0 2.917870e-07
I7398 n1_m1_340800_67200 0 1.724880e-07
I7399 n1_m1_340800_72000 0 1.398830e-07
I7400 n1_m1_340800_76800 0 9.877988e-08
I7401 n1_m1_340800_81600 0 2.049327e-07
I7402 n1_m1_340800_86400 0 1.814434e-07
I7403 n1_m1_340800_91200 0 1.910335e-07
I7404 n1_m1_340800_96000 0 1.499352e-07
I7405 n1_m1_340800_100800 0 9.219572e-08
I7406 n1_m1_340800_105600 0 1.412186e-07
I7407 n1_m1_340800_110400 0 9.198821e-08
I7408 n1_m1_340800_115200 0 8.882683e-08
I7409 n1_m1_340800_120000 0 1.332513e-07
I7410 n1_m1_340800_124800 0 8.865098e-08
I7411 n1_m1_340800_129600 0 1.302887e-07
I7412 n1_m1_340800_134400 0 8.560412e-08
I7413 n1_m1_340800_139200 0 8.440659e-08
I7414 n1_m1_340800_144000 0 1.269214e-07
I7415 n1_m1_340800_148800 0 8.638407e-08
I7416 n1_m1_340800_153600 0 1.299108e-07
I7417 n1_m1_340800_158400 0 8.660722e-08
I7418 n1_m1_340800_163200 0 8.660722e-08
I7419 n1_m1_340800_168000 0 1.273125e-07
I7420 n1_m1_340800_172800 0 8.440659e-08
I7421 n1_m1_340800_177600 0 1.266099e-07
I7422 n1_m1_340800_182400 0 8.443345e-08
I7423 n1_m1_340800_187200 0 8.524364e-08
I7424 n1_m1_340800_192000 0 1.282152e-07
I7425 n1_m1_340800_196800 0 8.591944e-08
I7426 n1_m1_340800_201600 0 1.289266e-07
I7427 n1_m1_340800_206400 0 8.553701e-08
I7428 n1_m1_340800_211200 0 8.621270e-08
I7429 n1_m1_340800_216000 0 1.352575e-07
I7430 n1_m1_340800_220800 0 9.667580e-08
I7431 n1_m1_340800_225600 0 1.610378e-07
I7432 n1_m1_340800_230400 0 9.220474e-08
I7433 n1_m1_340800_235200 0 9.498181e-08
I7434 n1_m1_340800_240000 0 2.000767e-07
I7435 n1_m1_340800_244800 0 2.043666e-07
I7436 n1_m1_340800_249600 0 2.340216e-07
I7437 n1_m1_340800_254400 0 1.073252e-07
I7438 n1_m1_340800_259200 0 8.960841e-08
I7439 n1_m1_340800_264000 0 1.320040e-07
I7440 n1_m1_340800_268800 0 9.205994e-08
I7441 n1_m1_340800_273600 0 1.496902e-07
I7442 n1_m1_340800_278400 0 1.088891e-07
I7443 n1_m1_340800_283200 0 1.697448e-07
I7444 n1_m1_340800_288000 0 3.954639e-07
I7445 n1_m1_340800_292800 0 1.784006e-07
I7446 n1_m1_340800_297600 0 1.396985e-07
I7447 n1_m1_340800_302400 0 8.837693e-08
I7448 n1_m1_340800_307200 0 8.845578e-08
I7449 n1_m1_340800_312000 0 1.668260e-07
I7450 n1_m1_340800_316800 0 2.238275e-07
I7451 n1_m1_340800_321600 0 2.416833e-07
I7452 n1_m1_340800_326400 0 8.215461e-08
I7453 n1_m1_340800_331200 0 8.549687e-08
I7454 n1_m1_340800_336000 0 1.348338e-07
I7455 n1_m1_340800_340800 0 8.462063e-08
I7456 n1_m1_340800_345600 0 1.268072e-07
I7457 n1_m1_340800_350400 0 8.391487e-08
I7458 n1_m1_340800_355200 0 9.738520e-08
I7459 n1_m1_340800_360000 0 2.608764e-07
I7460 n1_m1_340800_364800 0 1.796514e-07
I7461 n1_m1_340800_369600 0 1.599734e-07
I7462 n1_m1_340800_374400 0 9.616446e-08
I7463 n1_m1_340800_379200 0 1.729546e-07
I7464 n1_m1_340800_384000 0 5.758061e-07
I7465 n1_m1_340800_388800 0 5.197120e-07
I7466 n1_m1_340800_393600 0 4.025497e-07
I7467 n1_m1_340800_398400 0 8.353437e-08
I7468 n1_m1_340800_403200 0 8.699084e-08
I7469 n1_m1_340800_408000 0 2.065069e-07
I7470 n1_m1_340800_412800 0 2.611065e-07
I7471 n1_m1_340800_417600 0 2.199187e-07
I7472 n1_m1_340800_422400 0 9.840607e-08
I7473 n1_m1_340800_427200 0 9.391525e-08
I7474 n1_m1_340800_432000 0 2.420968e-07
I7475 n1_m1_340800_436800 0 1.180242e-07
I7476 n1_m1_340800_441600 0 1.330706e-07
I7477 n1_m1_340800_446400 0 8.474363e-08
I7478 n1_m1_340800_451200 0 8.587631e-08
I7479 n1_m1_340800_456000 0 1.257011e-07
I7480 n1_m1_340800_460800 0 8.219646e-08
I7481 n1_m1_340800_465600 0 1.398387e-07
I7482 n1_m1_340800_470400 0 1.024009e-07
I7483 n1_m1_340800_475200 0 9.585938e-08
I7484 n1_m1_340800_480000 0 1.326569e-07
I7485 n1_m1_340800_484800 0 8.255213e-08
I7486 n1_m1_340800_489600 0 1.154707e-07
I7487 n1_m1_340800_494400 0 7.384866e-08
I7488 n1_m1_345600_0 0 2.280432e-07
I7489 n1_m1_345600_4800 0 2.317445e-07
I7490 n1_m1_345600_9600 0 3.741673e-07
I7491 n1_m1_345600_14400 0 2.655282e-07
I7492 n1_m1_345600_19200 0 2.631708e-07
I7493 n1_m1_345600_24000 0 3.846671e-07
I7494 n1_m1_345600_28800 0 2.568135e-07
I7495 n1_m1_345600_33600 0 4.487187e-07
I7496 n1_m1_345600_38400 0 3.910051e-07
I7497 n1_m1_345600_43200 0 3.689621e-07
I7498 n1_m1_345600_48000 0 4.333144e-07
I7499 n1_m1_345600_52800 0 2.956708e-07
I7500 n1_m1_345600_57600 0 5.847478e-07
I7501 n1_m1_345600_62400 0 3.876787e-07
I7502 n1_m1_345600_67200 0 2.969191e-07
I7503 n1_m1_345600_72000 0 3.853704e-07
I7504 n1_m1_345600_76800 0 2.784467e-07
I7505 n1_m1_345600_81600 0 5.371073e-07
I7506 n1_m1_345600_86400 0 4.918207e-07
I7507 n1_m1_345600_91200 0 5.380095e-07
I7508 n1_m1_345600_96000 0 5.091097e-07
I7509 n1_m1_345600_100800 0 2.603276e-07
I7510 n1_m1_345600_105600 0 4.027835e-07
I7511 n1_m1_345600_110400 0 2.676575e-07
I7512 n1_m1_345600_115200 0 2.696359e-07
I7513 n1_m1_345600_120000 0 4.644385e-07
I7514 n1_m1_345600_124800 0 3.114268e-07
I7515 n1_m1_345600_129600 0 4.451850e-07
I7516 n1_m1_345600_134400 0 2.866455e-07
I7517 n1_m1_345600_139200 0 2.679086e-07
I7518 n1_m1_345600_144000 0 3.995480e-07
I7519 n1_m1_345600_148800 0 2.675643e-07
I7520 n1_m1_345600_153600 0 3.841717e-07
I7521 n1_m1_345600_158400 0 2.556411e-07
I7522 n1_m1_345600_163200 0 2.592512e-07
I7523 n1_m1_345600_168000 0 3.866441e-07
I7524 n1_m1_345600_172800 0 2.572133e-07
I7525 n1_m1_345600_177600 0 3.850691e-07
I7526 n1_m1_345600_182400 0 2.568233e-07
I7527 n1_m1_345600_187200 0 2.599313e-07
I7528 n1_m1_345600_192000 0 3.848483e-07
I7529 n1_m1_345600_196800 0 2.644182e-07
I7530 n1_m1_345600_201600 0 4.078268e-07
I7531 n1_m1_345600_206400 0 2.626946e-07
I7532 n1_m1_345600_211200 0 2.588602e-07
I7533 n1_m1_345600_216000 0 4.022016e-07
I7534 n1_m1_345600_220800 0 2.850076e-07
I7535 n1_m1_345600_225600 0 6.391972e-07
I7536 n1_m1_345600_230400 0 4.738688e-07
I7537 n1_m1_345600_235200 0 3.900762e-07
I7538 n1_m1_345600_240000 0 4.582572e-07
I7539 n1_m1_345600_244800 0 3.870677e-07
I7540 n1_m1_345600_249600 0 5.388094e-07
I7541 n1_m1_345600_254400 0 2.913626e-07
I7542 n1_m1_345600_259200 0 2.623684e-07
I7543 n1_m1_345600_264000 0 3.931678e-07
I7544 n1_m1_345600_268800 0 2.664516e-07
I7545 n1_m1_345600_273600 0 4.034636e-07
I7546 n1_m1_345600_278400 0 2.591319e-07
I7547 n1_m1_345600_283200 0 2.631672e-07
I7548 n1_m1_345600_288000 0 5.297730e-07
I7549 n1_m1_345600_292800 0 3.539595e-07
I7550 n1_m1_345600_297600 0 4.067300e-07
I7551 n1_m1_345600_302400 0 2.549245e-07
I7552 n1_m1_345600_307200 0 2.563573e-07
I7553 n1_m1_345600_312000 0 4.623310e-07
I7554 n1_m1_345600_316800 0 5.317050e-07
I7555 n1_m1_345600_321600 0 6.006192e-07
I7556 n1_m1_345600_326400 0 2.504590e-07
I7557 n1_m1_345600_331200 0 2.618544e-07
I7558 n1_m1_345600_336000 0 4.043435e-07
I7559 n1_m1_345600_340800 0 2.513566e-07
I7560 n1_m1_345600_345600 0 3.796860e-07
I7561 n1_m1_345600_350400 0 2.605484e-07
I7562 n1_m1_345600_355200 0 2.860619e-07
I7563 n1_m1_345600_360000 0 6.572433e-07
I7564 n1_m1_345600_364800 0 4.390622e-07
I7565 n1_m1_345600_369600 0 4.284717e-07
I7566 n1_m1_345600_374400 0 2.609105e-07
I7567 n1_m1_345600_379200 0 2.999372e-07
I7568 n1_m1_345600_384000 0 7.411339e-07
I7569 n1_m1_345600_388800 0 1.483363e-06
I7570 n1_m1_345600_393600 0 1.853873e-06
I7571 n1_m1_345600_398400 0 3.121976e-07
I7572 n1_m1_345600_403200 0 2.920045e-07
I7573 n1_m1_345600_408000 0 4.199805e-07
I7574 n1_m1_345600_412800 0 3.150435e-07
I7575 n1_m1_345600_417600 0 4.152251e-07
I7576 n1_m1_345600_422400 0 2.718287e-07
I7577 n1_m1_345600_427200 0 2.650348e-07
I7578 n1_m1_345600_432000 0 4.663883e-07
I7579 n1_m1_345600_436800 0 2.775941e-07
I7580 n1_m1_345600_441600 0 3.963944e-07
I7581 n1_m1_345600_446400 0 2.554770e-07
I7582 n1_m1_345600_451200 0 2.571190e-07
I7583 n1_m1_345600_456000 0 3.859010e-07
I7584 n1_m1_345600_460800 0 2.573879e-07
I7585 n1_m1_345600_465600 0 3.776924e-07
I7586 n1_m1_345600_470400 0 2.516226e-07
I7587 n1_m1_345600_475200 0 2.576897e-07
I7588 n1_m1_345600_480000 0 3.767258e-07
I7589 n1_m1_345600_484800 0 2.390727e-07
I7590 n1_m1_345600_489600 0 3.464625e-07
I7591 n1_m1_345600_494400 0 2.270294e-07
I7592 n1_m1_350400_0 0 1.496191e-07
I7593 n1_m1_350400_4800 0 1.551014e-07
I7594 n1_m1_350400_9600 0 2.517736e-07
I7595 n1_m1_350400_14400 0 1.737921e-07
I7596 n1_m1_350400_19200 0 1.730607e-07
I7597 n1_m1_350400_24000 0 2.541407e-07
I7598 n1_m1_350400_28800 0 1.751776e-07
I7599 n1_m1_350400_33600 0 2.627784e-07
I7600 n1_m1_350400_38400 0 1.690014e-07
I7601 n1_m1_350400_43200 0 1.701038e-07
I7602 n1_m1_350400_48000 0 2.630203e-07
I7603 n1_m1_350400_52800 0 1.771628e-07
I7604 n1_m1_350400_57600 0 2.573227e-07
I7605 n1_m1_350400_62400 0 1.721370e-07
I7606 n1_m1_350400_67200 0 1.707172e-07
I7607 n1_m1_350400_72000 0 2.602118e-07
I7608 n1_m1_350400_76800 0 1.761968e-07
I7609 n1_m1_350400_81600 0 2.703825e-07
I7610 n1_m1_350400_86400 0 1.877478e-07
I7611 n1_m1_350400_91200 0 2.017500e-07
I7612 n1_m1_350400_96000 0 3.078057e-07
I7613 n1_m1_350400_100800 0 1.773995e-07
I7614 n1_m1_350400_105600 0 2.730966e-07
I7615 n1_m1_350400_110400 0 1.934490e-07
I7616 n1_m1_350400_115200 0 2.078266e-07
I7617 n1_m1_350400_120000 0 3.902934e-07
I7618 n1_m1_350400_124800 0 4.054355e-07
I7619 n1_m1_350400_129600 0 6.504276e-07
I7620 n1_m1_350400_134400 0 3.976237e-07
I7621 n1_m1_350400_139200 0 2.989183e-07
I7622 n1_m1_350400_144000 0 3.466698e-07
I7623 n1_m1_350400_148800 0 2.230239e-07
I7624 n1_m1_350400_153600 0 2.983191e-07
I7625 n1_m1_350400_158400 0 2.002521e-07
I7626 n1_m1_350400_163200 0 1.913775e-07
I7627 n1_m1_350400_168000 0 2.758576e-07
I7628 n1_m1_350400_172800 0 1.841756e-07
I7629 n1_m1_350400_177600 0 2.730852e-07
I7630 n1_m1_350400_182400 0 1.875731e-07
I7631 n1_m1_350400_187200 0 2.197490e-07
I7632 n1_m1_350400_192000 0 3.054098e-07
I7633 n1_m1_350400_196800 0 1.841487e-07
I7634 n1_m1_350400_201600 0 2.707374e-07
I7635 n1_m1_350400_206400 0 1.751475e-07
I7636 n1_m1_350400_211200 0 1.745033e-07
I7637 n1_m1_350400_216000 0 2.716079e-07
I7638 n1_m1_350400_220800 0 2.030057e-07
I7639 n1_m1_350400_225600 0 3.896152e-07
I7640 n1_m1_350400_230400 0 2.927470e-07
I7641 n1_m1_350400_235200 0 2.450286e-07
I7642 n1_m1_350400_240000 0 2.745983e-07
I7643 n1_m1_350400_244800 0 1.702961e-07
I7644 n1_m1_350400_249600 0 2.552368e-07
I7645 n1_m1_350400_254400 0 1.741055e-07
I7646 n1_m1_350400_259200 0 1.739837e-07
I7647 n1_m1_350400_264000 0 2.599557e-07
I7648 n1_m1_350400_268800 0 1.685233e-07
I7649 n1_m1_350400_273600 0 2.515815e-07
I7650 n1_m1_350400_278400 0 1.701393e-07
I7651 n1_m1_350400_283200 0 1.703704e-07
I7652 n1_m1_350400_288000 0 2.562429e-07
I7653 n1_m1_350400_292800 0 1.711243e-07
I7654 n1_m1_350400_297600 0 2.612869e-07
I7655 n1_m1_350400_302400 0 1.746422e-07
I7656 n1_m1_350400_307200 0 1.723116e-07
I7657 n1_m1_350400_312000 0 2.579770e-07
I7658 n1_m1_350400_316800 0 1.882552e-07
I7659 n1_m1_350400_321600 0 2.672774e-07
I7660 n1_m1_350400_326400 0 1.677235e-07
I7661 n1_m1_350400_331200 0 1.721110e-07
I7662 n1_m1_350400_336000 0 2.573879e-07
I7663 n1_m1_350400_340800 0 1.664041e-07
I7664 n1_m1_350400_345600 0 2.752921e-07
I7665 n1_m1_350400_350400 0 2.130307e-07
I7666 n1_m1_350400_355200 0 1.847877e-07
I7667 n1_m1_350400_360000 0 2.628261e-07
I7668 n1_m1_350400_364800 0 1.744331e-07
I7669 n1_m1_350400_369600 0 2.515488e-07
I7670 n1_m1_350400_374400 0 1.868020e-07
I7671 n1_m1_350400_379200 0 2.505881e-07
I7672 n1_m1_350400_384000 0 3.259639e-07
I7673 n1_m1_350400_388800 0 7.359147e-07
I7674 n1_m1_350400_393600 0 1.276638e-06
I7675 n1_m1_350400_398400 0 4.710100e-07
I7676 n1_m1_350400_403200 0 3.352982e-07
I7677 n1_m1_350400_408000 0 2.664615e-07
I7678 n1_m1_350400_412800 0 1.776502e-07
I7679 n1_m1_350400_417600 0 2.505357e-07
I7680 n1_m1_350400_422400 0 2.034473e-07
I7681 n1_m1_350400_427200 0 2.008217e-07
I7682 n1_m1_350400_432000 0 2.544554e-07
I7683 n1_m1_350400_436800 0 2.025379e-07
I7684 n1_m1_350400_441600 0 4.177647e-07
I7685 n1_m1_350400_446400 0 2.635463e-07
I7686 n1_m1_350400_451200 0 2.041616e-07
I7687 n1_m1_350400_456000 0 2.579958e-07
I7688 n1_m1_350400_460800 0 1.638991e-07
I7689 n1_m1_350400_465600 0 2.432149e-07
I7690 n1_m1_350400_470400 0 1.660323e-07
I7691 n1_m1_350400_475200 0 1.671186e-07
I7692 n1_m1_350400_480000 0 2.399458e-07
I7693 n1_m1_350400_484800 0 1.537793e-07
I7694 n1_m1_350400_489600 0 2.291989e-07
I7695 n1_m1_350400_494400 0 1.530305e-07
I7696 n1_m1_355200_0 0 1.584096e-07
I7697 n1_m1_355200_4800 0 1.600732e-07
I7698 n1_m1_355200_9600 0 2.525159e-07
I7699 n1_m1_355200_14400 0 1.723516e-07
I7700 n1_m1_355200_19200 0 1.691810e-07
I7701 n1_m1_355200_24000 0 2.527730e-07
I7702 n1_m1_355200_28800 0 1.757694e-07
I7703 n1_m1_355200_33600 0 2.649560e-07
I7704 n1_m1_355200_38400 0 1.734496e-07
I7705 n1_m1_355200_43200 0 1.738971e-07
I7706 n1_m1_355200_48000 0 2.608109e-07
I7707 n1_m1_355200_52800 0 1.747572e-07
I7708 n1_m1_355200_57600 0 2.730705e-07
I7709 n1_m1_355200_62400 0 1.769086e-07
I7710 n1_m1_355200_67200 0 1.820673e-07
I7711 n1_m1_355200_72000 0 2.765958e-07
I7712 n1_m1_355200_76800 0 1.785426e-07
I7713 n1_m1_355200_81600 0 2.610982e-07
I7714 n1_m1_355200_86400 0 1.747244e-07
I7715 n1_m1_355200_91200 0 1.778417e-07
I7716 n1_m1_355200_96000 0 2.768065e-07
I7717 n1_m1_355200_100800 0 2.031322e-07
I7718 n1_m1_355200_105600 0 3.397831e-07
I7719 n1_m1_355200_110400 0 2.495847e-07
I7720 n1_m1_355200_115200 0 3.447964e-07
I7721 n1_m1_355200_120000 0 8.632347e-07
I7722 n1_m1_355200_124800 0 7.154918e-07
I7723 n1_m1_355200_129600 0 1.291457e-06
I7724 n1_m1_355200_134400 0 1.048381e-06
I7725 n1_m1_355200_139200 0 9.141081e-07
I7726 n1_m1_355200_144000 0 7.767198e-07
I7727 n1_m1_355200_148800 0 3.215527e-07
I7728 n1_m1_355200_153600 0 4.575170e-07
I7729 n1_m1_355200_158400 0 3.155351e-07
I7730 n1_m1_355200_163200 0 2.492149e-07
I7731 n1_m1_355200_168000 0 3.314908e-07
I7732 n1_m1_355200_172800 0 2.094162e-07
I7733 n1_m1_355200_177600 0 3.245278e-07
I7734 n1_m1_355200_182400 0 2.567800e-07
I7735 n1_m1_355200_187200 0 4.895106e-07
I7736 n1_m1_355200_192000 0 6.547776e-07
I7737 n1_m1_355200_196800 0 2.683908e-07
I7738 n1_m1_355200_201600 0 2.766986e-07
I7739 n1_m1_355200_206400 0 1.759720e-07
I7740 n1_m1_355200_211200 0 1.927682e-07
I7741 n1_m1_355200_216000 0 3.273569e-07
I7742 n1_m1_355200_220800 0 2.130120e-07
I7743 n1_m1_355200_225600 0 3.319816e-07
I7744 n1_m1_355200_230400 0 2.131994e-07
I7745 n1_m1_355200_235200 0 1.878550e-07
I7746 n1_m1_355200_240000 0 2.616902e-07
I7747 n1_m1_355200_244800 0 1.798111e-07
I7748 n1_m1_355200_249600 0 2.564072e-07
I7749 n1_m1_355200_254400 0 1.749536e-07
I7750 n1_m1_355200_259200 0 1.787446e-07
I7751 n1_m1_355200_264000 0 2.619072e-07
I7752 n1_m1_355200_268800 0 1.676613e-07
I7753 n1_m1_355200_273600 0 2.531566e-07
I7754 n1_m1_355200_278400 0 1.723587e-07
I7755 n1_m1_355200_283200 0 1.699032e-07
I7756 n1_m1_355200_288000 0 2.511228e-07
I7757 n1_m1_355200_292800 0 1.683526e-07
I7758 n1_m1_355200_297600 0 2.669482e-07
I7759 n1_m1_355200_302400 0 2.003875e-07
I7760 n1_m1_355200_307200 0 2.251107e-07
I7761 n1_m1_355200_312000 0 2.761339e-07
I7762 n1_m1_355200_316800 0 1.676689e-07
I7763 n1_m1_355200_321600 0 2.555258e-07
I7764 n1_m1_355200_326400 0 1.721836e-07
I7765 n1_m1_355200_331200 0 1.675496e-07
I7766 n1_m1_355200_336000 0 2.436919e-07
I7767 n1_m1_355200_340800 0 1.664610e-07
I7768 n1_m1_355200_345600 0 3.164454e-07
I7769 n1_m1_355200_350400 0 2.631154e-07
I7770 n1_m1_355200_355200 0 1.941879e-07
I7771 n1_m1_355200_360000 0 2.450387e-07
I7772 n1_m1_355200_364800 0 1.644353e-07
I7773 n1_m1_355200_369600 0 2.601495e-07
I7774 n1_m1_355200_374400 0 1.896477e-07
I7775 n1_m1_355200_379200 0 1.793937e-07
I7776 n1_m1_355200_384000 0 3.360323e-07
I7777 n1_m1_355200_388800 0 4.940916e-07
I7778 n1_m1_355200_393600 0 1.549621e-06
I7779 n1_m1_355200_398400 0 1.160159e-06
I7780 n1_m1_355200_403200 0 7.845045e-07
I7781 n1_m1_355200_408000 0 2.950836e-07
I7782 n1_m1_355200_412800 0 1.795553e-07
I7783 n1_m1_355200_417600 0 2.627179e-07
I7784 n1_m1_355200_422400 0 1.805168e-07
I7785 n1_m1_355200_427200 0 1.764172e-07
I7786 n1_m1_355200_432000 0 2.771503e-07
I7787 n1_m1_355200_436800 0 3.676863e-07
I7788 n1_m1_355200_441600 0 1.214500e-06
I7789 n1_m1_355200_446400 0 8.207482e-07
I7790 n1_m1_355200_451200 0 4.876749e-07
I7791 n1_m1_355200_456000 0 3.407296e-07
I7792 n1_m1_355200_460800 0 1.710770e-07
I7793 n1_m1_355200_465600 0 2.507855e-07
I7794 n1_m1_355200_470400 0 1.728251e-07
I7795 n1_m1_355200_475200 0 1.682705e-07
I7796 n1_m1_355200_480000 0 2.394910e-07
I7797 n1_m1_355200_484800 0 1.532282e-07
I7798 n1_m1_355200_489600 0 2.249809e-07
I7799 n1_m1_355200_494400 0 1.517342e-07
I7800 n1_m1_360000_0 0 2.335165e-07
I7801 n1_m1_360000_4800 0 2.373155e-07
I7802 n1_m1_360000_9600 0 3.709318e-07
I7803 n1_m1_360000_14400 0 2.505844e-07
I7804 n1_m1_360000_19200 0 2.501002e-07
I7805 n1_m1_360000_24000 0 4.101974e-07
I7806 n1_m1_360000_28800 0 4.278241e-07
I7807 n1_m1_360000_33600 0 8.964638e-07
I7808 n1_m1_360000_38400 0 3.214347e-07
I7809 n1_m1_360000_43200 0 2.712265e-07
I7810 n1_m1_360000_48000 0 3.966579e-07
I7811 n1_m1_360000_52800 0 2.581219e-07
I7812 n1_m1_360000_57600 0 3.928788e-07
I7813 n1_m1_360000_62400 0 2.668039e-07
I7814 n1_m1_360000_67200 0 2.808728e-07
I7815 n1_m1_360000_72000 0 6.294499e-07
I7816 n1_m1_360000_76800 0 5.095644e-07
I7817 n1_m1_360000_81600 0 6.239131e-07
I7818 n1_m1_360000_86400 0 3.010614e-07
I7819 n1_m1_360000_91200 0 3.006389e-07
I7820 n1_m1_360000_96000 0 4.804611e-07
I7821 n1_m1_360000_100800 0 4.021809e-07
I7822 n1_m1_360000_105600 0 5.253995e-07
I7823 n1_m1_360000_110400 0 3.329703e-07
I7824 n1_m1_360000_115200 0 6.883983e-07
I7825 n1_m1_360000_120000 0 2.273574e-06
I7826 n1_m1_360000_124800 0 1.649522e-06
I7827 n1_m1_360000_129600 0 1.944217e-06
I7828 n1_m1_360000_134400 0 1.261885e-06
I7829 n1_m1_360000_139200 0 1.153623e-06
I7830 n1_m1_360000_144000 0 9.336009e-07
I7831 n1_m1_360000_148800 0 3.903022e-07
I7832 n1_m1_360000_153600 0 6.895134e-07
I7833 n1_m1_360000_158400 0 4.404421e-07
I7834 n1_m1_360000_163200 0 4.168817e-07
I7835 n1_m1_360000_168000 0 7.787874e-07
I7836 n1_m1_360000_172800 0 5.186217e-07
I7837 n1_m1_360000_177600 0 6.486699e-07
I7838 n1_m1_360000_182400 0 4.621235e-07
I7839 n1_m1_360000_187200 0 8.600511e-07
I7840 n1_m1_360000_192000 0 1.407200e-06
I7841 n1_m1_360000_196800 0 6.793025e-07
I7842 n1_m1_360000_201600 0 5.206635e-07
I7843 n1_m1_360000_206400 0 2.748290e-07
I7844 n1_m1_360000_211200 0 3.549886e-07
I7845 n1_m1_360000_216000 0 6.066601e-07
I7846 n1_m1_360000_220800 0 3.005118e-07
I7847 n1_m1_360000_225600 0 7.705031e-07
I7848 n1_m1_360000_230400 0 5.382955e-07
I7849 n1_m1_360000_235200 0 3.513456e-07
I7850 n1_m1_360000_240000 0 3.960487e-07
I7851 n1_m1_360000_244800 0 2.609236e-07
I7852 n1_m1_360000_249600 0 3.883877e-07
I7853 n1_m1_360000_254400 0 2.581015e-07
I7854 n1_m1_360000_259200 0 2.595406e-07
I7855 n1_m1_360000_264000 0 3.747246e-07
I7856 n1_m1_360000_268800 0 2.500270e-07
I7857 n1_m1_360000_273600 0 3.874009e-07
I7858 n1_m1_360000_278400 0 2.554998e-07
I7859 n1_m1_360000_283200 0 2.547910e-07
I7860 n1_m1_360000_288000 0 3.885987e-07
I7861 n1_m1_360000_292800 0 2.591880e-07
I7862 n1_m1_360000_297600 0 4.052459e-07
I7863 n1_m1_360000_302400 0 4.324574e-07
I7864 n1_m1_360000_307200 0 6.472081e-07
I7865 n1_m1_360000_312000 0 5.388372e-07
I7866 n1_m1_360000_316800 0 2.577183e-07
I7867 n1_m1_360000_321600 0 3.891136e-07
I7868 n1_m1_360000_326400 0 2.566424e-07
I7869 n1_m1_360000_331200 0 2.467203e-07
I7870 n1_m1_360000_336000 0 3.722779e-07
I7871 n1_m1_360000_340800 0 2.596190e-07
I7872 n1_m1_360000_345600 0 4.243939e-07
I7873 n1_m1_360000_350400 0 3.176329e-07
I7874 n1_m1_360000_355200 0 2.695460e-07
I7875 n1_m1_360000_360000 0 3.721715e-07
I7876 n1_m1_360000_364800 0 2.495052e-07
I7877 n1_m1_360000_369600 0 3.926347e-07
I7878 n1_m1_360000_374400 0 3.461369e-07
I7879 n1_m1_360000_379200 0 4.358514e-07
I7880 n1_m1_360000_384000 0 6.784228e-07
I7881 n1_m1_360000_388800 0 4.012488e-07
I7882 n1_m1_360000_393600 0 1.878635e-06
I7883 n1_m1_360000_398400 0 2.031505e-06
I7884 n1_m1_360000_403200 0 1.850594e-06
I7885 n1_m1_360000_408000 0 1.084372e-06
I7886 n1_m1_360000_412800 0 2.775003e-07
I7887 n1_m1_360000_417600 0 4.106902e-07
I7888 n1_m1_360000_422400 0 2.604098e-07
I7889 n1_m1_360000_427200 0 2.513465e-07
I7890 n1_m1_360000_432000 0 4.684566e-07
I7891 n1_m1_360000_436800 0 5.598152e-07
I7892 n1_m1_360000_441600 0 1.706019e-06
I7893 n1_m1_360000_446400 0 1.212762e-06
I7894 n1_m1_360000_451200 0 8.688771e-07
I7895 n1_m1_360000_456000 0 7.527739e-07
I7896 n1_m1_360000_460800 0 2.766258e-07
I7897 n1_m1_360000_465600 0 3.905405e-07
I7898 n1_m1_360000_470400 0 2.688224e-07
I7899 n1_m1_360000_475200 0 2.634901e-07
I7900 n1_m1_360000_480000 0 3.735107e-07
I7901 n1_m1_360000_484800 0 2.319607e-07
I7902 n1_m1_360000_489600 0 3.360162e-07
I7903 n1_m1_360000_494400 0 2.245802e-07
I7904 n1_m1_364800_0 0 1.444658e-07
I7905 n1_m1_364800_4800 0 1.502668e-07
I7906 n1_m1_364800_9600 0 2.427502e-07
I7907 n1_m1_364800_14400 0 1.688874e-07
I7908 n1_m1_364800_19200 0 1.703650e-07
I7909 n1_m1_364800_24000 0 3.383510e-07
I7910 n1_m1_364800_28800 0 5.187173e-07
I7911 n1_m1_364800_33600 0 1.296277e-06
I7912 n1_m1_364800_38400 0 3.085032e-07
I7913 n1_m1_364800_43200 0 1.804658e-07
I7914 n1_m1_364800_48000 0 2.635026e-07
I7915 n1_m1_364800_52800 0 2.184164e-07
I7916 n1_m1_364800_57600 0 4.885713e-07
I7917 n1_m1_364800_62400 0 2.276313e-07
I7918 n1_m1_364800_67200 0 3.095081e-07
I7919 n1_m1_364800_72000 0 1.093193e-06
I7920 n1_m1_364800_76800 0 9.888055e-07
I7921 n1_m1_364800_81600 0 1.098248e-06
I7922 n1_m1_364800_86400 0 3.096304e-07
I7923 n1_m1_364800_91200 0 2.278398e-07
I7924 n1_m1_364800_96000 0 4.632706e-07
I7925 n1_m1_364800_100800 0 3.541458e-07
I7926 n1_m1_364800_105600 0 4.143438e-07
I7927 n1_m1_364800_110400 0 1.836910e-07
I7928 n1_m1_364800_115200 0 2.641406e-07
I7929 n1_m1_364800_120000 0 8.971100e-07
I7930 n1_m1_364800_124800 0 8.289260e-07
I7931 n1_m1_364800_129600 0 7.497409e-07
I7932 n1_m1_364800_134400 0 3.173799e-07
I7933 n1_m1_364800_139200 0 2.956624e-07
I7934 n1_m1_364800_144000 0 3.435340e-07
I7935 n1_m1_364800_148800 0 2.303307e-07
I7936 n1_m1_364800_153600 0 3.506149e-07
I7937 n1_m1_364800_158400 0 1.733212e-07
I7938 n1_m1_364800_163200 0 1.914756e-07
I7939 n1_m1_364800_168000 0 4.951734e-07
I7940 n1_m1_364800_172800 0 3.452847e-07
I7941 n1_m1_364800_177600 0 3.321546e-07
I7942 n1_m1_364800_182400 0 2.104681e-07
I7943 n1_m1_364800_187200 0 2.587105e-07
I7944 n1_m1_364800_192000 0 4.826137e-07
I7945 n1_m1_364800_196800 0 3.025542e-07
I7946 n1_m1_364800_201600 0 3.013211e-07
I7947 n1_m1_364800_206400 0 1.742587e-07
I7948 n1_m1_364800_211200 0 1.816712e-07
I7949 n1_m1_364800_216000 0 2.996561e-07
I7950 n1_m1_364800_220800 0 2.402590e-07
I7951 n1_m1_364800_225600 0 5.455691e-07
I7952 n1_m1_364800_230400 0 3.482871e-07
I7953 n1_m1_364800_235200 0 2.289592e-07
I7954 n1_m1_364800_240000 0 2.723599e-07
I7955 n1_m1_364800_244800 0 1.836188e-07
I7956 n1_m1_364800_249600 0 2.598416e-07
I7957 n1_m1_364800_254400 0 1.627397e-07
I7958 n1_m1_364800_259200 0 1.618071e-07
I7959 n1_m1_364800_264000 0 2.402568e-07
I7960 n1_m1_364800_268800 0 1.655753e-07
I7961 n1_m1_364800_273600 0 2.536307e-07
I7962 n1_m1_364800_278400 0 1.680686e-07
I7963 n1_m1_364800_283200 0 1.698566e-07
I7964 n1_m1_364800_288000 0 2.598217e-07
I7965 n1_m1_364800_292800 0 1.732144e-07
I7966 n1_m1_364800_297600 0 2.656088e-07
I7967 n1_m1_364800_302400 0 2.874925e-07
I7968 n1_m1_364800_307200 0 4.624403e-07
I7969 n1_m1_364800_312000 0 5.204187e-07
I7970 n1_m1_364800_316800 0 2.316586e-07
I7971 n1_m1_364800_321600 0 2.596735e-07
I7972 n1_m1_364800_326400 0 1.673147e-07
I7973 n1_m1_364800_331200 0 1.695573e-07
I7974 n1_m1_364800_336000 0 2.562558e-07
I7975 n1_m1_364800_340800 0 1.684123e-07
I7976 n1_m1_364800_345600 0 2.503168e-07
I7977 n1_m1_364800_350400 0 1.686326e-07
I7978 n1_m1_364800_355200 0 1.632201e-07
I7979 n1_m1_364800_360000 0 2.437840e-07
I7980 n1_m1_364800_364800 0 1.665524e-07
I7981 n1_m1_364800_369600 0 2.432057e-07
I7982 n1_m1_364800_374400 0 1.921430e-07
I7983 n1_m1_364800_379200 0 3.074432e-07
I7984 n1_m1_364800_384000 0 4.255183e-07
I7985 n1_m1_364800_388800 0 2.905327e-07
I7986 n1_m1_364800_393600 0 6.327006e-07
I7987 n1_m1_364800_398400 0 8.280675e-07
I7988 n1_m1_364800_403200 0 1.166646e-06
I7989 n1_m1_364800_408000 0 1.182765e-06
I7990 n1_m1_364800_412800 0 2.242415e-07
I7991 n1_m1_364800_417600 0 2.646274e-07
I7992 n1_m1_364800_422400 0 1.712316e-07
I7993 n1_m1_364800_427200 0 1.732144e-07
I7994 n1_m1_364800_432000 0 2.748798e-07
I7995 n1_m1_364800_436800 0 1.965373e-07
I7996 n1_m1_364800_441600 0 3.763479e-07
I7997 n1_m1_364800_446400 0 2.747257e-07
I7998 n1_m1_364800_451200 0 2.897982e-07
I7999 n1_m1_364800_456000 0 4.444890e-07
I8000 n1_m1_364800_460800 0 1.852557e-07
I8001 n1_m1_364800_465600 0 2.549440e-07
I8002 n1_m1_364800_470400 0 1.723929e-07
I8003 n1_m1_364800_475200 0 1.751333e-07
I8004 n1_m1_364800_480000 0 2.552043e-07
I8005 n1_m1_364800_484800 0 1.571211e-07
I8006 n1_m1_364800_489600 0 2.271530e-07
I8007 n1_m1_364800_494400 0 1.503787e-07
I8008 n1_m1_369600_0 0 1.539907e-07
I8009 n1_m1_369600_4800 0 1.591073e-07
I8010 n1_m1_369600_9600 0 2.506021e-07
I8011 n1_m1_369600_14400 0 1.695194e-07
I8012 n1_m1_369600_19200 0 1.714353e-07
I8013 n1_m1_369600_24000 0 3.207894e-07
I8014 n1_m1_369600_28800 0 3.675813e-07
I8015 n1_m1_369600_33600 0 6.533199e-07
I8016 n1_m1_369600_38400 0 2.330768e-07
I8017 n1_m1_369600_43200 0 1.871320e-07
I8018 n1_m1_369600_48000 0 2.626676e-07
I8019 n1_m1_369600_52800 0 1.909985e-07
I8020 n1_m1_369600_57600 0 5.163859e-07
I8021 n1_m1_369600_62400 0 5.688542e-07
I8022 n1_m1_369600_67200 0 5.984444e-07
I8023 n1_m1_369600_72000 0 1.481545e-06
I8024 n1_m1_369600_76800 0 1.243207e-06
I8025 n1_m1_369600_81600 0 1.497955e-06
I8026 n1_m1_369600_86400 0 4.753576e-07
I8027 n1_m1_369600_91200 0 4.134284e-07
I8028 n1_m1_369600_96000 0 7.592464e-07
I8029 n1_m1_369600_100800 0 3.155044e-07
I8030 n1_m1_369600_105600 0 3.133957e-07
I8031 n1_m1_369600_110400 0 1.779635e-07
I8032 n1_m1_369600_115200 0 1.736636e-07
I8033 n1_m1_369600_120000 0 2.812942e-07
I8034 n1_m1_369600_124800 0 2.066085e-07
I8035 n1_m1_369600_129600 0 2.862996e-07
I8036 n1_m1_369600_134400 0 1.816569e-07
I8037 n1_m1_369600_139200 0 1.724644e-07
I8038 n1_m1_369600_144000 0 2.603334e-07
I8039 n1_m1_369600_148800 0 1.821306e-07
I8040 n1_m1_369600_153600 0 2.643759e-07
I8041 n1_m1_369600_158400 0 1.793964e-07
I8042 n1_m1_369600_163200 0 1.949059e-07
I8043 n1_m1_369600_168000 0 3.581407e-07
I8044 n1_m1_369600_172800 0 2.154419e-07
I8045 n1_m1_369600_177600 0 2.608067e-07
I8046 n1_m1_369600_182400 0 1.807551e-07
I8047 n1_m1_369600_187200 0 1.709797e-07
I8048 n1_m1_369600_192000 0 2.745506e-07
I8049 n1_m1_369600_196800 0 1.838387e-07
I8050 n1_m1_369600_201600 0 2.677876e-07
I8051 n1_m1_369600_206400 0 1.854410e-07
I8052 n1_m1_369600_211200 0 1.956921e-07
I8053 n1_m1_369600_216000 0 3.269489e-07
I8054 n1_m1_369600_220800 0 2.349137e-07
I8055 n1_m1_369600_225600 0 3.414697e-07
I8056 n1_m1_369600_230400 0 2.413665e-07
I8057 n1_m1_369600_235200 0 2.394394e-07
I8058 n1_m1_369600_240000 0 3.125645e-07
I8059 n1_m1_369600_244800 0 1.874066e-07
I8060 n1_m1_369600_249600 0 2.613367e-07
I8061 n1_m1_369600_254400 0 1.654637e-07
I8062 n1_m1_369600_259200 0 1.627478e-07
I8063 n1_m1_369600_264000 0 2.505178e-07
I8064 n1_m1_369600_268800 0 1.716690e-07
I8065 n1_m1_369600_273600 0 2.547373e-07
I8066 n1_m1_369600_278400 0 1.682097e-07
I8067 n1_m1_369600_283200 0 1.692827e-07
I8068 n1_m1_369600_288000 0 2.505409e-07
I8069 n1_m1_369600_292800 0 1.672273e-07
I8070 n1_m1_369600_297600 0 2.555970e-07
I8071 n1_m1_369600_302400 0 2.112428e-07
I8072 n1_m1_369600_307200 0 3.001100e-07
I8073 n1_m1_369600_312000 0 8.346495e-07
I8074 n1_m1_369600_316800 0 3.811670e-07
I8075 n1_m1_369600_321600 0 2.595185e-07
I8076 n1_m1_369600_326400 0 1.620410e-07
I8077 n1_m1_369600_331200 0 1.722578e-07
I8078 n1_m1_369600_336000 0 2.495351e-07
I8079 n1_m1_369600_340800 0 1.621489e-07
I8080 n1_m1_369600_345600 0 2.467458e-07
I8081 n1_m1_369600_350400 0 1.659260e-07
I8082 n1_m1_369600_355200 0 1.618194e-07
I8083 n1_m1_369600_360000 0 2.446435e-07
I8084 n1_m1_369600_364800 0 1.658442e-07
I8085 n1_m1_369600_369600 0 2.466882e-07
I8086 n1_m1_369600_374400 0 1.790677e-07
I8087 n1_m1_369600_379200 0 1.640290e-07
I8088 n1_m1_369600_384000 0 2.891881e-07
I8089 n1_m1_369600_388800 0 1.882820e-07
I8090 n1_m1_369600_393600 0 2.611363e-07
I8091 n1_m1_369600_398400 0 2.647647e-07
I8092 n1_m1_369600_403200 0 6.622622e-07
I8093 n1_m1_369600_408000 0 1.150455e-06
I8094 n1_m1_369600_412800 0 3.112759e-07
I8095 n1_m1_369600_417600 0 3.344890e-07
I8096 n1_m1_369600_422400 0 1.697496e-07
I8097 n1_m1_369600_427200 0 1.706998e-07
I8098 n1_m1_369600_432000 0 2.487449e-07
I8099 n1_m1_369600_436800 0 1.710787e-07
I8100 n1_m1_369600_441600 0 2.509851e-07
I8101 n1_m1_369600_446400 0 1.737560e-07
I8102 n1_m1_369600_451200 0 1.834489e-07
I8103 n1_m1_369600_456000 0 2.683398e-07
I8104 n1_m1_369600_460800 0 1.619984e-07
I8105 n1_m1_369600_465600 0 2.399329e-07
I8106 n1_m1_369600_470400 0 1.593292e-07
I8107 n1_m1_369600_475200 0 1.634359e-07
I8108 n1_m1_369600_480000 0 2.464605e-07
I8109 n1_m1_369600_484800 0 1.613477e-07
I8110 n1_m1_369600_489600 0 2.325954e-07
I8111 n1_m1_369600_494400 0 1.532282e-07
I8112 n1_m1_374400_0 0 1.532673e-07
I8113 n1_m1_374400_4800 0 1.569116e-07
I8114 n1_m1_374400_9600 0 2.421437e-07
I8115 n1_m1_374400_14400 0 1.684005e-07
I8116 n1_m1_374400_19200 0 1.712679e-07
I8117 n1_m1_374400_24000 0 2.678907e-07
I8118 n1_m1_374400_28800 0 1.931206e-07
I8119 n1_m1_374400_33600 0 3.018893e-07
I8120 n1_m1_374400_38400 0 1.828558e-07
I8121 n1_m1_374400_43200 0 1.753160e-07
I8122 n1_m1_374400_48000 0 2.621888e-07
I8123 n1_m1_374400_52800 0 1.887432e-07
I8124 n1_m1_374400_57600 0 3.478422e-07
I8125 n1_m1_374400_62400 0 2.376289e-07
I8126 n1_m1_374400_67200 0 2.151919e-07
I8127 n1_m1_374400_72000 0 6.071342e-07
I8128 n1_m1_374400_76800 0 7.378594e-07
I8129 n1_m1_374400_81600 0 8.878112e-07
I8130 n1_m1_374400_86400 0 2.534463e-07
I8131 n1_m1_374400_91200 0 2.157087e-07
I8132 n1_m1_374400_96000 0 4.277493e-07
I8133 n1_m1_374400_100800 0 2.415829e-07
I8134 n1_m1_374400_105600 0 2.906491e-07
I8135 n1_m1_374400_110400 0 1.756836e-07
I8136 n1_m1_374400_115200 0 1.718834e-07
I8137 n1_m1_374400_120000 0 2.565162e-07
I8138 n1_m1_374400_124800 0 1.965498e-07
I8139 n1_m1_374400_129600 0 2.600828e-07
I8140 n1_m1_374400_134400 0 1.745830e-07
I8141 n1_m1_374400_139200 0 1.783235e-07
I8142 n1_m1_374400_144000 0 2.610029e-07
I8143 n1_m1_374400_148800 0 1.722639e-07
I8144 n1_m1_374400_153600 0 2.677733e-07
I8145 n1_m1_374400_158400 0 1.779675e-07
I8146 n1_m1_374400_163200 0 2.597714e-07
I8147 n1_m1_374400_168000 0 4.437951e-07
I8148 n1_m1_374400_172800 0 2.033511e-07
I8149 n1_m1_374400_177600 0 2.609461e-07
I8150 n1_m1_374400_182400 0 1.749114e-07
I8151 n1_m1_374400_187200 0 1.696527e-07
I8152 n1_m1_374400_192000 0 2.822542e-07
I8153 n1_m1_374400_196800 0 1.813881e-07
I8154 n1_m1_374400_201600 0 3.037104e-07
I8155 n1_m1_374400_206400 0 1.932286e-07
I8156 n1_m1_374400_211200 0 2.159875e-07
I8157 n1_m1_374400_216000 0 5.271889e-07
I8158 n1_m1_374400_220800 0 3.866817e-07
I8159 n1_m1_374400_225600 0 3.397123e-07
I8160 n1_m1_374400_230400 0 2.074303e-07
I8161 n1_m1_374400_235200 0 2.952089e-07
I8162 n1_m1_374400_240000 0 4.145039e-07
I8163 n1_m1_374400_244800 0 2.051693e-07
I8164 n1_m1_374400_249600 0 2.671995e-07
I8165 n1_m1_374400_254400 0 1.712382e-07
I8166 n1_m1_374400_259200 0 1.671913e-07
I8167 n1_m1_374400_264000 0 2.540868e-07
I8168 n1_m1_374400_268800 0 1.714322e-07
I8169 n1_m1_374400_273600 0 2.488761e-07
I8170 n1_m1_374400_278400 0 1.647196e-07
I8171 n1_m1_374400_283200 0 1.674154e-07
I8172 n1_m1_374400_288000 0 2.498285e-07
I8173 n1_m1_374400_292800 0 1.673525e-07
I8174 n1_m1_374400_297600 0 2.578925e-07
I8175 n1_m1_374400_302400 0 1.756414e-07
I8176 n1_m1_374400_307200 0 1.815885e-07
I8177 n1_m1_374400_312000 0 8.409533e-07
I8178 n1_m1_374400_316800 0 3.466905e-07
I8179 n1_m1_374400_321600 0 2.587143e-07
I8180 n1_m1_374400_326400 0 1.683312e-07
I8181 n1_m1_374400_331200 0 1.636408e-07
I8182 n1_m1_374400_336000 0 2.443955e-07
I8183 n1_m1_374400_340800 0 1.683292e-07
I8184 n1_m1_374400_345600 0 2.497468e-07
I8185 n1_m1_374400_350400 0 1.674973e-07
I8186 n1_m1_374400_355200 0 1.662170e-07
I8187 n1_m1_374400_360000 0 2.476185e-07
I8188 n1_m1_374400_364800 0 1.631503e-07
I8189 n1_m1_374400_369600 0 2.435559e-07
I8190 n1_m1_374400_374400 0 1.639688e-07
I8191 n1_m1_374400_379200 0 1.671102e-07
I8192 n1_m1_374400_384000 0 2.518970e-07
I8193 n1_m1_374400_388800 0 1.623576e-07
I8194 n1_m1_374400_393600 0 2.508569e-07
I8195 n1_m1_374400_398400 0 1.895128e-07
I8196 n1_m1_374400_403200 0 3.824140e-07
I8197 n1_m1_374400_408000 0 8.038112e-07
I8198 n1_m1_374400_412800 0 2.331678e-07
I8199 n1_m1_374400_417600 0 2.660718e-07
I8200 n1_m1_374400_422400 0 1.711342e-07
I8201 n1_m1_374400_427200 0 1.723445e-07
I8202 n1_m1_374400_432000 0 2.550402e-07
I8203 n1_m1_374400_436800 0 1.671249e-07
I8204 n1_m1_374400_441600 0 2.490313e-07
I8205 n1_m1_374400_446400 0 1.657158e-07
I8206 n1_m1_374400_451200 0 1.628923e-07
I8207 n1_m1_374400_456000 0 2.410228e-07
I8208 n1_m1_374400_460800 0 1.598941e-07
I8209 n1_m1_374400_465600 0 2.349671e-07
I8210 n1_m1_374400_470400 0 1.536236e-07
I8211 n1_m1_374400_475200 0 1.539122e-07
I8212 n1_m1_374400_480000 0 2.309860e-07
I8213 n1_m1_374400_484800 0 1.538322e-07
I8214 n1_m1_374400_489600 0 2.301973e-07
I8215 n1_m1_374400_494400 0 1.542171e-07
I8216 n1_m1_379200_0 0 1.472938e-07
I8217 n1_m1_379200_4800 0 1.491226e-07
I8218 n1_m1_379200_9600 0 2.337044e-07
I8219 n1_m1_379200_14400 0 1.603540e-07
I8220 n1_m1_379200_19200 0 1.645487e-07
I8221 n1_m1_379200_24000 0 2.516844e-07
I8222 n1_m1_379200_28800 0 1.720976e-07
I8223 n1_m1_379200_33600 0 2.598228e-07
I8224 n1_m1_379200_38400 0 1.735650e-07
I8225 n1_m1_379200_43200 0 1.732316e-07
I8226 n1_m1_379200_48000 0 2.598240e-07
I8227 n1_m1_379200_52800 0 1.817615e-07
I8228 n1_m1_379200_57600 0 3.131422e-07
I8229 n1_m1_379200_62400 0 1.871719e-07
I8230 n1_m1_379200_67200 0 1.675032e-07
I8231 n1_m1_379200_72000 0 2.734299e-07
I8232 n1_m1_379200_76800 0 2.453431e-07
I8233 n1_m1_379200_81600 0 3.223049e-07
I8234 n1_m1_379200_86400 0 1.728928e-07
I8235 n1_m1_379200_91200 0 1.748538e-07
I8236 n1_m1_379200_96000 0 2.773744e-07
I8237 n1_m1_379200_100800 0 1.766374e-07
I8238 n1_m1_379200_105600 0 2.580632e-07
I8239 n1_m1_379200_110400 0 1.670450e-07
I8240 n1_m1_379200_115200 0 1.672891e-07
I8241 n1_m1_379200_120000 0 2.524492e-07
I8242 n1_m1_379200_124800 0 1.720068e-07
I8243 n1_m1_379200_129600 0 2.623766e-07
I8244 n1_m1_379200_134400 0 1.942333e-07
I8245 n1_m1_379200_139200 0 1.920566e-07
I8246 n1_m1_379200_144000 0 2.562942e-07
I8247 n1_m1_379200_148800 0 1.813375e-07
I8248 n1_m1_379200_153600 0 3.021652e-07
I8249 n1_m1_379200_158400 0 1.740007e-07
I8250 n1_m1_379200_163200 0 1.741345e-07
I8251 n1_m1_379200_168000 0 2.666362e-07
I8252 n1_m1_379200_172800 0 1.734230e-07
I8253 n1_m1_379200_177600 0 2.624971e-07
I8254 n1_m1_379200_182400 0 1.778727e-07
I8255 n1_m1_379200_187200 0 1.693172e-07
I8256 n1_m1_379200_192000 0 2.561517e-07
I8257 n1_m1_379200_196800 0 2.001888e-07
I8258 n1_m1_379200_201600 0 5.438457e-07
I8259 n1_m1_379200_206400 0 3.800041e-07
I8260 n1_m1_379200_211200 0 3.371156e-07
I8261 n1_m1_379200_216000 0 5.192117e-07
I8262 n1_m1_379200_220800 0 2.526257e-07
I8263 n1_m1_379200_225600 0 3.662607e-07
I8264 n1_m1_379200_230400 0 2.972824e-07
I8265 n1_m1_379200_235200 0 3.250919e-07
I8266 n1_m1_379200_240000 0 4.320260e-07
I8267 n1_m1_379200_244800 0 2.499659e-07
I8268 n1_m1_379200_249600 0 2.810487e-07
I8269 n1_m1_379200_254400 0 1.759778e-07
I8270 n1_m1_379200_259200 0 1.732235e-07
I8271 n1_m1_379200_264000 0 2.509929e-07
I8272 n1_m1_379200_268800 0 1.668177e-07
I8273 n1_m1_379200_273600 0 2.510028e-07
I8274 n1_m1_379200_278400 0 1.708980e-07
I8275 n1_m1_379200_283200 0 1.697652e-07
I8276 n1_m1_379200_288000 0 2.498285e-07
I8277 n1_m1_379200_292800 0 1.665988e-07
I8278 n1_m1_379200_297600 0 2.532482e-07
I8279 n1_m1_379200_302400 0 1.726966e-07
I8280 n1_m1_379200_307200 0 1.732144e-07
I8281 n1_m1_379200_312000 0 3.137754e-07
I8282 n1_m1_379200_316800 0 1.809298e-07
I8283 n1_m1_379200_321600 0 2.520254e-07
I8284 n1_m1_379200_326400 0 1.761080e-07
I8285 n1_m1_379200_331200 0 1.774842e-07
I8286 n1_m1_379200_336000 0 2.570543e-07
I8287 n1_m1_379200_340800 0 1.648963e-07
I8288 n1_m1_379200_345600 0 2.508483e-07
I8289 n1_m1_379200_350400 0 1.716546e-07
I8290 n1_m1_379200_355200 0 1.675981e-07
I8291 n1_m1_379200_360000 0 2.411517e-07
I8292 n1_m1_379200_364800 0 1.628460e-07
I8293 n1_m1_379200_369600 0 2.546582e-07
I8294 n1_m1_379200_374400 0 1.679606e-07
I8295 n1_m1_379200_379200 0 1.712760e-07
I8296 n1_m1_379200_384000 0 2.464857e-07
I8297 n1_m1_379200_388800 0 1.613895e-07
I8298 n1_m1_379200_393600 0 2.501150e-07
I8299 n1_m1_379200_398400 0 1.739760e-07
I8300 n1_m1_379200_403200 0 2.130616e-07
I8301 n1_m1_379200_408000 0 3.399675e-07
I8302 n1_m1_379200_412800 0 1.707738e-07
I8303 n1_m1_379200_417600 0 2.608207e-07
I8304 n1_m1_379200_422400 0 1.749554e-07
I8305 n1_m1_379200_427200 0 1.685513e-07
I8306 n1_m1_379200_432000 0 2.439292e-07
I8307 n1_m1_379200_436800 0 1.660084e-07
I8308 n1_m1_379200_441600 0 2.458733e-07
I8309 n1_m1_379200_446400 0 1.601779e-07
I8310 n1_m1_379200_451200 0 1.599832e-07
I8311 n1_m1_379200_456000 0 2.398354e-07
I8312 n1_m1_379200_460800 0 1.598903e-07
I8313 n1_m1_379200_465600 0 2.346716e-07
I8314 n1_m1_379200_470400 0 1.532282e-07
I8315 n1_m1_379200_475200 0 1.532282e-07
I8316 n1_m1_379200_480000 0 2.298422e-07
I8317 n1_m1_379200_484800 0 1.532282e-07
I8318 n1_m1_379200_489600 0 2.303740e-07
I8319 n1_m1_379200_494400 0 1.569057e-07
I8320 n1_m1_384000_0 0 2.353944e-07
I8321 n1_m1_384000_4800 0 2.386329e-07
I8322 n1_m1_384000_9600 0 3.620568e-07
I8323 n1_m1_384000_14400 0 2.445845e-07
I8324 n1_m1_384000_19200 0 2.479436e-07
I8325 n1_m1_384000_24000 0 3.747854e-07
I8326 n1_m1_384000_28800 0 2.522400e-07
I8327 n1_m1_384000_33600 0 3.965964e-07
I8328 n1_m1_384000_38400 0 2.799051e-07
I8329 n1_m1_384000_43200 0 2.720277e-07
I8330 n1_m1_384000_48000 0 3.836095e-07
I8331 n1_m1_384000_52800 0 2.522803e-07
I8332 n1_m1_384000_57600 0 3.867972e-07
I8333 n1_m1_384000_62400 0 2.751042e-07
I8334 n1_m1_384000_67200 0 2.661011e-07
I8335 n1_m1_384000_72000 0 3.878189e-07
I8336 n1_m1_384000_76800 0 2.540558e-07
I8337 n1_m1_384000_81600 0 3.772029e-07
I8338 n1_m1_384000_86400 0 2.564519e-07
I8339 n1_m1_384000_91200 0 2.625002e-07
I8340 n1_m1_384000_96000 0 3.799708e-07
I8341 n1_m1_384000_100800 0 2.500774e-07
I8342 n1_m1_384000_105600 0 3.749835e-07
I8343 n1_m1_384000_110400 0 2.511922e-07
I8344 n1_m1_384000_115200 0 2.561697e-07
I8345 n1_m1_384000_120000 0 3.902913e-07
I8346 n1_m1_384000_124800 0 2.713803e-07
I8347 n1_m1_384000_129600 0 4.014648e-07
I8348 n1_m1_384000_134400 0 2.563488e-07
I8349 n1_m1_384000_139200 0 2.531154e-07
I8350 n1_m1_384000_144000 0 5.372145e-07
I8351 n1_m1_384000_148800 0 4.271816e-07
I8352 n1_m1_384000_153600 0 4.883082e-07
I8353 n1_m1_384000_158400 0 2.646838e-07
I8354 n1_m1_384000_163200 0 2.673470e-07
I8355 n1_m1_384000_168000 0 3.901060e-07
I8356 n1_m1_384000_172800 0 2.501846e-07
I8357 n1_m1_384000_177600 0 3.790403e-07
I8358 n1_m1_384000_182400 0 2.588969e-07
I8359 n1_m1_384000_187200 0 2.600700e-07
I8360 n1_m1_384000_192000 0 4.394781e-07
I8361 n1_m1_384000_196800 0 4.633640e-07
I8362 n1_m1_384000_201600 0 1.254731e-06
I8363 n1_m1_384000_206400 0 1.040395e-06
I8364 n1_m1_384000_211200 0 1.045774e-06
I8365 n1_m1_384000_216000 0 1.736073e-06
I8366 n1_m1_384000_220800 0 1.136552e-06
I8367 n1_m1_384000_225600 0 1.553436e-06
I8368 n1_m1_384000_230400 0 1.000468e-06
I8369 n1_m1_384000_235200 0 1.045585e-06
I8370 n1_m1_384000_240000 0 1.854782e-06
I8371 n1_m1_384000_244800 0 7.867541e-07
I8372 n1_m1_384000_249600 0 5.576383e-07
I8373 n1_m1_384000_254400 0 2.960609e-07
I8374 n1_m1_384000_259200 0 2.729418e-07
I8375 n1_m1_384000_264000 0 3.810591e-07
I8376 n1_m1_384000_268800 0 2.498285e-07
I8377 n1_m1_384000_273600 0 3.833613e-07
I8378 n1_m1_384000_278400 0 2.627109e-07
I8379 n1_m1_384000_283200 0 2.524716e-07
I8380 n1_m1_384000_288000 0 3.796063e-07
I8381 n1_m1_384000_292800 0 2.538099e-07
I8382 n1_m1_384000_297600 0 3.752470e-07
I8383 n1_m1_384000_302400 0 2.562601e-07
I8384 n1_m1_384000_307200 0 2.598217e-07
I8385 n1_m1_384000_312000 0 4.309713e-07
I8386 n1_m1_384000_316800 0 3.022892e-07
I8387 n1_m1_384000_321600 0 3.780719e-07
I8388 n1_m1_384000_326400 0 2.615487e-07
I8389 n1_m1_384000_331200 0 3.868119e-07
I8390 n1_m1_384000_336000 0 6.467438e-07
I8391 n1_m1_384000_340800 0 3.160084e-07
I8392 n1_m1_384000_345600 0 3.810228e-07
I8393 n1_m1_384000_350400 0 2.592235e-07
I8394 n1_m1_384000_355200 0 2.535605e-07
I8395 n1_m1_384000_360000 0 3.614598e-07
I8396 n1_m1_384000_364800 0 2.399464e-07
I8397 n1_m1_384000_369600 0 3.721619e-07
I8398 n1_m1_384000_374400 0 2.553819e-07
I8399 n1_m1_384000_379200 0 2.584738e-07
I8400 n1_m1_384000_384000 0 3.818808e-07
I8401 n1_m1_384000_388800 0 2.508647e-07
I8402 n1_m1_384000_393600 0 3.747504e-07
I8403 n1_m1_384000_398400 0 2.500829e-07
I8404 n1_m1_384000_403200 0 2.511676e-07
I8405 n1_m1_384000_408000 0 3.764805e-07
I8406 n1_m1_384000_412800 0 2.465286e-07
I8407 n1_m1_384000_417600 0 3.810532e-07
I8408 n1_m1_384000_422400 0 2.504707e-07
I8409 n1_m1_384000_427200 0 2.426093e-07
I8410 n1_m1_384000_432000 0 3.648398e-07
I8411 n1_m1_384000_436800 0 2.450352e-07
I8412 n1_m1_384000_441600 0 3.643653e-07
I8413 n1_m1_384000_446400 0 2.398354e-07
I8414 n1_m1_384000_451200 0 2.398354e-07
I8415 n1_m1_384000_456000 0 3.586230e-07
I8416 n1_m1_384000_460800 0 2.351101e-07
I8417 n1_m1_384000_465600 0 3.485648e-07
I8418 n1_m1_384000_470400 0 2.298422e-07
I8419 n1_m1_384000_475200 0 2.298422e-07
I8420 n1_m1_384000_480000 0 3.447634e-07
I8421 n1_m1_384000_484800 0 2.298422e-07
I8422 n1_m1_384000_489600 0 3.447842e-07
I8423 n1_m1_384000_494400 0 2.299864e-07
I8424 n1_m1_388800_0 0 1.764251e-07
I8425 n1_m1_388800_4800 0 1.756866e-07
I8426 n1_m1_388800_9600 0 2.576940e-07
I8427 n1_m1_388800_14400 0 1.684654e-07
I8428 n1_m1_388800_19200 0 1.665524e-07
I8429 n1_m1_388800_24000 0 2.498285e-07
I8430 n1_m1_388800_28800 0 1.685146e-07
I8431 n1_m1_388800_33600 0 2.711104e-07
I8432 n1_m1_388800_38400 0 2.014820e-07
I8433 n1_m1_388800_43200 0 1.945667e-07
I8434 n1_m1_388800_48000 0 2.723151e-07
I8435 n1_m1_388800_52800 0 1.714887e-07
I8436 n1_m1_388800_57600 0 2.567920e-07
I8437 n1_m1_388800_62400 0 1.674891e-07
I8438 n1_m1_388800_67200 0 1.680372e-07
I8439 n1_m1_388800_72000 0 2.489523e-07
I8440 n1_m1_388800_76800 0 1.643221e-07
I8441 n1_m1_388800_81600 0 2.542841e-07
I8442 n1_m1_388800_86400 0 1.668943e-07
I8443 n1_m1_388800_91200 0 1.665524e-07
I8444 n1_m1_388800_96000 0 2.498285e-07
I8445 n1_m1_388800_100800 0 1.700911e-07
I8446 n1_m1_388800_105600 0 2.572331e-07
I8447 n1_m1_388800_110400 0 1.705668e-07
I8448 n1_m1_388800_115200 0 1.682781e-07
I8449 n1_m1_388800_120000 0 2.522334e-07
I8450 n1_m1_388800_124800 0 1.665964e-07
I8451 n1_m1_388800_129600 0 2.769099e-07
I8452 n1_m1_388800_134400 0 1.925426e-07
I8453 n1_m1_388800_139200 0 1.772602e-07
I8454 n1_m1_388800_144000 0 3.600416e-07
I8455 n1_m1_388800_148800 0 3.059994e-07
I8456 n1_m1_388800_153600 0 3.369942e-07
I8457 n1_m1_388800_158400 0 1.724385e-07
I8458 n1_m1_388800_163200 0 1.771926e-07
I8459 n1_m1_388800_168000 0 2.696762e-07
I8460 n1_m1_388800_172800 0 1.813361e-07
I8461 n1_m1_388800_177600 0 2.683392e-07
I8462 n1_m1_388800_182400 0 1.774222e-07
I8463 n1_m1_388800_187200 0 1.683045e-07
I8464 n1_m1_388800_192000 0 2.944722e-07
I8465 n1_m1_388800_196800 0 3.759287e-07
I8466 n1_m1_388800_201600 0 9.205942e-07
I8467 n1_m1_388800_206400 0 6.472106e-07
I8468 n1_m1_388800_211200 0 8.544715e-07
I8469 n1_m1_388800_216000 0 1.813063e-06
I8470 n1_m1_388800_220800 0 1.240806e-06
I8471 n1_m1_388800_225600 0 1.541845e-06
I8472 n1_m1_388800_230400 0 6.434201e-07
I8473 n1_m1_388800_235200 0 5.735749e-07
I8474 n1_m1_388800_240000 0 1.429062e-06
I8475 n1_m1_388800_244800 0 6.149814e-07
I8476 n1_m1_388800_249600 0 5.035237e-07
I8477 n1_m1_388800_254400 0 2.340987e-07
I8478 n1_m1_388800_259200 0 1.821775e-07
I8479 n1_m1_388800_264000 0 2.583454e-07
I8480 n1_m1_388800_268800 0 1.714887e-07
I8481 n1_m1_388800_273600 0 2.587509e-07
I8482 n1_m1_388800_278400 0 1.687062e-07
I8483 n1_m1_388800_283200 0 1.640643e-07
I8484 n1_m1_388800_288000 0 2.566512e-07
I8485 n1_m1_388800_292800 0 1.729355e-07
I8486 n1_m1_388800_297600 0 2.543700e-07
I8487 n1_m1_388800_302400 0 1.676509e-07
I8488 n1_m1_388800_307200 0 1.715591e-07
I8489 n1_m1_388800_312000 0 4.159071e-07
I8490 n1_m1_388800_316800 0 3.530927e-07
I8491 n1_m1_388800_321600 0 3.740692e-07
I8492 n1_m1_388800_326400 0 1.833851e-07
I8493 n1_m1_388800_331200 0 2.639019e-07
I8494 n1_m1_388800_336000 0 3.958392e-07
I8495 n1_m1_388800_340800 0 1.931795e-07
I8496 n1_m1_388800_345600 0 2.565463e-07
I8497 n1_m1_388800_350400 0 1.644112e-07
I8498 n1_m1_388800_355200 0 1.665588e-07
I8499 n1_m1_388800_360000 0 2.569665e-07
I8500 n1_m1_388800_364800 0 1.718743e-07
I8501 n1_m1_388800_369600 0 2.453385e-07
I8502 n1_m1_388800_374400 0 1.677980e-07
I8503 n1_m1_388800_379200 0 1.693337e-07
I8504 n1_m1_388800_384000 0 2.561590e-07
I8505 n1_m1_388800_388800 0 1.669994e-07
I8506 n1_m1_388800_393600 0 2.436283e-07
I8507 n1_m1_388800_398400 0 1.616160e-07
I8508 n1_m1_388800_403200 0 1.672272e-07
I8509 n1_m1_388800_408000 0 2.624825e-07
I8510 n1_m1_388800_412800 0 1.681209e-07
I8511 n1_m1_388800_417600 0 2.542148e-07
I8512 n1_m1_388800_422400 0 1.633551e-07
I8513 n1_m1_388800_427200 0 1.623981e-07
I8514 n1_m1_388800_432000 0 2.480046e-07
I8515 n1_m1_388800_436800 0 1.604856e-07
I8516 n1_m1_388800_441600 0 2.398354e-07
I8517 n1_m1_388800_446400 0 1.598903e-07
I8518 n1_m1_388800_451200 0 1.598903e-07
I8519 n1_m1_388800_456000 0 2.334773e-07
I8520 n1_m1_388800_460800 0 1.532368e-07
I8521 n1_m1_388800_465600 0 2.298422e-07
I8522 n1_m1_388800_470400 0 1.532282e-07
I8523 n1_m1_388800_475200 0 1.532282e-07
I8524 n1_m1_388800_480000 0 2.298422e-07
I8525 n1_m1_388800_484800 0 1.532282e-07
I8526 n1_m1_388800_489600 0 2.298422e-07
I8527 n1_m1_388800_494400 0 1.532282e-07
I8528 n1_m1_393600_0 0 1.746659e-07
I8529 n1_m1_393600_4800 0 1.744358e-07
I8530 n1_m1_393600_9600 0 2.569426e-07
I8531 n1_m1_393600_14400 0 1.671823e-07
I8532 n1_m1_393600_19200 0 1.665524e-07
I8533 n1_m1_393600_24000 0 2.499302e-07
I8534 n1_m1_393600_28800 0 1.672230e-07
I8535 n1_m1_393600_33600 0 2.558345e-07
I8536 n1_m1_393600_38400 0 1.795732e-07
I8537 n1_m1_393600_43200 0 1.872256e-07
I8538 n1_m1_393600_48000 0 2.802134e-07
I8539 n1_m1_393600_52800 0 1.818410e-07
I8540 n1_m1_393600_57600 0 2.631538e-07
I8541 n1_m1_393600_62400 0 1.755073e-07
I8542 n1_m1_393600_67200 0 1.716134e-07
I8543 n1_m1_393600_72000 0 2.494849e-07
I8544 n1_m1_393600_76800 0 1.684921e-07
I8545 n1_m1_393600_81600 0 2.685154e-07
I8546 n1_m1_393600_86400 0 1.750487e-07
I8547 n1_m1_393600_91200 0 1.670990e-07
I8548 n1_m1_393600_96000 0 2.498285e-07
I8549 n1_m1_393600_100800 0 1.677175e-07
I8550 n1_m1_393600_105600 0 2.523748e-07
I8551 n1_m1_393600_110400 0 1.677980e-07
I8552 n1_m1_393600_115200 0 1.666667e-07
I8553 n1_m1_393600_120000 0 2.465016e-07
I8554 n1_m1_393600_124800 0 1.699234e-07
I8555 n1_m1_393600_129600 0 2.774849e-07
I8556 n1_m1_393600_134400 0 1.923935e-07
I8557 n1_m1_393600_139200 0 1.860336e-07
I8558 n1_m1_393600_144000 0 2.844781e-07
I8559 n1_m1_393600_148800 0 1.950684e-07
I8560 n1_m1_393600_153600 0 2.748800e-07
I8561 n1_m1_393600_158400 0 1.756111e-07
I8562 n1_m1_393600_163200 0 1.672349e-07
I8563 n1_m1_393600_168000 0 2.776828e-07
I8564 n1_m1_393600_172800 0 2.840418e-07
I8565 n1_m1_393600_177600 0 4.660611e-07
I8566 n1_m1_393600_182400 0 2.003656e-07
I8567 n1_m1_393600_187200 0 1.652799e-07
I8568 n1_m1_393600_192000 0 2.733830e-07
I8569 n1_m1_393600_196800 0 2.216657e-07
I8570 n1_m1_393600_201600 0 1.005473e-06
I8571 n1_m1_393600_206400 0 1.180903e-06
I8572 n1_m1_393600_211200 0 1.256164e-06
I8573 n1_m1_393600_216000 0 1.823864e-06
I8574 n1_m1_393600_220800 0 1.094549e-06
I8575 n1_m1_393600_225600 0 1.111617e-06
I8576 n1_m1_393600_230400 0 3.870530e-07
I8577 n1_m1_393600_235200 0 2.307898e-07
I8578 n1_m1_393600_240000 0 6.439229e-07
I8579 n1_m1_393600_244800 0 4.120153e-07
I8580 n1_m1_393600_249600 0 5.659891e-07
I8581 n1_m1_393600_254400 0 2.622589e-07
I8582 n1_m1_393600_259200 0 1.861490e-07
I8583 n1_m1_393600_264000 0 2.599338e-07
I8584 n1_m1_393600_268800 0 1.732144e-07
I8585 n1_m1_393600_273600 0 2.576450e-07
I8586 n1_m1_393600_278400 0 1.667031e-07
I8587 n1_m1_393600_283200 0 1.682313e-07
I8588 n1_m1_393600_288000 0 2.590481e-07
I8589 n1_m1_393600_292800 0 1.724143e-07
I8590 n1_m1_393600_297600 0 2.549810e-07
I8591 n1_m1_393600_302400 0 1.728462e-07
I8592 n1_m1_393600_307200 0 1.821733e-07
I8593 n1_m1_393600_312000 0 6.723571e-07
I8594 n1_m1_393600_316800 0 5.176868e-07
I8595 n1_m1_393600_321600 0 4.455449e-07
I8596 n1_m1_393600_326400 0 1.708638e-07
I8597 n1_m1_393600_331200 0 1.852591e-07
I8598 n1_m1_393600_336000 0 2.740767e-07
I8599 n1_m1_393600_340800 0 1.691170e-07
I8600 n1_m1_393600_345600 0 2.574469e-07
I8601 n1_m1_393600_350400 0 1.667018e-07
I8602 n1_m1_393600_355200 0 1.841845e-07
I8603 n1_m1_393600_360000 0 3.869193e-07
I8604 n1_m1_393600_364800 0 2.660404e-07
I8605 n1_m1_393600_369600 0 2.921458e-07
I8606 n1_m1_393600_374400 0 1.635869e-07
I8607 n1_m1_393600_379200 0 1.666825e-07
I8608 n1_m1_393600_384000 0 2.474702e-07
I8609 n1_m1_393600_388800 0 1.615156e-07
I8610 n1_m1_393600_393600 0 2.402812e-07
I8611 n1_m1_393600_398400 0 1.616589e-07
I8612 n1_m1_393600_403200 0 1.688764e-07
I8613 n1_m1_393600_408000 0 2.573523e-07
I8614 n1_m1_393600_412800 0 1.674998e-07
I8615 n1_m1_393600_417600 0 2.579984e-07
I8616 n1_m1_393600_422400 0 1.683466e-07
I8617 n1_m1_393600_427200 0 1.657527e-07
I8618 n1_m1_393600_432000 0 2.488051e-07
I8619 n1_m1_393600_436800 0 1.604856e-07
I8620 n1_m1_393600_441600 0 2.398354e-07
I8621 n1_m1_393600_446400 0 1.598339e-07
I8622 n1_m1_393600_451200 0 1.564538e-07
I8623 n1_m1_393600_456000 0 2.303220e-07
I8624 n1_m1_393600_460800 0 1.532282e-07
I8625 n1_m1_393600_465600 0 2.298422e-07
I8626 n1_m1_393600_470400 0 1.532282e-07
I8627 n1_m1_393600_475200 0 1.532282e-07
I8628 n1_m1_393600_480000 0 2.298422e-07
I8629 n1_m1_393600_484800 0 1.532282e-07
I8630 n1_m1_393600_489600 0 2.298516e-07
I8631 n1_m1_393600_494400 0 1.532928e-07
I8632 n1_m1_398400_0 0 1.578167e-07
I8633 n1_m1_398400_4800 0 1.588134e-07
I8634 n1_m1_398400_9600 0 2.473078e-07
I8635 n1_m1_398400_14400 0 1.678223e-07
I8636 n1_m1_398400_19200 0 1.686259e-07
I8637 n1_m1_398400_24000 0 2.611806e-07
I8638 n1_m1_398400_28800 0 2.317047e-07
I8639 n1_m1_398400_33600 0 5.690035e-07
I8640 n1_m1_398400_38400 0 3.266306e-07
I8641 n1_m1_398400_43200 0 3.284225e-07
I8642 n1_m1_398400_48000 0 4.896704e-07
I8643 n1_m1_398400_52800 0 2.635025e-07
I8644 n1_m1_398400_57600 0 2.818796e-07
I8645 n1_m1_398400_62400 0 1.743846e-07
I8646 n1_m1_398400_67200 0 1.672325e-07
I8647 n1_m1_398400_72000 0 2.456784e-07
I8648 n1_m1_398400_76800 0 1.674896e-07
I8649 n1_m1_398400_81600 0 2.507071e-07
I8650 n1_m1_398400_86400 0 1.669417e-07
I8651 n1_m1_398400_91200 0 1.697668e-07
I8652 n1_m1_398400_96000 0 2.605856e-07
I8653 n1_m1_398400_100800 0 1.712865e-07
I8654 n1_m1_398400_105600 0 2.628314e-07
I8655 n1_m1_398400_110400 0 1.877709e-07
I8656 n1_m1_398400_115200 0 2.190632e-07
I8657 n1_m1_398400_120000 0 3.879192e-07
I8658 n1_m1_398400_124800 0 3.524124e-07
I8659 n1_m1_398400_129600 0 8.622023e-07
I8660 n1_m1_398400_134400 0 7.924169e-07
I8661 n1_m1_398400_139200 0 8.754729e-07
I8662 n1_m1_398400_144000 0 1.078657e-06
I8663 n1_m1_398400_148800 0 4.098665e-07
I8664 n1_m1_398400_153600 0 5.168574e-07
I8665 n1_m1_398400_158400 0 4.584763e-07
I8666 n1_m1_398400_163200 0 5.158238e-07
I8667 n1_m1_398400_168000 0 8.272578e-07
I8668 n1_m1_398400_172800 0 4.929129e-07
I8669 n1_m1_398400_177600 0 5.137608e-07
I8670 n1_m1_398400_182400 0 1.971718e-07
I8671 n1_m1_398400_187200 0 1.754939e-07
I8672 n1_m1_398400_192000 0 2.525231e-07
I8673 n1_m1_398400_196800 0 2.182179e-07
I8674 n1_m1_398400_201600 0 6.363602e-07
I8675 n1_m1_398400_206400 0 5.321931e-07
I8676 n1_m1_398400_211200 0 6.058621e-07
I8677 n1_m1_398400_216000 0 1.144493e-06
I8678 n1_m1_398400_220800 0 5.400613e-07
I8679 n1_m1_398400_225600 0 3.713072e-07
I8680 n1_m1_398400_230400 0 1.779146e-07
I8681 n1_m1_398400_235200 0 1.774363e-07
I8682 n1_m1_398400_240000 0 2.798940e-07
I8683 n1_m1_398400_244800 0 1.934680e-07
I8684 n1_m1_398400_249600 0 5.233115e-07
I8685 n1_m1_398400_254400 0 3.205815e-07
I8686 n1_m1_398400_259200 0 2.473011e-07
I8687 n1_m1_398400_264000 0 2.749618e-07
I8688 n1_m1_398400_268800 0 1.715136e-07
I8689 n1_m1_398400_273600 0 2.576232e-07
I8690 n1_m1_398400_278400 0 1.700974e-07
I8691 n1_m1_398400_283200 0 1.688282e-07
I8692 n1_m1_398400_288000 0 2.570174e-07
I8693 n1_m1_398400_292800 0 1.736870e-07
I8694 n1_m1_398400_297600 0 3.043593e-07
I8695 n1_m1_398400_302400 0 3.462633e-07
I8696 n1_m1_398400_307200 0 5.098550e-07
I8697 n1_m1_398400_312000 0 9.501947e-07
I8698 n1_m1_398400_316800 0 5.865608e-07
I8699 n1_m1_398400_321600 0 5.169743e-07
I8700 n1_m1_398400_326400 0 1.843160e-07
I8701 n1_m1_398400_331200 0 1.636026e-07
I8702 n1_m1_398400_336000 0 2.539190e-07
I8703 n1_m1_398400_340800 0 1.788556e-07
I8704 n1_m1_398400_345600 0 2.783057e-07
I8705 n1_m1_398400_350400 0 1.944599e-07
I8706 n1_m1_398400_355200 0 2.274233e-07
I8707 n1_m1_398400_360000 0 4.436918e-07
I8708 n1_m1_398400_364800 0 2.695865e-07
I8709 n1_m1_398400_369600 0 2.976501e-07
I8710 n1_m1_398400_374400 0 1.643122e-07
I8711 n1_m1_398400_379200 0 1.663543e-07
I8712 n1_m1_398400_384000 0 2.465576e-07
I8713 n1_m1_398400_388800 0 1.619638e-07
I8714 n1_m1_398400_393600 0 2.493226e-07
I8715 n1_m1_398400_398400 0 1.866717e-07
I8716 n1_m1_398400_403200 0 2.738097e-07
I8717 n1_m1_398400_408000 0 4.758872e-07
I8718 n1_m1_398400_412800 0 1.914031e-07
I8719 n1_m1_398400_417600 0 2.546944e-07
I8720 n1_m1_398400_422400 0 1.644788e-07
I8721 n1_m1_398400_427200 0 1.655322e-07
I8722 n1_m1_398400_432000 0 2.488051e-07
I8723 n1_m1_398400_436800 0 1.604856e-07
I8724 n1_m1_398400_441600 0 2.398354e-07
I8725 n1_m1_398400_446400 0 1.555693e-07
I8726 n1_m1_398400_451200 0 1.532282e-07
I8727 n1_m1_398400_456000 0 2.298422e-07
I8728 n1_m1_398400_460800 0 1.532282e-07
I8729 n1_m1_398400_465600 0 2.298422e-07
I8730 n1_m1_398400_470400 0 1.532282e-07
I8731 n1_m1_398400_475200 0 1.532282e-07
I8732 n1_m1_398400_480000 0 2.298422e-07
I8733 n1_m1_398400_484800 0 1.532282e-07
I8734 n1_m1_398400_489600 0 2.305580e-07
I8735 n1_m1_398400_494400 0 1.581779e-07
I8736 n1_m1_403200_0 0 1.554890e-07
I8737 n1_m1_403200_4800 0 1.561474e-07
I8738 n1_m1_403200_9600 0 2.419962e-07
I8739 n1_m1_403200_14400 0 1.683717e-07
I8740 n1_m1_403200_19200 0 1.724018e-07
I8741 n1_m1_403200_24000 0 2.705637e-07
I8742 n1_m1_403200_28800 0 3.226980e-07
I8743 n1_m1_403200_33600 0 1.068587e-06
I8744 n1_m1_403200_38400 0 6.172128e-07
I8745 n1_m1_403200_43200 0 5.461719e-07
I8746 n1_m1_403200_48000 0 7.184559e-07
I8747 n1_m1_403200_52800 0 3.551065e-07
I8748 n1_m1_403200_57600 0 3.234196e-07
I8749 n1_m1_403200_62400 0 1.775135e-07
I8750 n1_m1_403200_67200 0 1.680963e-07
I8751 n1_m1_403200_72000 0 2.544065e-07
I8752 n1_m1_403200_76800 0 1.729421e-07
I8753 n1_m1_403200_81600 0 2.541267e-07
I8754 n1_m1_403200_86400 0 1.696395e-07
I8755 n1_m1_403200_91200 0 2.025549e-07
I8756 n1_m1_403200_96000 0 4.301589e-07
I8757 n1_m1_403200_100800 0 2.032271e-07
I8758 n1_m1_403200_105600 0 2.704470e-07
I8759 n1_m1_403200_110400 0 2.135136e-07
I8760 n1_m1_403200_115200 0 3.131231e-07
I8761 n1_m1_403200_120000 0 6.635526e-07
I8762 n1_m1_403200_124800 0 6.002136e-07
I8763 n1_m1_403200_129600 0 1.709772e-06
I8764 n1_m1_403200_134400 0 1.396316e-06
I8765 n1_m1_403200_139200 0 1.349874e-06
I8766 n1_m1_403200_144000 0 1.395266e-06
I8767 n1_m1_403200_148800 0 4.447344e-07
I8768 n1_m1_403200_153600 0 5.355766e-07
I8769 n1_m1_403200_158400 0 5.744590e-07
I8770 n1_m1_403200_163200 0 8.240756e-07
I8771 n1_m1_403200_168000 0 1.315597e-06
I8772 n1_m1_403200_172800 0 5.957345e-07
I8773 n1_m1_403200_177600 0 4.494390e-07
I8774 n1_m1_403200_182400 0 1.871384e-07
I8775 n1_m1_403200_187200 0 1.777898e-07
I8776 n1_m1_403200_192000 0 2.534142e-07
I8777 n1_m1_403200_196800 0 1.695821e-07
I8778 n1_m1_403200_201600 0 2.696317e-07
I8779 n1_m1_403200_206400 0 1.759586e-07
I8780 n1_m1_403200_211200 0 2.102010e-07
I8781 n1_m1_403200_216000 0 4.632906e-07
I8782 n1_m1_403200_220800 0 2.414846e-07
I8783 n1_m1_403200_225600 0 3.035813e-07
I8784 n1_m1_403200_230400 0 1.953954e-07
I8785 n1_m1_403200_235200 0 1.828584e-07
I8786 n1_m1_403200_240000 0 3.659474e-07
I8787 n1_m1_403200_244800 0 2.468098e-07
I8788 n1_m1_403200_249600 0 4.729521e-07
I8789 n1_m1_403200_254400 0 3.903040e-07
I8790 n1_m1_403200_259200 0 3.379582e-07
I8791 n1_m1_403200_264000 0 2.996609e-07
I8792 n1_m1_403200_268800 0 1.682740e-07
I8793 n1_m1_403200_273600 0 2.637968e-07
I8794 n1_m1_403200_278400 0 1.803438e-07
I8795 n1_m1_403200_283200 0 1.744743e-07
I8796 n1_m1_403200_288000 0 2.560212e-07
I8797 n1_m1_403200_292800 0 1.760448e-07
I8798 n1_m1_403200_297600 0 4.172672e-07
I8799 n1_m1_403200_302400 0 6.151352e-07
I8800 n1_m1_403200_307200 0 8.886355e-07
I8801 n1_m1_403200_312000 0 9.875261e-07
I8802 n1_m1_403200_316800 0 5.399509e-07
I8803 n1_m1_403200_321600 0 7.230245e-07
I8804 n1_m1_403200_326400 0 2.730096e-07
I8805 n1_m1_403200_331200 0 1.787297e-07
I8806 n1_m1_403200_336000 0 2.440972e-07
I8807 n1_m1_403200_340800 0 1.701692e-07
I8808 n1_m1_403200_345600 0 2.874804e-07
I8809 n1_m1_403200_350400 0 2.509501e-07
I8810 n1_m1_403200_355200 0 3.106294e-07
I8811 n1_m1_403200_360000 0 4.117949e-07
I8812 n1_m1_403200_364800 0 1.943303e-07
I8813 n1_m1_403200_369600 0 2.616818e-07
I8814 n1_m1_403200_374400 0 1.648022e-07
I8815 n1_m1_403200_379200 0 1.642915e-07
I8816 n1_m1_403200_384000 0 2.464373e-07
I8817 n1_m1_403200_388800 0 1.659667e-07
I8818 n1_m1_403200_393600 0 2.594900e-07
I8819 n1_m1_403200_398400 0 2.499439e-07
I8820 n1_m1_403200_403200 0 5.688769e-07
I8821 n1_m1_403200_408000 0 1.126637e-06
I8822 n1_m1_403200_412800 0 2.847636e-07
I8823 n1_m1_403200_417600 0 2.614222e-07
I8824 n1_m1_403200_422400 0 1.655877e-07
I8825 n1_m1_403200_427200 0 1.654993e-07
I8826 n1_m1_403200_432000 0 2.488051e-07
I8827 n1_m1_403200_436800 0 1.604856e-07
I8828 n1_m1_403200_441600 0 2.384326e-07
I8829 n1_m1_403200_446400 0 1.547748e-07
I8830 n1_m1_403200_451200 0 1.532282e-07
I8831 n1_m1_403200_456000 0 2.298422e-07
I8832 n1_m1_403200_460800 0 1.532282e-07
I8833 n1_m1_403200_465600 0 2.315424e-07
I8834 n1_m1_403200_470400 0 1.537253e-07
I8835 n1_m1_403200_475200 0 1.532282e-07
I8836 n1_m1_403200_480000 0 2.298422e-07
I8837 n1_m1_403200_484800 0 1.541679e-07
I8838 n1_m1_403200_489600 0 2.315726e-07
I8839 n1_m1_403200_494400 0 1.564982e-07
I8840 n1_m1_408000_0 0 2.354230e-07
I8841 n1_m1_408000_4800 0 2.388716e-07
I8842 n1_m1_408000_9600 0 3.630870e-07
I8843 n1_m1_408000_14400 0 2.484781e-07
I8844 n1_m1_408000_19200 0 2.563956e-07
I8845 n1_m1_408000_24000 0 4.057474e-07
I8846 n1_m1_408000_28800 0 3.612647e-07
I8847 n1_m1_408000_33600 0 9.287382e-07
I8848 n1_m1_408000_38400 0 6.136483e-07
I8849 n1_m1_408000_43200 0 5.237051e-07
I8850 n1_m1_408000_48000 0 6.724971e-07
I8851 n1_m1_408000_52800 0 4.052884e-07
I8852 n1_m1_408000_57600 0 4.727904e-07
I8853 n1_m1_408000_62400 0 2.584608e-07
I8854 n1_m1_408000_67200 0 2.509324e-07
I8855 n1_m1_408000_72000 0 3.760695e-07
I8856 n1_m1_408000_76800 0 2.512576e-07
I8857 n1_m1_408000_81600 0 3.889247e-07
I8858 n1_m1_408000_86400 0 2.642468e-07
I8859 n1_m1_408000_91200 0 3.476911e-07
I8860 n1_m1_408000_96000 0 8.328215e-07
I8861 n1_m1_408000_100800 0 3.263339e-07
I8862 n1_m1_408000_105600 0 3.945796e-07
I8863 n1_m1_408000_110400 0 2.788730e-07
I8864 n1_m1_408000_115200 0 3.517790e-07
I8865 n1_m1_408000_120000 0 7.467846e-07
I8866 n1_m1_408000_124800 0 9.822269e-07
I8867 n1_m1_408000_129600 0 2.100949e-06
I8868 n1_m1_408000_134400 0 1.332099e-06
I8869 n1_m1_408000_139200 0 1.124109e-06
I8870 n1_m1_408000_144000 0 1.180048e-06
I8871 n1_m1_408000_148800 0 5.107296e-07
I8872 n1_m1_408000_153600 0 5.324359e-07
I8873 n1_m1_408000_158400 0 3.853757e-07
I8874 n1_m1_408000_163200 0 6.717330e-07
I8875 n1_m1_408000_168000 0 1.378273e-06
I8876 n1_m1_408000_172800 0 7.347721e-07
I8877 n1_m1_408000_177600 0 5.823364e-07
I8878 n1_m1_408000_182400 0 2.674565e-07
I8879 n1_m1_408000_187200 0 2.596968e-07
I8880 n1_m1_408000_192000 0 3.890402e-07
I8881 n1_m1_408000_196800 0 2.593601e-07
I8882 n1_m1_408000_201600 0 3.890842e-07
I8883 n1_m1_408000_206400 0 2.597536e-07
I8884 n1_m1_408000_211200 0 2.598217e-07
I8885 n1_m1_408000_216000 0 3.874901e-07
I8886 n1_m1_408000_220800 0 3.167198e-07
I8887 n1_m1_408000_225600 0 4.402568e-07
I8888 n1_m1_408000_230400 0 2.996317e-07
I8889 n1_m1_408000_235200 0 2.855804e-07
I8890 n1_m1_408000_240000 0 9.723955e-07
I8891 n1_m1_408000_244800 0 8.172218e-07
I8892 n1_m1_408000_249600 0 6.286277e-07
I8893 n1_m1_408000_254400 0 5.462624e-07
I8894 n1_m1_408000_259200 0 5.588929e-07
I8895 n1_m1_408000_264000 0 5.069474e-07
I8896 n1_m1_408000_268800 0 2.646691e-07
I8897 n1_m1_408000_273600 0 4.044584e-07
I8898 n1_m1_408000_278400 0 2.687109e-07
I8899 n1_m1_408000_283200 0 3.019302e-07
I8900 n1_m1_408000_288000 0 6.584479e-07
I8901 n1_m1_408000_292800 0 3.622440e-07
I8902 n1_m1_408000_297600 0 5.548909e-07
I8903 n1_m1_408000_302400 0 9.164285e-07
I8904 n1_m1_408000_307200 0 1.558843e-06
I8905 n1_m1_408000_312000 0 1.928002e-06
I8906 n1_m1_408000_316800 0 6.991546e-07
I8907 n1_m1_408000_321600 0 8.201025e-07
I8908 n1_m1_408000_326400 0 3.786435e-07
I8909 n1_m1_408000_331200 0 2.687674e-07
I8910 n1_m1_408000_336000 0 3.938657e-07
I8911 n1_m1_408000_340800 0 2.574105e-07
I8912 n1_m1_408000_345600 0 4.072137e-07
I8913 n1_m1_408000_350400 0 4.032143e-07
I8914 n1_m1_408000_355200 0 5.450942e-07
I8915 n1_m1_408000_360000 0 6.414543e-07
I8916 n1_m1_408000_364800 0 2.697776e-07
I8917 n1_m1_408000_369600 0 3.860202e-07
I8918 n1_m1_408000_374400 0 2.422261e-07
I8919 n1_m1_408000_379200 0 2.446695e-07
I8920 n1_m1_408000_384000 0 3.650832e-07
I8921 n1_m1_408000_388800 0 2.491985e-07
I8922 n1_m1_408000_393600 0 3.736668e-07
I8923 n1_m1_408000_398400 0 4.132936e-07
I8924 n1_m1_408000_403200 0 1.110185e-06
I8925 n1_m1_408000_408000 0 2.140507e-06
I8926 n1_m1_408000_412800 0 4.622888e-07
I8927 n1_m1_408000_417600 0 4.032131e-07
I8928 n1_m1_408000_422400 0 2.647789e-07
I8929 n1_m1_408000_427200 0 2.545104e-07
I8930 n1_m1_408000_432000 0 3.725863e-07
I8931 n1_m1_408000_436800 0 2.406871e-07
I8932 n1_m1_408000_441600 0 3.535525e-07
I8933 n1_m1_408000_446400 0 2.298422e-07
I8934 n1_m1_408000_451200 0 2.298422e-07
I8935 n1_m1_408000_456000 0 3.447634e-07
I8936 n1_m1_408000_460800 0 2.298422e-07
I8937 n1_m1_408000_465600 0 3.479323e-07
I8938 n1_m1_408000_470400 0 2.307688e-07
I8939 n1_m1_408000_475200 0 2.298422e-07
I8940 n1_m1_408000_480000 0 3.447634e-07
I8941 n1_m1_408000_484800 0 2.314020e-07
I8942 n1_m1_408000_489600 0 3.458437e-07
I8943 n1_m1_408000_494400 0 2.254299e-07
I8944 n1_m1_412800_0 0 1.535256e-07
I8945 n1_m1_412800_4800 0 1.550845e-07
I8946 n1_m1_412800_9600 0 2.428899e-07
I8947 n1_m1_412800_14400 0 1.693687e-07
I8948 n1_m1_412800_19200 0 1.722433e-07
I8949 n1_m1_412800_24000 0 2.605957e-07
I8950 n1_m1_412800_28800 0 1.754773e-07
I8951 n1_m1_412800_33600 0 2.759727e-07
I8952 n1_m1_412800_38400 0 1.838019e-07
I8953 n1_m1_412800_43200 0 1.735742e-07
I8954 n1_m1_412800_48000 0 2.603326e-07
I8955 n1_m1_412800_52800 0 1.813146e-07
I8956 n1_m1_412800_57600 0 2.654522e-07
I8957 n1_m1_412800_62400 0 1.720075e-07
I8958 n1_m1_412800_67200 0 1.726265e-07
I8959 n1_m1_412800_72000 0 2.673848e-07
I8960 n1_m1_412800_76800 0 1.893635e-07
I8961 n1_m1_412800_81600 0 3.125122e-07
I8962 n1_m1_412800_86400 0 2.247482e-07
I8963 n1_m1_412800_91200 0 2.590757e-07
I8964 n1_m1_412800_96000 0 4.490701e-07
I8965 n1_m1_412800_100800 0 2.057291e-07
I8966 n1_m1_412800_105600 0 2.629350e-07
I8967 n1_m1_412800_110400 0 1.729916e-07
I8968 n1_m1_412800_115200 0 1.726208e-07
I8969 n1_m1_412800_120000 0 2.760298e-07
I8970 n1_m1_412800_124800 0 3.707751e-07
I8971 n1_m1_412800_129600 0 6.043757e-07
I8972 n1_m1_412800_134400 0 2.965711e-07
I8973 n1_m1_412800_139200 0 2.145632e-07
I8974 n1_m1_412800_144000 0 3.026469e-07
I8975 n1_m1_412800_148800 0 1.900694e-07
I8976 n1_m1_412800_153600 0 2.556349e-07
I8977 n1_m1_412800_158400 0 1.669948e-07
I8978 n1_m1_412800_163200 0 1.832382e-07
I8979 n1_m1_412800_168000 0 3.630092e-07
I8980 n1_m1_412800_172800 0 3.147213e-07
I8981 n1_m1_412800_177600 0 3.316140e-07
I8982 n1_m1_412800_182400 0 1.633055e-07
I8983 n1_m1_412800_187200 0 1.660059e-07
I8984 n1_m1_412800_192000 0 2.517661e-07
I8985 n1_m1_412800_196800 0 1.682647e-07
I8986 n1_m1_412800_201600 0 2.528692e-07
I8987 n1_m1_412800_206400 0 1.724839e-07
I8988 n1_m1_412800_211200 0 1.732144e-07
I8989 n1_m1_412800_216000 0 2.598217e-07
I8990 n1_m1_412800_220800 0 1.878367e-07
I8991 n1_m1_412800_225600 0 3.003150e-07
I8992 n1_m1_412800_230400 0 1.751373e-07
I8993 n1_m1_412800_235200 0 1.829954e-07
I8994 n1_m1_412800_240000 0 5.065619e-07
I8995 n1_m1_412800_244800 0 3.908181e-07
I8996 n1_m1_412800_249600 0 3.568813e-07
I8997 n1_m1_412800_254400 0 2.019880e-07
I8998 n1_m1_412800_259200 0 2.090366e-07
I8999 n1_m1_412800_264000 0 3.042724e-07
I9000 n1_m1_412800_268800 0 1.834875e-07
I9001 n1_m1_412800_273600 0 2.610887e-07
I9002 n1_m1_412800_278400 0 1.687738e-07
I9003 n1_m1_412800_283200 0 1.811273e-07
I9004 n1_m1_412800_288000 0 3.645743e-07
I9005 n1_m1_412800_292800 0 2.056617e-07
I9006 n1_m1_412800_297600 0 2.644082e-07
I9007 n1_m1_412800_302400 0 2.723408e-07
I9008 n1_m1_412800_307200 0 4.897630e-07
I9009 n1_m1_412800_312000 0 8.813167e-07
I9010 n1_m1_412800_316800 0 2.671203e-07
I9011 n1_m1_412800_321600 0 2.624642e-07
I9012 n1_m1_412800_326400 0 1.690040e-07
I9013 n1_m1_412800_331200 0 1.703155e-07
I9014 n1_m1_412800_336000 0 2.573037e-07
I9015 n1_m1_412800_340800 0 1.624277e-07
I9016 n1_m1_412800_345600 0 2.500120e-07
I9017 n1_m1_412800_350400 0 1.910415e-07
I9018 n1_m1_412800_355200 0 2.201919e-07
I9019 n1_m1_412800_360000 0 2.941619e-07
I9020 n1_m1_412800_364800 0 1.742043e-07
I9021 n1_m1_412800_369600 0 2.573468e-07
I9022 n1_m1_412800_374400 0 1.629728e-07
I9023 n1_m1_412800_379200 0 1.707533e-07
I9024 n1_m1_412800_384000 0 2.567717e-07
I9025 n1_m1_412800_388800 0 1.724686e-07
I9026 n1_m1_412800_393600 0 2.442919e-07
I9027 n1_m1_412800_398400 0 1.973938e-07
I9028 n1_m1_412800_403200 0 5.081609e-07
I9029 n1_m1_412800_408000 0 1.084643e-06
I9030 n1_m1_412800_412800 0 2.981203e-07
I9031 n1_m1_412800_417600 0 2.724353e-07
I9032 n1_m1_412800_422400 0 1.729947e-07
I9033 n1_m1_412800_427200 0 1.664870e-07
I9034 n1_m1_412800_432000 0 2.413934e-07
I9035 n1_m1_412800_436800 0 1.599937e-07
I9036 n1_m1_412800_441600 0 2.357017e-07
I9037 n1_m1_412800_446400 0 1.532282e-07
I9038 n1_m1_412800_451200 0 1.532282e-07
I9039 n1_m1_412800_456000 0 2.298422e-07
I9040 n1_m1_412800_460800 0 1.532282e-07
I9041 n1_m1_412800_465600 0 2.298551e-07
I9042 n1_m1_412800_470400 0 1.536613e-07
I9043 n1_m1_412800_475200 0 1.537549e-07
I9044 n1_m1_412800_480000 0 2.299487e-07
I9045 n1_m1_412800_484800 0 1.511707e-07
I9046 n1_m1_412800_489600 0 2.218290e-07
I9047 n1_m1_412800_494400 0 1.472760e-07
I9048 n1_m1_417600_0 0 2.298422e-07
I9049 n1_m1_417600_4800 0 2.308869e-07
I9050 n1_m1_417600_9600 0 3.569664e-07
I9051 n1_m1_417600_14400 0 2.470192e-07
I9052 n1_m1_417600_19200 0 2.508921e-07
I9053 n1_m1_417600_24000 0 3.763381e-07
I9054 n1_m1_417600_28800 0 2.536617e-07
I9055 n1_m1_417600_33600 0 3.991783e-07
I9056 n1_m1_417600_38400 0 2.641468e-07
I9057 n1_m1_417600_43200 0 2.527174e-07
I9058 n1_m1_417600_48000 0 3.782544e-07
I9059 n1_m1_417600_52800 0 2.598217e-07
I9060 n1_m1_417600_57600 0 3.765149e-07
I9061 n1_m1_417600_62400 0 2.483586e-07
I9062 n1_m1_417600_67200 0 2.567394e-07
I9063 n1_m1_417600_72000 0 4.189906e-07
I9064 n1_m1_417600_76800 0 3.405997e-07
I9065 n1_m1_417600_81600 0 6.070531e-07
I9066 n1_m1_417600_86400 0 4.320611e-07
I9067 n1_m1_417600_91200 0 4.624556e-07
I9068 n1_m1_417600_96000 0 7.179456e-07
I9069 n1_m1_417600_100800 0 3.210109e-07
I9070 n1_m1_417600_105600 0 3.932813e-07
I9071 n1_m1_417600_110400 0 2.500277e-07
I9072 n1_m1_417600_115200 0 2.484957e-07
I9073 n1_m1_417600_120000 0 3.842985e-07
I9074 n1_m1_417600_124800 0 2.780655e-07
I9075 n1_m1_417600_129600 0 4.903239e-07
I9076 n1_m1_417600_134400 0 3.269890e-07
I9077 n1_m1_417600_139200 0 2.532884e-07
I9078 n1_m1_417600_144000 0 3.682727e-07
I9079 n1_m1_417600_148800 0 2.514426e-07
I9080 n1_m1_417600_153600 0 3.829099e-07
I9081 n1_m1_417600_158400 0 2.483772e-07
I9082 n1_m1_417600_163200 0 2.438562e-07
I9083 n1_m1_417600_168000 0 4.040814e-07
I9084 n1_m1_417600_172800 0 3.388150e-07
I9085 n1_m1_417600_177600 0 4.580527e-07
I9086 n1_m1_417600_182400 0 2.506427e-07
I9087 n1_m1_417600_187200 0 2.513171e-07
I9088 n1_m1_417600_192000 0 3.814093e-07
I9089 n1_m1_417600_196800 0 2.599367e-07
I9090 n1_m1_417600_201600 0 3.927536e-07
I9091 n1_m1_417600_206400 0 2.626747e-07
I9092 n1_m1_417600_211200 0 2.624599e-07
I9093 n1_m1_417600_216000 0 4.205244e-07
I9094 n1_m1_417600_220800 0 2.844767e-07
I9095 n1_m1_417600_225600 0 4.727134e-07
I9096 n1_m1_417600_230400 0 2.790462e-07
I9097 n1_m1_417600_235200 0 2.699452e-07
I9098 n1_m1_417600_240000 0 4.508862e-07
I9099 n1_m1_417600_244800 0 2.952951e-07
I9100 n1_m1_417600_249600 0 4.750008e-07
I9101 n1_m1_417600_254400 0 2.742386e-07
I9102 n1_m1_417600_259200 0 3.789047e-07
I9103 n1_m1_417600_264000 0 8.517645e-07
I9104 n1_m1_417600_268800 0 3.905403e-07
I9105 n1_m1_417600_273600 0 4.046845e-07
I9106 n1_m1_417600_278400 0 2.757712e-07
I9107 n1_m1_417600_283200 0 2.732794e-07
I9108 n1_m1_417600_288000 0 3.895096e-07
I9109 n1_m1_417600_292800 0 2.522915e-07
I9110 n1_m1_417600_297600 0 3.900445e-07
I9111 n1_m1_417600_302400 0 2.694985e-07
I9112 n1_m1_417600_307200 0 2.877460e-07
I9113 n1_m1_417600_312000 0 5.095099e-07
I9114 n1_m1_417600_316800 0 2.798673e-07
I9115 n1_m1_417600_321600 0 4.453825e-07
I9116 n1_m1_417600_326400 0 2.678153e-07
I9117 n1_m1_417600_331200 0 2.447847e-07
I9118 n1_m1_417600_336000 0 3.766002e-07
I9119 n1_m1_417600_340800 0 2.464356e-07
I9120 n1_m1_417600_345600 0 3.715904e-07
I9121 n1_m1_417600_350400 0 2.572273e-07
I9122 n1_m1_417600_355200 0 2.615635e-07
I9123 n1_m1_417600_360000 0 3.917861e-07
I9124 n1_m1_417600_364800 0 2.598217e-07
I9125 n1_m1_417600_369600 0 3.860202e-07
I9126 n1_m1_417600_374400 0 2.431883e-07
I9127 n1_m1_417600_379200 0 2.497710e-07
I9128 n1_m1_417600_384000 0 3.761306e-07
I9129 n1_m1_417600_388800 0 2.626485e-07
I9130 n1_m1_417600_393600 0 3.781415e-07
I9131 n1_m1_417600_398400 0 2.832341e-07
I9132 n1_m1_417600_403200 0 6.646474e-07
I9133 n1_m1_417600_408000 0 1.677041e-06
I9134 n1_m1_417600_412800 0 6.656511e-07
I9135 n1_m1_417600_417600 0 4.631440e-07
I9136 n1_m1_417600_422400 0 2.450411e-07
I9137 n1_m1_417600_427200 0 2.408818e-07
I9138 n1_m1_417600_432000 0 3.597531e-07
I9139 n1_m1_417600_436800 0 2.398354e-07
I9140 n1_m1_417600_441600 0 3.535525e-07
I9141 n1_m1_417600_446400 0 2.298422e-07
I9142 n1_m1_417600_451200 0 2.298422e-07
I9143 n1_m1_417600_456000 0 3.447634e-07
I9144 n1_m1_417600_460800 0 2.298422e-07
I9145 n1_m1_417600_465600 0 3.473026e-07
I9146 n1_m1_417600_470400 0 2.398184e-07
I9147 n1_m1_417600_475200 0 2.413246e-07
I9148 n1_m1_417600_480000 0 3.498242e-07
I9149 n1_m1_417600_484800 0 2.294002e-07
I9150 n1_m1_417600_489600 0 3.385406e-07
I9151 n1_m1_417600_494400 0 2.294935e-07
I9152 n1_m1_422400_0 0 7.716571e-08
I9153 n1_m1_422400_4800 0 7.680492e-08
I9154 n1_m1_422400_9600 0 1.179119e-07
I9155 n1_m1_422400_14400 0 8.272769e-08
I9156 n1_m1_422400_19200 0 8.401864e-08
I9157 n1_m1_422400_24000 0 1.258647e-07
I9158 n1_m1_422400_28800 0 8.311963e-08
I9159 n1_m1_422400_33600 0 1.243626e-07
I9160 n1_m1_422400_38400 0 8.327618e-08
I9161 n1_m1_422400_43200 0 8.327618e-08
I9162 n1_m1_422400_48000 0 1.260848e-07
I9163 n1_m1_422400_52800 0 8.660722e-08
I9164 n1_m1_422400_57600 0 1.260486e-07
I9165 n1_m1_422400_62400 0 8.131566e-08
I9166 n1_m1_422400_67200 0 8.385784e-08
I9167 n1_m1_422400_72000 0 1.309322e-07
I9168 n1_m1_422400_76800 0 9.061485e-08
I9169 n1_m1_422400_81600 0 1.396636e-07
I9170 n1_m1_422400_86400 0 9.363051e-08
I9171 n1_m1_422400_91200 0 9.952670e-08
I9172 n1_m1_422400_96000 0 1.705881e-07
I9173 n1_m1_422400_100800 0 9.465778e-08
I9174 n1_m1_422400_105600 0 1.317458e-07
I9175 n1_m1_422400_110400 0 8.306213e-08
I9176 n1_m1_422400_115200 0 8.150367e-08
I9177 n1_m1_422400_120000 0 1.268525e-07
I9178 n1_m1_422400_124800 0 9.036243e-08
I9179 n1_m1_422400_129600 0 1.331310e-07
I9180 n1_m1_422400_134400 0 8.458578e-08
I9181 n1_m1_422400_139200 0 8.360973e-08
I9182 n1_m1_422400_144000 0 1.284101e-07
I9183 n1_m1_422400_148800 0 8.305895e-08
I9184 n1_m1_422400_153600 0 1.202087e-07
I9185 n1_m1_422400_158400 0 8.087246e-08
I9186 n1_m1_422400_163200 0 8.360393e-08
I9187 n1_m1_422400_168000 0 1.276923e-07
I9188 n1_m1_422400_172800 0 8.321173e-08
I9189 n1_m1_422400_177600 0 1.288035e-07
I9190 n1_m1_422400_182400 0 8.714022e-08
I9191 n1_m1_422400_187200 0 8.618828e-08
I9192 n1_m1_422400_192000 0 1.290670e-07
I9193 n1_m1_422400_196800 0 8.762083e-08
I9194 n1_m1_422400_201600 0 1.345474e-07
I9195 n1_m1_422400_206400 0 9.057115e-08
I9196 n1_m1_422400_211200 0 9.026937e-08
I9197 n1_m1_422400_216000 0 1.575942e-07
I9198 n1_m1_422400_220800 0 1.066963e-07
I9199 n1_m1_422400_225600 0 1.287954e-07
I9200 n1_m1_422400_230400 0 9.105223e-08
I9201 n1_m1_422400_235200 0 9.233536e-08
I9202 n1_m1_422400_240000 0 1.553393e-07
I9203 n1_m1_422400_244800 0 1.053566e-07
I9204 n1_m1_422400_249600 0 1.353740e-07
I9205 n1_m1_422400_254400 0 1.033019e-07
I9206 n1_m1_422400_259200 0 1.986814e-07
I9207 n1_m1_422400_264000 0 4.752650e-07
I9208 n1_m1_422400_268800 0 1.864771e-07
I9209 n1_m1_422400_273600 0 1.376209e-07
I9210 n1_m1_422400_278400 0 8.310984e-08
I9211 n1_m1_422400_283200 0 8.751691e-08
I9212 n1_m1_422400_288000 0 1.340624e-07
I9213 n1_m1_422400_292800 0 8.626647e-08
I9214 n1_m1_422400_297600 0 1.225569e-07
I9215 n1_m1_422400_302400 0 8.206549e-08
I9216 n1_m1_422400_307200 0 8.598367e-08
I9217 n1_m1_422400_312000 0 1.329952e-07
I9218 n1_m1_422400_316800 0 8.581224e-08
I9219 n1_m1_422400_321600 0 1.314338e-07
I9220 n1_m1_422400_326400 0 8.169944e-08
I9221 n1_m1_422400_331200 0 8.024613e-08
I9222 n1_m1_422400_336000 0 1.290076e-07
I9223 n1_m1_422400_340800 0 8.592097e-08
I9224 n1_m1_422400_345600 0 1.256060e-07
I9225 n1_m1_422400_350400 0 8.393291e-08
I9226 n1_m1_422400_355200 0 8.370612e-08
I9227 n1_m1_422400_360000 0 1.289075e-07
I9228 n1_m1_422400_364800 0 8.660722e-08
I9229 n1_m1_422400_369600 0 1.279943e-07
I9230 n1_m1_422400_374400 0 8.094944e-08
I9231 n1_m1_422400_379200 0 8.242000e-08
I9232 n1_m1_422400_384000 0 1.194854e-07
I9233 n1_m1_422400_388800 0 8.413904e-08
I9234 n1_m1_422400_393600 0 1.253462e-07
I9235 n1_m1_422400_398400 0 9.122426e-08
I9236 n1_m1_422400_403200 0 1.483981e-07
I9237 n1_m1_422400_408000 0 3.400616e-07
I9238 n1_m1_422400_412800 0 1.664014e-07
I9239 n1_m1_422400_417600 0 1.436442e-07
I9240 n1_m1_422400_422400 0 8.033127e-08
I9241 n1_m1_422400_427200 0 7.994513e-08
I9242 n1_m1_422400_432000 0 1.199177e-07
I9243 n1_m1_422400_436800 0 7.994513e-08
I9244 n1_m1_422400_441600 0 1.178508e-07
I9245 n1_m1_422400_446400 0 7.661408e-08
I9246 n1_m1_422400_451200 0 7.661408e-08
I9247 n1_m1_422400_456000 0 1.149211e-07
I9248 n1_m1_422400_460800 0 7.661408e-08
I9249 n1_m1_422400_465600 0 1.175971e-07
I9250 n1_m1_422400_470400 0 8.312296e-08
I9251 n1_m1_422400_475200 0 8.384807e-08
I9252 n1_m1_422400_480000 0 1.200915e-07
I9253 n1_m1_422400_484800 0 7.661408e-08
I9254 n1_m1_422400_489600 0 1.152790e-07
I9255 n1_m1_422400_494400 0 7.908896e-08
I9256 n1_m1_427200_0 0 1.565332e-07
I9257 n1_m1_427200_4800 0 1.581042e-07
I9258 n1_m1_427200_9600 0 2.549216e-07
I9259 n1_m1_427200_14400 0 1.994421e-07
I9260 n1_m1_427200_19200 0 2.094931e-07
I9261 n1_m1_427200_24000 0 2.727820e-07
I9262 n1_m1_427200_28800 0 1.668094e-07
I9263 n1_m1_427200_33600 0 2.549713e-07
I9264 n1_m1_427200_38400 0 1.731923e-07
I9265 n1_m1_427200_43200 0 1.680679e-07
I9266 n1_m1_427200_48000 0 2.521696e-07
I9267 n1_m1_427200_52800 0 1.719299e-07
I9268 n1_m1_427200_57600 0 2.472259e-07
I9269 n1_m1_427200_62400 0 1.741118e-07
I9270 n1_m1_427200_67200 0 1.762164e-07
I9271 n1_m1_427200_72000 0 2.584862e-07
I9272 n1_m1_427200_76800 0 1.698299e-07
I9273 n1_m1_427200_81600 0 2.512172e-07
I9274 n1_m1_427200_86400 0 1.665524e-07
I9275 n1_m1_427200_91200 0 1.672138e-07
I9276 n1_m1_427200_96000 0 2.569410e-07
I9277 n1_m1_427200_100800 0 1.827661e-07
I9278 n1_m1_427200_105600 0 2.772332e-07
I9279 n1_m1_427200_110400 0 1.746860e-07
I9280 n1_m1_427200_115200 0 1.688699e-07
I9281 n1_m1_427200_120000 0 2.476332e-07
I9282 n1_m1_427200_124800 0 1.713682e-07
I9283 n1_m1_427200_129600 0 2.569264e-07
I9284 n1_m1_427200_134400 0 1.679393e-07
I9285 n1_m1_427200_139200 0 1.760673e-07
I9286 n1_m1_427200_144000 0 2.667178e-07
I9287 n1_m1_427200_148800 0 1.753370e-07
I9288 n1_m1_427200_153600 0 2.779023e-07
I9289 n1_m1_427200_158400 0 1.707530e-07
I9290 n1_m1_427200_163200 0 1.753534e-07
I9291 n1_m1_427200_168000 0 2.514970e-07
I9292 n1_m1_427200_172800 0 1.624404e-07
I9293 n1_m1_427200_177600 0 2.751393e-07
I9294 n1_m1_427200_182400 0 1.860914e-07
I9295 n1_m1_427200_187200 0 1.729724e-07
I9296 n1_m1_427200_192000 0 2.592535e-07
I9297 n1_m1_427200_196800 0 1.718892e-07
I9298 n1_m1_427200_201600 0 2.615073e-07
I9299 n1_m1_427200_206400 0 1.825412e-07
I9300 n1_m1_427200_211200 0 1.856819e-07
I9301 n1_m1_427200_216000 0 2.752832e-07
I9302 n1_m1_427200_220800 0 2.213044e-07
I9303 n1_m1_427200_225600 0 2.956911e-07
I9304 n1_m1_427200_230400 0 1.759292e-07
I9305 n1_m1_427200_235200 0 1.760706e-07
I9306 n1_m1_427200_240000 0 4.442446e-07
I9307 n1_m1_427200_244800 0 2.869443e-07
I9308 n1_m1_427200_249600 0 3.280277e-07
I9309 n1_m1_427200_254400 0 2.058155e-07
I9310 n1_m1_427200_259200 0 3.126331e-07
I9311 n1_m1_427200_264000 0 6.294936e-07
I9312 n1_m1_427200_268800 0 2.735012e-07
I9313 n1_m1_427200_273600 0 2.748949e-07
I9314 n1_m1_427200_278400 0 1.717379e-07
I9315 n1_m1_427200_283200 0 1.698838e-07
I9316 n1_m1_427200_288000 0 2.541515e-07
I9317 n1_m1_427200_292800 0 1.662454e-07
I9318 n1_m1_427200_297600 0 2.472293e-07
I9319 n1_m1_427200_302400 0 1.687457e-07
I9320 n1_m1_427200_307200 0 1.720442e-07
I9321 n1_m1_427200_312000 0 2.533437e-07
I9322 n1_m1_427200_316800 0 1.599989e-07
I9323 n1_m1_427200_321600 0 2.449428e-07
I9324 n1_m1_427200_326400 0 1.641447e-07
I9325 n1_m1_427200_331200 0 1.662385e-07
I9326 n1_m1_427200_336000 0 2.535219e-07
I9327 n1_m1_427200_340800 0 1.625792e-07
I9328 n1_m1_427200_345600 0 2.560358e-07
I9329 n1_m1_427200_350400 0 1.724452e-07
I9330 n1_m1_427200_355200 0 1.678402e-07
I9331 n1_m1_427200_360000 0 2.581467e-07
I9332 n1_m1_427200_364800 0 1.746621e-07
I9333 n1_m1_427200_369600 0 2.481575e-07
I9334 n1_m1_427200_374400 0 1.614089e-07
I9335 n1_m1_427200_379200 0 1.648400e-07
I9336 n1_m1_427200_384000 0 2.352803e-07
I9337 n1_m1_427200_388800 0 1.631009e-07
I9338 n1_m1_427200_393600 0 2.447536e-07
I9339 n1_m1_427200_398400 0 1.619305e-07
I9340 n1_m1_427200_403200 0 1.653331e-07
I9341 n1_m1_427200_408000 0 2.508995e-07
I9342 n1_m1_427200_412800 0 1.749636e-07
I9343 n1_m1_427200_417600 0 2.573178e-07
I9344 n1_m1_427200_422400 0 1.633551e-07
I9345 n1_m1_427200_427200 0 1.598903e-07
I9346 n1_m1_427200_432000 0 2.398354e-07
I9347 n1_m1_427200_436800 0 1.598903e-07
I9348 n1_m1_427200_441600 0 2.378017e-07
I9349 n1_m1_427200_446400 0 1.544175e-07
I9350 n1_m1_427200_451200 0 1.532282e-07
I9351 n1_m1_427200_456000 0 2.298422e-07
I9352 n1_m1_427200_460800 0 1.540811e-07
I9353 n1_m1_427200_465600 0 2.377672e-07
I9354 n1_m1_427200_470400 0 1.702847e-07
I9355 n1_m1_427200_475200 0 1.728733e-07
I9356 n1_m1_427200_480000 0 2.459423e-07
I9357 n1_m1_427200_484800 0 1.532282e-07
I9358 n1_m1_427200_489600 0 2.305580e-07
I9359 n1_m1_427200_494400 0 1.581779e-07
I9360 n1_m1_432000_0 0 2.339602e-07
I9361 n1_m1_432000_4800 0 2.451754e-07
I9362 n1_m1_432000_9600 0 4.618261e-07
I9363 n1_m1_432000_14400 0 4.640102e-07
I9364 n1_m1_432000_19200 0 4.787721e-07
I9365 n1_m1_432000_24000 0 4.682266e-07
I9366 n1_m1_432000_28800 0 2.536692e-07
I9367 n1_m1_432000_33600 0 3.875836e-07
I9368 n1_m1_432000_38400 0 2.582014e-07
I9369 n1_m1_432000_43200 0 2.476387e-07
I9370 n1_m1_432000_48000 0 3.713564e-07
I9371 n1_m1_432000_52800 0 2.576255e-07
I9372 n1_m1_432000_57600 0 3.825934e-07
I9373 n1_m1_432000_62400 0 2.691607e-07
I9374 n1_m1_432000_67200 0 2.648100e-07
I9375 n1_m1_432000_72000 0 3.801564e-07
I9376 n1_m1_432000_76800 0 2.498285e-07
I9377 n1_m1_432000_81600 0 3.747428e-07
I9378 n1_m1_432000_86400 0 2.498285e-07
I9379 n1_m1_432000_91200 0 2.500351e-07
I9380 n1_m1_432000_96000 0 3.769544e-07
I9381 n1_m1_432000_100800 0 2.563260e-07
I9382 n1_m1_432000_105600 0 3.847903e-07
I9383 n1_m1_432000_110400 0 2.499071e-07
I9384 n1_m1_432000_115200 0 2.530974e-07
I9385 n1_m1_432000_120000 0 3.896192e-07
I9386 n1_m1_432000_124800 0 2.706481e-07
I9387 n1_m1_432000_129600 0 5.022994e-07
I9388 n1_m1_432000_134400 0 3.423952e-07
I9389 n1_m1_432000_139200 0 2.936649e-07
I9390 n1_m1_432000_144000 0 4.409270e-07
I9391 n1_m1_432000_148800 0 3.525577e-07
I9392 n1_m1_432000_153600 0 5.268843e-07
I9393 n1_m1_432000_158400 0 2.613903e-07
I9394 n1_m1_432000_163200 0 2.504564e-07
I9395 n1_m1_432000_168000 0 3.664676e-07
I9396 n1_m1_432000_172800 0 2.843274e-07
I9397 n1_m1_432000_177600 0 6.474085e-07
I9398 n1_m1_432000_182400 0 3.434089e-07
I9399 n1_m1_432000_187200 0 2.709395e-07
I9400 n1_m1_432000_192000 0 4.057198e-07
I9401 n1_m1_432000_196800 0 2.617882e-07
I9402 n1_m1_432000_201600 0 3.858552e-07
I9403 n1_m1_432000_206400 0 2.624870e-07
I9404 n1_m1_432000_211200 0 2.732975e-07
I9405 n1_m1_432000_216000 0 7.285646e-07
I9406 n1_m1_432000_220800 0 1.095760e-06
I9407 n1_m1_432000_225600 0 1.225494e-06
I9408 n1_m1_432000_230400 0 3.039379e-07
I9409 n1_m1_432000_235200 0 2.894922e-07
I9410 n1_m1_432000_240000 0 1.283017e-06
I9411 n1_m1_432000_244800 0 1.071322e-06
I9412 n1_m1_432000_249600 0 6.274440e-07
I9413 n1_m1_432000_254400 0 2.757367e-07
I9414 n1_m1_432000_259200 0 2.789423e-07
I9415 n1_m1_432000_264000 0 5.205862e-07
I9416 n1_m1_432000_268800 0 3.096596e-07
I9417 n1_m1_432000_273600 0 3.961574e-07
I9418 n1_m1_432000_278400 0 2.617717e-07
I9419 n1_m1_432000_283200 0 2.607447e-07
I9420 n1_m1_432000_288000 0 3.802463e-07
I9421 n1_m1_432000_292800 0 2.523570e-07
I9422 n1_m1_432000_297600 0 3.851077e-07
I9423 n1_m1_432000_302400 0 2.587983e-07
I9424 n1_m1_432000_307200 0 2.560641e-07
I9425 n1_m1_432000_312000 0 3.667565e-07
I9426 n1_m1_432000_316800 0 2.447747e-07
I9427 n1_m1_432000_321600 0 3.833625e-07
I9428 n1_m1_432000_326400 0 2.466230e-07
I9429 n1_m1_432000_331200 0 2.526709e-07
I9430 n1_m1_432000_336000 0 4.066258e-07
I9431 n1_m1_432000_340800 0 2.589179e-07
I9432 n1_m1_432000_345600 0 3.835779e-07
I9433 n1_m1_432000_350400 0 2.570023e-07
I9434 n1_m1_432000_355200 0 2.521361e-07
I9435 n1_m1_432000_360000 0 3.945937e-07
I9436 n1_m1_432000_364800 0 2.645336e-07
I9437 n1_m1_432000_369600 0 3.664574e-07
I9438 n1_m1_432000_374400 0 2.362944e-07
I9439 n1_m1_432000_379200 0 2.452224e-07
I9440 n1_m1_432000_384000 0 3.570058e-07
I9441 n1_m1_432000_388800 0 2.515543e-07
I9442 n1_m1_432000_393600 0 3.825575e-07
I9443 n1_m1_432000_398400 0 2.471246e-07
I9444 n1_m1_432000_403200 0 2.497054e-07
I9445 n1_m1_432000_408000 0 3.720827e-07
I9446 n1_m1_432000_412800 0 2.444301e-07
I9447 n1_m1_432000_417600 0 3.683704e-07
I9448 n1_m1_432000_422400 0 2.409514e-07
I9449 n1_m1_432000_427200 0 2.388120e-07
I9450 n1_m1_432000_432000 0 3.739417e-07
I9451 n1_m1_432000_436800 0 2.413201e-07
I9452 n1_m1_432000_441600 0 3.554700e-07
I9453 n1_m1_432000_446400 0 2.309282e-07
I9454 n1_m1_432000_451200 0 2.305348e-07
I9455 n1_m1_432000_456000 0 3.460549e-07
I9456 n1_m1_432000_460800 0 2.323657e-07
I9457 n1_m1_432000_465600 0 3.600552e-07
I9458 n1_m1_432000_470400 0 2.502984e-07
I9459 n1_m1_432000_475200 0 2.578892e-07
I9460 n1_m1_432000_480000 0 3.689135e-07
I9461 n1_m1_432000_484800 0 2.294169e-07
I9462 n1_m1_432000_489600 0 3.387529e-07
I9463 n1_m1_432000_494400 0 2.303640e-07
I9464 n1_m1_436800_0 0 1.621790e-07
I9465 n1_m1_436800_4800 0 1.751015e-07
I9466 n1_m1_436800_9600 0 2.995692e-07
I9467 n1_m1_436800_14400 0 3.000735e-07
I9468 n1_m1_436800_19200 0 2.892237e-07
I9469 n1_m1_436800_24000 0 2.988133e-07
I9470 n1_m1_436800_28800 0 1.823638e-07
I9471 n1_m1_436800_33600 0 2.602994e-07
I9472 n1_m1_436800_38400 0 1.707812e-07
I9473 n1_m1_436800_43200 0 1.698331e-07
I9474 n1_m1_436800_48000 0 2.519919e-07
I9475 n1_m1_436800_52800 0 1.698057e-07
I9476 n1_m1_436800_57600 0 2.616978e-07
I9477 n1_m1_436800_62400 0 2.146527e-07
I9478 n1_m1_436800_67200 0 1.939259e-07
I9479 n1_m1_436800_72000 0 2.596073e-07
I9480 n1_m1_436800_76800 0 1.670570e-07
I9481 n1_m1_436800_81600 0 2.498285e-07
I9482 n1_m1_436800_86400 0 1.665524e-07
I9483 n1_m1_436800_91200 0 1.675512e-07
I9484 n1_m1_436800_96000 0 2.502311e-07
I9485 n1_m1_436800_100800 0 1.616026e-07
I9486 n1_m1_436800_105600 0 2.422497e-07
I9487 n1_m1_436800_110400 0 1.608575e-07
I9488 n1_m1_436800_115200 0 1.622337e-07
I9489 n1_m1_436800_120000 0 2.560178e-07
I9490 n1_m1_436800_124800 0 2.146675e-07
I9491 n1_m1_436800_129600 0 1.029054e-06
I9492 n1_m1_436800_134400 0 7.776355e-07
I9493 n1_m1_436800_139200 0 4.350517e-07
I9494 n1_m1_436800_144000 0 3.154650e-07
I9495 n1_m1_436800_148800 0 2.015666e-07
I9496 n1_m1_436800_153600 0 2.735166e-07
I9497 n1_m1_436800_158400 0 1.685323e-07
I9498 n1_m1_436800_163200 0 1.627523e-07
I9499 n1_m1_436800_168000 0 2.430675e-07
I9500 n1_m1_436800_172800 0 2.488683e-07
I9501 n1_m1_436800_177600 0 7.598822e-07
I9502 n1_m1_436800_182400 0 2.647666e-07
I9503 n1_m1_436800_187200 0 1.759775e-07
I9504 n1_m1_436800_192000 0 2.611486e-07
I9505 n1_m1_436800_196800 0 1.712011e-07
I9506 n1_m1_436800_201600 0 2.476687e-07
I9507 n1_m1_436800_206400 0 1.686827e-07
I9508 n1_m1_436800_211200 0 1.829330e-07
I9509 n1_m1_436800_216000 0 7.425022e-07
I9510 n1_m1_436800_220800 0 1.088688e-06
I9511 n1_m1_436800_225600 0 1.301607e-06
I9512 n1_m1_436800_230400 0 2.285448e-07
I9513 n1_m1_436800_235200 0 1.756669e-07
I9514 n1_m1_436800_240000 0 3.615888e-07
I9515 n1_m1_436800_244800 0 3.211901e-07
I9516 n1_m1_436800_249600 0 3.255573e-07
I9517 n1_m1_436800_254400 0 2.226452e-07
I9518 n1_m1_436800_259200 0 1.748699e-07
I9519 n1_m1_436800_264000 0 5.161377e-07
I9520 n1_m1_436800_268800 0 3.355242e-07
I9521 n1_m1_436800_273600 0 2.968992e-07
I9522 n1_m1_436800_278400 0 1.912967e-07
I9523 n1_m1_436800_283200 0 1.710595e-07
I9524 n1_m1_436800_288000 0 2.503577e-07
I9525 n1_m1_436800_292800 0 1.624596e-07
I9526 n1_m1_436800_297600 0 2.486434e-07
I9527 n1_m1_436800_302400 0 1.660306e-07
I9528 n1_m1_436800_307200 0 1.642256e-07
I9529 n1_m1_436800_312000 0 2.579508e-07
I9530 n1_m1_436800_316800 0 1.872105e-07
I9531 n1_m1_436800_321600 0 2.761517e-07
I9532 n1_m1_436800_326400 0 1.630822e-07
I9533 n1_m1_436800_331200 0 1.685565e-07
I9534 n1_m1_436800_336000 0 2.584703e-07
I9535 n1_m1_436800_340800 0 1.716340e-07
I9536 n1_m1_436800_345600 0 2.555259e-07
I9537 n1_m1_436800_350400 0 1.635595e-07
I9538 n1_m1_436800_355200 0 1.667153e-07
I9539 n1_m1_436800_360000 0 2.638359e-07
I9540 n1_m1_436800_364800 0 1.777032e-07
I9541 n1_m1_436800_369600 0 2.449440e-07
I9542 n1_m1_436800_374400 0 1.541344e-07
I9543 n1_m1_436800_379200 0 1.555478e-07
I9544 n1_m1_436800_384000 0 2.375996e-07
I9545 n1_m1_436800_388800 0 1.683970e-07
I9546 n1_m1_436800_393600 0 2.577050e-07
I9547 n1_m1_436800_398400 0 1.684209e-07
I9548 n1_m1_436800_403200 0 1.620066e-07
I9549 n1_m1_436800_408000 0 2.471999e-07
I9550 n1_m1_436800_412800 0 1.686185e-07
I9551 n1_m1_436800_417600 0 2.443166e-07
I9552 n1_m1_436800_422400 0 1.563977e-07
I9553 n1_m1_436800_427200 0 1.538235e-07
I9554 n1_m1_436800_432000 0 2.332433e-07
I9555 n1_m1_436800_436800 0 1.595077e-07
I9556 n1_m1_436800_441600 0 2.357017e-07
I9557 n1_m1_436800_446400 0 1.532282e-07
I9558 n1_m1_436800_451200 0 1.565777e-07
I9559 n1_m1_436800_456000 0 2.371691e-07
I9560 n1_m1_436800_460800 0 1.549375e-07
I9561 n1_m1_436800_465600 0 2.399892e-07
I9562 n1_m1_436800_470400 0 1.653350e-07
I9563 n1_m1_436800_475200 0 1.715021e-07
I9564 n1_m1_436800_480000 0 2.459423e-07
I9565 n1_m1_436800_484800 0 1.507064e-07
I9566 n1_m1_436800_489600 0 2.219502e-07
I9567 n1_m1_436800_494400 0 1.526329e-07
I9568 n1_m1_441600_0 0 2.340688e-07
I9569 n1_m1_441600_4800 0 2.552903e-07
I9570 n1_m1_441600_9600 0 3.814941e-07
I9571 n1_m1_441600_14400 0 2.999783e-07
I9572 n1_m1_441600_19200 0 3.276002e-07
I9573 n1_m1_441600_24000 0 4.623171e-07
I9574 n1_m1_441600_28800 0 4.055526e-07
I9575 n1_m1_441600_33600 0 7.633753e-07
I9576 n1_m1_441600_38400 0 3.444561e-07
I9577 n1_m1_441600_43200 0 2.870879e-07
I9578 n1_m1_441600_48000 0 4.078856e-07
I9579 n1_m1_441600_52800 0 2.692760e-07
I9580 n1_m1_441600_57600 0 4.307606e-07
I9581 n1_m1_441600_62400 0 4.003746e-07
I9582 n1_m1_441600_67200 0 3.444214e-07
I9583 n1_m1_441600_72000 0 4.076020e-07
I9584 n1_m1_441600_76800 0 2.541168e-07
I9585 n1_m1_441600_81600 0 3.747428e-07
I9586 n1_m1_441600_86400 0 2.498285e-07
I9587 n1_m1_441600_91200 0 2.499298e-07
I9588 n1_m1_441600_96000 0 3.719365e-07
I9589 n1_m1_441600_100800 0 2.481565e-07
I9590 n1_m1_441600_105600 0 3.780618e-07
I9591 n1_m1_441600_110400 0 2.466014e-07
I9592 n1_m1_441600_115200 0 2.399935e-07
I9593 n1_m1_441600_120000 0 3.745672e-07
I9594 n1_m1_441600_124800 0 3.413879e-07
I9595 n1_m1_441600_129600 0 1.941386e-06
I9596 n1_m1_441600_134400 0 1.692902e-06
I9597 n1_m1_441600_139200 0 1.152092e-06
I9598 n1_m1_441600_144000 0 6.111534e-07
I9599 n1_m1_441600_148800 0 2.562784e-07
I9600 n1_m1_441600_153600 0 3.787285e-07
I9601 n1_m1_441600_158400 0 2.425373e-07
I9602 n1_m1_441600_163200 0 2.489016e-07
I9603 n1_m1_441600_168000 0 3.755783e-07
I9604 n1_m1_441600_172800 0 3.138894e-07
I9605 n1_m1_441600_177600 0 7.900575e-07
I9606 n1_m1_441600_182400 0 3.416298e-07
I9607 n1_m1_441600_187200 0 2.634329e-07
I9608 n1_m1_441600_192000 0 3.882301e-07
I9609 n1_m1_441600_196800 0 2.550122e-07
I9610 n1_m1_441600_201600 0 3.854573e-07
I9611 n1_m1_441600_206400 0 2.589034e-07
I9612 n1_m1_441600_211200 0 2.566547e-07
I9613 n1_m1_441600_216000 0 5.219695e-07
I9614 n1_m1_441600_220800 0 6.799219e-07
I9615 n1_m1_441600_225600 0 9.424522e-07
I9616 n1_m1_441600_230400 0 2.843382e-07
I9617 n1_m1_441600_235200 0 2.647754e-07
I9618 n1_m1_441600_240000 0 3.929849e-07
I9619 n1_m1_441600_244800 0 2.618633e-07
I9620 n1_m1_441600_249600 0 4.000754e-07
I9621 n1_m1_441600_254400 0 2.940195e-07
I9622 n1_m1_441600_259200 0 3.683531e-07
I9623 n1_m1_441600_264000 0 1.304485e-06
I9624 n1_m1_441600_268800 0 1.074555e-06
I9625 n1_m1_441600_273600 0 7.544783e-07
I9626 n1_m1_441600_278400 0 2.699577e-07
I9627 n1_m1_441600_283200 0 2.637398e-07
I9628 n1_m1_441600_288000 0 3.777849e-07
I9629 n1_m1_441600_292800 0 2.408696e-07
I9630 n1_m1_441600_297600 0 3.604648e-07
I9631 n1_m1_441600_302400 0 2.429683e-07
I9632 n1_m1_441600_307200 0 2.512595e-07
I9633 n1_m1_441600_312000 0 4.235897e-07
I9634 n1_m1_441600_316800 0 4.598767e-07
I9635 n1_m1_441600_321600 0 7.637168e-07
I9636 n1_m1_441600_326400 0 2.891495e-07
I9637 n1_m1_441600_331200 0 2.408702e-07
I9638 n1_m1_441600_336000 0 3.792805e-07
I9639 n1_m1_441600_340800 0 3.271729e-07
I9640 n1_m1_441600_345600 0 5.614492e-07
I9641 n1_m1_441600_350400 0 2.837488e-07
I9642 n1_m1_441600_355200 0 2.560633e-07
I9643 n1_m1_441600_360000 0 3.771194e-07
I9644 n1_m1_441600_364800 0 2.519834e-07
I9645 n1_m1_441600_369600 0 3.712612e-07
I9646 n1_m1_441600_374400 0 2.328537e-07
I9647 n1_m1_441600_379200 0 2.418378e-07
I9648 n1_m1_441600_384000 0 3.793993e-07
I9649 n1_m1_441600_388800 0 2.441082e-07
I9650 n1_m1_441600_393600 0 3.679876e-07
I9651 n1_m1_441600_398400 0 2.471708e-07
I9652 n1_m1_441600_403200 0 2.493269e-07
I9653 n1_m1_441600_408000 0 3.705032e-07
I9654 n1_m1_441600_412800 0 2.408494e-07
I9655 n1_m1_441600_417600 0 3.476370e-07
I9656 n1_m1_441600_422400 0 2.320870e-07
I9657 n1_m1_441600_427200 0 2.318759e-07
I9658 n1_m1_441600_432000 0 3.462985e-07
I9659 n1_m1_441600_436800 0 2.389424e-07
I9660 n1_m1_441600_441600 0 3.535525e-07
I9661 n1_m1_441600_446400 0 2.298422e-07
I9662 n1_m1_441600_451200 0 2.329790e-07
I9663 n1_m1_441600_456000 0 3.567773e-07
I9664 n1_m1_441600_460800 0 2.354820e-07
I9665 n1_m1_441600_465600 0 3.598884e-07
I9666 n1_m1_441600_470400 0 2.447777e-07
I9667 n1_m1_441600_475200 0 2.531194e-07
I9668 n1_m1_441600_480000 0 3.643149e-07
I9669 n1_m1_441600_484800 0 2.256885e-07
I9670 n1_m1_441600_489600 0 3.363478e-07
I9671 n1_m1_441600_494400 0 2.357027e-07
I9672 n1_m1_446400_0 0 1.604650e-07
I9673 n1_m1_446400_4800 0 1.663279e-07
I9674 n1_m1_446400_9600 0 2.381511e-07
I9675 n1_m1_446400_14400 0 1.637297e-07
I9676 n1_m1_446400_19200 0 1.746606e-07
I9677 n1_m1_446400_24000 0 4.342623e-07
I9678 n1_m1_446400_28800 0 6.713766e-07
I9679 n1_m1_446400_33600 0 1.420643e-06
I9680 n1_m1_446400_38400 0 5.679778e-07
I9681 n1_m1_446400_43200 0 4.810772e-07
I9682 n1_m1_446400_48000 0 8.054170e-07
I9683 n1_m1_446400_52800 0 4.216667e-07
I9684 n1_m1_446400_57600 0 3.490715e-07
I9685 n1_m1_446400_62400 0 2.336498e-07
I9686 n1_m1_446400_67200 0 2.040148e-07
I9687 n1_m1_446400_72000 0 2.571159e-07
I9688 n1_m1_446400_76800 0 1.656578e-07
I9689 n1_m1_446400_81600 0 2.498285e-07
I9690 n1_m1_446400_86400 0 1.657411e-07
I9691 n1_m1_446400_91200 0 1.624700e-07
I9692 n1_m1_446400_96000 0 2.417346e-07
I9693 n1_m1_446400_100800 0 1.646661e-07
I9694 n1_m1_446400_105600 0 2.510151e-07
I9695 n1_m1_446400_110400 0 1.615591e-07
I9696 n1_m1_446400_115200 0 1.598903e-07
I9697 n1_m1_446400_120000 0 2.498608e-07
I9698 n1_m1_446400_124800 0 1.917358e-07
I9699 n1_m1_446400_129600 0 5.309682e-07
I9700 n1_m1_446400_134400 0 4.790102e-07
I9701 n1_m1_446400_139200 0 4.028898e-07
I9702 n1_m1_446400_144000 0 3.803797e-07
I9703 n1_m1_446400_148800 0 1.774755e-07
I9704 n1_m1_446400_153600 0 2.505988e-07
I9705 n1_m1_446400_158400 0 1.642113e-07
I9706 n1_m1_446400_163200 0 1.982861e-07
I9707 n1_m1_446400_168000 0 3.597300e-07
I9708 n1_m1_446400_172800 0 1.720737e-07
I9709 n1_m1_446400_177600 0 2.657424e-07
I9710 n1_m1_446400_182400 0 1.694838e-07
I9711 n1_m1_446400_187200 0 1.679520e-07
I9712 n1_m1_446400_192000 0 2.509188e-07
I9713 n1_m1_446400_196800 0 1.648400e-07
I9714 n1_m1_446400_201600 0 2.577262e-07
I9715 n1_m1_446400_206400 0 1.771144e-07
I9716 n1_m1_446400_211200 0 1.789618e-07
I9717 n1_m1_446400_216000 0 2.614424e-07
I9718 n1_m1_446400_220800 0 1.750901e-07
I9719 n1_m1_446400_225600 0 2.669672e-07
I9720 n1_m1_446400_230400 0 1.739643e-07
I9721 n1_m1_446400_235200 0 1.754404e-07
I9722 n1_m1_446400_240000 0 2.600520e-07
I9723 n1_m1_446400_244800 0 1.708733e-07
I9724 n1_m1_446400_249600 0 2.687051e-07
I9725 n1_m1_446400_254400 0 2.447751e-07
I9726 n1_m1_446400_259200 0 3.350601e-07
I9727 n1_m1_446400_264000 0 6.059828e-07
I9728 n1_m1_446400_268800 0 6.207001e-07
I9729 n1_m1_446400_273600 0 1.024919e-06
I9730 n1_m1_446400_278400 0 4.310567e-07
I9731 n1_m1_446400_283200 0 2.299859e-07
I9732 n1_m1_446400_288000 0 2.553476e-07
I9733 n1_m1_446400_292800 0 1.718358e-07
I9734 n1_m1_446400_297600 0 3.018521e-07
I9735 n1_m1_446400_302400 0 1.916188e-07
I9736 n1_m1_446400_307200 0 1.665784e-07
I9737 n1_m1_446400_312000 0 2.926713e-07
I9738 n1_m1_446400_316800 0 3.496172e-07
I9739 n1_m1_446400_321600 0 6.183073e-07
I9740 n1_m1_446400_326400 0 2.145010e-07
I9741 n1_m1_446400_331200 0 1.612746e-07
I9742 n1_m1_446400_336000 0 2.555527e-07
I9743 n1_m1_446400_340800 0 3.380575e-07
I9744 n1_m1_446400_345600 0 7.658257e-07
I9745 n1_m1_446400_350400 0 3.690002e-07
I9746 n1_m1_446400_355200 0 2.424899e-07
I9747 n1_m1_446400_360000 0 2.574622e-07
I9748 n1_m1_446400_364800 0 1.574174e-07
I9749 n1_m1_446400_369600 0 2.398152e-07
I9750 n1_m1_446400_374400 0 1.582849e-07
I9751 n1_m1_446400_379200 0 1.617146e-07
I9752 n1_m1_446400_384000 0 2.561583e-07
I9753 n1_m1_446400_388800 0 1.697451e-07
I9754 n1_m1_446400_393600 0 2.419438e-07
I9755 n1_m1_446400_398400 0 1.606189e-07
I9756 n1_m1_446400_403200 0 1.651641e-07
I9757 n1_m1_446400_408000 0 2.467825e-07
I9758 n1_m1_446400_412800 0 1.596952e-07
I9759 n1_m1_446400_417600 0 2.386497e-07
I9760 n1_m1_446400_422400 0 1.588462e-07
I9761 n1_m1_446400_427200 0 1.543799e-07
I9762 n1_m1_446400_432000 0 2.308656e-07
I9763 n1_m1_446400_436800 0 1.592950e-07
I9764 n1_m1_446400_441600 0 2.357017e-07
I9765 n1_m1_446400_446400 0 1.532282e-07
I9766 n1_m1_446400_451200 0 1.606605e-07
I9767 n1_m1_446400_456000 0 2.515229e-07
I9768 n1_m1_446400_460800 0 1.685323e-07
I9769 n1_m1_446400_465600 0 2.495490e-07
I9770 n1_m1_446400_470400 0 1.676691e-07
I9771 n1_m1_446400_475200 0 1.700504e-07
I9772 n1_m1_446400_480000 0 2.433380e-07
I9773 n1_m1_446400_484800 0 1.504590e-07
I9774 n1_m1_446400_489600 0 2.208163e-07
I9775 n1_m1_446400_494400 0 1.532552e-07
I9776 n1_m1_451200_0 0 8.008267e-08
I9777 n1_m1_451200_4800 0 7.992443e-08
I9778 n1_m1_451200_9600 0 1.173559e-07
I9779 n1_m1_451200_14400 0 8.263403e-08
I9780 n1_m1_451200_19200 0 8.501692e-08
I9781 n1_m1_451200_24000 0 2.824092e-07
I9782 n1_m1_451200_28800 0 4.797965e-07
I9783 n1_m1_451200_33600 0 9.266398e-07
I9784 n1_m1_451200_38400 0 3.907040e-07
I9785 n1_m1_451200_43200 0 3.631791e-07
I9786 n1_m1_451200_48000 0 6.908692e-07
I9787 n1_m1_451200_52800 0 3.957956e-07
I9788 n1_m1_451200_57600 0 2.856495e-07
I9789 n1_m1_451200_62400 0 1.039321e-07
I9790 n1_m1_451200_67200 0 8.853281e-08
I9791 n1_m1_451200_72000 0 1.224726e-07
I9792 n1_m1_451200_76800 0 8.177118e-08
I9793 n1_m1_451200_81600 0 1.249143e-07
I9794 n1_m1_451200_86400 0 8.291324e-08
I9795 n1_m1_451200_91200 0 8.116772e-08
I9796 n1_m1_451200_96000 0 1.199752e-07
I9797 n1_m1_451200_100800 0 8.233305e-08
I9798 n1_m1_451200_105600 0 1.240514e-07
I9799 n1_m1_451200_110400 0 7.994513e-08
I9800 n1_m1_451200_115200 0 8.082658e-08
I9801 n1_m1_451200_120000 0 1.429796e-07
I9802 n1_m1_451200_124800 0 9.349020e-08
I9803 n1_m1_451200_129600 0 1.399587e-07
I9804 n1_m1_451200_134400 0 1.196564e-07
I9805 n1_m1_451200_139200 0 1.526998e-07
I9806 n1_m1_451200_144000 0 1.896851e-07
I9807 n1_m1_451200_148800 0 9.060347e-08
I9808 n1_m1_451200_153600 0 1.286194e-07
I9809 n1_m1_451200_158400 0 8.607212e-08
I9810 n1_m1_451200_163200 0 1.273190e-07
I9811 n1_m1_451200_168000 0 2.509568e-07
I9812 n1_m1_451200_172800 0 9.438123e-08
I9813 n1_m1_451200_177600 0 1.234808e-07
I9814 n1_m1_451200_182400 0 8.076621e-08
I9815 n1_m1_451200_187200 0 8.145704e-08
I9816 n1_m1_451200_192000 0 1.221147e-07
I9817 n1_m1_451200_196800 0 8.070206e-08
I9818 n1_m1_451200_201600 0 1.264652e-07
I9819 n1_m1_451200_206400 0 9.431528e-08
I9820 n1_m1_451200_211200 0 1.262256e-07
I9821 n1_m1_451200_216000 0 2.047359e-07
I9822 n1_m1_451200_220800 0 9.275492e-08
I9823 n1_m1_451200_225600 0 1.286406e-07
I9824 n1_m1_451200_230400 0 8.624791e-08
I9825 n1_m1_451200_235200 0 8.498749e-08
I9826 n1_m1_451200_240000 0 1.267458e-07
I9827 n1_m1_451200_244800 0 8.520925e-08
I9828 n1_m1_451200_249600 0 1.326190e-07
I9829 n1_m1_451200_254400 0 1.268540e-07
I9830 n1_m1_451200_259200 0 1.665935e-07
I9831 n1_m1_451200_264000 0 1.931437e-07
I9832 n1_m1_451200_268800 0 2.612978e-07
I9833 n1_m1_451200_273600 0 6.840559e-07
I9834 n1_m1_451200_278400 0 3.219384e-07
I9835 n1_m1_451200_283200 0 1.299397e-07
I9836 n1_m1_451200_288000 0 1.311323e-07
I9837 n1_m1_451200_292800 0 8.843717e-08
I9838 n1_m1_451200_297600 0 1.702822e-07
I9839 n1_m1_451200_302400 0 1.308390e-07
I9840 n1_m1_451200_307200 0 1.266165e-07
I9841 n1_m1_451200_312000 0 1.708015e-07
I9842 n1_m1_451200_316800 0 1.414245e-07
I9843 n1_m1_451200_321600 0 2.285206e-07
I9844 n1_m1_451200_326400 0 9.815662e-08
I9845 n1_m1_451200_331200 0 8.358428e-08
I9846 n1_m1_451200_336000 0 1.275110e-07
I9847 n1_m1_451200_340800 0 1.696993e-07
I9848 n1_m1_451200_345600 0 4.069934e-07
I9849 n1_m1_451200_350400 0 2.147491e-07
I9850 n1_m1_451200_355200 0 1.411439e-07
I9851 n1_m1_451200_360000 0 1.339905e-07
I9852 n1_m1_451200_364800 0 7.943678e-08
I9853 n1_m1_451200_369600 0 1.196646e-07
I9854 n1_m1_451200_374400 0 8.202243e-08
I9855 n1_m1_451200_379200 0 8.077820e-08
I9856 n1_m1_451200_384000 0 1.271918e-07
I9857 n1_m1_451200_388800 0 8.764307e-08
I9858 n1_m1_451200_393600 0 1.232442e-07
I9859 n1_m1_451200_398400 0 8.038024e-08
I9860 n1_m1_451200_403200 0 8.265511e-08
I9861 n1_m1_451200_408000 0 1.232474e-07
I9862 n1_m1_451200_412800 0 8.017812e-08
I9863 n1_m1_451200_417600 0 1.239070e-07
I9864 n1_m1_451200_422400 0 8.074982e-08
I9865 n1_m1_451200_427200 0 7.730184e-08
I9866 n1_m1_451200_432000 0 1.166666e-07
I9867 n1_m1_451200_436800 0 7.977239e-08
I9868 n1_m1_451200_441600 0 1.187183e-07
I9869 n1_m1_451200_446400 0 7.891877e-08
I9870 n1_m1_451200_451200 0 8.297229e-08
I9871 n1_m1_451200_456000 0 1.327088e-07
I9872 n1_m1_451200_460800 0 8.940316e-08
I9873 n1_m1_451200_465600 0 1.315675e-07
I9874 n1_m1_451200_470400 0 8.752822e-08
I9875 n1_m1_451200_475200 0 8.672439e-08
I9876 n1_m1_451200_480000 0 1.229712e-07
I9877 n1_m1_451200_484800 0 7.522949e-08
I9878 n1_m1_451200_489600 0 1.102824e-07
I9879 n1_m1_451200_494400 0 7.575791e-08
I9880 n1_m1_456000_0 0 1.560409e-07
I9881 n1_m1_456000_4800 0 1.470071e-07
I9882 n1_m1_456000_9600 0 2.355694e-07
I9883 n1_m1_456000_14400 0 1.755823e-07
I9884 n1_m1_456000_19200 0 1.717415e-07
I9885 n1_m1_456000_24000 0 5.649310e-07
I9886 n1_m1_456000_28800 0 1.003011e-06
I9887 n1_m1_456000_33600 0 1.996008e-06
I9888 n1_m1_456000_38400 0 1.166312e-06
I9889 n1_m1_456000_43200 0 1.005152e-06
I9890 n1_m1_456000_48000 0 1.380063e-06
I9891 n1_m1_456000_52800 0 7.596006e-07
I9892 n1_m1_456000_57600 0 6.206471e-07
I9893 n1_m1_456000_62400 0 1.941490e-07
I9894 n1_m1_456000_67200 0 1.630397e-07
I9895 n1_m1_456000_72000 0 2.434490e-07
I9896 n1_m1_456000_76800 0 1.664949e-07
I9897 n1_m1_456000_81600 0 2.565868e-07
I9898 n1_m1_456000_86400 0 1.706826e-07
I9899 n1_m1_456000_91200 0 1.658011e-07
I9900 n1_m1_456000_96000 0 2.424223e-07
I9901 n1_m1_456000_100800 0 1.662514e-07
I9902 n1_m1_456000_105600 0 2.508913e-07
I9903 n1_m1_456000_110400 0 1.644821e-07
I9904 n1_m1_456000_115200 0 1.768314e-07
I9905 n1_m1_456000_120000 0 4.388156e-07
I9906 n1_m1_456000_124800 0 2.563204e-07
I9907 n1_m1_456000_129600 0 2.927498e-07
I9908 n1_m1_456000_134400 0 2.102216e-07
I9909 n1_m1_456000_139200 0 2.143575e-07
I9910 n1_m1_456000_144000 0 2.646814e-07
I9911 n1_m1_456000_148800 0 1.639965e-07
I9912 n1_m1_456000_153600 0 2.421082e-07
I9913 n1_m1_456000_158400 0 1.586863e-07
I9914 n1_m1_456000_163200 0 2.020066e-07
I9915 n1_m1_456000_168000 0 3.939953e-07
I9916 n1_m1_456000_172800 0 1.741387e-07
I9917 n1_m1_456000_177600 0 2.497608e-07
I9918 n1_m1_456000_182400 0 1.604612e-07
I9919 n1_m1_456000_187200 0 1.546275e-07
I9920 n1_m1_456000_192000 0 2.370248e-07
I9921 n1_m1_456000_196800 0 1.598903e-07
I9922 n1_m1_456000_201600 0 2.430141e-07
I9923 n1_m1_456000_206400 0 1.948188e-07
I9924 n1_m1_456000_211200 0 3.499840e-07
I9925 n1_m1_456000_216000 0 6.042506e-07
I9926 n1_m1_456000_220800 0 1.895163e-07
I9927 n1_m1_456000_225600 0 2.619534e-07
I9928 n1_m1_456000_230400 0 1.777417e-07
I9929 n1_m1_456000_235200 0 1.650467e-07
I9930 n1_m1_456000_240000 0 2.470048e-07
I9931 n1_m1_456000_244800 0 1.622186e-07
I9932 n1_m1_456000_249600 0 2.544853e-07
I9933 n1_m1_456000_254400 0 1.777131e-07
I9934 n1_m1_456000_259200 0 1.910965e-07
I9935 n1_m1_456000_264000 0 3.020229e-07
I9936 n1_m1_456000_268800 0 4.130997e-07
I9937 n1_m1_456000_273600 0 8.760802e-07
I9938 n1_m1_456000_278400 0 3.390763e-07
I9939 n1_m1_456000_283200 0 1.856266e-07
I9940 n1_m1_456000_288000 0 2.704662e-07
I9941 n1_m1_456000_292800 0 1.683449e-07
I9942 n1_m1_456000_297600 0 2.645637e-07
I9943 n1_m1_456000_302400 0 4.243731e-07
I9944 n1_m1_456000_307200 0 7.752616e-07
I9945 n1_m1_456000_312000 0 6.612465e-07
I9946 n1_m1_456000_316800 0 1.874040e-07
I9947 n1_m1_456000_321600 0 2.443517e-07
I9948 n1_m1_456000_326400 0 1.651825e-07
I9949 n1_m1_456000_331200 0 1.649054e-07
I9950 n1_m1_456000_336000 0 2.331632e-07
I9951 n1_m1_456000_340800 0 1.608587e-07
I9952 n1_m1_456000_345600 0 2.609664e-07
I9953 n1_m1_456000_350400 0 1.838782e-07
I9954 n1_m1_456000_355200 0 1.799356e-07
I9955 n1_m1_456000_360000 0 2.557747e-07
I9956 n1_m1_456000_364800 0 1.664796e-07
I9957 n1_m1_456000_369600 0 2.590095e-07
I9958 n1_m1_456000_374400 0 1.816820e-07
I9959 n1_m1_456000_379200 0 1.724357e-07
I9960 n1_m1_456000_384000 0 2.606244e-07
I9961 n1_m1_456000_388800 0 1.786690e-07
I9962 n1_m1_456000_393600 0 2.777224e-07
I9963 n1_m1_456000_398400 0 2.629798e-07
I9964 n1_m1_456000_403200 0 3.075917e-07
I9965 n1_m1_456000_408000 0 2.953587e-07
I9966 n1_m1_456000_412800 0 1.614253e-07
I9967 n1_m1_456000_417600 0 2.474693e-07
I9968 n1_m1_456000_422400 0 1.633551e-07
I9969 n1_m1_456000_427200 0 1.598257e-07
I9970 n1_m1_456000_432000 0 2.475092e-07
I9971 n1_m1_456000_436800 0 1.559195e-07
I9972 n1_m1_456000_441600 0 2.433981e-07
I9973 n1_m1_456000_446400 0 1.707463e-07
I9974 n1_m1_456000_451200 0 1.820179e-07
I9975 n1_m1_456000_456000 0 2.972464e-07
I9976 n1_m1_456000_460800 0 1.969163e-07
I9977 n1_m1_456000_465600 0 2.783908e-07
I9978 n1_m1_456000_470400 0 1.778955e-07
I9979 n1_m1_456000_475200 0 1.708206e-07
I9980 n1_m1_456000_480000 0 2.372438e-07
I9981 n1_m1_456000_484800 0 1.522490e-07
I9982 n1_m1_456000_489600 0 2.255256e-07
I9983 n1_m1_456000_494400 0 1.519233e-07
I9984 n1_m1_460800_0 0 1.594801e-07
I9985 n1_m1_460800_4800 0 1.611285e-07
I9986 n1_m1_460800_9600 0 2.356032e-07
I9987 n1_m1_460800_14400 0 1.676858e-07
I9988 n1_m1_460800_19200 0 1.726016e-07
I9989 n1_m1_460800_24000 0 3.520541e-07
I9990 n1_m1_460800_28800 0 5.780023e-07
I9991 n1_m1_460800_33600 0 1.621682e-06
I9992 n1_m1_460800_38400 0 1.148262e-06
I9993 n1_m1_460800_43200 0 9.526216e-07
I9994 n1_m1_460800_48000 0 9.055097e-07
I9995 n1_m1_460800_52800 0 3.560959e-07
I9996 n1_m1_460800_57600 0 3.125658e-07
I9997 n1_m1_460800_62400 0 1.734262e-07
I9998 n1_m1_460800_67200 0 1.666747e-07
I9999 n1_m1_460800_72000 0 2.441321e-07
I10000 n1_m1_460800_76800 0 1.665524e-07
I10001 n1_m1_460800_81600 0 2.540406e-07
I10002 n1_m1_460800_86400 0 1.653598e-07
I10003 n1_m1_460800_91200 0 1.652074e-07
I10004 n1_m1_460800_96000 0 2.508670e-07
I10005 n1_m1_460800_100800 0 1.729736e-07
I10006 n1_m1_460800_105600 0 2.655884e-07
I10007 n1_m1_460800_110400 0 1.743540e-07
I10008 n1_m1_460800_115200 0 1.820841e-07
I10009 n1_m1_460800_120000 0 4.428874e-07
I10010 n1_m1_460800_124800 0 3.258377e-07
I10011 n1_m1_460800_129600 0 3.085691e-07
I10012 n1_m1_460800_134400 0 1.726867e-07
I10013 n1_m1_460800_139200 0 1.709787e-07
I10014 n1_m1_460800_144000 0 2.591040e-07
I10015 n1_m1_460800_148800 0 1.702951e-07
I10016 n1_m1_460800_153600 0 2.478313e-07
I10017 n1_m1_460800_158400 0 1.562014e-07
I10018 n1_m1_460800_163200 0 1.627586e-07
I10019 n1_m1_460800_168000 0 2.445585e-07
I10020 n1_m1_460800_172800 0 1.555215e-07
I10021 n1_m1_460800_177600 0 2.521368e-07
I10022 n1_m1_460800_182400 0 1.583122e-07
I10023 n1_m1_460800_187200 0 1.544841e-07
I10024 n1_m1_460800_192000 0 2.326370e-07
I10025 n1_m1_460800_196800 0 1.598903e-07
I10026 n1_m1_460800_201600 0 2.479573e-07
I10027 n1_m1_460800_206400 0 1.762278e-07
I10028 n1_m1_460800_211200 0 2.112204e-07
I10029 n1_m1_460800_216000 0 3.573316e-07
I10030 n1_m1_460800_220800 0 1.737549e-07
I10031 n1_m1_460800_225600 0 2.626845e-07
I10032 n1_m1_460800_230400 0 1.783320e-07
I10033 n1_m1_460800_235200 0 1.620880e-07
I10034 n1_m1_460800_240000 0 2.552858e-07
I10035 n1_m1_460800_244800 0 1.644034e-07
I10036 n1_m1_460800_249600 0 2.465613e-07
I10037 n1_m1_460800_254400 0 1.680968e-07
I10038 n1_m1_460800_259200 0 1.738055e-07
I10039 n1_m1_460800_264000 0 2.924176e-07
I10040 n1_m1_460800_268800 0 2.852610e-07
I10041 n1_m1_460800_273600 0 3.901754e-07
I10042 n1_m1_460800_278400 0 1.768324e-07
I10043 n1_m1_460800_283200 0 1.765825e-07
I10044 n1_m1_460800_288000 0 2.685391e-07
I10045 n1_m1_460800_292800 0 1.806653e-07
I10046 n1_m1_460800_297600 0 3.367047e-07
I10047 n1_m1_460800_302400 0 4.201126e-07
I10048 n1_m1_460800_307200 0 6.631792e-07
I10049 n1_m1_460800_312000 0 5.326718e-07
I10050 n1_m1_460800_316800 0 1.788934e-07
I10051 n1_m1_460800_321600 0 2.424348e-07
I10052 n1_m1_460800_326400 0 1.639207e-07
I10053 n1_m1_460800_331200 0 1.594983e-07
I10054 n1_m1_460800_336000 0 2.374011e-07
I10055 n1_m1_460800_340800 0 1.632464e-07
I10056 n1_m1_460800_345600 0 2.426493e-07
I10057 n1_m1_460800_350400 0 1.681890e-07
I10058 n1_m1_460800_355200 0 1.719756e-07
I10059 n1_m1_460800_360000 0 2.520306e-07
I10060 n1_m1_460800_364800 0 1.655915e-07
I10061 n1_m1_460800_369600 0 2.537255e-07
I10062 n1_m1_460800_374400 0 1.735839e-07
I10063 n1_m1_460800_379200 0 1.707842e-07
I10064 n1_m1_460800_384000 0 2.632508e-07
I10065 n1_m1_460800_388800 0 1.745301e-07
I10066 n1_m1_460800_393600 0 3.460668e-07
I10067 n1_m1_460800_398400 0 5.743079e-07
I10068 n1_m1_460800_403200 0 7.548117e-07
I10069 n1_m1_460800_408000 0 5.631397e-07
I10070 n1_m1_460800_412800 0 1.753692e-07
I10071 n1_m1_460800_417600 0 2.439016e-07
I10072 n1_m1_460800_422400 0 1.642282e-07
I10073 n1_m1_460800_427200 0 1.598903e-07
I10074 n1_m1_460800_432000 0 2.373893e-07
I10075 n1_m1_460800_436800 0 1.547965e-07
I10076 n1_m1_460800_441600 0 2.445092e-07
I10077 n1_m1_460800_446400 0 1.725522e-07
I10078 n1_m1_460800_451200 0 1.816377e-07
I10079 n1_m1_460800_456000 0 2.758332e-07
I10080 n1_m1_460800_460800 0 1.766774e-07
I10081 n1_m1_460800_465600 0 2.572741e-07
I10082 n1_m1_460800_470400 0 1.661577e-07
I10083 n1_m1_460800_475200 0 1.593066e-07
I10084 n1_m1_460800_480000 0 2.267268e-07
I10085 n1_m1_460800_484800 0 1.493548e-07
I10086 n1_m1_460800_489600 0 2.299946e-07
I10087 n1_m1_460800_494400 0 1.544669e-07
I10088 n1_m1_465600_0 0 2.235066e-07
I10089 n1_m1_465600_4800 0 2.319942e-07
I10090 n1_m1_465600_9600 0 3.455780e-07
I10091 n1_m1_465600_14400 0 2.423663e-07
I10092 n1_m1_465600_19200 0 2.530759e-07
I10093 n1_m1_465600_24000 0 3.746860e-07
I10094 n1_m1_465600_28800 0 3.438341e-07
I10095 n1_m1_465600_33600 0 1.149728e-06
I10096 n1_m1_465600_38400 0 1.184138e-06
I10097 n1_m1_465600_43200 0 1.475154e-06
I10098 n1_m1_465600_48000 0 2.233308e-06
I10099 n1_m1_465600_52800 0 1.265660e-06
I10100 n1_m1_465600_57600 0 1.036848e-06
I10101 n1_m1_465600_62400 0 3.000318e-07
I10102 n1_m1_465600_67200 0 2.472230e-07
I10103 n1_m1_465600_72000 0 3.630409e-07
I10104 n1_m1_465600_76800 0 2.446647e-07
I10105 n1_m1_465600_81600 0 3.717161e-07
I10106 n1_m1_465600_86400 0 2.453626e-07
I10107 n1_m1_465600_91200 0 2.470681e-07
I10108 n1_m1_465600_96000 0 3.822519e-07
I10109 n1_m1_465600_100800 0 6.390482e-07
I10110 n1_m1_465600_105600 0 5.640074e-07
I10111 n1_m1_465600_110400 0 2.784190e-07
I10112 n1_m1_465600_115200 0 2.559973e-07
I10113 n1_m1_465600_120000 0 6.977289e-07
I10114 n1_m1_465600_124800 0 5.206791e-07
I10115 n1_m1_465600_129600 0 4.940818e-07
I10116 n1_m1_465600_134400 0 2.500191e-07
I10117 n1_m1_465600_139200 0 2.423276e-07
I10118 n1_m1_465600_144000 0 3.590221e-07
I10119 n1_m1_465600_148800 0 2.351952e-07
I10120 n1_m1_465600_153600 0 3.607556e-07
I10121 n1_m1_465600_158400 0 2.433084e-07
I10122 n1_m1_465600_163200 0 2.395637e-07
I10123 n1_m1_465600_168000 0 3.537625e-07
I10124 n1_m1_465600_172800 0 2.383721e-07
I10125 n1_m1_465600_177600 0 3.813065e-07
I10126 n1_m1_465600_182400 0 2.443417e-07
I10127 n1_m1_465600_187200 0 2.398543e-07
I10128 n1_m1_465600_192000 0 3.638186e-07
I10129 n1_m1_465600_196800 0 2.481410e-07
I10130 n1_m1_465600_201600 0 3.716326e-07
I10131 n1_m1_465600_206400 0 2.500790e-07
I10132 n1_m1_465600_211200 0 2.541851e-07
I10133 n1_m1_465600_216000 0 5.158940e-07
I10134 n1_m1_465600_220800 0 3.709085e-07
I10135 n1_m1_465600_225600 0 3.808578e-07
I10136 n1_m1_465600_230400 0 2.497380e-07
I10137 n1_m1_465600_235200 0 2.501696e-07
I10138 n1_m1_465600_240000 0 3.818777e-07
I10139 n1_m1_465600_244800 0 2.452676e-07
I10140 n1_m1_465600_249600 0 3.660050e-07
I10141 n1_m1_465600_254400 0 2.446647e-07
I10142 n1_m1_465600_259200 0 2.462958e-07
I10143 n1_m1_465600_264000 0 3.851797e-07
I10144 n1_m1_465600_268800 0 2.884676e-07
I10145 n1_m1_465600_273600 0 4.624780e-07
I10146 n1_m1_465600_278400 0 3.433055e-07
I10147 n1_m1_465600_283200 0 3.322590e-07
I10148 n1_m1_465600_288000 0 5.682909e-07
I10149 n1_m1_465600_292800 0 4.993279e-07
I10150 n1_m1_465600_297600 0 7.821182e-07
I10151 n1_m1_465600_302400 0 7.057139e-07
I10152 n1_m1_465600_307200 0 1.000652e-06
I10153 n1_m1_465600_312000 0 8.033195e-07
I10154 n1_m1_465600_316800 0 2.667816e-07
I10155 n1_m1_465600_321600 0 3.707201e-07
I10156 n1_m1_465600_326400 0 2.406201e-07
I10157 n1_m1_465600_331200 0 2.322987e-07
I10158 n1_m1_465600_336000 0 3.604179e-07
I10159 n1_m1_465600_340800 0 2.553165e-07
I10160 n1_m1_465600_345600 0 3.843469e-07
I10161 n1_m1_465600_350400 0 2.640983e-07
I10162 n1_m1_465600_355200 0 2.632215e-07
I10163 n1_m1_465600_360000 0 3.806906e-07
I10164 n1_m1_465600_364800 0 2.450535e-07
I10165 n1_m1_465600_369600 0 3.757236e-07
I10166 n1_m1_465600_374400 0 2.583165e-07
I10167 n1_m1_465600_379200 0 2.472978e-07
I10168 n1_m1_465600_384000 0 3.748140e-07
I10169 n1_m1_465600_388800 0 2.495738e-07
I10170 n1_m1_465600_393600 0 6.243894e-07
I10171 n1_m1_465600_398400 0 1.292674e-06
I10172 n1_m1_465600_403200 0 1.606971e-06
I10173 n1_m1_465600_408000 0 1.126573e-06
I10174 n1_m1_465600_412800 0 2.909410e-07
I10175 n1_m1_465600_417600 0 3.890781e-07
I10176 n1_m1_465600_422400 0 2.627218e-07
I10177 n1_m1_465600_427200 0 2.551729e-07
I10178 n1_m1_465600_432000 0 3.619993e-07
I10179 n1_m1_465600_436800 0 2.349637e-07
I10180 n1_m1_465600_441600 0 3.674468e-07
I10181 n1_m1_465600_446400 0 3.418298e-07
I10182 n1_m1_465600_451200 0 4.246581e-07
I10183 n1_m1_465600_456000 0 4.812407e-07
I10184 n1_m1_465600_460800 0 2.522522e-07
I10185 n1_m1_465600_465600 0 3.666471e-07
I10186 n1_m1_465600_470400 0 2.365356e-07
I10187 n1_m1_465600_475200 0 2.301786e-07
I10188 n1_m1_465600_480000 0 3.316605e-07
I10189 n1_m1_465600_484800 0 2.218565e-07
I10190 n1_m1_465600_489600 0 3.424100e-07
I10191 n1_m1_465600_494400 0 2.334303e-07
I10192 n1_m1_470400_0 0 1.495212e-07
I10193 n1_m1_470400_4800 0 1.482206e-07
I10194 n1_m1_470400_9600 0 2.400081e-07
I10195 n1_m1_470400_14400 0 1.689202e-07
I10196 n1_m1_470400_19200 0 1.715021e-07
I10197 n1_m1_470400_24000 0 2.445617e-07
I10198 n1_m1_470400_28800 0 1.731574e-07
I10199 n1_m1_470400_33600 0 4.715262e-07
I10200 n1_m1_470400_38400 0 7.278943e-07
I10201 n1_m1_470400_43200 0 1.152264e-06
I10202 n1_m1_470400_48000 0 2.070055e-06
I10203 n1_m1_470400_52800 0 1.331710e-06
I10204 n1_m1_470400_57600 0 1.474960e-06
I10205 n1_m1_470400_62400 0 2.972932e-07
I10206 n1_m1_470400_67200 0 1.724635e-07
I10207 n1_m1_470400_72000 0 2.455805e-07
I10208 n1_m1_470400_76800 0 1.598903e-07
I10209 n1_m1_470400_81600 0 2.470058e-07
I10210 n1_m1_470400_86400 0 1.674817e-07
I10211 n1_m1_470400_91200 0 1.695765e-07
I10212 n1_m1_470400_96000 0 2.766876e-07
I10213 n1_m1_470400_100800 0 7.747808e-07
I10214 n1_m1_470400_105600 0 5.332986e-07
I10215 n1_m1_470400_110400 0 1.834063e-07
I10216 n1_m1_470400_115200 0 1.710180e-07
I10217 n1_m1_470400_120000 0 4.307880e-07
I10218 n1_m1_470400_124800 0 3.282508e-07
I10219 n1_m1_470400_129600 0 2.994659e-07
I10220 n1_m1_470400_134400 0 1.604399e-07
I10221 n1_m1_470400_139200 0 1.597625e-07
I10222 n1_m1_470400_144000 0 2.389273e-07
I10223 n1_m1_470400_148800 0 1.541646e-07
I10224 n1_m1_470400_153600 0 2.312891e-07
I10225 n1_m1_470400_158400 0 1.549405e-07
I10226 n1_m1_470400_163200 0 1.538230e-07
I10227 n1_m1_470400_168000 0 2.315718e-07
I10228 n1_m1_470400_172800 0 1.550445e-07
I10229 n1_m1_470400_177600 0 2.342324e-07
I10230 n1_m1_470400_182400 0 1.562516e-07
I10231 n1_m1_470400_187200 0 1.593379e-07
I10232 n1_m1_470400_192000 0 2.508921e-07
I10233 n1_m1_470400_196800 0 1.706058e-07
I10234 n1_m1_470400_201600 0 2.437015e-07
I10235 n1_m1_470400_206400 0 1.607797e-07
I10236 n1_m1_470400_211200 0 1.683660e-07
I10237 n1_m1_470400_216000 0 3.891196e-07
I10238 n1_m1_470400_220800 0 2.840921e-07
I10239 n1_m1_470400_225600 0 2.521384e-07
I10240 n1_m1_470400_230400 0 1.663336e-07
I10241 n1_m1_470400_235200 0 1.738433e-07
I10242 n1_m1_470400_240000 0 2.615504e-07
I10243 n1_m1_470400_244800 0 1.666768e-07
I10244 n1_m1_470400_249600 0 2.426305e-07
I10245 n1_m1_470400_254400 0 1.598903e-07
I10246 n1_m1_470400_259200 0 1.615914e-07
I10247 n1_m1_470400_264000 0 2.537359e-07
I10248 n1_m1_470400_268800 0 1.788068e-07
I10249 n1_m1_470400_273600 0 3.235224e-07
I10250 n1_m1_470400_278400 0 3.642942e-07
I10251 n1_m1_470400_283200 0 5.329206e-07
I10252 n1_m1_470400_288000 0 1.087243e-06
I10253 n1_m1_470400_292800 0 7.674299e-07
I10254 n1_m1_470400_297600 0 8.438225e-07
I10255 n1_m1_470400_302400 0 6.151845e-07
I10256 n1_m1_470400_307200 0 7.877775e-07
I10257 n1_m1_470400_312000 0 6.116410e-07
I10258 n1_m1_470400_316800 0 1.829305e-07
I10259 n1_m1_470400_321600 0 2.447492e-07
I10260 n1_m1_470400_326400 0 1.600362e-07
I10261 n1_m1_470400_331200 0 1.589832e-07
I10262 n1_m1_470400_336000 0 2.386523e-07
I10263 n1_m1_470400_340800 0 1.622831e-07
I10264 n1_m1_470400_345600 0 2.513329e-07
I10265 n1_m1_470400_350400 0 1.933546e-07
I10266 n1_m1_470400_355200 0 2.927981e-07
I10267 n1_m1_470400_360000 0 3.738043e-07
I10268 n1_m1_470400_364800 0 1.703359e-07
I10269 n1_m1_470400_369600 0 2.798526e-07
I10270 n1_m1_470400_374400 0 2.319977e-07
I10271 n1_m1_470400_379200 0 1.905780e-07
I10272 n1_m1_470400_384000 0 2.657216e-07
I10273 n1_m1_470400_388800 0 1.630778e-07
I10274 n1_m1_470400_393600 0 2.833359e-07
I10275 n1_m1_470400_398400 0 4.183596e-07
I10276 n1_m1_470400_403200 0 5.901548e-07
I10277 n1_m1_470400_408000 0 4.599903e-07
I10278 n1_m1_470400_412800 0 1.629507e-07
I10279 n1_m1_470400_417600 0 2.525482e-07
I10280 n1_m1_470400_422400 0 1.722432e-07
I10281 n1_m1_470400_427200 0 1.744358e-07
I10282 n1_m1_470400_432000 0 2.515005e-07
I10283 n1_m1_470400_436800 0 1.592597e-07
I10284 n1_m1_470400_441600 0 2.362955e-07
I10285 n1_m1_470400_446400 0 2.247890e-07
I10286 n1_m1_470400_451200 0 2.995808e-07
I10287 n1_m1_470400_456000 0 3.145739e-07
I10288 n1_m1_470400_460800 0 1.610582e-07
I10289 n1_m1_470400_465600 0 2.354795e-07
I10290 n1_m1_470400_470400 0 1.496797e-07
I10291 n1_m1_470400_475200 0 1.480069e-07
I10292 n1_m1_470400_480000 0 2.201300e-07
I10293 n1_m1_470400_484800 0 1.465661e-07
I10294 n1_m1_470400_489600 0 2.261366e-07
I10295 n1_m1_470400_494400 0 1.532282e-07
I10296 n1_m1_475200_0 0 1.637986e-07
I10297 n1_m1_475200_4800 0 1.617034e-07
I10298 n1_m1_475200_9600 0 2.361571e-07
I10299 n1_m1_475200_14400 0 1.646594e-07
I10300 n1_m1_475200_19200 0 1.674598e-07
I10301 n1_m1_475200_24000 0 2.474790e-07
I10302 n1_m1_475200_28800 0 1.607901e-07
I10303 n1_m1_475200_33600 0 2.911622e-07
I10304 n1_m1_475200_38400 0 3.796724e-07
I10305 n1_m1_475200_43200 0 7.164746e-07
I10306 n1_m1_475200_48000 0 1.652573e-06
I10307 n1_m1_475200_52800 0 1.144425e-06
I10308 n1_m1_475200_57600 0 1.296395e-06
I10309 n1_m1_475200_62400 0 2.847864e-07
I10310 n1_m1_475200_67200 0 1.750858e-07
I10311 n1_m1_475200_72000 0 2.469083e-07
I10312 n1_m1_475200_76800 0 1.598903e-07
I10313 n1_m1_475200_81600 0 2.466979e-07
I10314 n1_m1_475200_86400 0 1.668502e-07
I10315 n1_m1_475200_91200 0 1.686156e-07
I10316 n1_m1_475200_96000 0 4.449041e-07
I10317 n1_m1_475200_100800 0 9.650720e-07
I10318 n1_m1_475200_105600 0 6.303866e-07
I10319 n1_m1_475200_110400 0 1.785473e-07
I10320 n1_m1_475200_115200 0 1.748081e-07
I10321 n1_m1_475200_120000 0 2.944579e-07
I10322 n1_m1_475200_124800 0 1.960485e-07
I10323 n1_m1_475200_129600 0 2.418742e-07
I10324 n1_m1_475200_134400 0 1.547549e-07
I10325 n1_m1_475200_139200 0 1.575010e-07
I10326 n1_m1_475200_144000 0 2.404982e-07
I10327 n1_m1_475200_148800 0 1.601106e-07
I10328 n1_m1_475200_153600 0 2.428423e-07
I10329 n1_m1_475200_158400 0 1.589883e-07
I10330 n1_m1_475200_163200 0 1.556299e-07
I10331 n1_m1_475200_168000 0 2.304629e-07
I10332 n1_m1_475200_172800 0 1.534874e-07
I10333 n1_m1_475200_177600 0 2.298470e-07
I10334 n1_m1_475200_182400 0 1.536488e-07
I10335 n1_m1_475200_187200 0 1.587606e-07
I10336 n1_m1_475200_192000 0 2.504499e-07
I10337 n1_m1_475200_196800 0 1.702647e-07
I10338 n1_m1_475200_201600 0 2.435036e-07
I10339 n1_m1_475200_206400 0 1.605820e-07
I10340 n1_m1_475200_211200 0 1.663592e-07
I10341 n1_m1_475200_216000 0 3.021935e-07
I10342 n1_m1_475200_220800 0 2.093546e-07
I10343 n1_m1_475200_225600 0 2.473656e-07
I10344 n1_m1_475200_230400 0 1.672897e-07
I10345 n1_m1_475200_235200 0 1.725230e-07
I10346 n1_m1_475200_240000 0 2.600850e-07
I10347 n1_m1_475200_244800 0 1.718738e-07
I10348 n1_m1_475200_249600 0 2.431648e-07
I10349 n1_m1_475200_254400 0 1.601293e-07
I10350 n1_m1_475200_259200 0 1.620708e-07
I10351 n1_m1_475200_264000 0 2.553224e-07
I10352 n1_m1_475200_268800 0 1.751874e-07
I10353 n1_m1_475200_273600 0 2.983552e-07
I10354 n1_m1_475200_278400 0 4.802255e-07
I10355 n1_m1_475200_283200 0 9.488618e-07
I10356 n1_m1_475200_288000 0 1.850852e-06
I10357 n1_m1_475200_292800 0 1.161412e-06
I10358 n1_m1_475200_297600 0 1.159095e-06
I10359 n1_m1_475200_302400 0 6.629217e-07
I10360 n1_m1_475200_307200 0 6.577340e-07
I10361 n1_m1_475200_312000 0 5.042920e-07
I10362 n1_m1_475200_316800 0 1.790026e-07
I10363 n1_m1_475200_321600 0 2.450867e-07
I10364 n1_m1_475200_326400 0 1.639859e-07
I10365 n1_m1_475200_331200 0 1.651811e-07
I10366 n1_m1_475200_336000 0 2.496303e-07
I10367 n1_m1_475200_340800 0 1.685489e-07
I10368 n1_m1_475200_345600 0 2.460562e-07
I10369 n1_m1_475200_350400 0 2.034782e-07
I10370 n1_m1_475200_355200 0 4.101019e-07
I10371 n1_m1_475200_360000 0 5.433830e-07
I10372 n1_m1_475200_364800 0 1.733358e-07
I10373 n1_m1_475200_369600 0 2.678277e-07
I10374 n1_m1_475200_374400 0 2.262707e-07
I10375 n1_m1_475200_379200 0 2.348037e-07
I10376 n1_m1_475200_384000 0 3.086311e-07
I10377 n1_m1_475200_388800 0 1.734056e-07
I10378 n1_m1_475200_393600 0 2.437979e-07
I10379 n1_m1_475200_398400 0 1.859947e-07
I10380 n1_m1_475200_403200 0 2.358121e-07
I10381 n1_m1_475200_408000 0 2.958431e-07
I10382 n1_m1_475200_412800 0 1.545529e-07
I10383 n1_m1_475200_417600 0 2.382193e-07
I10384 n1_m1_475200_422400 0 1.591679e-07
I10385 n1_m1_475200_427200 0 1.681819e-07
I10386 n1_m1_475200_432000 0 2.574299e-07
I10387 n1_m1_475200_436800 0 1.604664e-07
I10388 n1_m1_475200_441600 0 2.348033e-07
I10389 n1_m1_475200_446400 0 1.838466e-07
I10390 n1_m1_475200_451200 0 2.087576e-07
I10391 n1_m1_475200_456000 0 2.649545e-07
I10392 n1_m1_475200_460800 0 1.583507e-07
I10393 n1_m1_475200_465600 0 2.313255e-07
I10394 n1_m1_475200_470400 0 1.523907e-07
I10395 n1_m1_475200_475200 0 1.482496e-07
I10396 n1_m1_475200_480000 0 2.202940e-07
I10397 n1_m1_475200_484800 0 1.465661e-07
I10398 n1_m1_475200_489600 0 2.258147e-07
I10399 n1_m1_475200_494400 0 1.528870e-07
I10400 n1_m1_480000_0 0 2.585441e-07
I10401 n1_m1_480000_4800 0 2.546366e-07
I10402 n1_m1_480000_9600 0 3.467288e-07
I10403 n1_m1_480000_14400 0 2.279439e-07
I10404 n1_m1_480000_19200 0 2.353984e-07
I10405 n1_m1_480000_24000 0 3.712864e-07
I10406 n1_m1_480000_28800 0 2.565434e-07
I10407 n1_m1_480000_33600 0 3.940318e-07
I10408 n1_m1_480000_38400 0 2.637089e-07
I10409 n1_m1_480000_43200 0 3.303071e-07
I10410 n1_m1_480000_48000 0 6.670644e-07
I10411 n1_m1_480000_52800 0 4.871945e-07
I10412 n1_m1_480000_57600 0 6.118000e-07
I10413 n1_m1_480000_62400 0 2.835240e-07
I10414 n1_m1_480000_67200 0 2.545147e-07
I10415 n1_m1_480000_72000 0 3.591561e-07
I10416 n1_m1_480000_76800 0 2.372535e-07
I10417 n1_m1_480000_81600 0 3.587691e-07
I10418 n1_m1_480000_86400 0 2.482792e-07
I10419 n1_m1_480000_91200 0 2.552177e-07
I10420 n1_m1_480000_96000 0 6.617210e-07
I10421 n1_m1_480000_100800 0 1.245386e-06
I10422 n1_m1_480000_105600 0 8.672602e-07
I10423 n1_m1_480000_110400 0 2.676867e-07
I10424 n1_m1_480000_115200 0 2.679959e-07
I10425 n1_m1_480000_120000 0 4.175794e-07
I10426 n1_m1_480000_124800 0 2.660516e-07
I10427 n1_m1_480000_129600 0 3.678307e-07
I10428 n1_m1_480000_134400 0 2.366250e-07
I10429 n1_m1_480000_139200 0 2.421444e-07
I10430 n1_m1_480000_144000 0 3.781397e-07
I10431 n1_m1_480000_148800 0 2.572035e-07
I10432 n1_m1_480000_153600 0 3.869426e-07
I10433 n1_m1_480000_158400 0 2.534361e-07
I10434 n1_m1_480000_163200 0 2.486141e-07
I10435 n1_m1_480000_168000 0 3.606194e-07
I10436 n1_m1_480000_172800 0 2.370860e-07
I10437 n1_m1_480000_177600 0 3.468042e-07
I10438 n1_m1_480000_182400 0 2.365037e-07
I10439 n1_m1_480000_187200 0 2.376888e-07
I10440 n1_m1_480000_192000 0 3.635765e-07
I10441 n1_m1_480000_196800 0 2.456222e-07
I10442 n1_m1_480000_201600 0 3.602482e-07
I10443 n1_m1_480000_206400 0 2.377744e-07
I10444 n1_m1_480000_211200 0 2.392757e-07
I10445 n1_m1_480000_216000 0 3.727868e-07
I10446 n1_m1_480000_220800 0 2.493317e-07
I10447 n1_m1_480000_225600 0 3.683557e-07
I10448 n1_m1_480000_230400 0 2.475815e-07
I10449 n1_m1_480000_235200 0 2.408382e-07
I10450 n1_m1_480000_240000 0 3.677936e-07
I10451 n1_m1_480000_244800 0 2.485242e-07
I10452 n1_m1_480000_249600 0 3.695924e-07
I10453 n1_m1_480000_254400 0 2.433614e-07
I10454 n1_m1_480000_259200 0 2.405243e-07
I10455 n1_m1_480000_264000 0 3.719628e-07
I10456 n1_m1_480000_268800 0 2.485221e-07
I10457 n1_m1_480000_273600 0 3.793925e-07
I10458 n1_m1_480000_278400 0 3.937796e-07
I10459 n1_m1_480000_283200 0 9.505174e-07
I10460 n1_m1_480000_288000 0 2.471792e-06
I10461 n1_m1_480000_292800 0 1.559317e-06
I10462 n1_m1_480000_297600 0 1.081413e-06
I10463 n1_m1_480000_302400 0 4.717868e-07
I10464 n1_m1_480000_307200 0 4.718095e-07
I10465 n1_m1_480000_312000 0 5.466775e-07
I10466 n1_m1_480000_316800 0 2.744250e-07
I10467 n1_m1_480000_321600 0 3.736669e-07
I10468 n1_m1_480000_326400 0 2.455724e-07
I10469 n1_m1_480000_331200 0 2.473633e-07
I10470 n1_m1_480000_336000 0 3.737423e-07
I10471 n1_m1_480000_340800 0 2.465750e-07
I10472 n1_m1_480000_345600 0 3.685225e-07
I10473 n1_m1_480000_350400 0 2.867055e-07
I10474 n1_m1_480000_355200 0 4.816255e-07
I10475 n1_m1_480000_360000 0 8.020893e-07
I10476 n1_m1_480000_364800 0 3.373765e-07
I10477 n1_m1_480000_369600 0 4.022737e-07
I10478 n1_m1_480000_374400 0 2.718032e-07
I10479 n1_m1_480000_379200 0 2.929841e-07
I10480 n1_m1_480000_384000 0 4.036579e-07
I10481 n1_m1_480000_388800 0 2.446911e-07
I10482 n1_m1_480000_393600 0 3.735093e-07
I10483 n1_m1_480000_398400 0 2.466774e-07
I10484 n1_m1_480000_403200 0 2.436219e-07
I10485 n1_m1_480000_408000 0 3.575438e-07
I10486 n1_m1_480000_412800 0 2.291612e-07
I10487 n1_m1_480000_417600 0 3.524763e-07
I10488 n1_m1_480000_422400 0 2.320563e-07
I10489 n1_m1_480000_427200 0 2.518350e-07
I10490 n1_m1_480000_432000 0 4.030114e-07
I10491 n1_m1_480000_436800 0 2.558870e-07
I10492 n1_m1_480000_441600 0 3.621146e-07
I10493 n1_m1_480000_446400 0 2.527810e-07
I10494 n1_m1_480000_451200 0 2.665573e-07
I10495 n1_m1_480000_456000 0 3.743007e-07
I10496 n1_m1_480000_460800 0 2.334478e-07
I10497 n1_m1_480000_465600 0 3.620055e-07
I10498 n1_m1_480000_470400 0 2.449269e-07
I10499 n1_m1_480000_475200 0 2.402102e-07
I10500 n1_m1_480000_480000 0 3.450135e-07
I10501 n1_m1_480000_484800 0 2.213578e-07
I10502 n1_m1_480000_489600 0 3.309794e-07
I10503 n1_m1_480000_494400 0 2.211267e-07
I10504 n1_m1_484800_0 0 1.676761e-07
I10505 n1_m1_484800_4800 0 1.665113e-07
I10506 n1_m1_484800_9600 0 2.366695e-07
I10507 n1_m1_484800_14400 0 1.525399e-07
I10508 n1_m1_484800_19200 0 1.563719e-07
I10509 n1_m1_484800_24000 0 2.519500e-07
I10510 n1_m1_484800_28800 0 1.732385e-07
I10511 n1_m1_484800_33600 0 2.445486e-07
I10512 n1_m1_484800_38400 0 1.610140e-07
I10513 n1_m1_484800_43200 0 1.611430e-07
I10514 n1_m1_484800_48000 0 2.475166e-07
I10515 n1_m1_484800_52800 0 1.651477e-07
I10516 n1_m1_484800_57600 0 2.351500e-07
I10517 n1_m1_484800_62400 0 1.594154e-07
I10518 n1_m1_484800_67200 0 1.572071e-07
I10519 n1_m1_484800_72000 0 2.303308e-07
I10520 n1_m1_484800_76800 0 1.532282e-07
I10521 n1_m1_484800_81600 0 2.309994e-07
I10522 n1_m1_484800_86400 0 1.601596e-07
I10523 n1_m1_484800_91200 0 1.633414e-07
I10524 n1_m1_484800_96000 0 2.700741e-07
I10525 n1_m1_484800_100800 0 3.495515e-07
I10526 n1_m1_484800_105600 0 3.402235e-07
I10527 n1_m1_484800_110400 0 1.747219e-07
I10528 n1_m1_484800_115200 0 1.745820e-07
I10529 n1_m1_484800_120000 0 2.909928e-07
I10530 n1_m1_484800_124800 0 1.865930e-07
I10531 n1_m1_484800_129600 0 2.659687e-07
I10532 n1_m1_484800_134400 0 1.650225e-07
I10533 n1_m1_484800_139200 0 1.585502e-07
I10534 n1_m1_484800_144000 0 2.429751e-07
I10535 n1_m1_484800_148800 0 1.672813e-07
I10536 n1_m1_484800_153600 0 2.531656e-07
I10537 n1_m1_484800_158400 0 1.687159e-07
I10538 n1_m1_484800_163200 0 1.651355e-07
I10539 n1_m1_484800_168000 0 2.378087e-07
I10540 n1_m1_484800_172800 0 1.571211e-07
I10541 n1_m1_484800_177600 0 2.327893e-07
I10542 n1_m1_484800_182400 0 1.561900e-07
I10543 n1_m1_484800_187200 0 1.563946e-07
I10544 n1_m1_484800_192000 0 2.390420e-07
I10545 n1_m1_484800_196800 0 1.598903e-07
I10546 n1_m1_484800_201600 0 2.394641e-07
I10547 n1_m1_484800_206400 0 1.562689e-07
I10548 n1_m1_484800_211200 0 1.535979e-07
I10549 n1_m1_484800_216000 0 2.298422e-07
I10550 n1_m1_484800_220800 0 1.622443e-07
I10551 n1_m1_484800_225600 0 2.570219e-07
I10552 n1_m1_484800_230400 0 1.643919e-07
I10553 n1_m1_484800_235200 0 1.546927e-07
I10554 n1_m1_484800_240000 0 2.374855e-07
I10555 n1_m1_484800_244800 0 1.578718e-07
I10556 n1_m1_484800_249600 0 2.322201e-07
I10557 n1_m1_484800_254400 0 1.540157e-07
I10558 n1_m1_484800_259200 0 1.545023e-07
I10559 n1_m1_484800_264000 0 2.356816e-07
I10560 n1_m1_484800_268800 0 1.568201e-07
I10561 n1_m1_484800_273600 0 2.334169e-07
I10562 n1_m1_484800_278400 0 1.588387e-07
I10563 n1_m1_484800_283200 0 1.954431e-07
I10564 n1_m1_484800_288000 0 6.422151e-07
I10565 n1_m1_484800_292800 0 5.174944e-07
I10566 n1_m1_484800_297600 0 3.805398e-07
I10567 n1_m1_484800_302400 0 1.752274e-07
I10568 n1_m1_484800_307200 0 1.765488e-07
I10569 n1_m1_484800_312000 0 2.884771e-07
I10570 n1_m1_484800_316800 0 1.833901e-07
I10571 n1_m1_484800_321600 0 2.496074e-07
I10572 n1_m1_484800_326400 0 1.578328e-07
I10573 n1_m1_484800_331200 0 1.594795e-07
I10574 n1_m1_484800_336000 0 2.424031e-07
I10575 n1_m1_484800_340800 0 1.598100e-07
I10576 n1_m1_484800_345600 0 2.548569e-07
I10577 n1_m1_484800_350400 0 1.763663e-07
I10578 n1_m1_484800_355200 0 1.839521e-07
I10579 n1_m1_484800_360000 0 3.920004e-07
I10580 n1_m1_484800_364800 0 2.788390e-07
I10581 n1_m1_484800_369600 0 2.895015e-07
I10582 n1_m1_484800_374400 0 1.643744e-07
I10583 n1_m1_484800_379200 0 1.743551e-07
I10584 n1_m1_484800_384000 0 2.505321e-07
I10585 n1_m1_484800_388800 0 1.490091e-07
I10586 n1_m1_484800_393600 0 2.266249e-07
I10587 n1_m1_484800_398400 0 1.538359e-07
I10588 n1_m1_484800_403200 0 1.501480e-07
I10589 n1_m1_484800_408000 0 2.267952e-07
I10590 n1_m1_484800_412800 0 1.503380e-07
I10591 n1_m1_484800_417600 0 2.298493e-07
I10592 n1_m1_484800_422400 0 1.484344e-07
I10593 n1_m1_484800_427200 0 1.606127e-07
I10594 n1_m1_484800_432000 0 2.503547e-07
I10595 n1_m1_484800_436800 0 1.663116e-07
I10596 n1_m1_484800_441600 0 2.396072e-07
I10597 n1_m1_484800_446400 0 1.596460e-07
I10598 n1_m1_484800_451200 0 1.636483e-07
I10599 n1_m1_484800_456000 0 2.379798e-07
I10600 n1_m1_484800_460800 0 1.571211e-07
I10601 n1_m1_484800_465600 0 2.460092e-07
I10602 n1_m1_484800_470400 0 1.701978e-07
I10603 n1_m1_484800_475200 0 1.649550e-07
I10604 n1_m1_484800_480000 0 2.380000e-07
I10605 n1_m1_484800_484800 0 1.516100e-07
I10606 n1_m1_484800_489600 0 2.240029e-07
I10607 n1_m1_484800_494400 0 1.493353e-07
I10608 n1_m1_489600_0 0 2.384033e-07
I10609 n1_m1_489600_4800 0 2.347551e-07
I10610 n1_m1_489600_9600 0 3.482233e-07
I10611 n1_m1_489600_14400 0 2.359625e-07
I10612 n1_m1_489600_19200 0 2.462366e-07
I10613 n1_m1_489600_24000 0 3.937479e-07
I10614 n1_m1_489600_28800 0 2.657135e-07
I10615 n1_m1_489600_33600 0 3.783887e-07
I10616 n1_m1_489600_38400 0 2.402632e-07
I10617 n1_m1_489600_43200 0 2.326577e-07
I10618 n1_m1_489600_48000 0 3.472893e-07
I10619 n1_m1_489600_52800 0 2.349718e-07
I10620 n1_m1_489600_57600 0 3.628153e-07
I10621 n1_m1_489600_62400 0 2.331257e-07
I10622 n1_m1_489600_67200 0 2.305580e-07
I10623 n1_m1_489600_72000 0 3.458369e-07
I10624 n1_m1_489600_76800 0 2.340047e-07
I10625 n1_m1_489600_81600 0 3.529573e-07
I10626 n1_m1_489600_86400 0 2.277404e-07
I10627 n1_m1_489600_91200 0 2.295809e-07
I10628 n1_m1_489600_96000 0 3.731859e-07
I10629 n1_m1_489600_100800 0 2.591958e-07
I10630 n1_m1_489600_105600 0 3.778699e-07
I10631 n1_m1_489600_110400 0 2.365780e-07
I10632 n1_m1_489600_115200 0 2.290779e-07
I10633 n1_m1_489600_120000 0 3.545618e-07
I10634 n1_m1_489600_124800 0 2.478431e-07
I10635 n1_m1_489600_129600 0 3.906567e-07
I10636 n1_m1_489600_134400 0 2.510377e-07
I10637 n1_m1_489600_139200 0 2.387578e-07
I10638 n1_m1_489600_144000 0 3.644916e-07
I10639 n1_m1_489600_148800 0 2.400988e-07
I10640 n1_m1_489600_153600 0 3.573201e-07
I10641 n1_m1_489600_158400 0 2.419426e-07
I10642 n1_m1_489600_163200 0 2.400840e-07
I10643 n1_m1_489600_168000 0 3.487990e-07
I10644 n1_m1_489600_172800 0 2.307297e-07
I10645 n1_m1_489600_177600 0 3.511175e-07
I10646 n1_m1_489600_182400 0 2.374702e-07
I10647 n1_m1_489600_187200 0 2.401178e-07
I10648 n1_m1_489600_192000 0 3.660236e-07
I10649 n1_m1_489600_196800 0 2.427328e-07
I10650 n1_m1_489600_201600 0 3.692429e-07
I10651 n1_m1_489600_206400 0 2.403854e-07
I10652 n1_m1_489600_211200 0 2.311159e-07
I10653 n1_m1_489600_216000 0 3.367760e-07
I10654 n1_m1_489600_220800 0 2.395485e-07
I10655 n1_m1_489600_225600 0 3.810698e-07
I10656 n1_m1_489600_230400 0 2.364839e-07
I10657 n1_m1_489600_235200 0 2.309466e-07
I10658 n1_m1_489600_240000 0 3.565455e-07
I10659 n1_m1_489600_244800 0 2.320295e-07
I10660 n1_m1_489600_249600 0 3.417417e-07
I10661 n1_m1_489600_254400 0 2.286767e-07
I10662 n1_m1_489600_259200 0 2.312737e-07
I10663 n1_m1_489600_264000 0 3.466054e-07
I10664 n1_m1_489600_268800 0 2.344860e-07
I10665 n1_m1_489600_273600 0 3.513454e-07
I10666 n1_m1_489600_278400 0 2.467272e-07
I10667 n1_m1_489600_283200 0 2.450371e-07
I10668 n1_m1_489600_288000 0 3.736962e-07
I10669 n1_m1_489600_292800 0 3.324496e-07
I10670 n1_m1_489600_297600 0 4.408981e-07
I10671 n1_m1_489600_302400 0 2.553572e-07
I10672 n1_m1_489600_307200 0 2.427517e-07
I10673 n1_m1_489600_312000 0 3.922154e-07
I10674 n1_m1_489600_316800 0 2.693577e-07
I10675 n1_m1_489600_321600 0 3.685474e-07
I10676 n1_m1_489600_326400 0 2.303192e-07
I10677 n1_m1_489600_331200 0 2.384149e-07
I10678 n1_m1_489600_336000 0 3.652619e-07
I10679 n1_m1_489600_340800 0 2.358034e-07
I10680 n1_m1_489600_345600 0 3.582714e-07
I10681 n1_m1_489600_350400 0 2.457487e-07
I10682 n1_m1_489600_355200 0 2.451496e-07
I10683 n1_m1_489600_360000 0 4.201776e-07
I10684 n1_m1_489600_364800 0 3.126212e-07
I10685 n1_m1_489600_369600 0 3.981412e-07
I10686 n1_m1_489600_374400 0 2.314316e-07
I10687 n1_m1_489600_379200 0 2.446327e-07
I10688 n1_m1_489600_384000 0 3.731319e-07
I10689 n1_m1_489600_388800 0 2.393854e-07
I10690 n1_m1_489600_393600 0 3.515488e-07
I10691 n1_m1_489600_398400 0 2.380983e-07
I10692 n1_m1_489600_403200 0 2.313180e-07
I10693 n1_m1_489600_408000 0 3.369829e-07
I10694 n1_m1_489600_412800 0 2.254130e-07
I10695 n1_m1_489600_417600 0 3.402928e-07
I10696 n1_m1_489600_422400 0 2.201926e-07
I10697 n1_m1_489600_427200 0 2.326011e-07
I10698 n1_m1_489600_432000 0 3.463600e-07
I10699 n1_m1_489600_436800 0 2.315018e-07
I10700 n1_m1_489600_441600 0 3.445444e-07
I10701 n1_m1_489600_446400 0 2.255127e-07
I10702 n1_m1_489600_451200 0 2.192999e-07
I10703 n1_m1_489600_456000 0 3.349723e-07
I10704 n1_m1_489600_460800 0 2.299910e-07
I10705 n1_m1_489600_465600 0 3.611831e-07
I10706 n1_m1_489600_470400 0 2.454750e-07
I10707 n1_m1_489600_475200 0 2.403868e-07
I10708 n1_m1_489600_480000 0 3.469958e-07
I10709 n1_m1_489600_484800 0 2.232572e-07
I10710 n1_m1_489600_489600 0 3.335831e-07
I10711 n1_m1_489600_494400 0 2.221233e-07
I10712 n1_m1_494400_0 0 1.594501e-07
I10713 n1_m1_494400_4800 0 1.576214e-07
I10714 n1_m1_494400_9600 0 2.303044e-07
I10715 n1_m1_494400_14400 0 1.573084e-07
I10716 n1_m1_494400_19200 0 1.641577e-07
I10717 n1_m1_494400_24000 0 2.596155e-07
I10718 n1_m1_494400_28800 0 1.760847e-07
I10719 n1_m1_494400_33600 0 2.684472e-07
I10720 n1_m1_494400_38400 0 1.716554e-07
I10721 n1_m1_494400_43200 0 1.644553e-07
I10722 n1_m1_494400_48000 0 2.383055e-07
I10723 n1_m1_494400_52800 0 1.588278e-07
I10724 n1_m1_494400_57600 0 2.424847e-07
I10725 n1_m1_494400_62400 0 1.589670e-07
I10726 n1_m1_494400_67200 0 1.581779e-07
I10727 n1_m1_494400_72000 0 2.372669e-07
I10728 n1_m1_494400_76800 0 1.618300e-07
I10729 n1_m1_494400_81600 0 2.396182e-07
I10730 n1_m1_494400_86400 0 1.465598e-07
I10731 n1_m1_494400_91200 0 1.425808e-07
I10732 n1_m1_494400_96000 0 2.300068e-07
I10733 n1_m1_494400_100800 0 1.585391e-07
I10734 n1_m1_494400_105600 0 2.389674e-07
I10735 n1_m1_494400_110400 0 1.555791e-07
I10736 n1_m1_494400_115200 0 1.650761e-07
I10737 n1_m1_494400_120000 0 2.413114e-07
I10738 n1_m1_494400_124800 0 1.515767e-07
I10739 n1_m1_494400_129600 0 2.513767e-07
I10740 n1_m1_494400_134400 0 1.693972e-07
I10741 n1_m1_494400_139200 0 1.648400e-07
I10742 n1_m1_494400_144000 0 2.530592e-07
I10743 n1_m1_494400_148800 0 1.637085e-07
I10744 n1_m1_494400_153600 0 2.377817e-07
I10745 n1_m1_494400_158400 0 1.648400e-07
I10746 n1_m1_494400_163200 0 1.616097e-07
I10747 n1_m1_494400_168000 0 2.378136e-07
I10748 n1_m1_494400_172800 0 1.593657e-07
I10749 n1_m1_494400_177600 0 2.460224e-07
I10750 n1_m1_494400_182400 0 1.685175e-07
I10751 n1_m1_494400_187200 0 1.659855e-07
I10752 n1_m1_494400_192000 0 2.488572e-07
I10753 n1_m1_494400_196800 0 1.655105e-07
I10754 n1_m1_494400_201600 0 2.537453e-07
I10755 n1_m1_494400_206400 0 1.650942e-07
I10756 n1_m1_494400_211200 0 1.582448e-07
I10757 n1_m1_494400_216000 0 2.254358e-07
I10758 n1_m1_494400_220800 0 1.522171e-07
I10759 n1_m1_494400_225600 0 2.395276e-07
I10760 n1_m1_494400_230400 0 1.492295e-07
I10761 n1_m1_494400_235200 0 1.506917e-07
I10762 n1_m1_494400_240000 0 2.394273e-07
I10763 n1_m1_494400_244800 0 1.514262e-07
I10764 n1_m1_494400_249600 0 2.409792e-07
I10765 n1_m1_494400_254400 0 1.631277e-07
I10766 n1_m1_494400_259200 0 1.631277e-07
I10767 n1_m1_494400_264000 0 2.402526e-07
I10768 n1_m1_494400_268800 0 1.551397e-07
I10769 n1_m1_494400_273600 0 2.250531e-07
I10770 n1_m1_494400_278400 0 1.514830e-07
I10771 n1_m1_494400_283200 0 1.508813e-07
I10772 n1_m1_494400_288000 0 2.367976e-07
I10773 n1_m1_494400_292800 0 1.696887e-07
I10774 n1_m1_494400_297600 0 2.417670e-07
I10775 n1_m1_494400_302400 0 1.705872e-07
I10776 n1_m1_494400_307200 0 1.703115e-07
I10777 n1_m1_494400_312000 0 2.491287e-07
I10778 n1_m1_494400_316800 0 1.731598e-07
I10779 n1_m1_494400_321600 0 2.371465e-07
I10780 n1_m1_494400_326400 0 1.487939e-07
I10781 n1_m1_494400_331200 0 1.616325e-07
I10782 n1_m1_494400_336000 0 2.534338e-07
I10783 n1_m1_494400_340800 0 1.621511e-07
I10784 n1_m1_494400_345600 0 2.333306e-07
I10785 n1_m1_494400_350400 0 1.606617e-07
I10786 n1_m1_494400_355200 0 1.739307e-07
I10787 n1_m1_494400_360000 0 2.692655e-07
I10788 n1_m1_494400_364800 0 1.720941e-07
I10789 n1_m1_494400_369600 0 2.556896e-07
I10790 n1_m1_494400_374400 0 1.653654e-07
I10791 n1_m1_494400_379200 0 1.594775e-07
I10792 n1_m1_494400_384000 0 2.386020e-07
I10793 n1_m1_494400_388800 0 1.579350e-07
I10794 n1_m1_494400_393600 0 2.333134e-07
I10795 n1_m1_494400_398400 0 1.561199e-07
I10796 n1_m1_494400_403200 0 1.560391e-07
I10797 n1_m1_494400_408000 0 2.276555e-07
I10798 n1_m1_494400_412800 0 1.524835e-07
I10799 n1_m1_494400_417600 0 2.312304e-07
I10800 n1_m1_494400_422400 0 1.489416e-07
I10801 n1_m1_494400_427200 0 1.582849e-07
I10802 n1_m1_494400_432000 0 2.285886e-07
I10803 n1_m1_494400_436800 0 1.489553e-07
I10804 n1_m1_494400_441600 0 2.263983e-07
I10805 n1_m1_494400_446400 0 1.471678e-07
I10806 n1_m1_494400_451200 0 1.420578e-07
I10807 n1_m1_494400_456000 0 2.194678e-07
I10808 n1_m1_494400_460800 0 1.544421e-07
I10809 n1_m1_494400_465600 0 2.474406e-07
I10810 n1_m1_494400_470400 0 1.661210e-07
I10811 n1_m1_494400_475200 0 1.603144e-07
I10812 n1_m1_494400_480000 0 2.239808e-07
I10813 n1_m1_494400_484800 0 1.445086e-07
I10814 n1_m1_494400_489600 0 2.077530e-07
I10815 n1_m1_494400_494400 0 1.366666e-07
I10816 n1_m1_4000_0 0 8.066084e-08
I10817 n1_m1_4000_4800 0 8.055377e-08
I10818 n1_m1_4000_9600 0 1.184563e-07
I10819 n1_m1_4000_14400 0 7.689145e-08
I10820 n1_m1_4000_19200 0 7.661408e-08
I10821 n1_m1_4000_24000 0 1.150785e-07
I10822 n1_m1_4000_28800 0 7.759022e-08
I10823 n1_m1_4000_33600 0 1.152683e-07
I10824 n1_m1_4000_38400 0 7.518267e-08
I10825 n1_m1_4000_43200 0 7.529303e-08
I10826 n1_m1_4000_48000 0 1.170716e-07
I10827 n1_m1_4000_52800 0 7.851372e-08
I10828 n1_m1_4000_57600 0 1.207300e-07
I10829 n1_m1_4000_62400 0 8.096854e-08
I10830 n1_m1_4000_67200 0 7.887871e-08
I10831 n1_m1_4000_72000 0 1.177706e-07
I10832 n1_m1_4000_76800 0 7.851372e-08
I10833 n1_m1_4000_81600 0 1.184166e-07
I10834 n1_m1_4000_86400 0 7.856330e-08
I10835 n1_m1_4000_91200 0 7.760256e-08
I10836 n1_m1_4000_96000 0 1.129853e-07
I10837 n1_m1_4000_100800 0 7.661408e-08
I10838 n1_m1_4000_105600 0 1.149211e-07
I10839 n1_m1_4000_110400 0 7.586309e-08
I10840 n1_m1_4000_115200 0 7.377311e-08
I10841 n1_m1_4000_120000 0 1.100742e-07
I10842 n1_m1_4000_124800 0 7.546361e-08
I10843 n1_m1_4000_129600 0 1.159169e-07
I10844 n1_m1_4000_134400 0 7.922942e-08
I10845 n1_m1_4000_139200 0 7.922942e-08
I10846 n1_m1_4000_144000 0 1.184739e-07
I10847 n1_m1_4000_148800 0 7.687929e-08
I10848 n1_m1_4000_153600 0 1.160540e-07
I10849 n1_m1_4000_158400 0 7.688044e-08
I10850 n1_m1_4000_163200 0 7.589838e-08
I10851 n1_m1_4000_168000 0 1.150292e-07
I10852 n1_m1_4000_172800 0 8.103978e-08
I10853 n1_m1_4000_177600 0 1.196927e-07
I10854 n1_m1_4000_182400 0 7.658856e-08
I10855 n1_m1_4000_187200 0 7.850368e-08
I10856 n1_m1_4000_192000 0 1.188441e-07
I10857 n1_m1_4000_196800 0 7.922942e-08
I10858 n1_m1_4000_201600 0 1.188441e-07
I10859 n1_m1_4000_206400 0 7.922942e-08
I10860 n1_m1_4000_211200 0 7.922942e-08
I10861 n1_m1_4000_216000 0 1.192250e-07
I10862 n1_m1_4000_220800 0 8.141035e-08
I10863 n1_m1_4000_225600 0 1.238407e-07
I10864 n1_m1_4000_230400 0 8.205368e-08
I10865 n1_m1_4000_235200 0 7.992505e-08
I10866 n1_m1_4000_240000 0 1.188693e-07
I10867 n1_m1_4000_244800 0 7.922942e-08
I10868 n1_m1_4000_249600 0 1.197388e-07
I10869 n1_m1_4000_254400 0 7.973099e-08
I10870 n1_m1_4000_259200 0 7.922942e-08
I10871 n1_m1_4000_264000 0 1.188441e-07
I10872 n1_m1_4000_268800 0 7.943161e-08
I10873 n1_m1_4000_273600 0 1.223339e-07
I10874 n1_m1_4000_278400 0 7.973233e-08
I10875 n1_m1_4000_283200 0 7.697481e-08
I10876 n1_m1_4000_288000 0 1.180911e-07
I10877 n1_m1_4000_292800 0 8.278120e-08
I10878 n1_m1_4000_297600 0 1.290018e-07
I10879 n1_m1_4000_302400 0 8.569606e-08
I10880 n1_m1_4000_307200 0 8.248610e-08
I10881 n1_m1_4000_312000 0 1.250602e-07
I10882 n1_m1_4000_316800 0 8.140637e-08
I10883 n1_m1_4000_321600 0 1.224919e-07
I10884 n1_m1_4000_326400 0 8.467985e-08
I10885 n1_m1_4000_331200 0 8.351589e-08
I10886 n1_m1_4000_336000 0 1.257438e-07
I10887 n1_m1_4000_340800 0 8.292666e-08
I10888 n1_m1_4000_345600 0 1.209187e-07
I10889 n1_m1_4000_350400 0 8.004645e-08
I10890 n1_m1_4000_355200 0 7.951370e-08
I10891 n1_m1_4000_360000 0 1.152990e-07
I10892 n1_m1_4000_364800 0 7.811081e-08
I10893 n1_m1_4000_369600 0 1.154804e-07
I10894 n1_m1_4000_374400 0 7.481396e-08
I10895 n1_m1_4000_379200 0 7.718598e-08
I10896 n1_m1_4000_384000 0 1.149743e-07
I10897 n1_m1_4000_388800 0 7.396050e-08
I10898 n1_m1_4000_393600 0 1.190770e-07
I10899 n1_m1_4000_398400 0 8.413904e-08
I10900 n1_m1_4000_403200 0 7.982681e-08
I10901 n1_m1_4000_408000 0 1.138476e-07
I10902 n1_m1_4000_412800 0 7.611632e-08
I10903 n1_m1_4000_417600 0 1.161714e-07
I10904 n1_m1_4000_422400 0 7.624186e-08
I10905 n1_m1_4000_427200 0 7.794276e-08
I10906 n1_m1_4000_432000 0 1.185623e-07
I10907 n1_m1_4000_436800 0 7.455686e-08
I10908 n1_m1_4000_441600 0 1.152459e-07
I10909 n1_m1_4000_446400 0 7.398938e-08
I10910 n1_m1_4000_451200 0 7.256733e-08
I10911 n1_m1_4000_456000 0 1.152809e-07
I10912 n1_m1_4000_460800 0 7.697265e-08
I10913 n1_m1_4000_465600 0 1.144023e-07
I10914 n1_m1_4000_470400 0 7.649034e-08
I10915 n1_m1_4000_475200 0 7.396864e-08
I10916 n1_m1_4000_480000 0 1.086336e-07
I10917 n1_m1_4000_484800 0 6.945987e-08
I10918 n1_m1_4000_489600 0 1.144352e-07
I10919 n1_m1_4000_494400 0 9.811178e-08
I10920 n1_m1_32000_0 0 7.571318e-08
I10921 n1_m1_32000_4800 0 7.363442e-08
I10922 n1_m1_32000_9600 0 1.099246e-07
I10923 n1_m1_32000_14400 0 7.331990e-08
I10924 n1_m1_32000_19200 0 7.753360e-08
I10925 n1_m1_32000_24000 0 1.244395e-07
I10926 n1_m1_32000_28800 0 9.025122e-08
I10927 n1_m1_32000_33600 0 1.668472e-07
I10928 n1_m1_32000_38400 0 1.831136e-07
I10929 n1_m1_32000_43200 0 2.602157e-07
I10930 n1_m1_32000_48000 0 3.017567e-07
I10931 n1_m1_32000_52800 0 8.946223e-08
I10932 n1_m1_32000_57600 0 1.276703e-07
I10933 n1_m1_32000_62400 0 8.374315e-08
I10934 n1_m1_32000_67200 0 8.328192e-08
I10935 n1_m1_32000_72000 0 1.250484e-07
I10936 n1_m1_32000_76800 0 8.330337e-08
I10937 n1_m1_32000_81600 0 1.249143e-07
I10938 n1_m1_32000_86400 0 8.329878e-08
I10939 n1_m1_32000_91200 0 8.340208e-08
I10940 n1_m1_32000_96000 0 1.251412e-07
I10941 n1_m1_32000_100800 0 8.569818e-08
I10942 n1_m1_32000_105600 0 1.281258e-07
I10943 n1_m1_32000_110400 0 8.088435e-08
I10944 n1_m1_32000_115200 0 8.424715e-08
I10945 n1_m1_32000_120000 0 1.242166e-07
I10946 n1_m1_32000_124800 0 7.999415e-08
I10947 n1_m1_32000_129600 0 1.200080e-07
I10948 n1_m1_32000_134400 0 8.000533e-08
I10949 n1_m1_32000_139200 0 8.000533e-08
I10950 n1_m1_32000_144000 0 1.200080e-07
I10951 n1_m1_32000_148800 0 7.999596e-08
I10952 n1_m1_32000_153600 0 1.199589e-07
I10953 n1_m1_32000_158400 0 8.000533e-08
I10954 n1_m1_32000_163200 0 8.000533e-08
I10955 n1_m1_32000_168000 0 1.247071e-07
I10956 n1_m1_32000_172800 0 8.665529e-08
I10957 n1_m1_32000_177600 0 1.274883e-07
I10958 n1_m1_32000_182400 0 8.316180e-08
I10959 n1_m1_32000_187200 0 8.065775e-08
I10960 n1_m1_32000_192000 0 1.222953e-07
I10961 n1_m1_32000_196800 0 8.902476e-08
I10962 n1_m1_32000_201600 0 1.328123e-07
I10963 n1_m1_32000_206400 0 8.085701e-08
I10964 n1_m1_32000_211200 0 8.074495e-08
I10965 n1_m1_32000_216000 0 1.307212e-07
I10966 n1_m1_32000_220800 0 8.432048e-08
I10967 n1_m1_32000_225600 0 1.300997e-07
I10968 n1_m1_32000_230400 0 8.610844e-08
I10969 n1_m1_32000_235200 0 8.337985e-08
I10970 n1_m1_32000_240000 0 1.225317e-07
I10971 n1_m1_32000_244800 0 8.709764e-08
I10972 n1_m1_32000_249600 0 1.292862e-07
I10973 n1_m1_32000_254400 0 9.420576e-08
I10974 n1_m1_32000_259200 0 9.449753e-08
I10975 n1_m1_32000_264000 0 1.327095e-07
I10976 n1_m1_32000_268800 0 8.498892e-08
I10977 n1_m1_32000_273600 0 1.319109e-07
I10978 n1_m1_32000_278400 0 8.720181e-08
I10979 n1_m1_32000_283200 0 8.330652e-08
I10980 n1_m1_32000_288000 0 1.282728e-07
I10981 n1_m1_32000_292800 0 8.661121e-08
I10982 n1_m1_32000_297600 0 1.300695e-07
I10983 n1_m1_32000_302400 0 8.678782e-08
I10984 n1_m1_32000_307200 0 8.674781e-08
I10985 n1_m1_32000_312000 0 1.235187e-07
I10986 n1_m1_32000_316800 0 8.561000e-08
I10987 n1_m1_32000_321600 0 1.224758e-07
I10988 n1_m1_32000_326400 0 8.259561e-08
I10989 n1_m1_32000_331200 0 8.329165e-08
I10990 n1_m1_32000_336000 0 1.262435e-07
I10991 n1_m1_32000_340800 0 8.532296e-08
I10992 n1_m1_32000_345600 0 1.219570e-07
I10993 n1_m1_32000_350400 0 8.043624e-08
I10994 n1_m1_32000_355200 0 8.286679e-08
I10995 n1_m1_32000_360000 0 1.248815e-07
I10996 n1_m1_32000_364800 0 7.947224e-08
I10997 n1_m1_32000_369600 0 1.192182e-07
I10998 n1_m1_32000_374400 0 8.304082e-08
I10999 n1_m1_32000_379200 0 8.258696e-08
I11000 n1_m1_32000_384000 0 1.201059e-07
I11001 n1_m1_32000_388800 0 8.236871e-08
I11002 n1_m1_32000_393600 0 1.280988e-07
I11003 n1_m1_32000_398400 0 8.333638e-08
I11004 n1_m1_32000_403200 0 8.331595e-08
I11005 n1_m1_32000_408000 0 1.251409e-07
I11006 n1_m1_32000_412800 0 8.598391e-08
I11007 n1_m1_32000_417600 0 1.284234e-07
I11008 n1_m1_32000_422400 0 8.333638e-08
I11009 n1_m1_32000_427200 0 8.496749e-08
I11010 n1_m1_32000_432000 0 1.768031e-07
I11011 n1_m1_32000_436800 0 2.203727e-07
I11012 n1_m1_32000_441600 0 8.065443e-07
I11013 n1_m1_32000_446400 0 5.041003e-07
I11014 n1_m1_32000_451200 0 2.454346e-07
I11015 n1_m1_32000_456000 0 1.562100e-07
I11016 n1_m1_32000_460800 0 8.432020e-08
I11017 n1_m1_32000_465600 0 1.175540e-07
I11018 n1_m1_32000_470400 0 7.716480e-08
I11019 n1_m1_32000_475200 0 7.395933e-08
I11020 n1_m1_32000_480000 0 1.112943e-07
I11021 n1_m1_32000_484800 0 7.936840e-08
I11022 n1_m1_32000_489600 0 1.209439e-07
I11023 n1_m1_32000_494400 0 7.502463e-08
I11024 n1_m1_60000_0 0 7.617179e-08
I11025 n1_m1_60000_4800 0 7.605181e-08
I11026 n1_m1_60000_9600 0 1.105834e-07
I11027 n1_m1_60000_14400 0 7.628304e-08
I11028 n1_m1_60000_19200 0 7.955711e-08
I11029 n1_m1_60000_24000 0 1.239137e-07
I11030 n1_m1_60000_28800 0 8.613268e-08
I11031 n1_m1_60000_33600 0 1.314659e-07
I11032 n1_m1_60000_38400 0 8.287999e-08
I11033 n1_m1_60000_43200 0 8.113894e-08
I11034 n1_m1_60000_48000 0 1.175993e-07
I11035 n1_m1_60000_52800 0 8.098339e-08
I11036 n1_m1_60000_57600 0 1.225125e-07
I11037 n1_m1_60000_62400 0 8.018959e-08
I11038 n1_m1_60000_67200 0 8.045736e-08
I11039 n1_m1_60000_72000 0 1.208107e-07
I11040 n1_m1_60000_76800 0 8.236649e-08
I11041 n1_m1_60000_81600 0 1.263858e-07
I11042 n1_m1_60000_86400 0 8.697177e-08
I11043 n1_m1_60000_91200 0 8.732267e-08
I11044 n1_m1_60000_96000 0 1.342107e-07
I11045 n1_m1_60000_100800 0 8.994899e-08
I11046 n1_m1_60000_105600 0 1.494800e-07
I11047 n1_m1_60000_110400 0 3.015139e-07
I11048 n1_m1_60000_115200 0 6.250777e-07
I11049 n1_m1_60000_120000 0 9.047277e-07
I11050 n1_m1_60000_124800 0 2.365042e-07
I11051 n1_m1_60000_129600 0 1.862976e-07
I11052 n1_m1_60000_134400 0 8.898937e-08
I11053 n1_m1_60000_139200 0 8.439990e-08
I11054 n1_m1_60000_144000 0 1.250953e-07
I11055 n1_m1_60000_148800 0 8.688047e-08
I11056 n1_m1_60000_153600 0 1.452467e-07
I11057 n1_m1_60000_158400 0 3.584264e-07
I11058 n1_m1_60000_163200 0 6.197362e-07
I11059 n1_m1_60000_168000 0 9.425048e-07
I11060 n1_m1_60000_172800 0 3.597235e-07
I11061 n1_m1_60000_177600 0 2.536775e-07
I11062 n1_m1_60000_182400 0 3.124632e-07
I11063 n1_m1_60000_187200 0 2.580756e-07
I11064 n1_m1_60000_192000 0 1.684734e-07
I11065 n1_m1_60000_196800 0 8.862258e-08
I11066 n1_m1_60000_201600 0 1.522450e-07
I11067 n1_m1_60000_206400 0 9.326898e-08
I11068 n1_m1_60000_211200 0 1.238127e-07
I11069 n1_m1_60000_216000 0 2.875251e-07
I11070 n1_m1_60000_220800 0 1.173926e-07
I11071 n1_m1_60000_225600 0 1.465510e-07
I11072 n1_m1_60000_230400 0 8.490975e-08
I11073 n1_m1_60000_235200 0 8.500863e-08
I11074 n1_m1_60000_240000 0 1.295705e-07
I11075 n1_m1_60000_244800 0 8.969248e-08
I11076 n1_m1_60000_249600 0 1.634154e-07
I11077 n1_m1_60000_254400 0 8.497017e-08
I11078 n1_m1_60000_259200 0 8.292661e-08
I11079 n1_m1_60000_264000 0 1.295271e-07
I11080 n1_m1_60000_268800 0 8.167678e-08
I11081 n1_m1_60000_273600 0 1.254760e-07
I11082 n1_m1_60000_278400 0 8.682127e-08
I11083 n1_m1_60000_283200 0 8.357144e-08
I11084 n1_m1_60000_288000 0 1.267328e-07
I11085 n1_m1_60000_292800 0 8.640307e-08
I11086 n1_m1_60000_297600 0 1.282463e-07
I11087 n1_m1_60000_302400 0 8.599185e-08
I11088 n1_m1_60000_307200 0 8.775826e-08
I11089 n1_m1_60000_312000 0 1.302236e-07
I11090 n1_m1_60000_316800 0 8.478895e-08
I11091 n1_m1_60000_321600 0 1.327803e-07
I11092 n1_m1_60000_326400 0 1.240800e-07
I11093 n1_m1_60000_331200 0 1.298880e-07
I11094 n1_m1_60000_336000 0 2.858615e-07
I11095 n1_m1_60000_340800 0 3.583957e-07
I11096 n1_m1_60000_345600 0 5.735661e-07
I11097 n1_m1_60000_350400 0 2.742227e-07
I11098 n1_m1_60000_355200 0 1.904305e-07
I11099 n1_m1_60000_360000 0 4.890341e-07
I11100 n1_m1_60000_364800 0 5.907039e-07
I11101 n1_m1_60000_369600 0 4.443429e-07
I11102 n1_m1_60000_374400 0 9.330691e-08
I11103 n1_m1_60000_379200 0 8.660722e-08
I11104 n1_m1_60000_384000 0 1.275363e-07
I11105 n1_m1_60000_388800 0 8.327618e-08
I11106 n1_m1_60000_393600 0 1.457105e-07
I11107 n1_m1_60000_398400 0 1.667102e-07
I11108 n1_m1_60000_403200 0 2.209148e-07
I11109 n1_m1_60000_408000 0 2.660647e-07
I11110 n1_m1_60000_412800 0 9.908606e-08
I11111 n1_m1_60000_417600 0 1.295496e-07
I11112 n1_m1_60000_422400 0 8.601192e-08
I11113 n1_m1_60000_427200 0 8.462207e-08
I11114 n1_m1_60000_432000 0 1.254260e-07
I11115 n1_m1_60000_436800 0 8.730773e-08
I11116 n1_m1_60000_441600 0 1.400897e-07
I11117 n1_m1_60000_446400 0 1.152741e-07
I11118 n1_m1_60000_451200 0 1.483137e-07
I11119 n1_m1_60000_456000 0 2.093268e-07
I11120 n1_m1_60000_460800 0 1.223827e-07
I11121 n1_m1_60000_465600 0 2.374358e-07
I11122 n1_m1_60000_470400 0 1.138881e-07
I11123 n1_m1_60000_475200 0 8.490363e-08
I11124 n1_m1_60000_480000 0 1.228294e-07
I11125 n1_m1_60000_484800 0 8.278128e-08
I11126 n1_m1_60000_489600 0 1.239581e-07
I11127 n1_m1_60000_494400 0 8.124360e-08
I11128 n1_m1_88000_0 0 7.520856e-08
I11129 n1_m1_88000_4800 0 8.165181e-08
I11130 n1_m1_88000_9600 0 1.389243e-07
I11131 n1_m1_88000_14400 0 9.330945e-08
I11132 n1_m1_88000_19200 0 8.694979e-08
I11133 n1_m1_88000_24000 0 1.210211e-07
I11134 n1_m1_88000_28800 0 7.872320e-08
I11135 n1_m1_88000_33600 0 1.164855e-07
I11136 n1_m1_88000_38400 0 7.661408e-08
I11137 n1_m1_88000_43200 0 7.672445e-08
I11138 n1_m1_88000_48000 0 1.192187e-07
I11139 n1_m1_88000_52800 0 7.994513e-08
I11140 n1_m1_88000_57600 0 1.204389e-07
I11141 n1_m1_88000_62400 0 8.475247e-08
I11142 n1_m1_88000_67200 0 8.455462e-08
I11143 n1_m1_88000_72000 0 1.257218e-07
I11144 n1_m1_88000_76800 0 8.521268e-08
I11145 n1_m1_88000_81600 0 1.322519e-07
I11146 n1_m1_88000_86400 0 8.949942e-08
I11147 n1_m1_88000_91200 0 8.989714e-08
I11148 n1_m1_88000_96000 0 1.836552e-07
I11149 n1_m1_88000_100800 0 2.803640e-07
I11150 n1_m1_88000_105600 0 5.943816e-07
I11151 n1_m1_88000_110400 0 3.018659e-07
I11152 n1_m1_88000_115200 0 1.252471e-07
I11153 n1_m1_88000_120000 0 1.243624e-07
I11154 n1_m1_88000_124800 0 8.366256e-08
I11155 n1_m1_88000_129600 0 1.249143e-07
I11156 n1_m1_88000_134400 0 8.327618e-08
I11157 n1_m1_88000_139200 0 8.428287e-08
I11158 n1_m1_88000_144000 0 1.299491e-07
I11159 n1_m1_88000_148800 0 9.163215e-08
I11160 n1_m1_88000_153600 0 1.544455e-07
I11161 n1_m1_88000_158400 0 9.904868e-08
I11162 n1_m1_88000_163200 0 9.402414e-08
I11163 n1_m1_88000_168000 0 1.775115e-07
I11164 n1_m1_88000_172800 0 1.053287e-07
I11165 n1_m1_88000_177600 0 1.324533e-07
I11166 n1_m1_88000_182400 0 8.606574e-08
I11167 n1_m1_88000_187200 0 8.646514e-08
I11168 n1_m1_88000_192000 0 1.327164e-07
I11169 n1_m1_88000_196800 0 8.479825e-08
I11170 n1_m1_88000_201600 0 1.271451e-07
I11171 n1_m1_88000_206400 0 8.819582e-08
I11172 n1_m1_88000_211200 0 8.812162e-08
I11173 n1_m1_88000_216000 0 1.280370e-07
I11174 n1_m1_88000_220800 0 8.800874e-08
I11175 n1_m1_88000_225600 0 1.292145e-07
I11176 n1_m1_88000_230400 0 8.124338e-08
I11177 n1_m1_88000_235200 0 8.139126e-08
I11178 n1_m1_88000_240000 0 1.296767e-07
I11179 n1_m1_88000_244800 0 8.478375e-08
I11180 n1_m1_88000_249600 0 1.274005e-07
I11181 n1_m1_88000_254400 0 8.806506e-08
I11182 n1_m1_88000_259200 0 8.592634e-08
I11183 n1_m1_88000_264000 0 1.332666e-07
I11184 n1_m1_88000_268800 0 1.217827e-07
I11185 n1_m1_88000_273600 0 1.727717e-07
I11186 n1_m1_88000_278400 0 8.918615e-08
I11187 n1_m1_88000_283200 0 8.452699e-08
I11188 n1_m1_88000_288000 0 1.256941e-07
I11189 n1_m1_88000_292800 0 8.440769e-08
I11190 n1_m1_88000_297600 0 1.267905e-07
I11191 n1_m1_88000_302400 0 8.452699e-08
I11192 n1_m1_88000_307200 0 8.369563e-08
I11193 n1_m1_88000_312000 0 1.283806e-07
I11194 n1_m1_88000_316800 0 8.752738e-08
I11195 n1_m1_88000_321600 0 1.283022e-07
I11196 n1_m1_88000_326400 0 8.366242e-08
I11197 n1_m1_88000_331200 0 8.605205e-08
I11198 n1_m1_88000_336000 0 1.359691e-07
I11199 n1_m1_88000_340800 0 9.250074e-08
I11200 n1_m1_88000_345600 0 1.288116e-07
I11201 n1_m1_88000_350400 0 8.077430e-08
I11202 n1_m1_88000_355200 0 8.305440e-08
I11203 n1_m1_88000_360000 0 1.325880e-07
I11204 n1_m1_88000_364800 0 8.172460e-08
I11205 n1_m1_88000_369600 0 1.279139e-07
I11206 n1_m1_88000_374400 0 8.136090e-08
I11207 n1_m1_88000_379200 0 8.664650e-08
I11208 n1_m1_88000_384000 0 1.427289e-07
I11209 n1_m1_88000_388800 0 8.980208e-08
I11210 n1_m1_88000_393600 0 1.276032e-07
I11211 n1_m1_88000_398400 0 8.517445e-08
I11212 n1_m1_88000_403200 0 8.703170e-08
I11213 n1_m1_88000_408000 0 1.406500e-07
I11214 n1_m1_88000_412800 0 1.028702e-07
I11215 n1_m1_88000_417600 0 1.377121e-07
I11216 n1_m1_88000_422400 0 9.801275e-08
I11217 n1_m1_88000_427200 0 1.717773e-07
I11218 n1_m1_88000_432000 0 4.604007e-07
I11219 n1_m1_88000_436800 0 2.423160e-07
I11220 n1_m1_88000_441600 0 1.480914e-07
I11221 n1_m1_88000_446400 0 8.624795e-08
I11222 n1_m1_88000_451200 0 1.073170e-07
I11223 n1_m1_88000_456000 0 4.318170e-07
I11224 n1_m1_88000_460800 0 3.210840e-07
I11225 n1_m1_88000_465600 0 2.312009e-07
I11226 n1_m1_88000_470400 0 4.577504e-07
I11227 n1_m1_88000_475200 0 5.363390e-07
I11228 n1_m1_88000_480000 0 3.516673e-07
I11229 n1_m1_88000_484800 0 7.911571e-08
I11230 n1_m1_88000_489600 0 1.177166e-07
I11231 n1_m1_88000_494400 0 7.941045e-08
I11232 n1_m1_116000_0 0 1.468537e-07
I11233 n1_m1_116000_4800 0 1.468107e-07
I11234 n1_m1_116000_9600 0 2.207085e-07
I11235 n1_m1_116000_14400 0 1.511984e-07
I11236 n1_m1_116000_19200 0 1.532282e-07
I11237 n1_m1_116000_24000 0 2.309938e-07
I11238 n1_m1_116000_28800 0 1.571194e-07
I11239 n1_m1_116000_33600 0 2.309801e-07
I11240 n1_m1_116000_38400 0 1.584248e-07
I11241 n1_m1_116000_43200 0 1.596026e-07
I11242 n1_m1_116000_48000 0 2.395050e-07
I11243 n1_m1_116000_52800 0 1.624186e-07
I11244 n1_m1_116000_57600 0 2.507565e-07
I11245 n1_m1_116000_62400 0 1.684470e-07
I11246 n1_m1_116000_67200 0 1.942376e-07
I11247 n1_m1_116000_72000 0 2.665167e-07
I11248 n1_m1_116000_76800 0 1.681768e-07
I11249 n1_m1_116000_81600 0 2.606726e-07
I11250 n1_m1_116000_86400 0 1.673142e-07
I11251 n1_m1_116000_91200 0 1.606458e-07
I11252 n1_m1_116000_96000 0 2.421119e-07
I11253 n1_m1_116000_100800 0 1.651509e-07
I11254 n1_m1_116000_105600 0 2.498285e-07
I11255 n1_m1_116000_110400 0 1.664698e-07
I11256 n1_m1_116000_115200 0 1.647043e-07
I11257 n1_m1_116000_120000 0 2.464467e-07
I11258 n1_m1_116000_124800 0 1.705293e-07
I11259 n1_m1_116000_129600 0 2.545267e-07
I11260 n1_m1_116000_134400 0 1.627403e-07
I11261 n1_m1_116000_139200 0 1.631143e-07
I11262 n1_m1_116000_144000 0 2.498692e-07
I11263 n1_m1_116000_148800 0 1.668108e-07
I11264 n1_m1_116000_153600 0 2.576917e-07
I11265 n1_m1_116000_158400 0 1.713396e-07
I11266 n1_m1_116000_163200 0 1.665524e-07
I11267 n1_m1_116000_168000 0 2.501032e-07
I11268 n1_m1_116000_172800 0 1.699584e-07
I11269 n1_m1_116000_177600 0 4.157579e-07
I11270 n1_m1_116000_182400 0 6.302166e-07
I11271 n1_m1_116000_187200 0 1.238907e-06
I11272 n1_m1_116000_192000 0 1.855646e-06
I11273 n1_m1_116000_196800 0 8.066482e-07
I11274 n1_m1_116000_201600 0 5.266097e-07
I11275 n1_m1_116000_206400 0 1.930437e-07
I11276 n1_m1_116000_211200 0 1.792735e-07
I11277 n1_m1_116000_216000 0 3.366488e-07
I11278 n1_m1_116000_220800 0 2.630674e-07
I11279 n1_m1_116000_225600 0 3.216256e-07
I11280 n1_m1_116000_230400 0 1.843506e-07
I11281 n1_m1_116000_235200 0 1.814539e-07
I11282 n1_m1_116000_240000 0 2.481006e-07
I11283 n1_m1_116000_244800 0 1.750788e-07
I11284 n1_m1_116000_249600 0 3.591944e-07
I11285 n1_m1_116000_254400 0 3.666859e-07
I11286 n1_m1_116000_259200 0 5.182346e-07
I11287 n1_m1_116000_264000 0 1.126265e-06
I11288 n1_m1_116000_268800 0 9.980518e-07
I11289 n1_m1_116000_273600 0 1.206609e-06
I11290 n1_m1_116000_278400 0 3.459012e-07
I11291 n1_m1_116000_283200 0 2.051174e-07
I11292 n1_m1_116000_288000 0 2.592983e-07
I11293 n1_m1_116000_292800 0 1.673983e-07
I11294 n1_m1_116000_297600 0 2.488335e-07
I11295 n1_m1_116000_302400 0 1.740453e-07
I11296 n1_m1_116000_307200 0 2.145743e-07
I11297 n1_m1_116000_312000 0 6.071535e-07
I11298 n1_m1_116000_316800 0 4.455970e-07
I11299 n1_m1_116000_321600 0 8.729743e-07
I11300 n1_m1_116000_326400 0 5.805622e-07
I11301 n1_m1_116000_331200 0 3.551191e-07
I11302 n1_m1_116000_336000 0 2.967267e-07
I11303 n1_m1_116000_340800 0 1.760503e-07
I11304 n1_m1_116000_345600 0 2.588883e-07
I11305 n1_m1_116000_350400 0 1.685133e-07
I11306 n1_m1_116000_355200 0 1.667340e-07
I11307 n1_m1_116000_360000 0 2.498285e-07
I11308 n1_m1_116000_364800 0 1.657370e-07
I11309 n1_m1_116000_369600 0 2.444565e-07
I11310 n1_m1_116000_374400 0 1.713920e-07
I11311 n1_m1_116000_379200 0 1.670661e-07
I11312 n1_m1_116000_384000 0 2.543810e-07
I11313 n1_m1_116000_388800 0 1.731399e-07
I11314 n1_m1_116000_393600 0 2.518152e-07
I11315 n1_m1_116000_398400 0 1.689135e-07
I11316 n1_m1_116000_403200 0 1.746983e-07
I11317 n1_m1_116000_408000 0 2.622134e-07
I11318 n1_m1_116000_412800 0 1.729768e-07
I11319 n1_m1_116000_417600 0 2.565102e-07
I11320 n1_m1_116000_422400 0 1.666904e-07
I11321 n1_m1_116000_427200 0 1.692085e-07
I11322 n1_m1_116000_432000 0 2.589482e-07
I11323 n1_m1_116000_436800 0 1.732519e-07
I11324 n1_m1_116000_441600 0 2.669446e-07
I11325 n1_m1_116000_446400 0 2.382295e-07
I11326 n1_m1_116000_451200 0 2.907821e-07
I11327 n1_m1_116000_456000 0 2.980894e-07
I11328 n1_m1_116000_460800 0 1.691349e-07
I11329 n1_m1_116000_465600 0 2.642570e-07
I11330 n1_m1_116000_470400 0 1.746119e-07
I11331 n1_m1_116000_475200 0 1.728642e-07
I11332 n1_m1_116000_480000 0 2.505213e-07
I11333 n1_m1_116000_484800 0 1.654875e-07
I11334 n1_m1_116000_489600 0 2.416968e-07
I11335 n1_m1_116000_494400 0 1.632755e-07
I11336 n1_m1_172000_0 0 7.413921e-08
I11337 n1_m1_172000_4800 0 7.675455e-08
I11338 n1_m1_172000_9600 0 1.196067e-07
I11339 n1_m1_172000_14400 0 7.790503e-08
I11340 n1_m1_172000_19200 0 7.661408e-08
I11341 n1_m1_172000_24000 0 1.110282e-07
I11342 n1_m1_172000_28800 0 7.406229e-08
I11343 n1_m1_172000_33600 0 1.148910e-07
I11344 n1_m1_172000_38400 0 7.661408e-08
I11345 n1_m1_172000_43200 0 7.661408e-08
I11346 n1_m1_172000_48000 0 1.149211e-07
I11347 n1_m1_172000_52800 0 7.661408e-08
I11348 n1_m1_172000_57600 0 1.179445e-07
I11349 n1_m1_172000_62400 0 7.961241e-08
I11350 n1_m1_172000_67200 0 7.717680e-08
I11351 n1_m1_172000_72000 0 1.150325e-07
I11352 n1_m1_172000_76800 0 7.661408e-08
I11353 n1_m1_172000_81600 0 1.184037e-07
I11354 n1_m1_172000_86400 0 8.056266e-08
I11355 n1_m1_172000_91200 0 8.306929e-08
I11356 n1_m1_172000_96000 0 1.226107e-07
I11357 n1_m1_172000_100800 0 8.005884e-08
I11358 n1_m1_172000_105600 0 1.200883e-07
I11359 n1_m1_172000_110400 0 8.009149e-08
I11360 n1_m1_172000_115200 0 8.220115e-08
I11361 n1_m1_172000_120000 0 1.668015e-07
I11362 n1_m1_172000_124800 0 4.851518e-07
I11363 n1_m1_172000_129600 0 4.735582e-07
I11364 n1_m1_172000_134400 0 1.899584e-07
I11365 n1_m1_172000_139200 0 2.198513e-07
I11366 n1_m1_172000_144000 0 2.958272e-07
I11367 n1_m1_172000_148800 0 1.531538e-07
I11368 n1_m1_172000_153600 0 1.642053e-07
I11369 n1_m1_172000_158400 0 8.982456e-08
I11370 n1_m1_172000_163200 0 8.562522e-08
I11371 n1_m1_172000_168000 0 1.249506e-07
I11372 n1_m1_172000_172800 0 8.247686e-08
I11373 n1_m1_172000_177600 0 1.200490e-07
I11374 n1_m1_172000_182400 0 8.261074e-08
I11375 n1_m1_172000_187200 0 8.579700e-08
I11376 n1_m1_172000_192000 0 1.298877e-07
I11377 n1_m1_172000_196800 0 8.534742e-08
I11378 n1_m1_172000_201600 0 2.530049e-07
I11379 n1_m1_172000_206400 0 1.477584e-07
I11380 n1_m1_172000_211200 0 1.401268e-07
I11381 n1_m1_172000_216000 0 1.950636e-07
I11382 n1_m1_172000_220800 0 1.020824e-07
I11383 n1_m1_172000_225600 0 1.374120e-07
I11384 n1_m1_172000_230400 0 1.022750e-07
I11385 n1_m1_172000_235200 0 1.982351e-07
I11386 n1_m1_172000_240000 0 6.016165e-07
I11387 n1_m1_172000_244800 0 3.101631e-07
I11388 n1_m1_172000_249600 0 1.772027e-07
I11389 n1_m1_172000_254400 0 8.652753e-08
I11390 n1_m1_172000_259200 0 8.984085e-08
I11391 n1_m1_172000_264000 0 1.392690e-07
I11392 n1_m1_172000_268800 0 8.486713e-08
I11393 n1_m1_172000_273600 0 1.266391e-07
I11394 n1_m1_172000_278400 0 1.076814e-07
I11395 n1_m1_172000_283200 0 1.109616e-07
I11396 n1_m1_172000_288000 0 1.314793e-07
I11397 n1_m1_172000_292800 0 8.700605e-08
I11398 n1_m1_172000_297600 0 1.342817e-07
I11399 n1_m1_172000_302400 0 8.572859e-08
I11400 n1_m1_172000_307200 0 8.331431e-08
I11401 n1_m1_172000_312000 0 1.256868e-07
I11402 n1_m1_172000_316800 0 8.577902e-08
I11403 n1_m1_172000_321600 0 1.224563e-07
I11404 n1_m1_172000_326400 0 8.004881e-08
I11405 n1_m1_172000_331200 0 8.257050e-08
I11406 n1_m1_172000_336000 0 1.237061e-07
I11407 n1_m1_172000_340800 0 8.001294e-08
I11408 n1_m1_172000_345600 0 1.202555e-07
I11409 n1_m1_172000_350400 0 8.280461e-08
I11410 n1_m1_172000_355200 0 8.369288e-08
I11411 n1_m1_172000_360000 0 1.294371e-07
I11412 n1_m1_172000_364800 0 8.660722e-08
I11413 n1_m1_172000_369600 0 1.477435e-07
I11414 n1_m1_172000_374400 0 2.165020e-07
I11415 n1_m1_172000_379200 0 4.878836e-07
I11416 n1_m1_172000_384000 0 1.050762e-06
I11417 n1_m1_172000_388800 0 7.182853e-07
I11418 n1_m1_172000_393600 0 6.873268e-07
I11419 n1_m1_172000_398400 0 1.096034e-07
I11420 n1_m1_172000_403200 0 8.909189e-08
I11421 n1_m1_172000_408000 0 1.323511e-07
I11422 n1_m1_172000_412800 0 8.673121e-08
I11423 n1_m1_172000_417600 0 1.313826e-07
I11424 n1_m1_172000_422400 0 9.600081e-08
I11425 n1_m1_172000_427200 0 1.109242e-07
I11426 n1_m1_172000_432000 0 1.607927e-07
I11427 n1_m1_172000_436800 0 9.294295e-08
I11428 n1_m1_172000_441600 0 1.322173e-07
I11429 n1_m1_172000_446400 0 9.436681e-08
I11430 n1_m1_172000_451200 0 9.006536e-08
I11431 n1_m1_172000_456000 0 1.299780e-07
I11432 n1_m1_172000_460800 0 8.492832e-08
I11433 n1_m1_172000_465600 0 1.199177e-07
I11434 n1_m1_172000_470400 0 7.994513e-08
I11435 n1_m1_172000_475200 0 7.995095e-08
I11436 n1_m1_172000_480000 0 1.200665e-07
I11437 n1_m1_172000_484800 0 7.867425e-08
I11438 n1_m1_172000_489600 0 1.181159e-07
I11439 n1_m1_172000_494400 0 7.986065e-08
I11440 n1_m1_200000_0 0 7.661408e-08
I11441 n1_m1_200000_4800 0 7.661408e-08
I11442 n1_m1_200000_9600 0 1.165510e-07
I11443 n1_m1_200000_14400 0 7.940333e-08
I11444 n1_m1_200000_19200 0 7.940333e-08
I11445 n1_m1_200000_24000 0 1.184917e-07
I11446 n1_m1_200000_28800 0 7.745774e-08
I11447 n1_m1_200000_33600 0 1.198876e-07
I11448 n1_m1_200000_38400 0 7.994513e-08
I11449 n1_m1_200000_43200 0 7.994513e-08
I11450 n1_m1_200000_48000 0 1.199177e-07
I11451 n1_m1_200000_52800 0 7.994513e-08
I11452 n1_m1_200000_57600 0 1.198693e-07
I11453 n1_m1_200000_62400 0 7.954259e-08
I11454 n1_m1_200000_67200 0 7.986952e-08
I11455 n1_m1_200000_72000 0 1.199177e-07
I11456 n1_m1_200000_76800 0 8.177118e-08
I11457 n1_m1_200000_81600 0 1.280105e-07
I11458 n1_m1_200000_86400 0 8.656969e-08
I11459 n1_m1_200000_91200 0 8.727945e-08
I11460 n1_m1_200000_96000 0 1.332223e-07
I11461 n1_m1_200000_100800 0 8.969034e-08
I11462 n1_m1_200000_105600 0 1.366748e-07
I11463 n1_m1_200000_110400 0 9.179430e-08
I11464 n1_m1_200000_115200 0 8.997171e-08
I11465 n1_m1_200000_120000 0 1.315362e-07
I11466 n1_m1_200000_124800 0 8.821007e-08
I11467 n1_m1_200000_129600 0 1.849492e-07
I11468 n1_m1_200000_134400 0 2.228634e-07
I11469 n1_m1_200000_139200 0 2.124416e-07
I11470 n1_m1_200000_144000 0 2.050541e-07
I11471 n1_m1_200000_148800 0 1.329574e-07
I11472 n1_m1_200000_153600 0 2.046566e-07
I11473 n1_m1_200000_158400 0 1.192945e-07
I11474 n1_m1_200000_163200 0 1.035321e-07
I11475 n1_m1_200000_168000 0 1.460821e-07
I11476 n1_m1_200000_172800 0 8.909052e-08
I11477 n1_m1_200000_177600 0 1.313557e-07
I11478 n1_m1_200000_182400 0 1.042217e-07
I11479 n1_m1_200000_187200 0 1.373166e-07
I11480 n1_m1_200000_192000 0 1.914631e-07
I11481 n1_m1_200000_196800 0 2.677440e-07
I11482 n1_m1_200000_201600 0 7.626157e-07
I11483 n1_m1_200000_206400 0 4.093897e-07
I11484 n1_m1_200000_211200 0 2.793307e-07
I11485 n1_m1_200000_216000 0 2.260521e-07
I11486 n1_m1_200000_220800 0 8.776854e-08
I11487 n1_m1_200000_225600 0 1.290981e-07
I11488 n1_m1_200000_230400 0 8.606543e-08
I11489 n1_m1_200000_235200 0 8.606543e-08
I11490 n1_m1_200000_240000 0 1.294778e-07
I11491 n1_m1_200000_244800 0 8.457409e-08
I11492 n1_m1_200000_249600 0 1.430165e-07
I11493 n1_m1_200000_254400 0 1.283000e-07
I11494 n1_m1_200000_259200 0 1.214292e-07
I11495 n1_m1_200000_264000 0 1.347307e-07
I11496 n1_m1_200000_268800 0 8.915271e-08
I11497 n1_m1_200000_273600 0 1.373129e-07
I11498 n1_m1_200000_278400 0 8.993827e-08
I11499 n1_m1_200000_283200 0 8.828612e-08
I11500 n1_m1_200000_288000 0 1.299108e-07
I11501 n1_m1_200000_292800 0 8.723326e-08
I11502 n1_m1_200000_297600 0 1.374319e-07
I11503 n1_m1_200000_302400 0 9.169075e-08
I11504 n1_m1_200000_307200 0 8.826606e-08
I11505 n1_m1_200000_312000 0 1.262298e-07
I11506 n1_m1_200000_316800 0 8.463137e-08
I11507 n1_m1_200000_321600 0 1.307143e-07
I11508 n1_m1_200000_326400 0 8.672962e-08
I11509 n1_m1_200000_331200 0 8.660722e-08
I11510 n1_m1_200000_336000 0 1.299108e-07
I11511 n1_m1_200000_340800 0 8.773300e-08
I11512 n1_m1_200000_345600 0 1.341497e-07
I11513 n1_m1_200000_350400 0 8.947696e-08
I11514 n1_m1_200000_355200 0 8.696179e-08
I11515 n1_m1_200000_360000 0 1.276418e-07
I11516 n1_m1_200000_364800 0 8.327618e-08
I11517 n1_m1_200000_369600 0 1.256336e-07
I11518 n1_m1_200000_374400 0 8.737642e-08
I11519 n1_m1_200000_379200 0 9.728563e-08
I11520 n1_m1_200000_384000 0 1.576535e-07
I11521 n1_m1_200000_388800 0 8.761128e-08
I11522 n1_m1_200000_393600 0 1.578013e-07
I11523 n1_m1_200000_398400 0 1.512884e-07
I11524 n1_m1_200000_403200 0 1.347450e-07
I11525 n1_m1_200000_408000 0 1.435893e-07
I11526 n1_m1_200000_412800 0 8.653959e-08
I11527 n1_m1_200000_417600 0 1.335969e-07
I11528 n1_m1_200000_422400 0 8.848764e-08
I11529 n1_m1_200000_427200 0 8.966302e-08
I11530 n1_m1_200000_432000 0 1.283481e-07
I11531 n1_m1_200000_436800 0 8.919180e-08
I11532 n1_m1_200000_441600 0 1.622648e-07
I11533 n1_m1_200000_446400 0 1.091173e-07
I11534 n1_m1_200000_451200 0 9.090888e-08
I11535 n1_m1_200000_456000 0 1.233500e-07
I11536 n1_m1_200000_460800 0 8.534633e-08
I11537 n1_m1_200000_465600 0 1.322486e-07
I11538 n1_m1_200000_470400 0 8.400861e-08
I11539 n1_m1_200000_475200 0 8.330392e-08
I11540 n1_m1_200000_480000 0 1.256231e-07
I11541 n1_m1_200000_484800 0 8.243338e-08
I11542 n1_m1_200000_489600 0 1.205187e-07
I11543 n1_m1_200000_494400 0 8.201746e-08
I11544 n1_m1_228000_0 0 7.661408e-08
I11545 n1_m1_228000_4800 0 7.661408e-08
I11546 n1_m1_228000_9600 0 1.149211e-07
I11547 n1_m1_228000_14400 0 7.734737e-08
I11548 n1_m1_228000_19200 0 7.917818e-08
I11549 n1_m1_228000_24000 0 1.199177e-07
I11550 n1_m1_228000_28800 0 8.022522e-08
I11551 n1_m1_228000_33600 0 1.216968e-07
I11552 n1_m1_228000_38400 0 8.023003e-08
I11553 n1_m1_228000_43200 0 7.994513e-08
I11554 n1_m1_228000_48000 0 1.199177e-07
I11555 n1_m1_228000_52800 0 8.075492e-08
I11556 n1_m1_228000_57600 0 1.239074e-07
I11557 n1_m1_228000_62400 0 8.126960e-08
I11558 n1_m1_228000_67200 0 8.578444e-08
I11559 n1_m1_228000_72000 0 1.274824e-07
I11560 n1_m1_228000_76800 0 8.697257e-08
I11561 n1_m1_228000_81600 0 1.851248e-07
I11562 n1_m1_228000_86400 0 2.560394e-07
I11563 n1_m1_228000_91200 0 1.107777e-07
I11564 n1_m1_228000_96000 0 1.390559e-07
I11565 n1_m1_228000_100800 0 9.386249e-08
I11566 n1_m1_228000_105600 0 1.474007e-07
I11567 n1_m1_228000_110400 0 9.856823e-08
I11568 n1_m1_228000_115200 0 9.572884e-08
I11569 n1_m1_228000_120000 0 1.500038e-07
I11570 n1_m1_228000_124800 0 1.314308e-07
I11571 n1_m1_228000_129600 0 1.719617e-07
I11572 n1_m1_228000_134400 0 8.903528e-08
I11573 n1_m1_228000_139200 0 8.689569e-08
I11574 n1_m1_228000_144000 0 2.498632e-07
I11575 n1_m1_228000_148800 0 2.350291e-07
I11576 n1_m1_228000_153600 0 2.460724e-07
I11577 n1_m1_228000_158400 0 1.376010e-07
I11578 n1_m1_228000_163200 0 1.053645e-07
I11579 n1_m1_228000_168000 0 1.423022e-07
I11580 n1_m1_228000_172800 0 1.003048e-07
I11581 n1_m1_228000_177600 0 1.284143e-07
I11582 n1_m1_228000_182400 0 8.836296e-08
I11583 n1_m1_228000_187200 0 8.921937e-08
I11584 n1_m1_228000_192000 0 1.704628e-07
I11585 n1_m1_228000_196800 0 1.183847e-07
I11586 n1_m1_228000_201600 0 1.431982e-07
I11587 n1_m1_228000_206400 0 9.113677e-08
I11588 n1_m1_228000_211200 0 9.294956e-08
I11589 n1_m1_228000_216000 0 1.345863e-07
I11590 n1_m1_228000_220800 0 8.820396e-08
I11591 n1_m1_228000_225600 0 1.343144e-07
I11592 n1_m1_228000_230400 0 9.364321e-08
I11593 n1_m1_228000_235200 0 1.140317e-07
I11594 n1_m1_228000_240000 0 1.468696e-07
I11595 n1_m1_228000_244800 0 8.660722e-08
I11596 n1_m1_228000_249600 0 1.334962e-07
I11597 n1_m1_228000_254400 0 8.744630e-08
I11598 n1_m1_228000_259200 0 8.590883e-08
I11599 n1_m1_228000_264000 0 1.264995e-07
I11600 n1_m1_228000_268800 0 8.164852e-08
I11601 n1_m1_228000_273600 0 1.201160e-07
I11602 n1_m1_228000_278400 0 8.150363e-08
I11603 n1_m1_228000_283200 0 8.327618e-08
I11604 n1_m1_228000_288000 0 1.264553e-07
I11605 n1_m1_228000_292800 0 8.640370e-08
I11606 n1_m1_228000_297600 0 1.299108e-07
I11607 n1_m1_228000_302400 0 8.660722e-08
I11608 n1_m1_228000_307200 0 8.518901e-08
I11609 n1_m1_228000_312000 0 1.332619e-07
I11610 n1_m1_228000_316800 0 8.819567e-08
I11611 n1_m1_228000_321600 0 1.292936e-07
I11612 n1_m1_228000_326400 0 9.027999e-08
I11613 n1_m1_228000_331200 0 1.012451e-07
I11614 n1_m1_228000_336000 0 1.850585e-07
I11615 n1_m1_228000_340800 0 1.333657e-07
I11616 n1_m1_228000_345600 0 1.653455e-07
I11617 n1_m1_228000_350400 0 8.896277e-08
I11618 n1_m1_228000_355200 0 1.023673e-07
I11619 n1_m1_228000_360000 0 3.080595e-07
I11620 n1_m1_228000_364800 0 2.270038e-07
I11621 n1_m1_228000_369600 0 1.772814e-07
I11622 n1_m1_228000_374400 0 1.216989e-07
I11623 n1_m1_228000_379200 0 3.289229e-07
I11624 n1_m1_228000_384000 0 6.823997e-07
I11625 n1_m1_228000_388800 0 1.822010e-07
I11626 n1_m1_228000_393600 0 1.666308e-07
I11627 n1_m1_228000_398400 0 9.614930e-08
I11628 n1_m1_228000_403200 0 8.511377e-08
I11629 n1_m1_228000_408000 0 1.478803e-07
I11630 n1_m1_228000_412800 0 1.071281e-07
I11631 n1_m1_228000_417600 0 1.368837e-07
I11632 n1_m1_228000_422400 0 8.971691e-08
I11633 n1_m1_228000_427200 0 1.041830e-07
I11634 n1_m1_228000_432000 0 1.964996e-07
I11635 n1_m1_228000_436800 0 1.755752e-07
I11636 n1_m1_228000_441600 0 1.941128e-07
I11637 n1_m1_228000_446400 0 9.504449e-08
I11638 n1_m1_228000_451200 0 9.024101e-08
I11639 n1_m1_228000_456000 0 1.358422e-07
I11640 n1_m1_228000_460800 0 8.901254e-08
I11641 n1_m1_228000_465600 0 1.316467e-07
I11642 n1_m1_228000_470400 0 8.665170e-08
I11643 n1_m1_228000_475200 0 8.755809e-08
I11644 n1_m1_228000_480000 0 1.312428e-07
I11645 n1_m1_228000_484800 0 8.433571e-08
I11646 n1_m1_228000_489600 0 1.170821e-07
I11647 n1_m1_228000_494400 0 7.413921e-08
I11648 n1_m1_256000_0 0 7.994513e-08
I11649 n1_m1_256000_4800 0 8.016627e-08
I11650 n1_m1_256000_9600 0 1.219970e-07
I11651 n1_m1_256000_14400 0 8.255812e-08
I11652 n1_m1_256000_19200 0 8.327618e-08
I11653 n1_m1_256000_24000 0 1.270796e-07
I11654 n1_m1_256000_28800 0 8.434974e-08
I11655 n1_m1_256000_33600 0 1.238569e-07
I11656 n1_m1_256000_38400 0 8.694108e-08
I11657 n1_m1_256000_43200 0 8.797509e-08
I11658 n1_m1_256000_48000 0 1.266601e-07
I11659 n1_m1_256000_52800 0 8.282972e-08
I11660 n1_m1_256000_57600 0 1.304527e-07
I11661 n1_m1_256000_62400 0 8.649380e-08
I11662 n1_m1_256000_67200 0 8.987597e-08
I11663 n1_m1_256000_72000 0 1.340378e-07
I11664 n1_m1_256000_76800 0 8.829080e-08
I11665 n1_m1_256000_81600 0 1.302927e-07
I11666 n1_m1_256000_86400 0 8.630297e-08
I11667 n1_m1_256000_91200 0 8.628822e-08
I11668 n1_m1_256000_96000 0 1.285145e-07
I11669 n1_m1_256000_100800 0 1.045161e-07
I11670 n1_m1_256000_105600 0 1.627727e-07
I11671 n1_m1_256000_110400 0 9.426088e-08
I11672 n1_m1_256000_115200 0 9.206520e-08
I11673 n1_m1_256000_120000 0 1.385279e-07
I11674 n1_m1_256000_124800 0 8.602228e-08
I11675 n1_m1_256000_129600 0 1.275333e-07
I11676 n1_m1_256000_134400 0 8.408060e-08
I11677 n1_m1_256000_139200 0 8.417282e-08
I11678 n1_m1_256000_144000 0 1.293988e-07
I11679 n1_m1_256000_148800 0 8.816560e-08
I11680 n1_m1_256000_153600 0 1.313482e-07
I11681 n1_m1_256000_158400 0 8.475441e-08
I11682 n1_m1_256000_163200 0 8.596358e-08
I11683 n1_m1_256000_168000 0 1.294923e-07
I11684 n1_m1_256000_172800 0 8.478604e-08
I11685 n1_m1_256000_177600 0 1.285450e-07
I11686 n1_m1_256000_182400 0 8.770551e-08
I11687 n1_m1_256000_187200 0 8.679886e-08
I11688 n1_m1_256000_192000 0 1.261305e-07
I11689 n1_m1_256000_196800 0 8.547991e-08
I11690 n1_m1_256000_201600 0 1.280658e-07
I11691 n1_m1_256000_206400 0 8.385889e-08
I11692 n1_m1_256000_211200 0 8.675633e-08
I11693 n1_m1_256000_216000 0 1.389207e-07
I11694 n1_m1_256000_220800 0 9.171920e-08
I11695 n1_m1_256000_225600 0 1.286570e-07
I11696 n1_m1_256000_230400 0 8.675953e-08
I11697 n1_m1_256000_235200 0 1.066526e-07
I11698 n1_m1_256000_240000 0 2.939958e-07
I11699 n1_m1_256000_244800 0 2.933528e-07
I11700 n1_m1_256000_249600 0 1.997798e-07
I11701 n1_m1_256000_254400 0 9.267155e-08
I11702 n1_m1_256000_259200 0 8.859601e-08
I11703 n1_m1_256000_264000 0 1.270614e-07
I11704 n1_m1_256000_268800 0 8.327618e-08
I11705 n1_m1_256000_273600 0 1.249143e-07
I11706 n1_m1_256000_278400 0 8.414305e-08
I11707 n1_m1_256000_283200 0 8.586217e-08
I11708 n1_m1_256000_288000 0 1.299108e-07
I11709 n1_m1_256000_292800 0 8.606877e-08
I11710 n1_m1_256000_297600 0 1.260846e-07
I11711 n1_m1_256000_302400 0 9.652286e-08
I11712 n1_m1_256000_307200 0 1.219236e-07
I11713 n1_m1_256000_312000 0 2.556710e-07
I11714 n1_m1_256000_316800 0 1.069544e-07
I11715 n1_m1_256000_321600 0 1.367211e-07
I11716 n1_m1_256000_326400 0 1.645747e-07
I11717 n1_m1_256000_331200 0 3.120138e-07
I11718 n1_m1_256000_336000 0 4.729068e-07
I11719 n1_m1_256000_340800 0 1.603214e-07
I11720 n1_m1_256000_345600 0 1.436817e-07
I11721 n1_m1_256000_350400 0 1.607159e-07
I11722 n1_m1_256000_355200 0 2.653364e-07
I11723 n1_m1_256000_360000 0 2.769773e-07
I11724 n1_m1_256000_364800 0 9.715078e-08
I11725 n1_m1_256000_369600 0 1.379421e-07
I11726 n1_m1_256000_374400 0 9.014156e-08
I11727 n1_m1_256000_379200 0 1.018389e-07
I11728 n1_m1_256000_384000 0 1.888283e-07
I11729 n1_m1_256000_388800 0 9.661185e-08
I11730 n1_m1_256000_393600 0 2.199911e-07
I11731 n1_m1_256000_398400 0 4.068962e-07
I11732 n1_m1_256000_403200 0 5.809474e-07
I11733 n1_m1_256000_408000 0 5.898398e-07
I11734 n1_m1_256000_412800 0 1.429569e-07
I11735 n1_m1_256000_417600 0 1.500163e-07
I11736 n1_m1_256000_422400 0 1.048636e-07
I11737 n1_m1_256000_427200 0 1.028069e-07
I11738 n1_m1_256000_432000 0 2.258858e-07
I11739 n1_m1_256000_436800 0 9.850348e-08
I11740 n1_m1_256000_441600 0 1.315346e-07
I11741 n1_m1_256000_446400 0 1.400176e-07
I11742 n1_m1_256000_451200 0 1.906146e-07
I11743 n1_m1_256000_456000 0 1.761056e-07
I11744 n1_m1_256000_460800 0 8.413107e-08
I11745 n1_m1_256000_465600 0 1.300733e-07
I11746 n1_m1_256000_470400 0 8.569279e-08
I11747 n1_m1_256000_475200 0 9.044442e-08
I11748 n1_m1_256000_480000 0 1.369668e-07
I11749 n1_m1_256000_484800 0 8.383804e-08
I11750 n1_m1_256000_489600 0 1.197186e-07
I11751 n1_m1_256000_494400 0 7.856854e-08
I11752 n1_m1_284000_0 0 1.597285e-07
I11753 n1_m1_284000_4800 0 1.595323e-07
I11754 n1_m1_284000_9600 0 2.493391e-07
I11755 n1_m1_284000_14400 0 1.739703e-07
I11756 n1_m1_284000_19200 0 1.692186e-07
I11757 n1_m1_284000_24000 0 2.500094e-07
I11758 n1_m1_284000_28800 0 1.689146e-07
I11759 n1_m1_284000_33600 0 2.597192e-07
I11760 n1_m1_284000_38400 0 1.730015e-07
I11761 n1_m1_284000_43200 0 1.733810e-07
I11762 n1_m1_284000_48000 0 2.682302e-07
I11763 n1_m1_284000_52800 0 1.794559e-07
I11764 n1_m1_284000_57600 0 2.704758e-07
I11765 n1_m1_284000_62400 0 1.992403e-07
I11766 n1_m1_284000_67200 0 2.182320e-07
I11767 n1_m1_284000_72000 0 3.319814e-07
I11768 n1_m1_284000_76800 0 1.856162e-07
I11769 n1_m1_284000_81600 0 4.729758e-07
I11770 n1_m1_284000_86400 0 6.267448e-07
I11771 n1_m1_284000_91200 0 6.354432e-07
I11772 n1_m1_284000_96000 0 4.951788e-07
I11773 n1_m1_284000_100800 0 1.990444e-07
I11774 n1_m1_284000_105600 0 2.835228e-07
I11775 n1_m1_284000_110400 0 2.364042e-07
I11776 n1_m1_284000_115200 0 1.944250e-07
I11777 n1_m1_284000_120000 0 2.810329e-07
I11778 n1_m1_284000_124800 0 1.835071e-07
I11779 n1_m1_284000_129600 0 2.700950e-07
I11780 n1_m1_284000_134400 0 1.802938e-07
I11781 n1_m1_284000_139200 0 1.802402e-07
I11782 n1_m1_284000_144000 0 2.695155e-07
I11783 n1_m1_284000_148800 0 1.754287e-07
I11784 n1_m1_284000_153600 0 2.659126e-07
I11785 n1_m1_284000_158400 0 1.771864e-07
I11786 n1_m1_284000_163200 0 1.744131e-07
I11787 n1_m1_284000_168000 0 2.530890e-07
I11788 n1_m1_284000_172800 0 1.665675e-07
I11789 n1_m1_284000_177600 0 2.454354e-07
I11790 n1_m1_284000_182400 0 1.616894e-07
I11791 n1_m1_284000_187200 0 1.714702e-07
I11792 n1_m1_284000_192000 0 3.995677e-07
I11793 n1_m1_284000_196800 0 6.873456e-07
I11794 n1_m1_284000_201600 0 1.362662e-06
I11795 n1_m1_284000_206400 0 4.695368e-07
I11796 n1_m1_284000_211200 0 2.114137e-07
I11797 n1_m1_284000_216000 0 2.650488e-07
I11798 n1_m1_284000_220800 0 1.723248e-07
I11799 n1_m1_284000_225600 0 2.542975e-07
I11800 n1_m1_284000_230400 0 1.756935e-07
I11801 n1_m1_284000_235200 0 1.845878e-07
I11802 n1_m1_284000_240000 0 2.749786e-07
I11803 n1_m1_284000_244800 0 1.762017e-07
I11804 n1_m1_284000_249600 0 2.607973e-07
I11805 n1_m1_284000_254400 0 1.723448e-07
I11806 n1_m1_284000_259200 0 1.723917e-07
I11807 n1_m1_284000_264000 0 2.542972e-07
I11808 n1_m1_284000_268800 0 1.667758e-07
I11809 n1_m1_284000_273600 0 2.509263e-07
I11810 n1_m1_284000_278400 0 1.704921e-07
I11811 n1_m1_284000_283200 0 1.769002e-07
I11812 n1_m1_284000_288000 0 2.796034e-07
I11813 n1_m1_284000_292800 0 1.919294e-07
I11814 n1_m1_284000_297600 0 2.781296e-07
I11815 n1_m1_284000_302400 0 1.718945e-07
I11816 n1_m1_284000_307200 0 1.668282e-07
I11817 n1_m1_284000_312000 0 2.567138e-07
I11818 n1_m1_284000_316800 0 1.711073e-07
I11819 n1_m1_284000_321600 0 2.504348e-07
I11820 n1_m1_284000_326400 0 1.667320e-07
I11821 n1_m1_284000_331200 0 1.711019e-07
I11822 n1_m1_284000_336000 0 2.588213e-07
I11823 n1_m1_284000_340800 0 1.735735e-07
I11824 n1_m1_284000_345600 0 2.595607e-07
I11825 n1_m1_284000_350400 0 1.724867e-07
I11826 n1_m1_284000_355200 0 1.746048e-07
I11827 n1_m1_284000_360000 0 2.780678e-07
I11828 n1_m1_284000_364800 0 1.841570e-07
I11829 n1_m1_284000_369600 0 2.623926e-07
I11830 n1_m1_284000_374400 0 1.723926e-07
I11831 n1_m1_284000_379200 0 1.883617e-07
I11832 n1_m1_284000_384000 0 3.768474e-07
I11833 n1_m1_284000_388800 0 5.692971e-07
I11834 n1_m1_284000_393600 0 5.545660e-07
I11835 n1_m1_284000_398400 0 1.726560e-07
I11836 n1_m1_284000_403200 0 1.823904e-07
I11837 n1_m1_284000_408000 0 6.490900e-07
I11838 n1_m1_284000_412800 0 8.120197e-07
I11839 n1_m1_284000_417600 0 8.560217e-07
I11840 n1_m1_284000_422400 0 2.837644e-07
I11841 n1_m1_284000_427200 0 2.071477e-07
I11842 n1_m1_284000_432000 0 2.663510e-07
I11843 n1_m1_284000_436800 0 2.057372e-07
I11844 n1_m1_284000_441600 0 2.925843e-07
I11845 n1_m1_284000_446400 0 1.777697e-07
I11846 n1_m1_284000_451200 0 1.661589e-07
I11847 n1_m1_284000_456000 0 3.271557e-07
I11848 n1_m1_284000_460800 0 2.625834e-07
I11849 n1_m1_284000_465600 0 2.639898e-07
I11850 n1_m1_284000_470400 0 1.761011e-07
I11851 n1_m1_284000_475200 0 1.800033e-07
I11852 n1_m1_284000_480000 0 2.614670e-07
I11853 n1_m1_284000_484800 0 1.598062e-07
I11854 n1_m1_284000_489600 0 2.370522e-07
I11855 n1_m1_284000_494400 0 1.599400e-07
I11856 n1_m1_340000_0 0 7.697686e-08
I11857 n1_m1_340000_4800 0 7.723790e-08
I11858 n1_m1_340000_9600 0 1.272233e-07
I11859 n1_m1_340000_14400 0 1.100023e-07
I11860 n1_m1_340000_19200 0 1.026862e-07
I11861 n1_m1_340000_24000 0 1.305989e-07
I11862 n1_m1_340000_28800 0 1.028560e-07
I11863 n1_m1_340000_33600 0 2.479837e-07
I11864 n1_m1_340000_38400 0 1.490230e-07
I11865 n1_m1_340000_43200 0 1.158780e-07
I11866 n1_m1_340000_48000 0 2.213873e-07
I11867 n1_m1_340000_52800 0 3.154492e-07
I11868 n1_m1_340000_57600 0 7.554580e-07
I11869 n1_m1_340000_62400 0 4.575389e-07
I11870 n1_m1_340000_67200 0 2.566199e-07
I11871 n1_m1_340000_72000 0 1.505559e-07
I11872 n1_m1_340000_76800 0 8.955797e-08
I11873 n1_m1_340000_81600 0 1.545853e-07
I11874 n1_m1_340000_86400 0 1.268839e-07
I11875 n1_m1_340000_91200 0 1.481286e-07
I11876 n1_m1_340000_96000 0 1.582253e-07
I11877 n1_m1_340000_100800 0 9.704392e-08
I11878 n1_m1_340000_105600 0 1.395321e-07
I11879 n1_m1_340000_110400 0 9.149652e-08
I11880 n1_m1_340000_115200 0 8.873400e-08
I11881 n1_m1_340000_120000 0 1.340559e-07
I11882 n1_m1_340000_124800 0 8.706070e-08
I11883 n1_m1_340000_129600 0 1.299947e-07
I11884 n1_m1_340000_134400 0 8.638465e-08
I11885 n1_m1_340000_139200 0 8.611894e-08
I11886 n1_m1_340000_144000 0 1.292475e-07
I11887 n1_m1_340000_148800 0 8.655771e-08
I11888 n1_m1_340000_153600 0 1.299108e-07
I11889 n1_m1_340000_158400 0 8.660722e-08
I11890 n1_m1_340000_163200 0 8.660722e-08
I11891 n1_m1_340000_168000 0 1.293343e-07
I11892 n1_m1_340000_172800 0 8.611894e-08
I11893 n1_m1_340000_177600 0 1.291784e-07
I11894 n1_m1_340000_182400 0 8.605984e-08
I11895 n1_m1_340000_187200 0 8.427743e-08
I11896 n1_m1_340000_192000 0 1.256467e-07
I11897 n1_m1_340000_196800 0 8.487759e-08
I11898 n1_m1_340000_201600 0 1.320762e-07
I11899 n1_m1_340000_206400 0 8.896170e-08
I11900 n1_m1_340000_211200 0 8.879154e-08
I11901 n1_m1_340000_216000 0 1.300276e-07
I11902 n1_m1_340000_220800 0 8.770145e-08
I11903 n1_m1_340000_225600 0 1.368174e-07
I11904 n1_m1_340000_230400 0 8.935598e-08
I11905 n1_m1_340000_235200 0 1.071711e-07
I11906 n1_m1_340000_240000 0 2.568575e-07
I11907 n1_m1_340000_244800 0 2.091220e-07
I11908 n1_m1_340000_249600 0 2.065209e-07
I11909 n1_m1_340000_254400 0 1.018374e-07
I11910 n1_m1_340000_259200 0 9.076029e-08
I11911 n1_m1_340000_264000 0 1.305392e-07
I11912 n1_m1_340000_268800 0 9.074474e-08
I11913 n1_m1_340000_273600 0 1.600004e-07
I11914 n1_m1_340000_278400 0 1.396322e-07
I11915 n1_m1_340000_283200 0 2.907161e-07
I11916 n1_m1_340000_288000 0 6.488085e-07
I11917 n1_m1_340000_292800 0 2.123673e-07
I11918 n1_m1_340000_297600 0 1.395695e-07
I11919 n1_m1_340000_302400 0 9.289161e-08
I11920 n1_m1_340000_307200 0 8.790219e-08
I11921 n1_m1_340000_312000 0 1.516470e-07
I11922 n1_m1_340000_316800 0 1.932615e-07
I11923 n1_m1_340000_321600 0 2.214773e-07
I11924 n1_m1_340000_326400 0 8.176778e-08
I11925 n1_m1_340000_331200 0 8.549687e-08
I11926 n1_m1_340000_336000 0 1.348338e-07
I11927 n1_m1_340000_340800 0 8.462063e-08
I11928 n1_m1_340000_345600 0 1.268072e-07
I11929 n1_m1_340000_350400 0 8.371716e-08
I11930 n1_m1_340000_355200 0 9.034671e-08
I11931 n1_m1_340000_360000 0 1.896335e-07
I11932 n1_m1_340000_364800 0 1.376061e-07
I11933 n1_m1_340000_369600 0 1.530880e-07
I11934 n1_m1_340000_374400 0 1.086254e-07
I11935 n1_m1_340000_379200 0 2.703571e-07
I11936 n1_m1_340000_384000 0 8.030563e-07
I11937 n1_m1_340000_388800 0 4.930365e-07
I11938 n1_m1_340000_393600 0 2.862289e-07
I11939 n1_m1_340000_398400 0 8.235498e-08
I11940 n1_m1_340000_403200 0 8.757194e-08
I11941 n1_m1_340000_408000 0 3.125640e-07
I11942 n1_m1_340000_412800 0 4.578853e-07
I11943 n1_m1_340000_417600 0 3.089039e-07
I11944 n1_m1_340000_422400 0 1.160762e-07
I11945 n1_m1_340000_427200 0 1.100312e-07
I11946 n1_m1_340000_432000 0 3.075012e-07
I11947 n1_m1_340000_436800 0 1.547932e-07
I11948 n1_m1_340000_441600 0 1.378569e-07
I11949 n1_m1_340000_446400 0 8.192066e-08
I11950 n1_m1_340000_451200 0 8.476913e-08
I11951 n1_m1_340000_456000 0 1.314828e-07
I11952 n1_m1_340000_460800 0 8.433518e-08
I11953 n1_m1_340000_465600 0 1.623295e-07
I11954 n1_m1_340000_470400 0 1.274345e-07
I11955 n1_m1_340000_475200 0 1.098745e-07
I11956 n1_m1_340000_480000 0 1.387722e-07
I11957 n1_m1_340000_484800 0 8.355272e-08
I11958 n1_m1_340000_489600 0 1.140386e-07
I11959 n1_m1_340000_494400 0 7.340854e-08
I11960 n1_m1_368000_0 0 7.309575e-08
I11961 n1_m1_368000_4800 0 7.603830e-08
I11962 n1_m1_368000_9600 0 1.230646e-07
I11963 n1_m1_368000_14400 0 8.505904e-08
I11964 n1_m1_368000_19200 0 8.619610e-08
I11965 n1_m1_368000_24000 0 1.775373e-07
I11966 n1_m1_368000_28800 0 2.537899e-07
I11967 n1_m1_368000_33600 0 5.800726e-07
I11968 n1_m1_368000_38400 0 1.504443e-07
I11969 n1_m1_368000_43200 0 9.301530e-08
I11970 n1_m1_368000_48000 0 1.319281e-07
I11971 n1_m1_368000_52800 0 1.130746e-07
I11972 n1_m1_368000_57600 0 3.071561e-07
I11973 n1_m1_368000_62400 0 2.064340e-07
I11974 n1_m1_368000_67200 0 2.529493e-07
I11975 n1_m1_368000_72000 0 7.549785e-07
I11976 n1_m1_368000_76800 0 6.446480e-07
I11977 n1_m1_368000_81600 0 7.417798e-07
I11978 n1_m1_368000_86400 0 2.136541e-07
I11979 n1_m1_368000_91200 0 1.624799e-07
I11980 n1_m1_368000_96000 0 3.241562e-07
I11981 n1_m1_368000_100800 0 1.804644e-07
I11982 n1_m1_368000_105600 0 1.965448e-07
I11983 n1_m1_368000_110400 0 8.898176e-08
I11984 n1_m1_368000_115200 0 8.867589e-08
I11985 n1_m1_368000_120000 0 1.969579e-07
I11986 n1_m1_368000_124800 0 2.011015e-07
I11987 n1_m1_368000_129600 0 1.857944e-07
I11988 n1_m1_368000_134400 0 9.584001e-08
I11989 n1_m1_368000_139200 0 9.381450e-08
I11990 n1_m1_368000_144000 0 1.316634e-07
I11991 n1_m1_368000_148800 0 8.701319e-08
I11992 n1_m1_368000_153600 0 1.280425e-07
I11993 n1_m1_368000_158400 0 8.570846e-08
I11994 n1_m1_368000_163200 0 8.584739e-08
I11995 n1_m1_368000_168000 0 1.950800e-07
I11996 n1_m1_368000_172800 0 1.335279e-07
I11997 n1_m1_368000_177600 0 1.333926e-07
I11998 n1_m1_368000_182400 0 8.984829e-08
I11999 n1_m1_368000_187200 0 8.523772e-08
I12000 n1_m1_368000_192000 0 1.387351e-07
I12001 n1_m1_368000_196800 0 9.947544e-08
I12002 n1_m1_368000_201600 0 1.342742e-07
I12003 n1_m1_368000_206400 0 8.885117e-08
I12004 n1_m1_368000_211200 0 8.974462e-08
I12005 n1_m1_368000_216000 0 1.380811e-07
I12006 n1_m1_368000_220800 0 1.135298e-07
I12007 n1_m1_368000_225600 0 2.150422e-07
I12008 n1_m1_368000_230400 0 1.352726e-07
I12009 n1_m1_368000_235200 0 1.038680e-07
I12010 n1_m1_368000_240000 0 1.395051e-07
I12011 n1_m1_368000_244800 0 9.402991e-08
I12012 n1_m1_368000_249600 0 1.303413e-07
I12013 n1_m1_368000_254400 0 8.074670e-08
I12014 n1_m1_368000_259200 0 8.031950e-08
I12015 n1_m1_368000_264000 0 1.218441e-07
I12016 n1_m1_368000_268800 0 8.382132e-08
I12017 n1_m1_368000_273600 0 1.261270e-07
I12018 n1_m1_368000_278400 0 8.381132e-08
I12019 n1_m1_368000_283200 0 8.493751e-08
I12020 n1_m1_368000_288000 0 1.281951e-07
I12021 n1_m1_368000_292800 0 8.546343e-08
I12022 n1_m1_368000_297600 0 1.302219e-07
I12023 n1_m1_368000_302400 0 1.239210e-07
I12024 n1_m1_368000_307200 0 1.954599e-07
I12025 n1_m1_368000_312000 0 3.404024e-07
I12026 n1_m1_368000_316800 0 1.559806e-07
I12027 n1_m1_368000_321600 0 1.297940e-07
I12028 n1_m1_368000_326400 0 8.230726e-08
I12029 n1_m1_368000_331200 0 8.645737e-08
I12030 n1_m1_368000_336000 0 1.273968e-07
I12031 n1_m1_368000_340800 0 8.124958e-08
I12032 n1_m1_368000_345600 0 1.230213e-07
I12033 n1_m1_368000_350400 0 8.289157e-08
I12034 n1_m1_368000_355200 0 8.036987e-08
I12035 n1_m1_368000_360000 0 1.217304e-07
I12036 n1_m1_368000_364800 0 8.327618e-08
I12037 n1_m1_368000_369600 0 1.227173e-07
I12038 n1_m1_368000_374400 0 8.669325e-08
I12039 n1_m1_368000_379200 0 8.424896e-08
I12040 n1_m1_368000_384000 0 1.370319e-07
I12041 n1_m1_368000_388800 0 1.419239e-07
I12042 n1_m1_368000_393600 0 2.103103e-07
I12043 n1_m1_368000_398400 0 2.244501e-07
I12044 n1_m1_368000_403200 0 4.523372e-07
I12045 n1_m1_368000_408000 0 6.213772e-07
I12046 n1_m1_368000_412800 0 1.367416e-07
I12047 n1_m1_368000_417600 0 1.483963e-07
I12048 n1_m1_368000_422400 0 8.487481e-08
I12049 n1_m1_368000_427200 0 8.602614e-08
I12050 n1_m1_368000_432000 0 1.280334e-07
I12051 n1_m1_368000_436800 0 8.946117e-08
I12052 n1_m1_368000_441600 0 1.286107e-07
I12053 n1_m1_368000_446400 0 8.836579e-08
I12054 n1_m1_368000_451200 0 1.069937e-07
I12055 n1_m1_368000_456000 0 1.837612e-07
I12056 n1_m1_368000_460800 0 8.943691e-08
I12057 n1_m1_368000_465600 0 1.247841e-07
I12058 n1_m1_368000_470400 0 8.225613e-08
I12059 n1_m1_368000_475200 0 8.477782e-08
I12060 n1_m1_368000_480000 0 1.264998e-07
I12061 n1_m1_368000_484800 0 7.970433e-08
I12062 n1_m1_368000_489600 0 1.155573e-07
I12063 n1_m1_368000_494400 0 7.661408e-08
I12064 n1_m1_396000_0 0 8.300862e-08
I12065 n1_m1_396000_4800 0 8.327779e-08
I12066 n1_m1_396000_9600 0 1.261488e-07
I12067 n1_m1_396000_14400 0 8.327618e-08
I12068 n1_m1_396000_19200 0 8.327618e-08
I12069 n1_m1_396000_24000 0 1.270171e-07
I12070 n1_m1_396000_28800 0 8.928468e-08
I12071 n1_m1_396000_33600 0 1.477185e-07
I12072 n1_m1_396000_38400 0 9.546930e-08
I12073 n1_m1_396000_43200 0 1.050828e-07
I12074 n1_m1_396000_48000 0 1.648738e-07
I12075 n1_m1_396000_52800 0 1.016195e-07
I12076 n1_m1_396000_57600 0 1.330868e-07
I12077 n1_m1_396000_62400 0 8.755920e-08
I12078 n1_m1_396000_67200 0 8.488150e-08
I12079 n1_m1_396000_72000 0 1.226334e-07
I12080 n1_m1_396000_76800 0 8.330293e-08
I12081 n1_m1_396000_81600 0 1.302431e-07
I12082 n1_m1_396000_86400 0 8.587061e-08
I12083 n1_m1_396000_91200 0 8.344534e-08
I12084 n1_m1_396000_96000 0 1.249143e-07
I12085 n1_m1_396000_100800 0 8.327618e-08
I12086 n1_m1_396000_105600 0 1.271526e-07
I12087 n1_m1_396000_110400 0 8.507548e-08
I12088 n1_m1_396000_115200 0 8.564273e-08
I12089 n1_m1_396000_120000 0 1.315369e-07
I12090 n1_m1_396000_124800 0 1.026211e-07
I12091 n1_m1_396000_129600 0 1.988008e-07
I12092 n1_m1_396000_134400 0 1.842270e-07
I12093 n1_m1_396000_139200 0 2.173418e-07
I12094 n1_m1_396000_144000 0 3.028708e-07
I12095 n1_m1_396000_148800 0 1.441580e-07
I12096 n1_m1_396000_153600 0 1.902634e-07
I12097 n1_m1_396000_158400 0 1.360650e-07
I12098 n1_m1_396000_163200 0 1.296075e-07
I12099 n1_m1_396000_168000 0 2.254909e-07
I12100 n1_m1_396000_172800 0 1.932845e-07
I12101 n1_m1_396000_177600 0 2.679074e-07
I12102 n1_m1_396000_182400 0 1.028493e-07
I12103 n1_m1_396000_187200 0 8.510638e-08
I12104 n1_m1_396000_192000 0 1.304656e-07
I12105 n1_m1_396000_196800 0 1.061250e-07
I12106 n1_m1_396000_201600 0 4.535448e-07
I12107 n1_m1_396000_206400 0 4.945894e-07
I12108 n1_m1_396000_211200 0 5.235226e-07
I12109 n1_m1_396000_216000 0 7.987767e-07
I12110 n1_m1_396000_220800 0 4.223950e-07
I12111 n1_m1_396000_225600 0 3.290533e-07
I12112 n1_m1_396000_230400 0 1.235982e-07
I12113 n1_m1_396000_235200 0 8.961790e-08
I12114 n1_m1_396000_240000 0 1.799891e-07
I12115 n1_m1_396000_244800 0 1.325557e-07
I12116 n1_m1_396000_249600 0 2.770747e-07
I12117 n1_m1_396000_254400 0 1.451008e-07
I12118 n1_m1_396000_259200 0 1.054007e-07
I12119 n1_m1_396000_264000 0 1.322304e-07
I12120 n1_m1_396000_268800 0 8.660722e-08
I12121 n1_m1_396000_273600 0 1.292372e-07
I12122 n1_m1_396000_278400 0 8.423364e-08
I12123 n1_m1_396000_283200 0 8.492832e-08
I12124 n1_m1_396000_288000 0 1.299108e-07
I12125 n1_m1_396000_292800 0 8.635962e-08
I12126 n1_m1_396000_297600 0 1.319540e-07
I12127 n1_m1_396000_302400 0 1.126212e-07
I12128 n1_m1_396000_307200 0 1.491512e-07
I12129 n1_m1_396000_312000 0 4.355980e-07
I12130 n1_m1_396000_316800 0 2.943537e-07
I12131 n1_m1_396000_321600 0 2.307016e-07
I12132 n1_m1_396000_326400 0 8.300279e-08
I12133 n1_m1_396000_331200 0 8.138417e-08
I12134 n1_m1_396000_336000 0 1.284214e-07
I12135 n1_m1_396000_340800 0 8.792396e-08
I12136 n1_m1_396000_345600 0 1.330756e-07
I12137 n1_m1_396000_350400 0 8.805950e-08
I12138 n1_m1_396000_355200 0 1.021349e-07
I12139 n1_m1_396000_360000 0 2.264612e-07
I12140 n1_m1_396000_364800 0 1.490283e-07
I12141 n1_m1_396000_369600 0 1.550478e-07
I12142 n1_m1_396000_374400 0 8.147617e-08
I12143 n1_m1_396000_379200 0 8.313237e-08
I12144 n1_m1_396000_384000 0 1.225397e-07
I12145 n1_m1_396000_388800 0 7.994513e-08
I12146 n1_m1_396000_393600 0 1.209366e-07
I12147 n1_m1_396000_398400 0 8.514052e-08
I12148 n1_m1_396000_403200 0 9.652116e-08
I12149 n1_m1_396000_408000 0 1.473880e-07
I12150 n1_m1_396000_412800 0 8.582818e-08
I12151 n1_m1_396000_417600 0 1.288534e-07
I12152 n1_m1_396000_422400 0 8.407281e-08
I12153 n1_m1_396000_427200 0 8.327618e-08
I12154 n1_m1_396000_432000 0 1.244026e-07
I12155 n1_m1_396000_436800 0 8.024278e-08
I12156 n1_m1_396000_441600 0 1.199177e-07
I12157 n1_m1_396000_446400 0 7.877811e-08
I12158 n1_m1_396000_451200 0 7.710929e-08
I12159 n1_m1_396000_456000 0 1.149211e-07
I12160 n1_m1_396000_460800 0 7.661408e-08
I12161 n1_m1_396000_465600 0 1.149211e-07
I12162 n1_m1_396000_470400 0 7.661408e-08
I12163 n1_m1_396000_475200 0 7.661408e-08
I12164 n1_m1_396000_480000 0 1.149211e-07
I12165 n1_m1_396000_484800 0 7.661408e-08
I12166 n1_m1_396000_489600 0 1.151144e-07
I12167 n1_m1_396000_494400 0 7.795091e-08
I12168 n1_m1_424000_0 0 7.843794e-08
I12169 n1_m1_424000_4800 0 7.724504e-08
I12170 n1_m1_424000_9600 0 1.203206e-07
I12171 n1_m1_424000_14400 0 8.444004e-08
I12172 n1_m1_424000_19200 0 8.573098e-08
I12173 n1_m1_424000_24000 0 1.280567e-07
I12174 n1_m1_424000_28800 0 8.275860e-08
I12175 n1_m1_424000_33600 0 1.230904e-07
I12176 n1_m1_424000_38400 0 8.327618e-08
I12177 n1_m1_424000_43200 0 8.327618e-08
I12178 n1_m1_424000_48000 0 1.260848e-07
I12179 n1_m1_424000_52800 0 8.660722e-08
I12180 n1_m1_424000_57600 0 1.248005e-07
I12181 n1_m1_424000_62400 0 8.250192e-08
I12182 n1_m1_424000_67200 0 8.536904e-08
I12183 n1_m1_424000_72000 0 1.302566e-07
I12184 n1_m1_424000_76800 0 8.796381e-08
I12185 n1_m1_424000_81600 0 1.308405e-07
I12186 n1_m1_424000_86400 0 8.678113e-08
I12187 n1_m1_424000_91200 0 8.922168e-08
I12188 n1_m1_424000_96000 0 1.435894e-07
I12189 n1_m1_424000_100800 0 9.249156e-08
I12190 n1_m1_424000_105600 0 1.360009e-07
I12191 n1_m1_424000_110400 0 8.477448e-08
I12192 n1_m1_424000_115200 0 8.267618e-08
I12193 n1_m1_424000_120000 0 1.239642e-07
I12194 n1_m1_424000_124800 0 8.705980e-08
I12195 n1_m1_424000_129600 0 1.310009e-07
I12196 n1_m1_424000_134400 0 8.692736e-08
I12197 n1_m1_424000_139200 0 9.206143e-08
I12198 n1_m1_424000_144000 0 1.402211e-07
I12199 n1_m1_424000_148800 0 8.375352e-08
I12200 n1_m1_424000_153600 0 1.202087e-07
I12201 n1_m1_424000_158400 0 8.301117e-08
I12202 n1_m1_424000_163200 0 8.702862e-08
I12203 n1_m1_424000_168000 0 1.267639e-07
I12204 n1_m1_424000_172800 0 8.108849e-08
I12205 n1_m1_424000_177600 0 1.262728e-07
I12206 n1_m1_424000_182400 0 8.836946e-08
I12207 n1_m1_424000_187200 0 8.522208e-08
I12208 n1_m1_424000_192000 0 1.271208e-07
I12209 n1_m1_424000_196800 0 8.695033e-08
I12210 n1_m1_424000_201600 0 1.337170e-07
I12211 n1_m1_424000_206400 0 9.203077e-08
I12212 n1_m1_424000_211200 0 9.198171e-08
I12213 n1_m1_424000_216000 0 1.428502e-07
I12214 n1_m1_424000_220800 0 9.314191e-08
I12215 n1_m1_424000_225600 0 1.266241e-07
I12216 n1_m1_424000_230400 0 8.839947e-08
I12217 n1_m1_424000_235200 0 9.109924e-08
I12218 n1_m1_424000_240000 0 1.682145e-07
I12219 n1_m1_424000_244800 0 1.143516e-07
I12220 n1_m1_424000_249600 0 1.383706e-07
I12221 n1_m1_424000_254400 0 1.096252e-07
I12222 n1_m1_424000_259200 0 2.062769e-07
I12223 n1_m1_424000_264000 0 4.520761e-07
I12224 n1_m1_424000_268800 0 1.768632e-07
I12225 n1_m1_424000_273600 0 1.384873e-07
I12226 n1_m1_424000_278400 0 8.321987e-08
I12227 n1_m1_424000_283200 0 8.580456e-08
I12228 n1_m1_424000_288000 0 1.332475e-07
I12229 n1_m1_424000_292800 0 8.598968e-08
I12230 n1_m1_424000_297600 0 1.211695e-07
I12231 n1_m1_424000_302400 0 8.206549e-08
I12232 n1_m1_424000_307200 0 8.712179e-08
I12233 n1_m1_424000_312000 0 1.327270e-07
I12234 n1_m1_424000_316800 0 8.200416e-08
I12235 n1_m1_424000_321600 0 1.238159e-07
I12236 n1_m1_424000_326400 0 8.053897e-08
I12237 n1_m1_424000_331200 0 8.024613e-08
I12238 n1_m1_424000_336000 0 1.270786e-07
I12239 n1_m1_424000_340800 0 8.285732e-08
I12240 n1_m1_424000_345600 0 1.272015e-07
I12241 n1_m1_424000_350400 0 8.544755e-08
I12242 n1_m1_424000_355200 0 8.370268e-08
I12243 n1_m1_424000_360000 0 1.274651e-07
I12244 n1_m1_424000_364800 0 8.660722e-08
I12245 n1_m1_424000_369600 0 1.264281e-07
I12246 n1_m1_424000_374400 0 8.085145e-08
I12247 n1_m1_424000_379200 0 8.242000e-08
I12248 n1_m1_424000_384000 0 1.182648e-07
I12249 n1_m1_424000_388800 0 8.242669e-08
I12250 n1_m1_424000_393600 0 1.222928e-07
I12251 n1_m1_424000_398400 0 8.513478e-08
I12252 n1_m1_424000_403200 0 1.067758e-07
I12253 n1_m1_424000_408000 0 2.017175e-07
I12254 n1_m1_424000_412800 0 1.172747e-07
I12255 n1_m1_424000_417600 0 1.342676e-07
I12256 n1_m1_424000_422400 0 8.122183e-08
I12257 n1_m1_424000_427200 0 7.994513e-08
I12258 n1_m1_424000_432000 0 1.199177e-07
I12259 n1_m1_424000_436800 0 7.994513e-08
I12260 n1_m1_424000_441600 0 1.178508e-07
I12261 n1_m1_424000_446400 0 7.661408e-08
I12262 n1_m1_424000_451200 0 7.661408e-08
I12263 n1_m1_424000_456000 0 1.149211e-07
I12264 n1_m1_424000_460800 0 7.661408e-08
I12265 n1_m1_424000_465600 0 1.176366e-07
I12266 n1_m1_424000_470400 0 8.445879e-08
I12267 n1_m1_424000_475200 0 8.556042e-08
I12268 n1_m1_424000_480000 0 1.219964e-07
I12269 n1_m1_424000_484800 0 7.661408e-08
I12270 n1_m1_424000_489600 0 1.152790e-07
I12271 n1_m1_424000_494400 0 7.908896e-08
I12272 n1_m1_452000_0 0 1.575246e-07
I12273 n1_m1_452000_4800 0 1.511248e-07
I12274 n1_m1_452000_9600 0 2.328892e-07
I12275 n1_m1_452000_14400 0 1.718179e-07
I12276 n1_m1_452000_19200 0 1.695452e-07
I12277 n1_m1_452000_24000 0 6.475483e-07
I12278 n1_m1_452000_28800 0 1.126299e-06
I12279 n1_m1_452000_33600 0 2.022849e-06
I12280 n1_m1_452000_38400 0 9.461740e-07
I12281 n1_m1_452000_43200 0 9.018894e-07
I12282 n1_m1_452000_48000 0 1.711674e-06
I12283 n1_m1_452000_52800 0 1.051019e-06
I12284 n1_m1_452000_57600 0 7.894905e-07
I12285 n1_m1_452000_62400 0 2.034951e-07
I12286 n1_m1_452000_67200 0 1.668516e-07
I12287 n1_m1_452000_72000 0 2.415041e-07
I12288 n1_m1_452000_76800 0 1.642163e-07
I12289 n1_m1_452000_81600 0 2.514340e-07
I12290 n1_m1_452000_86400 0 1.677225e-07
I12291 n1_m1_452000_91200 0 1.651263e-07
I12292 n1_m1_452000_96000 0 2.401005e-07
I12293 n1_m1_452000_100800 0 1.646661e-07
I12294 n1_m1_452000_105600 0 2.481028e-07
I12295 n1_m1_452000_110400 0 1.603186e-07
I12296 n1_m1_452000_115200 0 1.663838e-07
I12297 n1_m1_452000_120000 0 3.534945e-07
I12298 n1_m1_452000_124800 0 1.978160e-07
I12299 n1_m1_452000_129600 0 2.806397e-07
I12300 n1_m1_452000_134400 0 2.573853e-07
I12301 n1_m1_452000_139200 0 3.167072e-07
I12302 n1_m1_452000_144000 0 3.403900e-07
I12303 n1_m1_452000_148800 0 1.715506e-07
I12304 n1_m1_452000_153600 0 2.541461e-07
I12305 n1_m1_452000_158400 0 1.749602e-07
I12306 n1_m1_452000_163200 0 2.851338e-07
I12307 n1_m1_452000_168000 0 5.737260e-07
I12308 n1_m1_452000_172800 0 2.029056e-07
I12309 n1_m1_452000_177600 0 2.497199e-07
I12310 n1_m1_452000_182400 0 1.614035e-07
I12311 n1_m1_452000_187200 0 1.589547e-07
I12312 n1_m1_452000_192000 0 2.397822e-07
I12313 n1_m1_452000_196800 0 1.599767e-07
I12314 n1_m1_452000_201600 0 2.467859e-07
I12315 n1_m1_452000_206400 0 2.001900e-07
I12316 n1_m1_452000_211200 0 3.496870e-07
I12317 n1_m1_452000_216000 0 6.043584e-07
I12318 n1_m1_452000_220800 0 1.995731e-07
I12319 n1_m1_452000_225600 0 2.555922e-07
I12320 n1_m1_452000_230400 0 1.727614e-07
I12321 n1_m1_452000_235200 0 1.658246e-07
I12322 n1_m1_452000_240000 0 2.452381e-07
I12323 n1_m1_452000_244800 0 1.656858e-07
I12324 n1_m1_452000_249600 0 2.560955e-07
I12325 n1_m1_452000_254400 0 2.231257e-07
I12326 n1_m1_452000_259200 0 2.815766e-07
I12327 n1_m1_452000_264000 0 3.139040e-07
I12328 n1_m1_452000_268800 0 4.911105e-07
I12329 n1_m1_452000_273600 0 1.437063e-06
I12330 n1_m1_452000_278400 0 6.650135e-07
I12331 n1_m1_452000_283200 0 2.462163e-07
I12332 n1_m1_452000_288000 0 2.693070e-07
I12333 n1_m1_452000_292800 0 1.735238e-07
I12334 n1_m1_452000_297600 0 3.268454e-07
I12335 n1_m1_452000_302400 0 3.538232e-07
I12336 n1_m1_452000_307200 0 4.610164e-07
I12337 n1_m1_452000_312000 0 4.694546e-07
I12338 n1_m1_452000_316800 0 2.120245e-07
I12339 n1_m1_452000_321600 0 2.818950e-07
I12340 n1_m1_452000_326400 0 1.737868e-07
I12341 n1_m1_452000_331200 0 1.710264e-07
I12342 n1_m1_452000_336000 0 2.489864e-07
I12343 n1_m1_452000_340800 0 2.664330e-07
I12344 n1_m1_452000_345600 0 6.093913e-07
I12345 n1_m1_452000_350400 0 3.547152e-07
I12346 n1_m1_452000_355200 0 2.634301e-07
I12347 n1_m1_452000_360000 0 2.703122e-07
I12348 n1_m1_452000_364800 0 1.633726e-07
I12349 n1_m1_452000_369600 0 2.460189e-07
I12350 n1_m1_452000_374400 0 1.724450e-07
I12351 n1_m1_452000_379200 0 1.642164e-07
I12352 n1_m1_452000_384000 0 2.555338e-07
I12353 n1_m1_452000_388800 0 1.783736e-07
I12354 n1_m1_452000_393600 0 2.536426e-07
I12355 n1_m1_452000_398400 0 1.686912e-07
I12356 n1_m1_452000_403200 0 1.748710e-07
I12357 n1_m1_452000_408000 0 2.451325e-07
I12358 n1_m1_452000_412800 0 1.608395e-07
I12359 n1_m1_452000_417600 0 2.529670e-07
I12360 n1_m1_452000_422400 0 1.632491e-07
I12361 n1_m1_452000_427200 0 1.571549e-07
I12362 n1_m1_452000_432000 0 2.396459e-07
I12363 n1_m1_452000_436800 0 1.590289e-07
I12364 n1_m1_452000_441600 0 2.405116e-07
I12365 n1_m1_452000_446400 0 1.653390e-07
I12366 n1_m1_452000_451200 0 1.732695e-07
I12367 n1_m1_452000_456000 0 2.815498e-07
I12368 n1_m1_452000_460800 0 1.898202e-07
I12369 n1_m1_452000_465600 0 2.761900e-07
I12370 n1_m1_452000_470400 0 1.796960e-07
I12371 n1_m1_452000_475200 0 1.741227e-07
I12372 n1_m1_452000_480000 0 2.445690e-07
I12373 n1_m1_452000_484800 0 1.510790e-07
I12374 n1_m1_452000_489600 0 2.213945e-07
I12375 n1_m1_452000_494400 0 1.515158e-07
.op
.end
